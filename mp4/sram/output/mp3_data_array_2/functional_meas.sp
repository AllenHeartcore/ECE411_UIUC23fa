.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_128ck40 FIND v(dout0_128) AT=25.025n

.meas tran vdout0_129ck40 FIND v(dout0_129) AT=25.025n

.meas tran vdout0_130ck40 FIND v(dout0_130) AT=25.025n

.meas tran vdout0_131ck40 FIND v(dout0_131) AT=25.025n

.meas tran vdout0_132ck40 FIND v(dout0_132) AT=25.025n

.meas tran vdout0_133ck40 FIND v(dout0_133) AT=25.025n

.meas tran vdout0_134ck40 FIND v(dout0_134) AT=25.025n

.meas tran vdout0_135ck40 FIND v(dout0_135) AT=25.025n

.meas tran vdout0_136ck40 FIND v(dout0_136) AT=25.025n

.meas tran vdout0_137ck40 FIND v(dout0_137) AT=25.025n

.meas tran vdout0_138ck40 FIND v(dout0_138) AT=25.025n

.meas tran vdout0_139ck40 FIND v(dout0_139) AT=25.025n

.meas tran vdout0_140ck40 FIND v(dout0_140) AT=25.025n

.meas tran vdout0_141ck40 FIND v(dout0_141) AT=25.025n

.meas tran vdout0_142ck40 FIND v(dout0_142) AT=25.025n

.meas tran vdout0_143ck40 FIND v(dout0_143) AT=25.025n

.meas tran vdout0_144ck40 FIND v(dout0_144) AT=25.025n

.meas tran vdout0_145ck40 FIND v(dout0_145) AT=25.025n

.meas tran vdout0_146ck40 FIND v(dout0_146) AT=25.025n

.meas tran vdout0_147ck40 FIND v(dout0_147) AT=25.025n

.meas tran vdout0_148ck40 FIND v(dout0_148) AT=25.025n

.meas tran vdout0_149ck40 FIND v(dout0_149) AT=25.025n

.meas tran vdout0_150ck40 FIND v(dout0_150) AT=25.025n

.meas tran vdout0_151ck40 FIND v(dout0_151) AT=25.025n

.meas tran vdout0_152ck40 FIND v(dout0_152) AT=25.025n

.meas tran vdout0_153ck40 FIND v(dout0_153) AT=25.025n

.meas tran vdout0_154ck40 FIND v(dout0_154) AT=25.025n

.meas tran vdout0_155ck40 FIND v(dout0_155) AT=25.025n

.meas tran vdout0_156ck40 FIND v(dout0_156) AT=25.025n

.meas tran vdout0_157ck40 FIND v(dout0_157) AT=25.025n

.meas tran vdout0_158ck40 FIND v(dout0_158) AT=25.025n

.meas tran vdout0_159ck40 FIND v(dout0_159) AT=25.025n

.meas tran vdout0_160ck40 FIND v(dout0_160) AT=25.025n

.meas tran vdout0_161ck40 FIND v(dout0_161) AT=25.025n

.meas tran vdout0_162ck40 FIND v(dout0_162) AT=25.025n

.meas tran vdout0_163ck40 FIND v(dout0_163) AT=25.025n

.meas tran vdout0_164ck40 FIND v(dout0_164) AT=25.025n

.meas tran vdout0_165ck40 FIND v(dout0_165) AT=25.025n

.meas tran vdout0_166ck40 FIND v(dout0_166) AT=25.025n

.meas tran vdout0_167ck40 FIND v(dout0_167) AT=25.025n

.meas tran vdout0_168ck40 FIND v(dout0_168) AT=25.025n

.meas tran vdout0_169ck40 FIND v(dout0_169) AT=25.025n

.meas tran vdout0_170ck40 FIND v(dout0_170) AT=25.025n

.meas tran vdout0_171ck40 FIND v(dout0_171) AT=25.025n

.meas tran vdout0_172ck40 FIND v(dout0_172) AT=25.025n

.meas tran vdout0_173ck40 FIND v(dout0_173) AT=25.025n

.meas tran vdout0_174ck40 FIND v(dout0_174) AT=25.025n

.meas tran vdout0_175ck40 FIND v(dout0_175) AT=25.025n

.meas tran vdout0_176ck40 FIND v(dout0_176) AT=25.025n

.meas tran vdout0_177ck40 FIND v(dout0_177) AT=25.025n

.meas tran vdout0_178ck40 FIND v(dout0_178) AT=25.025n

.meas tran vdout0_179ck40 FIND v(dout0_179) AT=25.025n

.meas tran vdout0_180ck40 FIND v(dout0_180) AT=25.025n

.meas tran vdout0_181ck40 FIND v(dout0_181) AT=25.025n

.meas tran vdout0_182ck40 FIND v(dout0_182) AT=25.025n

.meas tran vdout0_183ck40 FIND v(dout0_183) AT=25.025n

.meas tran vdout0_184ck40 FIND v(dout0_184) AT=25.025n

.meas tran vdout0_185ck40 FIND v(dout0_185) AT=25.025n

.meas tran vdout0_186ck40 FIND v(dout0_186) AT=25.025n

.meas tran vdout0_187ck40 FIND v(dout0_187) AT=25.025n

.meas tran vdout0_188ck40 FIND v(dout0_188) AT=25.025n

.meas tran vdout0_189ck40 FIND v(dout0_189) AT=25.025n

.meas tran vdout0_190ck40 FIND v(dout0_190) AT=25.025n

.meas tran vdout0_191ck40 FIND v(dout0_191) AT=25.025n

.meas tran vdout0_192ck40 FIND v(dout0_192) AT=25.025n

.meas tran vdout0_193ck40 FIND v(dout0_193) AT=25.025n

.meas tran vdout0_194ck40 FIND v(dout0_194) AT=25.025n

.meas tran vdout0_195ck40 FIND v(dout0_195) AT=25.025n

.meas tran vdout0_196ck40 FIND v(dout0_196) AT=25.025n

.meas tran vdout0_197ck40 FIND v(dout0_197) AT=25.025n

.meas tran vdout0_198ck40 FIND v(dout0_198) AT=25.025n

.meas tran vdout0_199ck40 FIND v(dout0_199) AT=25.025n

.meas tran vdout0_200ck40 FIND v(dout0_200) AT=25.025n

.meas tran vdout0_201ck40 FIND v(dout0_201) AT=25.025n

.meas tran vdout0_202ck40 FIND v(dout0_202) AT=25.025n

.meas tran vdout0_203ck40 FIND v(dout0_203) AT=25.025n

.meas tran vdout0_204ck40 FIND v(dout0_204) AT=25.025n

.meas tran vdout0_205ck40 FIND v(dout0_205) AT=25.025n

.meas tran vdout0_206ck40 FIND v(dout0_206) AT=25.025n

.meas tran vdout0_207ck40 FIND v(dout0_207) AT=25.025n

.meas tran vdout0_208ck40 FIND v(dout0_208) AT=25.025n

.meas tran vdout0_209ck40 FIND v(dout0_209) AT=25.025n

.meas tran vdout0_210ck40 FIND v(dout0_210) AT=25.025n

.meas tran vdout0_211ck40 FIND v(dout0_211) AT=25.025n

.meas tran vdout0_212ck40 FIND v(dout0_212) AT=25.025n

.meas tran vdout0_213ck40 FIND v(dout0_213) AT=25.025n

.meas tran vdout0_214ck40 FIND v(dout0_214) AT=25.025n

.meas tran vdout0_215ck40 FIND v(dout0_215) AT=25.025n

.meas tran vdout0_216ck40 FIND v(dout0_216) AT=25.025n

.meas tran vdout0_217ck40 FIND v(dout0_217) AT=25.025n

.meas tran vdout0_218ck40 FIND v(dout0_218) AT=25.025n

.meas tran vdout0_219ck40 FIND v(dout0_219) AT=25.025n

.meas tran vdout0_220ck40 FIND v(dout0_220) AT=25.025n

.meas tran vdout0_221ck40 FIND v(dout0_221) AT=25.025n

.meas tran vdout0_222ck40 FIND v(dout0_222) AT=25.025n

.meas tran vdout0_223ck40 FIND v(dout0_223) AT=25.025n

.meas tran vdout0_224ck40 FIND v(dout0_224) AT=25.025n

.meas tran vdout0_225ck40 FIND v(dout0_225) AT=25.025n

.meas tran vdout0_226ck40 FIND v(dout0_226) AT=25.025n

.meas tran vdout0_227ck40 FIND v(dout0_227) AT=25.025n

.meas tran vdout0_228ck40 FIND v(dout0_228) AT=25.025n

.meas tran vdout0_229ck40 FIND v(dout0_229) AT=25.025n

.meas tran vdout0_230ck40 FIND v(dout0_230) AT=25.025n

.meas tran vdout0_231ck40 FIND v(dout0_231) AT=25.025n

.meas tran vdout0_232ck40 FIND v(dout0_232) AT=25.025n

.meas tran vdout0_233ck40 FIND v(dout0_233) AT=25.025n

.meas tran vdout0_234ck40 FIND v(dout0_234) AT=25.025n

.meas tran vdout0_235ck40 FIND v(dout0_235) AT=25.025n

.meas tran vdout0_236ck40 FIND v(dout0_236) AT=25.025n

.meas tran vdout0_237ck40 FIND v(dout0_237) AT=25.025n

.meas tran vdout0_238ck40 FIND v(dout0_238) AT=25.025n

.meas tran vdout0_239ck40 FIND v(dout0_239) AT=25.025n

.meas tran vdout0_240ck40 FIND v(dout0_240) AT=25.025n

.meas tran vdout0_241ck40 FIND v(dout0_241) AT=25.025n

.meas tran vdout0_242ck40 FIND v(dout0_242) AT=25.025n

.meas tran vdout0_243ck40 FIND v(dout0_243) AT=25.025n

.meas tran vdout0_244ck40 FIND v(dout0_244) AT=25.025n

.meas tran vdout0_245ck40 FIND v(dout0_245) AT=25.025n

.meas tran vdout0_246ck40 FIND v(dout0_246) AT=25.025n

.meas tran vdout0_247ck40 FIND v(dout0_247) AT=25.025n

.meas tran vdout0_248ck40 FIND v(dout0_248) AT=25.025n

.meas tran vdout0_249ck40 FIND v(dout0_249) AT=25.025n

.meas tran vdout0_250ck40 FIND v(dout0_250) AT=25.025n

.meas tran vdout0_251ck40 FIND v(dout0_251) AT=25.025n

.meas tran vdout0_252ck40 FIND v(dout0_252) AT=25.025n

.meas tran vdout0_253ck40 FIND v(dout0_253) AT=25.025n

.meas tran vdout0_254ck40 FIND v(dout0_254) AT=25.025n

.meas tran vdout0_255ck40 FIND v(dout0_255) AT=25.025n

.meas tran vdout0_0ck50 FIND v(dout0_0) AT=30.025n

.meas tran vdout0_1ck50 FIND v(dout0_1) AT=30.025n

.meas tran vdout0_2ck50 FIND v(dout0_2) AT=30.025n

.meas tran vdout0_3ck50 FIND v(dout0_3) AT=30.025n

.meas tran vdout0_4ck50 FIND v(dout0_4) AT=30.025n

.meas tran vdout0_5ck50 FIND v(dout0_5) AT=30.025n

.meas tran vdout0_6ck50 FIND v(dout0_6) AT=30.025n

.meas tran vdout0_7ck50 FIND v(dout0_7) AT=30.025n

.meas tran vdout0_8ck50 FIND v(dout0_8) AT=30.025n

.meas tran vdout0_9ck50 FIND v(dout0_9) AT=30.025n

.meas tran vdout0_10ck50 FIND v(dout0_10) AT=30.025n

.meas tran vdout0_11ck50 FIND v(dout0_11) AT=30.025n

.meas tran vdout0_12ck50 FIND v(dout0_12) AT=30.025n

.meas tran vdout0_13ck50 FIND v(dout0_13) AT=30.025n

.meas tran vdout0_14ck50 FIND v(dout0_14) AT=30.025n

.meas tran vdout0_15ck50 FIND v(dout0_15) AT=30.025n

.meas tran vdout0_16ck50 FIND v(dout0_16) AT=30.025n

.meas tran vdout0_17ck50 FIND v(dout0_17) AT=30.025n

.meas tran vdout0_18ck50 FIND v(dout0_18) AT=30.025n

.meas tran vdout0_19ck50 FIND v(dout0_19) AT=30.025n

.meas tran vdout0_20ck50 FIND v(dout0_20) AT=30.025n

.meas tran vdout0_21ck50 FIND v(dout0_21) AT=30.025n

.meas tran vdout0_22ck50 FIND v(dout0_22) AT=30.025n

.meas tran vdout0_23ck50 FIND v(dout0_23) AT=30.025n

.meas tran vdout0_24ck50 FIND v(dout0_24) AT=30.025n

.meas tran vdout0_25ck50 FIND v(dout0_25) AT=30.025n

.meas tran vdout0_26ck50 FIND v(dout0_26) AT=30.025n

.meas tran vdout0_27ck50 FIND v(dout0_27) AT=30.025n

.meas tran vdout0_28ck50 FIND v(dout0_28) AT=30.025n

.meas tran vdout0_29ck50 FIND v(dout0_29) AT=30.025n

.meas tran vdout0_30ck50 FIND v(dout0_30) AT=30.025n

.meas tran vdout0_31ck50 FIND v(dout0_31) AT=30.025n

.meas tran vdout0_32ck50 FIND v(dout0_32) AT=30.025n

.meas tran vdout0_33ck50 FIND v(dout0_33) AT=30.025n

.meas tran vdout0_34ck50 FIND v(dout0_34) AT=30.025n

.meas tran vdout0_35ck50 FIND v(dout0_35) AT=30.025n

.meas tran vdout0_36ck50 FIND v(dout0_36) AT=30.025n

.meas tran vdout0_37ck50 FIND v(dout0_37) AT=30.025n

.meas tran vdout0_38ck50 FIND v(dout0_38) AT=30.025n

.meas tran vdout0_39ck50 FIND v(dout0_39) AT=30.025n

.meas tran vdout0_40ck50 FIND v(dout0_40) AT=30.025n

.meas tran vdout0_41ck50 FIND v(dout0_41) AT=30.025n

.meas tran vdout0_42ck50 FIND v(dout0_42) AT=30.025n

.meas tran vdout0_43ck50 FIND v(dout0_43) AT=30.025n

.meas tran vdout0_44ck50 FIND v(dout0_44) AT=30.025n

.meas tran vdout0_45ck50 FIND v(dout0_45) AT=30.025n

.meas tran vdout0_46ck50 FIND v(dout0_46) AT=30.025n

.meas tran vdout0_47ck50 FIND v(dout0_47) AT=30.025n

.meas tran vdout0_48ck50 FIND v(dout0_48) AT=30.025n

.meas tran vdout0_49ck50 FIND v(dout0_49) AT=30.025n

.meas tran vdout0_50ck50 FIND v(dout0_50) AT=30.025n

.meas tran vdout0_51ck50 FIND v(dout0_51) AT=30.025n

.meas tran vdout0_52ck50 FIND v(dout0_52) AT=30.025n

.meas tran vdout0_53ck50 FIND v(dout0_53) AT=30.025n

.meas tran vdout0_54ck50 FIND v(dout0_54) AT=30.025n

.meas tran vdout0_55ck50 FIND v(dout0_55) AT=30.025n

.meas tran vdout0_56ck50 FIND v(dout0_56) AT=30.025n

.meas tran vdout0_57ck50 FIND v(dout0_57) AT=30.025n

.meas tran vdout0_58ck50 FIND v(dout0_58) AT=30.025n

.meas tran vdout0_59ck50 FIND v(dout0_59) AT=30.025n

.meas tran vdout0_60ck50 FIND v(dout0_60) AT=30.025n

.meas tran vdout0_61ck50 FIND v(dout0_61) AT=30.025n

.meas tran vdout0_62ck50 FIND v(dout0_62) AT=30.025n

.meas tran vdout0_63ck50 FIND v(dout0_63) AT=30.025n

.meas tran vdout0_64ck50 FIND v(dout0_64) AT=30.025n

.meas tran vdout0_65ck50 FIND v(dout0_65) AT=30.025n

.meas tran vdout0_66ck50 FIND v(dout0_66) AT=30.025n

.meas tran vdout0_67ck50 FIND v(dout0_67) AT=30.025n

.meas tran vdout0_68ck50 FIND v(dout0_68) AT=30.025n

.meas tran vdout0_69ck50 FIND v(dout0_69) AT=30.025n

.meas tran vdout0_70ck50 FIND v(dout0_70) AT=30.025n

.meas tran vdout0_71ck50 FIND v(dout0_71) AT=30.025n

.meas tran vdout0_72ck50 FIND v(dout0_72) AT=30.025n

.meas tran vdout0_73ck50 FIND v(dout0_73) AT=30.025n

.meas tran vdout0_74ck50 FIND v(dout0_74) AT=30.025n

.meas tran vdout0_75ck50 FIND v(dout0_75) AT=30.025n

.meas tran vdout0_76ck50 FIND v(dout0_76) AT=30.025n

.meas tran vdout0_77ck50 FIND v(dout0_77) AT=30.025n

.meas tran vdout0_78ck50 FIND v(dout0_78) AT=30.025n

.meas tran vdout0_79ck50 FIND v(dout0_79) AT=30.025n

.meas tran vdout0_80ck50 FIND v(dout0_80) AT=30.025n

.meas tran vdout0_81ck50 FIND v(dout0_81) AT=30.025n

.meas tran vdout0_82ck50 FIND v(dout0_82) AT=30.025n

.meas tran vdout0_83ck50 FIND v(dout0_83) AT=30.025n

.meas tran vdout0_84ck50 FIND v(dout0_84) AT=30.025n

.meas tran vdout0_85ck50 FIND v(dout0_85) AT=30.025n

.meas tran vdout0_86ck50 FIND v(dout0_86) AT=30.025n

.meas tran vdout0_87ck50 FIND v(dout0_87) AT=30.025n

.meas tran vdout0_88ck50 FIND v(dout0_88) AT=30.025n

.meas tran vdout0_89ck50 FIND v(dout0_89) AT=30.025n

.meas tran vdout0_90ck50 FIND v(dout0_90) AT=30.025n

.meas tran vdout0_91ck50 FIND v(dout0_91) AT=30.025n

.meas tran vdout0_92ck50 FIND v(dout0_92) AT=30.025n

.meas tran vdout0_93ck50 FIND v(dout0_93) AT=30.025n

.meas tran vdout0_94ck50 FIND v(dout0_94) AT=30.025n

.meas tran vdout0_95ck50 FIND v(dout0_95) AT=30.025n

.meas tran vdout0_96ck50 FIND v(dout0_96) AT=30.025n

.meas tran vdout0_97ck50 FIND v(dout0_97) AT=30.025n

.meas tran vdout0_98ck50 FIND v(dout0_98) AT=30.025n

.meas tran vdout0_99ck50 FIND v(dout0_99) AT=30.025n

.meas tran vdout0_100ck50 FIND v(dout0_100) AT=30.025n

.meas tran vdout0_101ck50 FIND v(dout0_101) AT=30.025n

.meas tran vdout0_102ck50 FIND v(dout0_102) AT=30.025n

.meas tran vdout0_103ck50 FIND v(dout0_103) AT=30.025n

.meas tran vdout0_104ck50 FIND v(dout0_104) AT=30.025n

.meas tran vdout0_105ck50 FIND v(dout0_105) AT=30.025n

.meas tran vdout0_106ck50 FIND v(dout0_106) AT=30.025n

.meas tran vdout0_107ck50 FIND v(dout0_107) AT=30.025n

.meas tran vdout0_108ck50 FIND v(dout0_108) AT=30.025n

.meas tran vdout0_109ck50 FIND v(dout0_109) AT=30.025n

.meas tran vdout0_110ck50 FIND v(dout0_110) AT=30.025n

.meas tran vdout0_111ck50 FIND v(dout0_111) AT=30.025n

.meas tran vdout0_112ck50 FIND v(dout0_112) AT=30.025n

.meas tran vdout0_113ck50 FIND v(dout0_113) AT=30.025n

.meas tran vdout0_114ck50 FIND v(dout0_114) AT=30.025n

.meas tran vdout0_115ck50 FIND v(dout0_115) AT=30.025n

.meas tran vdout0_116ck50 FIND v(dout0_116) AT=30.025n

.meas tran vdout0_117ck50 FIND v(dout0_117) AT=30.025n

.meas tran vdout0_118ck50 FIND v(dout0_118) AT=30.025n

.meas tran vdout0_119ck50 FIND v(dout0_119) AT=30.025n

.meas tran vdout0_120ck50 FIND v(dout0_120) AT=30.025n

.meas tran vdout0_121ck50 FIND v(dout0_121) AT=30.025n

.meas tran vdout0_122ck50 FIND v(dout0_122) AT=30.025n

.meas tran vdout0_123ck50 FIND v(dout0_123) AT=30.025n

.meas tran vdout0_124ck50 FIND v(dout0_124) AT=30.025n

.meas tran vdout0_125ck50 FIND v(dout0_125) AT=30.025n

.meas tran vdout0_126ck50 FIND v(dout0_126) AT=30.025n

.meas tran vdout0_127ck50 FIND v(dout0_127) AT=30.025n

.meas tran vdout0_128ck50 FIND v(dout0_128) AT=30.025n

.meas tran vdout0_129ck50 FIND v(dout0_129) AT=30.025n

.meas tran vdout0_130ck50 FIND v(dout0_130) AT=30.025n

.meas tran vdout0_131ck50 FIND v(dout0_131) AT=30.025n

.meas tran vdout0_132ck50 FIND v(dout0_132) AT=30.025n

.meas tran vdout0_133ck50 FIND v(dout0_133) AT=30.025n

.meas tran vdout0_134ck50 FIND v(dout0_134) AT=30.025n

.meas tran vdout0_135ck50 FIND v(dout0_135) AT=30.025n

.meas tran vdout0_136ck50 FIND v(dout0_136) AT=30.025n

.meas tran vdout0_137ck50 FIND v(dout0_137) AT=30.025n

.meas tran vdout0_138ck50 FIND v(dout0_138) AT=30.025n

.meas tran vdout0_139ck50 FIND v(dout0_139) AT=30.025n

.meas tran vdout0_140ck50 FIND v(dout0_140) AT=30.025n

.meas tran vdout0_141ck50 FIND v(dout0_141) AT=30.025n

.meas tran vdout0_142ck50 FIND v(dout0_142) AT=30.025n

.meas tran vdout0_143ck50 FIND v(dout0_143) AT=30.025n

.meas tran vdout0_144ck50 FIND v(dout0_144) AT=30.025n

.meas tran vdout0_145ck50 FIND v(dout0_145) AT=30.025n

.meas tran vdout0_146ck50 FIND v(dout0_146) AT=30.025n

.meas tran vdout0_147ck50 FIND v(dout0_147) AT=30.025n

.meas tran vdout0_148ck50 FIND v(dout0_148) AT=30.025n

.meas tran vdout0_149ck50 FIND v(dout0_149) AT=30.025n

.meas tran vdout0_150ck50 FIND v(dout0_150) AT=30.025n

.meas tran vdout0_151ck50 FIND v(dout0_151) AT=30.025n

.meas tran vdout0_152ck50 FIND v(dout0_152) AT=30.025n

.meas tran vdout0_153ck50 FIND v(dout0_153) AT=30.025n

.meas tran vdout0_154ck50 FIND v(dout0_154) AT=30.025n

.meas tran vdout0_155ck50 FIND v(dout0_155) AT=30.025n

.meas tran vdout0_156ck50 FIND v(dout0_156) AT=30.025n

.meas tran vdout0_157ck50 FIND v(dout0_157) AT=30.025n

.meas tran vdout0_158ck50 FIND v(dout0_158) AT=30.025n

.meas tran vdout0_159ck50 FIND v(dout0_159) AT=30.025n

.meas tran vdout0_160ck50 FIND v(dout0_160) AT=30.025n

.meas tran vdout0_161ck50 FIND v(dout0_161) AT=30.025n

.meas tran vdout0_162ck50 FIND v(dout0_162) AT=30.025n

.meas tran vdout0_163ck50 FIND v(dout0_163) AT=30.025n

.meas tran vdout0_164ck50 FIND v(dout0_164) AT=30.025n

.meas tran vdout0_165ck50 FIND v(dout0_165) AT=30.025n

.meas tran vdout0_166ck50 FIND v(dout0_166) AT=30.025n

.meas tran vdout0_167ck50 FIND v(dout0_167) AT=30.025n

.meas tran vdout0_168ck50 FIND v(dout0_168) AT=30.025n

.meas tran vdout0_169ck50 FIND v(dout0_169) AT=30.025n

.meas tran vdout0_170ck50 FIND v(dout0_170) AT=30.025n

.meas tran vdout0_171ck50 FIND v(dout0_171) AT=30.025n

.meas tran vdout0_172ck50 FIND v(dout0_172) AT=30.025n

.meas tran vdout0_173ck50 FIND v(dout0_173) AT=30.025n

.meas tran vdout0_174ck50 FIND v(dout0_174) AT=30.025n

.meas tran vdout0_175ck50 FIND v(dout0_175) AT=30.025n

.meas tran vdout0_176ck50 FIND v(dout0_176) AT=30.025n

.meas tran vdout0_177ck50 FIND v(dout0_177) AT=30.025n

.meas tran vdout0_178ck50 FIND v(dout0_178) AT=30.025n

.meas tran vdout0_179ck50 FIND v(dout0_179) AT=30.025n

.meas tran vdout0_180ck50 FIND v(dout0_180) AT=30.025n

.meas tran vdout0_181ck50 FIND v(dout0_181) AT=30.025n

.meas tran vdout0_182ck50 FIND v(dout0_182) AT=30.025n

.meas tran vdout0_183ck50 FIND v(dout0_183) AT=30.025n

.meas tran vdout0_184ck50 FIND v(dout0_184) AT=30.025n

.meas tran vdout0_185ck50 FIND v(dout0_185) AT=30.025n

.meas tran vdout0_186ck50 FIND v(dout0_186) AT=30.025n

.meas tran vdout0_187ck50 FIND v(dout0_187) AT=30.025n

.meas tran vdout0_188ck50 FIND v(dout0_188) AT=30.025n

.meas tran vdout0_189ck50 FIND v(dout0_189) AT=30.025n

.meas tran vdout0_190ck50 FIND v(dout0_190) AT=30.025n

.meas tran vdout0_191ck50 FIND v(dout0_191) AT=30.025n

.meas tran vdout0_192ck50 FIND v(dout0_192) AT=30.025n

.meas tran vdout0_193ck50 FIND v(dout0_193) AT=30.025n

.meas tran vdout0_194ck50 FIND v(dout0_194) AT=30.025n

.meas tran vdout0_195ck50 FIND v(dout0_195) AT=30.025n

.meas tran vdout0_196ck50 FIND v(dout0_196) AT=30.025n

.meas tran vdout0_197ck50 FIND v(dout0_197) AT=30.025n

.meas tran vdout0_198ck50 FIND v(dout0_198) AT=30.025n

.meas tran vdout0_199ck50 FIND v(dout0_199) AT=30.025n

.meas tran vdout0_200ck50 FIND v(dout0_200) AT=30.025n

.meas tran vdout0_201ck50 FIND v(dout0_201) AT=30.025n

.meas tran vdout0_202ck50 FIND v(dout0_202) AT=30.025n

.meas tran vdout0_203ck50 FIND v(dout0_203) AT=30.025n

.meas tran vdout0_204ck50 FIND v(dout0_204) AT=30.025n

.meas tran vdout0_205ck50 FIND v(dout0_205) AT=30.025n

.meas tran vdout0_206ck50 FIND v(dout0_206) AT=30.025n

.meas tran vdout0_207ck50 FIND v(dout0_207) AT=30.025n

.meas tran vdout0_208ck50 FIND v(dout0_208) AT=30.025n

.meas tran vdout0_209ck50 FIND v(dout0_209) AT=30.025n

.meas tran vdout0_210ck50 FIND v(dout0_210) AT=30.025n

.meas tran vdout0_211ck50 FIND v(dout0_211) AT=30.025n

.meas tran vdout0_212ck50 FIND v(dout0_212) AT=30.025n

.meas tran vdout0_213ck50 FIND v(dout0_213) AT=30.025n

.meas tran vdout0_214ck50 FIND v(dout0_214) AT=30.025n

.meas tran vdout0_215ck50 FIND v(dout0_215) AT=30.025n

.meas tran vdout0_216ck50 FIND v(dout0_216) AT=30.025n

.meas tran vdout0_217ck50 FIND v(dout0_217) AT=30.025n

.meas tran vdout0_218ck50 FIND v(dout0_218) AT=30.025n

.meas tran vdout0_219ck50 FIND v(dout0_219) AT=30.025n

.meas tran vdout0_220ck50 FIND v(dout0_220) AT=30.025n

.meas tran vdout0_221ck50 FIND v(dout0_221) AT=30.025n

.meas tran vdout0_222ck50 FIND v(dout0_222) AT=30.025n

.meas tran vdout0_223ck50 FIND v(dout0_223) AT=30.025n

.meas tran vdout0_224ck50 FIND v(dout0_224) AT=30.025n

.meas tran vdout0_225ck50 FIND v(dout0_225) AT=30.025n

.meas tran vdout0_226ck50 FIND v(dout0_226) AT=30.025n

.meas tran vdout0_227ck50 FIND v(dout0_227) AT=30.025n

.meas tran vdout0_228ck50 FIND v(dout0_228) AT=30.025n

.meas tran vdout0_229ck50 FIND v(dout0_229) AT=30.025n

.meas tran vdout0_230ck50 FIND v(dout0_230) AT=30.025n

.meas tran vdout0_231ck50 FIND v(dout0_231) AT=30.025n

.meas tran vdout0_232ck50 FIND v(dout0_232) AT=30.025n

.meas tran vdout0_233ck50 FIND v(dout0_233) AT=30.025n

.meas tran vdout0_234ck50 FIND v(dout0_234) AT=30.025n

.meas tran vdout0_235ck50 FIND v(dout0_235) AT=30.025n

.meas tran vdout0_236ck50 FIND v(dout0_236) AT=30.025n

.meas tran vdout0_237ck50 FIND v(dout0_237) AT=30.025n

.meas tran vdout0_238ck50 FIND v(dout0_238) AT=30.025n

.meas tran vdout0_239ck50 FIND v(dout0_239) AT=30.025n

.meas tran vdout0_240ck50 FIND v(dout0_240) AT=30.025n

.meas tran vdout0_241ck50 FIND v(dout0_241) AT=30.025n

.meas tran vdout0_242ck50 FIND v(dout0_242) AT=30.025n

.meas tran vdout0_243ck50 FIND v(dout0_243) AT=30.025n

.meas tran vdout0_244ck50 FIND v(dout0_244) AT=30.025n

.meas tran vdout0_245ck50 FIND v(dout0_245) AT=30.025n

.meas tran vdout0_246ck50 FIND v(dout0_246) AT=30.025n

.meas tran vdout0_247ck50 FIND v(dout0_247) AT=30.025n

.meas tran vdout0_248ck50 FIND v(dout0_248) AT=30.025n

.meas tran vdout0_249ck50 FIND v(dout0_249) AT=30.025n

.meas tran vdout0_250ck50 FIND v(dout0_250) AT=30.025n

.meas tran vdout0_251ck50 FIND v(dout0_251) AT=30.025n

.meas tran vdout0_252ck50 FIND v(dout0_252) AT=30.025n

.meas tran vdout0_253ck50 FIND v(dout0_253) AT=30.025n

.meas tran vdout0_254ck50 FIND v(dout0_254) AT=30.025n

.meas tran vdout0_255ck50 FIND v(dout0_255) AT=30.025n

.meas tran vdout0_0ck90 FIND v(dout0_0) AT=50.025n

.meas tran vdout0_1ck90 FIND v(dout0_1) AT=50.025n

.meas tran vdout0_2ck90 FIND v(dout0_2) AT=50.025n

.meas tran vdout0_3ck90 FIND v(dout0_3) AT=50.025n

.meas tran vdout0_4ck90 FIND v(dout0_4) AT=50.025n

.meas tran vdout0_5ck90 FIND v(dout0_5) AT=50.025n

.meas tran vdout0_6ck90 FIND v(dout0_6) AT=50.025n

.meas tran vdout0_7ck90 FIND v(dout0_7) AT=50.025n

.meas tran vdout0_8ck90 FIND v(dout0_8) AT=50.025n

.meas tran vdout0_9ck90 FIND v(dout0_9) AT=50.025n

.meas tran vdout0_10ck90 FIND v(dout0_10) AT=50.025n

.meas tran vdout0_11ck90 FIND v(dout0_11) AT=50.025n

.meas tran vdout0_12ck90 FIND v(dout0_12) AT=50.025n

.meas tran vdout0_13ck90 FIND v(dout0_13) AT=50.025n

.meas tran vdout0_14ck90 FIND v(dout0_14) AT=50.025n

.meas tran vdout0_15ck90 FIND v(dout0_15) AT=50.025n

.meas tran vdout0_16ck90 FIND v(dout0_16) AT=50.025n

.meas tran vdout0_17ck90 FIND v(dout0_17) AT=50.025n

.meas tran vdout0_18ck90 FIND v(dout0_18) AT=50.025n

.meas tran vdout0_19ck90 FIND v(dout0_19) AT=50.025n

.meas tran vdout0_20ck90 FIND v(dout0_20) AT=50.025n

.meas tran vdout0_21ck90 FIND v(dout0_21) AT=50.025n

.meas tran vdout0_22ck90 FIND v(dout0_22) AT=50.025n

.meas tran vdout0_23ck90 FIND v(dout0_23) AT=50.025n

.meas tran vdout0_24ck90 FIND v(dout0_24) AT=50.025n

.meas tran vdout0_25ck90 FIND v(dout0_25) AT=50.025n

.meas tran vdout0_26ck90 FIND v(dout0_26) AT=50.025n

.meas tran vdout0_27ck90 FIND v(dout0_27) AT=50.025n

.meas tran vdout0_28ck90 FIND v(dout0_28) AT=50.025n

.meas tran vdout0_29ck90 FIND v(dout0_29) AT=50.025n

.meas tran vdout0_30ck90 FIND v(dout0_30) AT=50.025n

.meas tran vdout0_31ck90 FIND v(dout0_31) AT=50.025n

.meas tran vdout0_32ck90 FIND v(dout0_32) AT=50.025n

.meas tran vdout0_33ck90 FIND v(dout0_33) AT=50.025n

.meas tran vdout0_34ck90 FIND v(dout0_34) AT=50.025n

.meas tran vdout0_35ck90 FIND v(dout0_35) AT=50.025n

.meas tran vdout0_36ck90 FIND v(dout0_36) AT=50.025n

.meas tran vdout0_37ck90 FIND v(dout0_37) AT=50.025n

.meas tran vdout0_38ck90 FIND v(dout0_38) AT=50.025n

.meas tran vdout0_39ck90 FIND v(dout0_39) AT=50.025n

.meas tran vdout0_40ck90 FIND v(dout0_40) AT=50.025n

.meas tran vdout0_41ck90 FIND v(dout0_41) AT=50.025n

.meas tran vdout0_42ck90 FIND v(dout0_42) AT=50.025n

.meas tran vdout0_43ck90 FIND v(dout0_43) AT=50.025n

.meas tran vdout0_44ck90 FIND v(dout0_44) AT=50.025n

.meas tran vdout0_45ck90 FIND v(dout0_45) AT=50.025n

.meas tran vdout0_46ck90 FIND v(dout0_46) AT=50.025n

.meas tran vdout0_47ck90 FIND v(dout0_47) AT=50.025n

.meas tran vdout0_48ck90 FIND v(dout0_48) AT=50.025n

.meas tran vdout0_49ck90 FIND v(dout0_49) AT=50.025n

.meas tran vdout0_50ck90 FIND v(dout0_50) AT=50.025n

.meas tran vdout0_51ck90 FIND v(dout0_51) AT=50.025n

.meas tran vdout0_52ck90 FIND v(dout0_52) AT=50.025n

.meas tran vdout0_53ck90 FIND v(dout0_53) AT=50.025n

.meas tran vdout0_54ck90 FIND v(dout0_54) AT=50.025n

.meas tran vdout0_55ck90 FIND v(dout0_55) AT=50.025n

.meas tran vdout0_56ck90 FIND v(dout0_56) AT=50.025n

.meas tran vdout0_57ck90 FIND v(dout0_57) AT=50.025n

.meas tran vdout0_58ck90 FIND v(dout0_58) AT=50.025n

.meas tran vdout0_59ck90 FIND v(dout0_59) AT=50.025n

.meas tran vdout0_60ck90 FIND v(dout0_60) AT=50.025n

.meas tran vdout0_61ck90 FIND v(dout0_61) AT=50.025n

.meas tran vdout0_62ck90 FIND v(dout0_62) AT=50.025n

.meas tran vdout0_63ck90 FIND v(dout0_63) AT=50.025n

.meas tran vdout0_64ck90 FIND v(dout0_64) AT=50.025n

.meas tran vdout0_65ck90 FIND v(dout0_65) AT=50.025n

.meas tran vdout0_66ck90 FIND v(dout0_66) AT=50.025n

.meas tran vdout0_67ck90 FIND v(dout0_67) AT=50.025n

.meas tran vdout0_68ck90 FIND v(dout0_68) AT=50.025n

.meas tran vdout0_69ck90 FIND v(dout0_69) AT=50.025n

.meas tran vdout0_70ck90 FIND v(dout0_70) AT=50.025n

.meas tran vdout0_71ck90 FIND v(dout0_71) AT=50.025n

.meas tran vdout0_72ck90 FIND v(dout0_72) AT=50.025n

.meas tran vdout0_73ck90 FIND v(dout0_73) AT=50.025n

.meas tran vdout0_74ck90 FIND v(dout0_74) AT=50.025n

.meas tran vdout0_75ck90 FIND v(dout0_75) AT=50.025n

.meas tran vdout0_76ck90 FIND v(dout0_76) AT=50.025n

.meas tran vdout0_77ck90 FIND v(dout0_77) AT=50.025n

.meas tran vdout0_78ck90 FIND v(dout0_78) AT=50.025n

.meas tran vdout0_79ck90 FIND v(dout0_79) AT=50.025n

.meas tran vdout0_80ck90 FIND v(dout0_80) AT=50.025n

.meas tran vdout0_81ck90 FIND v(dout0_81) AT=50.025n

.meas tran vdout0_82ck90 FIND v(dout0_82) AT=50.025n

.meas tran vdout0_83ck90 FIND v(dout0_83) AT=50.025n

.meas tran vdout0_84ck90 FIND v(dout0_84) AT=50.025n

.meas tran vdout0_85ck90 FIND v(dout0_85) AT=50.025n

.meas tran vdout0_86ck90 FIND v(dout0_86) AT=50.025n

.meas tran vdout0_87ck90 FIND v(dout0_87) AT=50.025n

.meas tran vdout0_88ck90 FIND v(dout0_88) AT=50.025n

.meas tran vdout0_89ck90 FIND v(dout0_89) AT=50.025n

.meas tran vdout0_90ck90 FIND v(dout0_90) AT=50.025n

.meas tran vdout0_91ck90 FIND v(dout0_91) AT=50.025n

.meas tran vdout0_92ck90 FIND v(dout0_92) AT=50.025n

.meas tran vdout0_93ck90 FIND v(dout0_93) AT=50.025n

.meas tran vdout0_94ck90 FIND v(dout0_94) AT=50.025n

.meas tran vdout0_95ck90 FIND v(dout0_95) AT=50.025n

.meas tran vdout0_96ck90 FIND v(dout0_96) AT=50.025n

.meas tran vdout0_97ck90 FIND v(dout0_97) AT=50.025n

.meas tran vdout0_98ck90 FIND v(dout0_98) AT=50.025n

.meas tran vdout0_99ck90 FIND v(dout0_99) AT=50.025n

.meas tran vdout0_100ck90 FIND v(dout0_100) AT=50.025n

.meas tran vdout0_101ck90 FIND v(dout0_101) AT=50.025n

.meas tran vdout0_102ck90 FIND v(dout0_102) AT=50.025n

.meas tran vdout0_103ck90 FIND v(dout0_103) AT=50.025n

.meas tran vdout0_104ck90 FIND v(dout0_104) AT=50.025n

.meas tran vdout0_105ck90 FIND v(dout0_105) AT=50.025n

.meas tran vdout0_106ck90 FIND v(dout0_106) AT=50.025n

.meas tran vdout0_107ck90 FIND v(dout0_107) AT=50.025n

.meas tran vdout0_108ck90 FIND v(dout0_108) AT=50.025n

.meas tran vdout0_109ck90 FIND v(dout0_109) AT=50.025n

.meas tran vdout0_110ck90 FIND v(dout0_110) AT=50.025n

.meas tran vdout0_111ck90 FIND v(dout0_111) AT=50.025n

.meas tran vdout0_112ck90 FIND v(dout0_112) AT=50.025n

.meas tran vdout0_113ck90 FIND v(dout0_113) AT=50.025n

.meas tran vdout0_114ck90 FIND v(dout0_114) AT=50.025n

.meas tran vdout0_115ck90 FIND v(dout0_115) AT=50.025n

.meas tran vdout0_116ck90 FIND v(dout0_116) AT=50.025n

.meas tran vdout0_117ck90 FIND v(dout0_117) AT=50.025n

.meas tran vdout0_118ck90 FIND v(dout0_118) AT=50.025n

.meas tran vdout0_119ck90 FIND v(dout0_119) AT=50.025n

.meas tran vdout0_120ck90 FIND v(dout0_120) AT=50.025n

.meas tran vdout0_121ck90 FIND v(dout0_121) AT=50.025n

.meas tran vdout0_122ck90 FIND v(dout0_122) AT=50.025n

.meas tran vdout0_123ck90 FIND v(dout0_123) AT=50.025n

.meas tran vdout0_124ck90 FIND v(dout0_124) AT=50.025n

.meas tran vdout0_125ck90 FIND v(dout0_125) AT=50.025n

.meas tran vdout0_126ck90 FIND v(dout0_126) AT=50.025n

.meas tran vdout0_127ck90 FIND v(dout0_127) AT=50.025n

.meas tran vdout0_128ck90 FIND v(dout0_128) AT=50.025n

.meas tran vdout0_129ck90 FIND v(dout0_129) AT=50.025n

.meas tran vdout0_130ck90 FIND v(dout0_130) AT=50.025n

.meas tran vdout0_131ck90 FIND v(dout0_131) AT=50.025n

.meas tran vdout0_132ck90 FIND v(dout0_132) AT=50.025n

.meas tran vdout0_133ck90 FIND v(dout0_133) AT=50.025n

.meas tran vdout0_134ck90 FIND v(dout0_134) AT=50.025n

.meas tran vdout0_135ck90 FIND v(dout0_135) AT=50.025n

.meas tran vdout0_136ck90 FIND v(dout0_136) AT=50.025n

.meas tran vdout0_137ck90 FIND v(dout0_137) AT=50.025n

.meas tran vdout0_138ck90 FIND v(dout0_138) AT=50.025n

.meas tran vdout0_139ck90 FIND v(dout0_139) AT=50.025n

.meas tran vdout0_140ck90 FIND v(dout0_140) AT=50.025n

.meas tran vdout0_141ck90 FIND v(dout0_141) AT=50.025n

.meas tran vdout0_142ck90 FIND v(dout0_142) AT=50.025n

.meas tran vdout0_143ck90 FIND v(dout0_143) AT=50.025n

.meas tran vdout0_144ck90 FIND v(dout0_144) AT=50.025n

.meas tran vdout0_145ck90 FIND v(dout0_145) AT=50.025n

.meas tran vdout0_146ck90 FIND v(dout0_146) AT=50.025n

.meas tran vdout0_147ck90 FIND v(dout0_147) AT=50.025n

.meas tran vdout0_148ck90 FIND v(dout0_148) AT=50.025n

.meas tran vdout0_149ck90 FIND v(dout0_149) AT=50.025n

.meas tran vdout0_150ck90 FIND v(dout0_150) AT=50.025n

.meas tran vdout0_151ck90 FIND v(dout0_151) AT=50.025n

.meas tran vdout0_152ck90 FIND v(dout0_152) AT=50.025n

.meas tran vdout0_153ck90 FIND v(dout0_153) AT=50.025n

.meas tran vdout0_154ck90 FIND v(dout0_154) AT=50.025n

.meas tran vdout0_155ck90 FIND v(dout0_155) AT=50.025n

.meas tran vdout0_156ck90 FIND v(dout0_156) AT=50.025n

.meas tran vdout0_157ck90 FIND v(dout0_157) AT=50.025n

.meas tran vdout0_158ck90 FIND v(dout0_158) AT=50.025n

.meas tran vdout0_159ck90 FIND v(dout0_159) AT=50.025n

.meas tran vdout0_160ck90 FIND v(dout0_160) AT=50.025n

.meas tran vdout0_161ck90 FIND v(dout0_161) AT=50.025n

.meas tran vdout0_162ck90 FIND v(dout0_162) AT=50.025n

.meas tran vdout0_163ck90 FIND v(dout0_163) AT=50.025n

.meas tran vdout0_164ck90 FIND v(dout0_164) AT=50.025n

.meas tran vdout0_165ck90 FIND v(dout0_165) AT=50.025n

.meas tran vdout0_166ck90 FIND v(dout0_166) AT=50.025n

.meas tran vdout0_167ck90 FIND v(dout0_167) AT=50.025n

.meas tran vdout0_168ck90 FIND v(dout0_168) AT=50.025n

.meas tran vdout0_169ck90 FIND v(dout0_169) AT=50.025n

.meas tran vdout0_170ck90 FIND v(dout0_170) AT=50.025n

.meas tran vdout0_171ck90 FIND v(dout0_171) AT=50.025n

.meas tran vdout0_172ck90 FIND v(dout0_172) AT=50.025n

.meas tran vdout0_173ck90 FIND v(dout0_173) AT=50.025n

.meas tran vdout0_174ck90 FIND v(dout0_174) AT=50.025n

.meas tran vdout0_175ck90 FIND v(dout0_175) AT=50.025n

.meas tran vdout0_176ck90 FIND v(dout0_176) AT=50.025n

.meas tran vdout0_177ck90 FIND v(dout0_177) AT=50.025n

.meas tran vdout0_178ck90 FIND v(dout0_178) AT=50.025n

.meas tran vdout0_179ck90 FIND v(dout0_179) AT=50.025n

.meas tran vdout0_180ck90 FIND v(dout0_180) AT=50.025n

.meas tran vdout0_181ck90 FIND v(dout0_181) AT=50.025n

.meas tran vdout0_182ck90 FIND v(dout0_182) AT=50.025n

.meas tran vdout0_183ck90 FIND v(dout0_183) AT=50.025n

.meas tran vdout0_184ck90 FIND v(dout0_184) AT=50.025n

.meas tran vdout0_185ck90 FIND v(dout0_185) AT=50.025n

.meas tran vdout0_186ck90 FIND v(dout0_186) AT=50.025n

.meas tran vdout0_187ck90 FIND v(dout0_187) AT=50.025n

.meas tran vdout0_188ck90 FIND v(dout0_188) AT=50.025n

.meas tran vdout0_189ck90 FIND v(dout0_189) AT=50.025n

.meas tran vdout0_190ck90 FIND v(dout0_190) AT=50.025n

.meas tran vdout0_191ck90 FIND v(dout0_191) AT=50.025n

.meas tran vdout0_192ck90 FIND v(dout0_192) AT=50.025n

.meas tran vdout0_193ck90 FIND v(dout0_193) AT=50.025n

.meas tran vdout0_194ck90 FIND v(dout0_194) AT=50.025n

.meas tran vdout0_195ck90 FIND v(dout0_195) AT=50.025n

.meas tran vdout0_196ck90 FIND v(dout0_196) AT=50.025n

.meas tran vdout0_197ck90 FIND v(dout0_197) AT=50.025n

.meas tran vdout0_198ck90 FIND v(dout0_198) AT=50.025n

.meas tran vdout0_199ck90 FIND v(dout0_199) AT=50.025n

.meas tran vdout0_200ck90 FIND v(dout0_200) AT=50.025n

.meas tran vdout0_201ck90 FIND v(dout0_201) AT=50.025n

.meas tran vdout0_202ck90 FIND v(dout0_202) AT=50.025n

.meas tran vdout0_203ck90 FIND v(dout0_203) AT=50.025n

.meas tran vdout0_204ck90 FIND v(dout0_204) AT=50.025n

.meas tran vdout0_205ck90 FIND v(dout0_205) AT=50.025n

.meas tran vdout0_206ck90 FIND v(dout0_206) AT=50.025n

.meas tran vdout0_207ck90 FIND v(dout0_207) AT=50.025n

.meas tran vdout0_208ck90 FIND v(dout0_208) AT=50.025n

.meas tran vdout0_209ck90 FIND v(dout0_209) AT=50.025n

.meas tran vdout0_210ck90 FIND v(dout0_210) AT=50.025n

.meas tran vdout0_211ck90 FIND v(dout0_211) AT=50.025n

.meas tran vdout0_212ck90 FIND v(dout0_212) AT=50.025n

.meas tran vdout0_213ck90 FIND v(dout0_213) AT=50.025n

.meas tran vdout0_214ck90 FIND v(dout0_214) AT=50.025n

.meas tran vdout0_215ck90 FIND v(dout0_215) AT=50.025n

.meas tran vdout0_216ck90 FIND v(dout0_216) AT=50.025n

.meas tran vdout0_217ck90 FIND v(dout0_217) AT=50.025n

.meas tran vdout0_218ck90 FIND v(dout0_218) AT=50.025n

.meas tran vdout0_219ck90 FIND v(dout0_219) AT=50.025n

.meas tran vdout0_220ck90 FIND v(dout0_220) AT=50.025n

.meas tran vdout0_221ck90 FIND v(dout0_221) AT=50.025n

.meas tran vdout0_222ck90 FIND v(dout0_222) AT=50.025n

.meas tran vdout0_223ck90 FIND v(dout0_223) AT=50.025n

.meas tran vdout0_224ck90 FIND v(dout0_224) AT=50.025n

.meas tran vdout0_225ck90 FIND v(dout0_225) AT=50.025n

.meas tran vdout0_226ck90 FIND v(dout0_226) AT=50.025n

.meas tran vdout0_227ck90 FIND v(dout0_227) AT=50.025n

.meas tran vdout0_228ck90 FIND v(dout0_228) AT=50.025n

.meas tran vdout0_229ck90 FIND v(dout0_229) AT=50.025n

.meas tran vdout0_230ck90 FIND v(dout0_230) AT=50.025n

.meas tran vdout0_231ck90 FIND v(dout0_231) AT=50.025n

.meas tran vdout0_232ck90 FIND v(dout0_232) AT=50.025n

.meas tran vdout0_233ck90 FIND v(dout0_233) AT=50.025n

.meas tran vdout0_234ck90 FIND v(dout0_234) AT=50.025n

.meas tran vdout0_235ck90 FIND v(dout0_235) AT=50.025n

.meas tran vdout0_236ck90 FIND v(dout0_236) AT=50.025n

.meas tran vdout0_237ck90 FIND v(dout0_237) AT=50.025n

.meas tran vdout0_238ck90 FIND v(dout0_238) AT=50.025n

.meas tran vdout0_239ck90 FIND v(dout0_239) AT=50.025n

.meas tran vdout0_240ck90 FIND v(dout0_240) AT=50.025n

.meas tran vdout0_241ck90 FIND v(dout0_241) AT=50.025n

.meas tran vdout0_242ck90 FIND v(dout0_242) AT=50.025n

.meas tran vdout0_243ck90 FIND v(dout0_243) AT=50.025n

.meas tran vdout0_244ck90 FIND v(dout0_244) AT=50.025n

.meas tran vdout0_245ck90 FIND v(dout0_245) AT=50.025n

.meas tran vdout0_246ck90 FIND v(dout0_246) AT=50.025n

.meas tran vdout0_247ck90 FIND v(dout0_247) AT=50.025n

.meas tran vdout0_248ck90 FIND v(dout0_248) AT=50.025n

.meas tran vdout0_249ck90 FIND v(dout0_249) AT=50.025n

.meas tran vdout0_250ck90 FIND v(dout0_250) AT=50.025n

.meas tran vdout0_251ck90 FIND v(dout0_251) AT=50.025n

.meas tran vdout0_252ck90 FIND v(dout0_252) AT=50.025n

.meas tran vdout0_253ck90 FIND v(dout0_253) AT=50.025n

.meas tran vdout0_254ck90 FIND v(dout0_254) AT=50.025n

.meas tran vdout0_255ck90 FIND v(dout0_255) AT=50.025n

.meas tran vdout0_0ck120 FIND v(dout0_0) AT=65.025n

.meas tran vdout0_1ck120 FIND v(dout0_1) AT=65.025n

.meas tran vdout0_2ck120 FIND v(dout0_2) AT=65.025n

.meas tran vdout0_3ck120 FIND v(dout0_3) AT=65.025n

.meas tran vdout0_4ck120 FIND v(dout0_4) AT=65.025n

.meas tran vdout0_5ck120 FIND v(dout0_5) AT=65.025n

.meas tran vdout0_6ck120 FIND v(dout0_6) AT=65.025n

.meas tran vdout0_7ck120 FIND v(dout0_7) AT=65.025n

.meas tran vdout0_8ck120 FIND v(dout0_8) AT=65.025n

.meas tran vdout0_9ck120 FIND v(dout0_9) AT=65.025n

.meas tran vdout0_10ck120 FIND v(dout0_10) AT=65.025n

.meas tran vdout0_11ck120 FIND v(dout0_11) AT=65.025n

.meas tran vdout0_12ck120 FIND v(dout0_12) AT=65.025n

.meas tran vdout0_13ck120 FIND v(dout0_13) AT=65.025n

.meas tran vdout0_14ck120 FIND v(dout0_14) AT=65.025n

.meas tran vdout0_15ck120 FIND v(dout0_15) AT=65.025n

.meas tran vdout0_16ck120 FIND v(dout0_16) AT=65.025n

.meas tran vdout0_17ck120 FIND v(dout0_17) AT=65.025n

.meas tran vdout0_18ck120 FIND v(dout0_18) AT=65.025n

.meas tran vdout0_19ck120 FIND v(dout0_19) AT=65.025n

.meas tran vdout0_20ck120 FIND v(dout0_20) AT=65.025n

.meas tran vdout0_21ck120 FIND v(dout0_21) AT=65.025n

.meas tran vdout0_22ck120 FIND v(dout0_22) AT=65.025n

.meas tran vdout0_23ck120 FIND v(dout0_23) AT=65.025n

.meas tran vdout0_24ck120 FIND v(dout0_24) AT=65.025n

.meas tran vdout0_25ck120 FIND v(dout0_25) AT=65.025n

.meas tran vdout0_26ck120 FIND v(dout0_26) AT=65.025n

.meas tran vdout0_27ck120 FIND v(dout0_27) AT=65.025n

.meas tran vdout0_28ck120 FIND v(dout0_28) AT=65.025n

.meas tran vdout0_29ck120 FIND v(dout0_29) AT=65.025n

.meas tran vdout0_30ck120 FIND v(dout0_30) AT=65.025n

.meas tran vdout0_31ck120 FIND v(dout0_31) AT=65.025n

.meas tran vdout0_32ck120 FIND v(dout0_32) AT=65.025n

.meas tran vdout0_33ck120 FIND v(dout0_33) AT=65.025n

.meas tran vdout0_34ck120 FIND v(dout0_34) AT=65.025n

.meas tran vdout0_35ck120 FIND v(dout0_35) AT=65.025n

.meas tran vdout0_36ck120 FIND v(dout0_36) AT=65.025n

.meas tran vdout0_37ck120 FIND v(dout0_37) AT=65.025n

.meas tran vdout0_38ck120 FIND v(dout0_38) AT=65.025n

.meas tran vdout0_39ck120 FIND v(dout0_39) AT=65.025n

.meas tran vdout0_40ck120 FIND v(dout0_40) AT=65.025n

.meas tran vdout0_41ck120 FIND v(dout0_41) AT=65.025n

.meas tran vdout0_42ck120 FIND v(dout0_42) AT=65.025n

.meas tran vdout0_43ck120 FIND v(dout0_43) AT=65.025n

.meas tran vdout0_44ck120 FIND v(dout0_44) AT=65.025n

.meas tran vdout0_45ck120 FIND v(dout0_45) AT=65.025n

.meas tran vdout0_46ck120 FIND v(dout0_46) AT=65.025n

.meas tran vdout0_47ck120 FIND v(dout0_47) AT=65.025n

.meas tran vdout0_48ck120 FIND v(dout0_48) AT=65.025n

.meas tran vdout0_49ck120 FIND v(dout0_49) AT=65.025n

.meas tran vdout0_50ck120 FIND v(dout0_50) AT=65.025n

.meas tran vdout0_51ck120 FIND v(dout0_51) AT=65.025n

.meas tran vdout0_52ck120 FIND v(dout0_52) AT=65.025n

.meas tran vdout0_53ck120 FIND v(dout0_53) AT=65.025n

.meas tran vdout0_54ck120 FIND v(dout0_54) AT=65.025n

.meas tran vdout0_55ck120 FIND v(dout0_55) AT=65.025n

.meas tran vdout0_56ck120 FIND v(dout0_56) AT=65.025n

.meas tran vdout0_57ck120 FIND v(dout0_57) AT=65.025n

.meas tran vdout0_58ck120 FIND v(dout0_58) AT=65.025n

.meas tran vdout0_59ck120 FIND v(dout0_59) AT=65.025n

.meas tran vdout0_60ck120 FIND v(dout0_60) AT=65.025n

.meas tran vdout0_61ck120 FIND v(dout0_61) AT=65.025n

.meas tran vdout0_62ck120 FIND v(dout0_62) AT=65.025n

.meas tran vdout0_63ck120 FIND v(dout0_63) AT=65.025n

.meas tran vdout0_64ck120 FIND v(dout0_64) AT=65.025n

.meas tran vdout0_65ck120 FIND v(dout0_65) AT=65.025n

.meas tran vdout0_66ck120 FIND v(dout0_66) AT=65.025n

.meas tran vdout0_67ck120 FIND v(dout0_67) AT=65.025n

.meas tran vdout0_68ck120 FIND v(dout0_68) AT=65.025n

.meas tran vdout0_69ck120 FIND v(dout0_69) AT=65.025n

.meas tran vdout0_70ck120 FIND v(dout0_70) AT=65.025n

.meas tran vdout0_71ck120 FIND v(dout0_71) AT=65.025n

.meas tran vdout0_72ck120 FIND v(dout0_72) AT=65.025n

.meas tran vdout0_73ck120 FIND v(dout0_73) AT=65.025n

.meas tran vdout0_74ck120 FIND v(dout0_74) AT=65.025n

.meas tran vdout0_75ck120 FIND v(dout0_75) AT=65.025n

.meas tran vdout0_76ck120 FIND v(dout0_76) AT=65.025n

.meas tran vdout0_77ck120 FIND v(dout0_77) AT=65.025n

.meas tran vdout0_78ck120 FIND v(dout0_78) AT=65.025n

.meas tran vdout0_79ck120 FIND v(dout0_79) AT=65.025n

.meas tran vdout0_80ck120 FIND v(dout0_80) AT=65.025n

.meas tran vdout0_81ck120 FIND v(dout0_81) AT=65.025n

.meas tran vdout0_82ck120 FIND v(dout0_82) AT=65.025n

.meas tran vdout0_83ck120 FIND v(dout0_83) AT=65.025n

.meas tran vdout0_84ck120 FIND v(dout0_84) AT=65.025n

.meas tran vdout0_85ck120 FIND v(dout0_85) AT=65.025n

.meas tran vdout0_86ck120 FIND v(dout0_86) AT=65.025n

.meas tran vdout0_87ck120 FIND v(dout0_87) AT=65.025n

.meas tran vdout0_88ck120 FIND v(dout0_88) AT=65.025n

.meas tran vdout0_89ck120 FIND v(dout0_89) AT=65.025n

.meas tran vdout0_90ck120 FIND v(dout0_90) AT=65.025n

.meas tran vdout0_91ck120 FIND v(dout0_91) AT=65.025n

.meas tran vdout0_92ck120 FIND v(dout0_92) AT=65.025n

.meas tran vdout0_93ck120 FIND v(dout0_93) AT=65.025n

.meas tran vdout0_94ck120 FIND v(dout0_94) AT=65.025n

.meas tran vdout0_95ck120 FIND v(dout0_95) AT=65.025n

.meas tran vdout0_96ck120 FIND v(dout0_96) AT=65.025n

.meas tran vdout0_97ck120 FIND v(dout0_97) AT=65.025n

.meas tran vdout0_98ck120 FIND v(dout0_98) AT=65.025n

.meas tran vdout0_99ck120 FIND v(dout0_99) AT=65.025n

.meas tran vdout0_100ck120 FIND v(dout0_100) AT=65.025n

.meas tran vdout0_101ck120 FIND v(dout0_101) AT=65.025n

.meas tran vdout0_102ck120 FIND v(dout0_102) AT=65.025n

.meas tran vdout0_103ck120 FIND v(dout0_103) AT=65.025n

.meas tran vdout0_104ck120 FIND v(dout0_104) AT=65.025n

.meas tran vdout0_105ck120 FIND v(dout0_105) AT=65.025n

.meas tran vdout0_106ck120 FIND v(dout0_106) AT=65.025n

.meas tran vdout0_107ck120 FIND v(dout0_107) AT=65.025n

.meas tran vdout0_108ck120 FIND v(dout0_108) AT=65.025n

.meas tran vdout0_109ck120 FIND v(dout0_109) AT=65.025n

.meas tran vdout0_110ck120 FIND v(dout0_110) AT=65.025n

.meas tran vdout0_111ck120 FIND v(dout0_111) AT=65.025n

.meas tran vdout0_112ck120 FIND v(dout0_112) AT=65.025n

.meas tran vdout0_113ck120 FIND v(dout0_113) AT=65.025n

.meas tran vdout0_114ck120 FIND v(dout0_114) AT=65.025n

.meas tran vdout0_115ck120 FIND v(dout0_115) AT=65.025n

.meas tran vdout0_116ck120 FIND v(dout0_116) AT=65.025n

.meas tran vdout0_117ck120 FIND v(dout0_117) AT=65.025n

.meas tran vdout0_118ck120 FIND v(dout0_118) AT=65.025n

.meas tran vdout0_119ck120 FIND v(dout0_119) AT=65.025n

.meas tran vdout0_120ck120 FIND v(dout0_120) AT=65.025n

.meas tran vdout0_121ck120 FIND v(dout0_121) AT=65.025n

.meas tran vdout0_122ck120 FIND v(dout0_122) AT=65.025n

.meas tran vdout0_123ck120 FIND v(dout0_123) AT=65.025n

.meas tran vdout0_124ck120 FIND v(dout0_124) AT=65.025n

.meas tran vdout0_125ck120 FIND v(dout0_125) AT=65.025n

.meas tran vdout0_126ck120 FIND v(dout0_126) AT=65.025n

.meas tran vdout0_127ck120 FIND v(dout0_127) AT=65.025n

.meas tran vdout0_128ck120 FIND v(dout0_128) AT=65.025n

.meas tran vdout0_129ck120 FIND v(dout0_129) AT=65.025n

.meas tran vdout0_130ck120 FIND v(dout0_130) AT=65.025n

.meas tran vdout0_131ck120 FIND v(dout0_131) AT=65.025n

.meas tran vdout0_132ck120 FIND v(dout0_132) AT=65.025n

.meas tran vdout0_133ck120 FIND v(dout0_133) AT=65.025n

.meas tran vdout0_134ck120 FIND v(dout0_134) AT=65.025n

.meas tran vdout0_135ck120 FIND v(dout0_135) AT=65.025n

.meas tran vdout0_136ck120 FIND v(dout0_136) AT=65.025n

.meas tran vdout0_137ck120 FIND v(dout0_137) AT=65.025n

.meas tran vdout0_138ck120 FIND v(dout0_138) AT=65.025n

.meas tran vdout0_139ck120 FIND v(dout0_139) AT=65.025n

.meas tran vdout0_140ck120 FIND v(dout0_140) AT=65.025n

.meas tran vdout0_141ck120 FIND v(dout0_141) AT=65.025n

.meas tran vdout0_142ck120 FIND v(dout0_142) AT=65.025n

.meas tran vdout0_143ck120 FIND v(dout0_143) AT=65.025n

.meas tran vdout0_144ck120 FIND v(dout0_144) AT=65.025n

.meas tran vdout0_145ck120 FIND v(dout0_145) AT=65.025n

.meas tran vdout0_146ck120 FIND v(dout0_146) AT=65.025n

.meas tran vdout0_147ck120 FIND v(dout0_147) AT=65.025n

.meas tran vdout0_148ck120 FIND v(dout0_148) AT=65.025n

.meas tran vdout0_149ck120 FIND v(dout0_149) AT=65.025n

.meas tran vdout0_150ck120 FIND v(dout0_150) AT=65.025n

.meas tran vdout0_151ck120 FIND v(dout0_151) AT=65.025n

.meas tran vdout0_152ck120 FIND v(dout0_152) AT=65.025n

.meas tran vdout0_153ck120 FIND v(dout0_153) AT=65.025n

.meas tran vdout0_154ck120 FIND v(dout0_154) AT=65.025n

.meas tran vdout0_155ck120 FIND v(dout0_155) AT=65.025n

.meas tran vdout0_156ck120 FIND v(dout0_156) AT=65.025n

.meas tran vdout0_157ck120 FIND v(dout0_157) AT=65.025n

.meas tran vdout0_158ck120 FIND v(dout0_158) AT=65.025n

.meas tran vdout0_159ck120 FIND v(dout0_159) AT=65.025n

.meas tran vdout0_160ck120 FIND v(dout0_160) AT=65.025n

.meas tran vdout0_161ck120 FIND v(dout0_161) AT=65.025n

.meas tran vdout0_162ck120 FIND v(dout0_162) AT=65.025n

.meas tran vdout0_163ck120 FIND v(dout0_163) AT=65.025n

.meas tran vdout0_164ck120 FIND v(dout0_164) AT=65.025n

.meas tran vdout0_165ck120 FIND v(dout0_165) AT=65.025n

.meas tran vdout0_166ck120 FIND v(dout0_166) AT=65.025n

.meas tran vdout0_167ck120 FIND v(dout0_167) AT=65.025n

.meas tran vdout0_168ck120 FIND v(dout0_168) AT=65.025n

.meas tran vdout0_169ck120 FIND v(dout0_169) AT=65.025n

.meas tran vdout0_170ck120 FIND v(dout0_170) AT=65.025n

.meas tran vdout0_171ck120 FIND v(dout0_171) AT=65.025n

.meas tran vdout0_172ck120 FIND v(dout0_172) AT=65.025n

.meas tran vdout0_173ck120 FIND v(dout0_173) AT=65.025n

.meas tran vdout0_174ck120 FIND v(dout0_174) AT=65.025n

.meas tran vdout0_175ck120 FIND v(dout0_175) AT=65.025n

.meas tran vdout0_176ck120 FIND v(dout0_176) AT=65.025n

.meas tran vdout0_177ck120 FIND v(dout0_177) AT=65.025n

.meas tran vdout0_178ck120 FIND v(dout0_178) AT=65.025n

.meas tran vdout0_179ck120 FIND v(dout0_179) AT=65.025n

.meas tran vdout0_180ck120 FIND v(dout0_180) AT=65.025n

.meas tran vdout0_181ck120 FIND v(dout0_181) AT=65.025n

.meas tran vdout0_182ck120 FIND v(dout0_182) AT=65.025n

.meas tran vdout0_183ck120 FIND v(dout0_183) AT=65.025n

.meas tran vdout0_184ck120 FIND v(dout0_184) AT=65.025n

.meas tran vdout0_185ck120 FIND v(dout0_185) AT=65.025n

.meas tran vdout0_186ck120 FIND v(dout0_186) AT=65.025n

.meas tran vdout0_187ck120 FIND v(dout0_187) AT=65.025n

.meas tran vdout0_188ck120 FIND v(dout0_188) AT=65.025n

.meas tran vdout0_189ck120 FIND v(dout0_189) AT=65.025n

.meas tran vdout0_190ck120 FIND v(dout0_190) AT=65.025n

.meas tran vdout0_191ck120 FIND v(dout0_191) AT=65.025n

.meas tran vdout0_192ck120 FIND v(dout0_192) AT=65.025n

.meas tran vdout0_193ck120 FIND v(dout0_193) AT=65.025n

.meas tran vdout0_194ck120 FIND v(dout0_194) AT=65.025n

.meas tran vdout0_195ck120 FIND v(dout0_195) AT=65.025n

.meas tran vdout0_196ck120 FIND v(dout0_196) AT=65.025n

.meas tran vdout0_197ck120 FIND v(dout0_197) AT=65.025n

.meas tran vdout0_198ck120 FIND v(dout0_198) AT=65.025n

.meas tran vdout0_199ck120 FIND v(dout0_199) AT=65.025n

.meas tran vdout0_200ck120 FIND v(dout0_200) AT=65.025n

.meas tran vdout0_201ck120 FIND v(dout0_201) AT=65.025n

.meas tran vdout0_202ck120 FIND v(dout0_202) AT=65.025n

.meas tran vdout0_203ck120 FIND v(dout0_203) AT=65.025n

.meas tran vdout0_204ck120 FIND v(dout0_204) AT=65.025n

.meas tran vdout0_205ck120 FIND v(dout0_205) AT=65.025n

.meas tran vdout0_206ck120 FIND v(dout0_206) AT=65.025n

.meas tran vdout0_207ck120 FIND v(dout0_207) AT=65.025n

.meas tran vdout0_208ck120 FIND v(dout0_208) AT=65.025n

.meas tran vdout0_209ck120 FIND v(dout0_209) AT=65.025n

.meas tran vdout0_210ck120 FIND v(dout0_210) AT=65.025n

.meas tran vdout0_211ck120 FIND v(dout0_211) AT=65.025n

.meas tran vdout0_212ck120 FIND v(dout0_212) AT=65.025n

.meas tran vdout0_213ck120 FIND v(dout0_213) AT=65.025n

.meas tran vdout0_214ck120 FIND v(dout0_214) AT=65.025n

.meas tran vdout0_215ck120 FIND v(dout0_215) AT=65.025n

.meas tran vdout0_216ck120 FIND v(dout0_216) AT=65.025n

.meas tran vdout0_217ck120 FIND v(dout0_217) AT=65.025n

.meas tran vdout0_218ck120 FIND v(dout0_218) AT=65.025n

.meas tran vdout0_219ck120 FIND v(dout0_219) AT=65.025n

.meas tran vdout0_220ck120 FIND v(dout0_220) AT=65.025n

.meas tran vdout0_221ck120 FIND v(dout0_221) AT=65.025n

.meas tran vdout0_222ck120 FIND v(dout0_222) AT=65.025n

.meas tran vdout0_223ck120 FIND v(dout0_223) AT=65.025n

.meas tran vdout0_224ck120 FIND v(dout0_224) AT=65.025n

.meas tran vdout0_225ck120 FIND v(dout0_225) AT=65.025n

.meas tran vdout0_226ck120 FIND v(dout0_226) AT=65.025n

.meas tran vdout0_227ck120 FIND v(dout0_227) AT=65.025n

.meas tran vdout0_228ck120 FIND v(dout0_228) AT=65.025n

.meas tran vdout0_229ck120 FIND v(dout0_229) AT=65.025n

.meas tran vdout0_230ck120 FIND v(dout0_230) AT=65.025n

.meas tran vdout0_231ck120 FIND v(dout0_231) AT=65.025n

.meas tran vdout0_232ck120 FIND v(dout0_232) AT=65.025n

.meas tran vdout0_233ck120 FIND v(dout0_233) AT=65.025n

.meas tran vdout0_234ck120 FIND v(dout0_234) AT=65.025n

.meas tran vdout0_235ck120 FIND v(dout0_235) AT=65.025n

.meas tran vdout0_236ck120 FIND v(dout0_236) AT=65.025n

.meas tran vdout0_237ck120 FIND v(dout0_237) AT=65.025n

.meas tran vdout0_238ck120 FIND v(dout0_238) AT=65.025n

.meas tran vdout0_239ck120 FIND v(dout0_239) AT=65.025n

.meas tran vdout0_240ck120 FIND v(dout0_240) AT=65.025n

.meas tran vdout0_241ck120 FIND v(dout0_241) AT=65.025n

.meas tran vdout0_242ck120 FIND v(dout0_242) AT=65.025n

.meas tran vdout0_243ck120 FIND v(dout0_243) AT=65.025n

.meas tran vdout0_244ck120 FIND v(dout0_244) AT=65.025n

.meas tran vdout0_245ck120 FIND v(dout0_245) AT=65.025n

.meas tran vdout0_246ck120 FIND v(dout0_246) AT=65.025n

.meas tran vdout0_247ck120 FIND v(dout0_247) AT=65.025n

.meas tran vdout0_248ck120 FIND v(dout0_248) AT=65.025n

.meas tran vdout0_249ck120 FIND v(dout0_249) AT=65.025n

.meas tran vdout0_250ck120 FIND v(dout0_250) AT=65.025n

.meas tran vdout0_251ck120 FIND v(dout0_251) AT=65.025n

.meas tran vdout0_252ck120 FIND v(dout0_252) AT=65.025n

.meas tran vdout0_253ck120 FIND v(dout0_253) AT=65.025n

.meas tran vdout0_254ck120 FIND v(dout0_254) AT=65.025n

.meas tran vdout0_255ck120 FIND v(dout0_255) AT=65.025n

.meas tran vdout0_0ck140 FIND v(dout0_0) AT=75.025n

.meas tran vdout0_1ck140 FIND v(dout0_1) AT=75.025n

.meas tran vdout0_2ck140 FIND v(dout0_2) AT=75.025n

.meas tran vdout0_3ck140 FIND v(dout0_3) AT=75.025n

.meas tran vdout0_4ck140 FIND v(dout0_4) AT=75.025n

.meas tran vdout0_5ck140 FIND v(dout0_5) AT=75.025n

.meas tran vdout0_6ck140 FIND v(dout0_6) AT=75.025n

.meas tran vdout0_7ck140 FIND v(dout0_7) AT=75.025n

.meas tran vdout0_8ck140 FIND v(dout0_8) AT=75.025n

.meas tran vdout0_9ck140 FIND v(dout0_9) AT=75.025n

.meas tran vdout0_10ck140 FIND v(dout0_10) AT=75.025n

.meas tran vdout0_11ck140 FIND v(dout0_11) AT=75.025n

.meas tran vdout0_12ck140 FIND v(dout0_12) AT=75.025n

.meas tran vdout0_13ck140 FIND v(dout0_13) AT=75.025n

.meas tran vdout0_14ck140 FIND v(dout0_14) AT=75.025n

.meas tran vdout0_15ck140 FIND v(dout0_15) AT=75.025n

.meas tran vdout0_16ck140 FIND v(dout0_16) AT=75.025n

.meas tran vdout0_17ck140 FIND v(dout0_17) AT=75.025n

.meas tran vdout0_18ck140 FIND v(dout0_18) AT=75.025n

.meas tran vdout0_19ck140 FIND v(dout0_19) AT=75.025n

.meas tran vdout0_20ck140 FIND v(dout0_20) AT=75.025n

.meas tran vdout0_21ck140 FIND v(dout0_21) AT=75.025n

.meas tran vdout0_22ck140 FIND v(dout0_22) AT=75.025n

.meas tran vdout0_23ck140 FIND v(dout0_23) AT=75.025n

.meas tran vdout0_24ck140 FIND v(dout0_24) AT=75.025n

.meas tran vdout0_25ck140 FIND v(dout0_25) AT=75.025n

.meas tran vdout0_26ck140 FIND v(dout0_26) AT=75.025n

.meas tran vdout0_27ck140 FIND v(dout0_27) AT=75.025n

.meas tran vdout0_28ck140 FIND v(dout0_28) AT=75.025n

.meas tran vdout0_29ck140 FIND v(dout0_29) AT=75.025n

.meas tran vdout0_30ck140 FIND v(dout0_30) AT=75.025n

.meas tran vdout0_31ck140 FIND v(dout0_31) AT=75.025n

.meas tran vdout0_32ck140 FIND v(dout0_32) AT=75.025n

.meas tran vdout0_33ck140 FIND v(dout0_33) AT=75.025n

.meas tran vdout0_34ck140 FIND v(dout0_34) AT=75.025n

.meas tran vdout0_35ck140 FIND v(dout0_35) AT=75.025n

.meas tran vdout0_36ck140 FIND v(dout0_36) AT=75.025n

.meas tran vdout0_37ck140 FIND v(dout0_37) AT=75.025n

.meas tran vdout0_38ck140 FIND v(dout0_38) AT=75.025n

.meas tran vdout0_39ck140 FIND v(dout0_39) AT=75.025n

.meas tran vdout0_40ck140 FIND v(dout0_40) AT=75.025n

.meas tran vdout0_41ck140 FIND v(dout0_41) AT=75.025n

.meas tran vdout0_42ck140 FIND v(dout0_42) AT=75.025n

.meas tran vdout0_43ck140 FIND v(dout0_43) AT=75.025n

.meas tran vdout0_44ck140 FIND v(dout0_44) AT=75.025n

.meas tran vdout0_45ck140 FIND v(dout0_45) AT=75.025n

.meas tran vdout0_46ck140 FIND v(dout0_46) AT=75.025n

.meas tran vdout0_47ck140 FIND v(dout0_47) AT=75.025n

.meas tran vdout0_48ck140 FIND v(dout0_48) AT=75.025n

.meas tran vdout0_49ck140 FIND v(dout0_49) AT=75.025n

.meas tran vdout0_50ck140 FIND v(dout0_50) AT=75.025n

.meas tran vdout0_51ck140 FIND v(dout0_51) AT=75.025n

.meas tran vdout0_52ck140 FIND v(dout0_52) AT=75.025n

.meas tran vdout0_53ck140 FIND v(dout0_53) AT=75.025n

.meas tran vdout0_54ck140 FIND v(dout0_54) AT=75.025n

.meas tran vdout0_55ck140 FIND v(dout0_55) AT=75.025n

.meas tran vdout0_56ck140 FIND v(dout0_56) AT=75.025n

.meas tran vdout0_57ck140 FIND v(dout0_57) AT=75.025n

.meas tran vdout0_58ck140 FIND v(dout0_58) AT=75.025n

.meas tran vdout0_59ck140 FIND v(dout0_59) AT=75.025n

.meas tran vdout0_60ck140 FIND v(dout0_60) AT=75.025n

.meas tran vdout0_61ck140 FIND v(dout0_61) AT=75.025n

.meas tran vdout0_62ck140 FIND v(dout0_62) AT=75.025n

.meas tran vdout0_63ck140 FIND v(dout0_63) AT=75.025n

.meas tran vdout0_64ck140 FIND v(dout0_64) AT=75.025n

.meas tran vdout0_65ck140 FIND v(dout0_65) AT=75.025n

.meas tran vdout0_66ck140 FIND v(dout0_66) AT=75.025n

.meas tran vdout0_67ck140 FIND v(dout0_67) AT=75.025n

.meas tran vdout0_68ck140 FIND v(dout0_68) AT=75.025n

.meas tran vdout0_69ck140 FIND v(dout0_69) AT=75.025n

.meas tran vdout0_70ck140 FIND v(dout0_70) AT=75.025n

.meas tran vdout0_71ck140 FIND v(dout0_71) AT=75.025n

.meas tran vdout0_72ck140 FIND v(dout0_72) AT=75.025n

.meas tran vdout0_73ck140 FIND v(dout0_73) AT=75.025n

.meas tran vdout0_74ck140 FIND v(dout0_74) AT=75.025n

.meas tran vdout0_75ck140 FIND v(dout0_75) AT=75.025n

.meas tran vdout0_76ck140 FIND v(dout0_76) AT=75.025n

.meas tran vdout0_77ck140 FIND v(dout0_77) AT=75.025n

.meas tran vdout0_78ck140 FIND v(dout0_78) AT=75.025n

.meas tran vdout0_79ck140 FIND v(dout0_79) AT=75.025n

.meas tran vdout0_80ck140 FIND v(dout0_80) AT=75.025n

.meas tran vdout0_81ck140 FIND v(dout0_81) AT=75.025n

.meas tran vdout0_82ck140 FIND v(dout0_82) AT=75.025n

.meas tran vdout0_83ck140 FIND v(dout0_83) AT=75.025n

.meas tran vdout0_84ck140 FIND v(dout0_84) AT=75.025n

.meas tran vdout0_85ck140 FIND v(dout0_85) AT=75.025n

.meas tran vdout0_86ck140 FIND v(dout0_86) AT=75.025n

.meas tran vdout0_87ck140 FIND v(dout0_87) AT=75.025n

.meas tran vdout0_88ck140 FIND v(dout0_88) AT=75.025n

.meas tran vdout0_89ck140 FIND v(dout0_89) AT=75.025n

.meas tran vdout0_90ck140 FIND v(dout0_90) AT=75.025n

.meas tran vdout0_91ck140 FIND v(dout0_91) AT=75.025n

.meas tran vdout0_92ck140 FIND v(dout0_92) AT=75.025n

.meas tran vdout0_93ck140 FIND v(dout0_93) AT=75.025n

.meas tran vdout0_94ck140 FIND v(dout0_94) AT=75.025n

.meas tran vdout0_95ck140 FIND v(dout0_95) AT=75.025n

.meas tran vdout0_96ck140 FIND v(dout0_96) AT=75.025n

.meas tran vdout0_97ck140 FIND v(dout0_97) AT=75.025n

.meas tran vdout0_98ck140 FIND v(dout0_98) AT=75.025n

.meas tran vdout0_99ck140 FIND v(dout0_99) AT=75.025n

.meas tran vdout0_100ck140 FIND v(dout0_100) AT=75.025n

.meas tran vdout0_101ck140 FIND v(dout0_101) AT=75.025n

.meas tran vdout0_102ck140 FIND v(dout0_102) AT=75.025n

.meas tran vdout0_103ck140 FIND v(dout0_103) AT=75.025n

.meas tran vdout0_104ck140 FIND v(dout0_104) AT=75.025n

.meas tran vdout0_105ck140 FIND v(dout0_105) AT=75.025n

.meas tran vdout0_106ck140 FIND v(dout0_106) AT=75.025n

.meas tran vdout0_107ck140 FIND v(dout0_107) AT=75.025n

.meas tran vdout0_108ck140 FIND v(dout0_108) AT=75.025n

.meas tran vdout0_109ck140 FIND v(dout0_109) AT=75.025n

.meas tran vdout0_110ck140 FIND v(dout0_110) AT=75.025n

.meas tran vdout0_111ck140 FIND v(dout0_111) AT=75.025n

.meas tran vdout0_112ck140 FIND v(dout0_112) AT=75.025n

.meas tran vdout0_113ck140 FIND v(dout0_113) AT=75.025n

.meas tran vdout0_114ck140 FIND v(dout0_114) AT=75.025n

.meas tran vdout0_115ck140 FIND v(dout0_115) AT=75.025n

.meas tran vdout0_116ck140 FIND v(dout0_116) AT=75.025n

.meas tran vdout0_117ck140 FIND v(dout0_117) AT=75.025n

.meas tran vdout0_118ck140 FIND v(dout0_118) AT=75.025n

.meas tran vdout0_119ck140 FIND v(dout0_119) AT=75.025n

.meas tran vdout0_120ck140 FIND v(dout0_120) AT=75.025n

.meas tran vdout0_121ck140 FIND v(dout0_121) AT=75.025n

.meas tran vdout0_122ck140 FIND v(dout0_122) AT=75.025n

.meas tran vdout0_123ck140 FIND v(dout0_123) AT=75.025n

.meas tran vdout0_124ck140 FIND v(dout0_124) AT=75.025n

.meas tran vdout0_125ck140 FIND v(dout0_125) AT=75.025n

.meas tran vdout0_126ck140 FIND v(dout0_126) AT=75.025n

.meas tran vdout0_127ck140 FIND v(dout0_127) AT=75.025n

.meas tran vdout0_128ck140 FIND v(dout0_128) AT=75.025n

.meas tran vdout0_129ck140 FIND v(dout0_129) AT=75.025n

.meas tran vdout0_130ck140 FIND v(dout0_130) AT=75.025n

.meas tran vdout0_131ck140 FIND v(dout0_131) AT=75.025n

.meas tran vdout0_132ck140 FIND v(dout0_132) AT=75.025n

.meas tran vdout0_133ck140 FIND v(dout0_133) AT=75.025n

.meas tran vdout0_134ck140 FIND v(dout0_134) AT=75.025n

.meas tran vdout0_135ck140 FIND v(dout0_135) AT=75.025n

.meas tran vdout0_136ck140 FIND v(dout0_136) AT=75.025n

.meas tran vdout0_137ck140 FIND v(dout0_137) AT=75.025n

.meas tran vdout0_138ck140 FIND v(dout0_138) AT=75.025n

.meas tran vdout0_139ck140 FIND v(dout0_139) AT=75.025n

.meas tran vdout0_140ck140 FIND v(dout0_140) AT=75.025n

.meas tran vdout0_141ck140 FIND v(dout0_141) AT=75.025n

.meas tran vdout0_142ck140 FIND v(dout0_142) AT=75.025n

.meas tran vdout0_143ck140 FIND v(dout0_143) AT=75.025n

.meas tran vdout0_144ck140 FIND v(dout0_144) AT=75.025n

.meas tran vdout0_145ck140 FIND v(dout0_145) AT=75.025n

.meas tran vdout0_146ck140 FIND v(dout0_146) AT=75.025n

.meas tran vdout0_147ck140 FIND v(dout0_147) AT=75.025n

.meas tran vdout0_148ck140 FIND v(dout0_148) AT=75.025n

.meas tran vdout0_149ck140 FIND v(dout0_149) AT=75.025n

.meas tran vdout0_150ck140 FIND v(dout0_150) AT=75.025n

.meas tran vdout0_151ck140 FIND v(dout0_151) AT=75.025n

.meas tran vdout0_152ck140 FIND v(dout0_152) AT=75.025n

.meas tran vdout0_153ck140 FIND v(dout0_153) AT=75.025n

.meas tran vdout0_154ck140 FIND v(dout0_154) AT=75.025n

.meas tran vdout0_155ck140 FIND v(dout0_155) AT=75.025n

.meas tran vdout0_156ck140 FIND v(dout0_156) AT=75.025n

.meas tran vdout0_157ck140 FIND v(dout0_157) AT=75.025n

.meas tran vdout0_158ck140 FIND v(dout0_158) AT=75.025n

.meas tran vdout0_159ck140 FIND v(dout0_159) AT=75.025n

.meas tran vdout0_160ck140 FIND v(dout0_160) AT=75.025n

.meas tran vdout0_161ck140 FIND v(dout0_161) AT=75.025n

.meas tran vdout0_162ck140 FIND v(dout0_162) AT=75.025n

.meas tran vdout0_163ck140 FIND v(dout0_163) AT=75.025n

.meas tran vdout0_164ck140 FIND v(dout0_164) AT=75.025n

.meas tran vdout0_165ck140 FIND v(dout0_165) AT=75.025n

.meas tran vdout0_166ck140 FIND v(dout0_166) AT=75.025n

.meas tran vdout0_167ck140 FIND v(dout0_167) AT=75.025n

.meas tran vdout0_168ck140 FIND v(dout0_168) AT=75.025n

.meas tran vdout0_169ck140 FIND v(dout0_169) AT=75.025n

.meas tran vdout0_170ck140 FIND v(dout0_170) AT=75.025n

.meas tran vdout0_171ck140 FIND v(dout0_171) AT=75.025n

.meas tran vdout0_172ck140 FIND v(dout0_172) AT=75.025n

.meas tran vdout0_173ck140 FIND v(dout0_173) AT=75.025n

.meas tran vdout0_174ck140 FIND v(dout0_174) AT=75.025n

.meas tran vdout0_175ck140 FIND v(dout0_175) AT=75.025n

.meas tran vdout0_176ck140 FIND v(dout0_176) AT=75.025n

.meas tran vdout0_177ck140 FIND v(dout0_177) AT=75.025n

.meas tran vdout0_178ck140 FIND v(dout0_178) AT=75.025n

.meas tran vdout0_179ck140 FIND v(dout0_179) AT=75.025n

.meas tran vdout0_180ck140 FIND v(dout0_180) AT=75.025n

.meas tran vdout0_181ck140 FIND v(dout0_181) AT=75.025n

.meas tran vdout0_182ck140 FIND v(dout0_182) AT=75.025n

.meas tran vdout0_183ck140 FIND v(dout0_183) AT=75.025n

.meas tran vdout0_184ck140 FIND v(dout0_184) AT=75.025n

.meas tran vdout0_185ck140 FIND v(dout0_185) AT=75.025n

.meas tran vdout0_186ck140 FIND v(dout0_186) AT=75.025n

.meas tran vdout0_187ck140 FIND v(dout0_187) AT=75.025n

.meas tran vdout0_188ck140 FIND v(dout0_188) AT=75.025n

.meas tran vdout0_189ck140 FIND v(dout0_189) AT=75.025n

.meas tran vdout0_190ck140 FIND v(dout0_190) AT=75.025n

.meas tran vdout0_191ck140 FIND v(dout0_191) AT=75.025n

.meas tran vdout0_192ck140 FIND v(dout0_192) AT=75.025n

.meas tran vdout0_193ck140 FIND v(dout0_193) AT=75.025n

.meas tran vdout0_194ck140 FIND v(dout0_194) AT=75.025n

.meas tran vdout0_195ck140 FIND v(dout0_195) AT=75.025n

.meas tran vdout0_196ck140 FIND v(dout0_196) AT=75.025n

.meas tran vdout0_197ck140 FIND v(dout0_197) AT=75.025n

.meas tran vdout0_198ck140 FIND v(dout0_198) AT=75.025n

.meas tran vdout0_199ck140 FIND v(dout0_199) AT=75.025n

.meas tran vdout0_200ck140 FIND v(dout0_200) AT=75.025n

.meas tran vdout0_201ck140 FIND v(dout0_201) AT=75.025n

.meas tran vdout0_202ck140 FIND v(dout0_202) AT=75.025n

.meas tran vdout0_203ck140 FIND v(dout0_203) AT=75.025n

.meas tran vdout0_204ck140 FIND v(dout0_204) AT=75.025n

.meas tran vdout0_205ck140 FIND v(dout0_205) AT=75.025n

.meas tran vdout0_206ck140 FIND v(dout0_206) AT=75.025n

.meas tran vdout0_207ck140 FIND v(dout0_207) AT=75.025n

.meas tran vdout0_208ck140 FIND v(dout0_208) AT=75.025n

.meas tran vdout0_209ck140 FIND v(dout0_209) AT=75.025n

.meas tran vdout0_210ck140 FIND v(dout0_210) AT=75.025n

.meas tran vdout0_211ck140 FIND v(dout0_211) AT=75.025n

.meas tran vdout0_212ck140 FIND v(dout0_212) AT=75.025n

.meas tran vdout0_213ck140 FIND v(dout0_213) AT=75.025n

.meas tran vdout0_214ck140 FIND v(dout0_214) AT=75.025n

.meas tran vdout0_215ck140 FIND v(dout0_215) AT=75.025n

.meas tran vdout0_216ck140 FIND v(dout0_216) AT=75.025n

.meas tran vdout0_217ck140 FIND v(dout0_217) AT=75.025n

.meas tran vdout0_218ck140 FIND v(dout0_218) AT=75.025n

.meas tran vdout0_219ck140 FIND v(dout0_219) AT=75.025n

.meas tran vdout0_220ck140 FIND v(dout0_220) AT=75.025n

.meas tran vdout0_221ck140 FIND v(dout0_221) AT=75.025n

.meas tran vdout0_222ck140 FIND v(dout0_222) AT=75.025n

.meas tran vdout0_223ck140 FIND v(dout0_223) AT=75.025n

.meas tran vdout0_224ck140 FIND v(dout0_224) AT=75.025n

.meas tran vdout0_225ck140 FIND v(dout0_225) AT=75.025n

.meas tran vdout0_226ck140 FIND v(dout0_226) AT=75.025n

.meas tran vdout0_227ck140 FIND v(dout0_227) AT=75.025n

.meas tran vdout0_228ck140 FIND v(dout0_228) AT=75.025n

.meas tran vdout0_229ck140 FIND v(dout0_229) AT=75.025n

.meas tran vdout0_230ck140 FIND v(dout0_230) AT=75.025n

.meas tran vdout0_231ck140 FIND v(dout0_231) AT=75.025n

.meas tran vdout0_232ck140 FIND v(dout0_232) AT=75.025n

.meas tran vdout0_233ck140 FIND v(dout0_233) AT=75.025n

.meas tran vdout0_234ck140 FIND v(dout0_234) AT=75.025n

.meas tran vdout0_235ck140 FIND v(dout0_235) AT=75.025n

.meas tran vdout0_236ck140 FIND v(dout0_236) AT=75.025n

.meas tran vdout0_237ck140 FIND v(dout0_237) AT=75.025n

.meas tran vdout0_238ck140 FIND v(dout0_238) AT=75.025n

.meas tran vdout0_239ck140 FIND v(dout0_239) AT=75.025n

.meas tran vdout0_240ck140 FIND v(dout0_240) AT=75.025n

.meas tran vdout0_241ck140 FIND v(dout0_241) AT=75.025n

.meas tran vdout0_242ck140 FIND v(dout0_242) AT=75.025n

.meas tran vdout0_243ck140 FIND v(dout0_243) AT=75.025n

.meas tran vdout0_244ck140 FIND v(dout0_244) AT=75.025n

.meas tran vdout0_245ck140 FIND v(dout0_245) AT=75.025n

.meas tran vdout0_246ck140 FIND v(dout0_246) AT=75.025n

.meas tran vdout0_247ck140 FIND v(dout0_247) AT=75.025n

.meas tran vdout0_248ck140 FIND v(dout0_248) AT=75.025n

.meas tran vdout0_249ck140 FIND v(dout0_249) AT=75.025n

.meas tran vdout0_250ck140 FIND v(dout0_250) AT=75.025n

.meas tran vdout0_251ck140 FIND v(dout0_251) AT=75.025n

.meas tran vdout0_252ck140 FIND v(dout0_252) AT=75.025n

.meas tran vdout0_253ck140 FIND v(dout0_253) AT=75.025n

.meas tran vdout0_254ck140 FIND v(dout0_254) AT=75.025n

.meas tran vdout0_255ck140 FIND v(dout0_255) AT=75.025n

.meas tran vdout0_0ck150 FIND v(dout0_0) AT=80.025n

.meas tran vdout0_1ck150 FIND v(dout0_1) AT=80.025n

.meas tran vdout0_2ck150 FIND v(dout0_2) AT=80.025n

.meas tran vdout0_3ck150 FIND v(dout0_3) AT=80.025n

.meas tran vdout0_4ck150 FIND v(dout0_4) AT=80.025n

.meas tran vdout0_5ck150 FIND v(dout0_5) AT=80.025n

.meas tran vdout0_6ck150 FIND v(dout0_6) AT=80.025n

.meas tran vdout0_7ck150 FIND v(dout0_7) AT=80.025n

.meas tran vdout0_8ck150 FIND v(dout0_8) AT=80.025n

.meas tran vdout0_9ck150 FIND v(dout0_9) AT=80.025n

.meas tran vdout0_10ck150 FIND v(dout0_10) AT=80.025n

.meas tran vdout0_11ck150 FIND v(dout0_11) AT=80.025n

.meas tran vdout0_12ck150 FIND v(dout0_12) AT=80.025n

.meas tran vdout0_13ck150 FIND v(dout0_13) AT=80.025n

.meas tran vdout0_14ck150 FIND v(dout0_14) AT=80.025n

.meas tran vdout0_15ck150 FIND v(dout0_15) AT=80.025n

.meas tran vdout0_16ck150 FIND v(dout0_16) AT=80.025n

.meas tran vdout0_17ck150 FIND v(dout0_17) AT=80.025n

.meas tran vdout0_18ck150 FIND v(dout0_18) AT=80.025n

.meas tran vdout0_19ck150 FIND v(dout0_19) AT=80.025n

.meas tran vdout0_20ck150 FIND v(dout0_20) AT=80.025n

.meas tran vdout0_21ck150 FIND v(dout0_21) AT=80.025n

.meas tran vdout0_22ck150 FIND v(dout0_22) AT=80.025n

.meas tran vdout0_23ck150 FIND v(dout0_23) AT=80.025n

.meas tran vdout0_24ck150 FIND v(dout0_24) AT=80.025n

.meas tran vdout0_25ck150 FIND v(dout0_25) AT=80.025n

.meas tran vdout0_26ck150 FIND v(dout0_26) AT=80.025n

.meas tran vdout0_27ck150 FIND v(dout0_27) AT=80.025n

.meas tran vdout0_28ck150 FIND v(dout0_28) AT=80.025n

.meas tran vdout0_29ck150 FIND v(dout0_29) AT=80.025n

.meas tran vdout0_30ck150 FIND v(dout0_30) AT=80.025n

.meas tran vdout0_31ck150 FIND v(dout0_31) AT=80.025n

.meas tran vdout0_32ck150 FIND v(dout0_32) AT=80.025n

.meas tran vdout0_33ck150 FIND v(dout0_33) AT=80.025n

.meas tran vdout0_34ck150 FIND v(dout0_34) AT=80.025n

.meas tran vdout0_35ck150 FIND v(dout0_35) AT=80.025n

.meas tran vdout0_36ck150 FIND v(dout0_36) AT=80.025n

.meas tran vdout0_37ck150 FIND v(dout0_37) AT=80.025n

.meas tran vdout0_38ck150 FIND v(dout0_38) AT=80.025n

.meas tran vdout0_39ck150 FIND v(dout0_39) AT=80.025n

.meas tran vdout0_40ck150 FIND v(dout0_40) AT=80.025n

.meas tran vdout0_41ck150 FIND v(dout0_41) AT=80.025n

.meas tran vdout0_42ck150 FIND v(dout0_42) AT=80.025n

.meas tran vdout0_43ck150 FIND v(dout0_43) AT=80.025n

.meas tran vdout0_44ck150 FIND v(dout0_44) AT=80.025n

.meas tran vdout0_45ck150 FIND v(dout0_45) AT=80.025n

.meas tran vdout0_46ck150 FIND v(dout0_46) AT=80.025n

.meas tran vdout0_47ck150 FIND v(dout0_47) AT=80.025n

.meas tran vdout0_48ck150 FIND v(dout0_48) AT=80.025n

.meas tran vdout0_49ck150 FIND v(dout0_49) AT=80.025n

.meas tran vdout0_50ck150 FIND v(dout0_50) AT=80.025n

.meas tran vdout0_51ck150 FIND v(dout0_51) AT=80.025n

.meas tran vdout0_52ck150 FIND v(dout0_52) AT=80.025n

.meas tran vdout0_53ck150 FIND v(dout0_53) AT=80.025n

.meas tran vdout0_54ck150 FIND v(dout0_54) AT=80.025n

.meas tran vdout0_55ck150 FIND v(dout0_55) AT=80.025n

.meas tran vdout0_56ck150 FIND v(dout0_56) AT=80.025n

.meas tran vdout0_57ck150 FIND v(dout0_57) AT=80.025n

.meas tran vdout0_58ck150 FIND v(dout0_58) AT=80.025n

.meas tran vdout0_59ck150 FIND v(dout0_59) AT=80.025n

.meas tran vdout0_60ck150 FIND v(dout0_60) AT=80.025n

.meas tran vdout0_61ck150 FIND v(dout0_61) AT=80.025n

.meas tran vdout0_62ck150 FIND v(dout0_62) AT=80.025n

.meas tran vdout0_63ck150 FIND v(dout0_63) AT=80.025n

.meas tran vdout0_64ck150 FIND v(dout0_64) AT=80.025n

.meas tran vdout0_65ck150 FIND v(dout0_65) AT=80.025n

.meas tran vdout0_66ck150 FIND v(dout0_66) AT=80.025n

.meas tran vdout0_67ck150 FIND v(dout0_67) AT=80.025n

.meas tran vdout0_68ck150 FIND v(dout0_68) AT=80.025n

.meas tran vdout0_69ck150 FIND v(dout0_69) AT=80.025n

.meas tran vdout0_70ck150 FIND v(dout0_70) AT=80.025n

.meas tran vdout0_71ck150 FIND v(dout0_71) AT=80.025n

.meas tran vdout0_72ck150 FIND v(dout0_72) AT=80.025n

.meas tran vdout0_73ck150 FIND v(dout0_73) AT=80.025n

.meas tran vdout0_74ck150 FIND v(dout0_74) AT=80.025n

.meas tran vdout0_75ck150 FIND v(dout0_75) AT=80.025n

.meas tran vdout0_76ck150 FIND v(dout0_76) AT=80.025n

.meas tran vdout0_77ck150 FIND v(dout0_77) AT=80.025n

.meas tran vdout0_78ck150 FIND v(dout0_78) AT=80.025n

.meas tran vdout0_79ck150 FIND v(dout0_79) AT=80.025n

.meas tran vdout0_80ck150 FIND v(dout0_80) AT=80.025n

.meas tran vdout0_81ck150 FIND v(dout0_81) AT=80.025n

.meas tran vdout0_82ck150 FIND v(dout0_82) AT=80.025n

.meas tran vdout0_83ck150 FIND v(dout0_83) AT=80.025n

.meas tran vdout0_84ck150 FIND v(dout0_84) AT=80.025n

.meas tran vdout0_85ck150 FIND v(dout0_85) AT=80.025n

.meas tran vdout0_86ck150 FIND v(dout0_86) AT=80.025n

.meas tran vdout0_87ck150 FIND v(dout0_87) AT=80.025n

.meas tran vdout0_88ck150 FIND v(dout0_88) AT=80.025n

.meas tran vdout0_89ck150 FIND v(dout0_89) AT=80.025n

.meas tran vdout0_90ck150 FIND v(dout0_90) AT=80.025n

.meas tran vdout0_91ck150 FIND v(dout0_91) AT=80.025n

.meas tran vdout0_92ck150 FIND v(dout0_92) AT=80.025n

.meas tran vdout0_93ck150 FIND v(dout0_93) AT=80.025n

.meas tran vdout0_94ck150 FIND v(dout0_94) AT=80.025n

.meas tran vdout0_95ck150 FIND v(dout0_95) AT=80.025n

.meas tran vdout0_96ck150 FIND v(dout0_96) AT=80.025n

.meas tran vdout0_97ck150 FIND v(dout0_97) AT=80.025n

.meas tran vdout0_98ck150 FIND v(dout0_98) AT=80.025n

.meas tran vdout0_99ck150 FIND v(dout0_99) AT=80.025n

.meas tran vdout0_100ck150 FIND v(dout0_100) AT=80.025n

.meas tran vdout0_101ck150 FIND v(dout0_101) AT=80.025n

.meas tran vdout0_102ck150 FIND v(dout0_102) AT=80.025n

.meas tran vdout0_103ck150 FIND v(dout0_103) AT=80.025n

.meas tran vdout0_104ck150 FIND v(dout0_104) AT=80.025n

.meas tran vdout0_105ck150 FIND v(dout0_105) AT=80.025n

.meas tran vdout0_106ck150 FIND v(dout0_106) AT=80.025n

.meas tran vdout0_107ck150 FIND v(dout0_107) AT=80.025n

.meas tran vdout0_108ck150 FIND v(dout0_108) AT=80.025n

.meas tran vdout0_109ck150 FIND v(dout0_109) AT=80.025n

.meas tran vdout0_110ck150 FIND v(dout0_110) AT=80.025n

.meas tran vdout0_111ck150 FIND v(dout0_111) AT=80.025n

.meas tran vdout0_112ck150 FIND v(dout0_112) AT=80.025n

.meas tran vdout0_113ck150 FIND v(dout0_113) AT=80.025n

.meas tran vdout0_114ck150 FIND v(dout0_114) AT=80.025n

.meas tran vdout0_115ck150 FIND v(dout0_115) AT=80.025n

.meas tran vdout0_116ck150 FIND v(dout0_116) AT=80.025n

.meas tran vdout0_117ck150 FIND v(dout0_117) AT=80.025n

.meas tran vdout0_118ck150 FIND v(dout0_118) AT=80.025n

.meas tran vdout0_119ck150 FIND v(dout0_119) AT=80.025n

.meas tran vdout0_120ck150 FIND v(dout0_120) AT=80.025n

.meas tran vdout0_121ck150 FIND v(dout0_121) AT=80.025n

.meas tran vdout0_122ck150 FIND v(dout0_122) AT=80.025n

.meas tran vdout0_123ck150 FIND v(dout0_123) AT=80.025n

.meas tran vdout0_124ck150 FIND v(dout0_124) AT=80.025n

.meas tran vdout0_125ck150 FIND v(dout0_125) AT=80.025n

.meas tran vdout0_126ck150 FIND v(dout0_126) AT=80.025n

.meas tran vdout0_127ck150 FIND v(dout0_127) AT=80.025n

.meas tran vdout0_128ck150 FIND v(dout0_128) AT=80.025n

.meas tran vdout0_129ck150 FIND v(dout0_129) AT=80.025n

.meas tran vdout0_130ck150 FIND v(dout0_130) AT=80.025n

.meas tran vdout0_131ck150 FIND v(dout0_131) AT=80.025n

.meas tran vdout0_132ck150 FIND v(dout0_132) AT=80.025n

.meas tran vdout0_133ck150 FIND v(dout0_133) AT=80.025n

.meas tran vdout0_134ck150 FIND v(dout0_134) AT=80.025n

.meas tran vdout0_135ck150 FIND v(dout0_135) AT=80.025n

.meas tran vdout0_136ck150 FIND v(dout0_136) AT=80.025n

.meas tran vdout0_137ck150 FIND v(dout0_137) AT=80.025n

.meas tran vdout0_138ck150 FIND v(dout0_138) AT=80.025n

.meas tran vdout0_139ck150 FIND v(dout0_139) AT=80.025n

.meas tran vdout0_140ck150 FIND v(dout0_140) AT=80.025n

.meas tran vdout0_141ck150 FIND v(dout0_141) AT=80.025n

.meas tran vdout0_142ck150 FIND v(dout0_142) AT=80.025n

.meas tran vdout0_143ck150 FIND v(dout0_143) AT=80.025n

.meas tran vdout0_144ck150 FIND v(dout0_144) AT=80.025n

.meas tran vdout0_145ck150 FIND v(dout0_145) AT=80.025n

.meas tran vdout0_146ck150 FIND v(dout0_146) AT=80.025n

.meas tran vdout0_147ck150 FIND v(dout0_147) AT=80.025n

.meas tran vdout0_148ck150 FIND v(dout0_148) AT=80.025n

.meas tran vdout0_149ck150 FIND v(dout0_149) AT=80.025n

.meas tran vdout0_150ck150 FIND v(dout0_150) AT=80.025n

.meas tran vdout0_151ck150 FIND v(dout0_151) AT=80.025n

.meas tran vdout0_152ck150 FIND v(dout0_152) AT=80.025n

.meas tran vdout0_153ck150 FIND v(dout0_153) AT=80.025n

.meas tran vdout0_154ck150 FIND v(dout0_154) AT=80.025n

.meas tran vdout0_155ck150 FIND v(dout0_155) AT=80.025n

.meas tran vdout0_156ck150 FIND v(dout0_156) AT=80.025n

.meas tran vdout0_157ck150 FIND v(dout0_157) AT=80.025n

.meas tran vdout0_158ck150 FIND v(dout0_158) AT=80.025n

.meas tran vdout0_159ck150 FIND v(dout0_159) AT=80.025n

.meas tran vdout0_160ck150 FIND v(dout0_160) AT=80.025n

.meas tran vdout0_161ck150 FIND v(dout0_161) AT=80.025n

.meas tran vdout0_162ck150 FIND v(dout0_162) AT=80.025n

.meas tran vdout0_163ck150 FIND v(dout0_163) AT=80.025n

.meas tran vdout0_164ck150 FIND v(dout0_164) AT=80.025n

.meas tran vdout0_165ck150 FIND v(dout0_165) AT=80.025n

.meas tran vdout0_166ck150 FIND v(dout0_166) AT=80.025n

.meas tran vdout0_167ck150 FIND v(dout0_167) AT=80.025n

.meas tran vdout0_168ck150 FIND v(dout0_168) AT=80.025n

.meas tran vdout0_169ck150 FIND v(dout0_169) AT=80.025n

.meas tran vdout0_170ck150 FIND v(dout0_170) AT=80.025n

.meas tran vdout0_171ck150 FIND v(dout0_171) AT=80.025n

.meas tran vdout0_172ck150 FIND v(dout0_172) AT=80.025n

.meas tran vdout0_173ck150 FIND v(dout0_173) AT=80.025n

.meas tran vdout0_174ck150 FIND v(dout0_174) AT=80.025n

.meas tran vdout0_175ck150 FIND v(dout0_175) AT=80.025n

.meas tran vdout0_176ck150 FIND v(dout0_176) AT=80.025n

.meas tran vdout0_177ck150 FIND v(dout0_177) AT=80.025n

.meas tran vdout0_178ck150 FIND v(dout0_178) AT=80.025n

.meas tran vdout0_179ck150 FIND v(dout0_179) AT=80.025n

.meas tran vdout0_180ck150 FIND v(dout0_180) AT=80.025n

.meas tran vdout0_181ck150 FIND v(dout0_181) AT=80.025n

.meas tran vdout0_182ck150 FIND v(dout0_182) AT=80.025n

.meas tran vdout0_183ck150 FIND v(dout0_183) AT=80.025n

.meas tran vdout0_184ck150 FIND v(dout0_184) AT=80.025n

.meas tran vdout0_185ck150 FIND v(dout0_185) AT=80.025n

.meas tran vdout0_186ck150 FIND v(dout0_186) AT=80.025n

.meas tran vdout0_187ck150 FIND v(dout0_187) AT=80.025n

.meas tran vdout0_188ck150 FIND v(dout0_188) AT=80.025n

.meas tran vdout0_189ck150 FIND v(dout0_189) AT=80.025n

.meas tran vdout0_190ck150 FIND v(dout0_190) AT=80.025n

.meas tran vdout0_191ck150 FIND v(dout0_191) AT=80.025n

.meas tran vdout0_192ck150 FIND v(dout0_192) AT=80.025n

.meas tran vdout0_193ck150 FIND v(dout0_193) AT=80.025n

.meas tran vdout0_194ck150 FIND v(dout0_194) AT=80.025n

.meas tran vdout0_195ck150 FIND v(dout0_195) AT=80.025n

.meas tran vdout0_196ck150 FIND v(dout0_196) AT=80.025n

.meas tran vdout0_197ck150 FIND v(dout0_197) AT=80.025n

.meas tran vdout0_198ck150 FIND v(dout0_198) AT=80.025n

.meas tran vdout0_199ck150 FIND v(dout0_199) AT=80.025n

.meas tran vdout0_200ck150 FIND v(dout0_200) AT=80.025n

.meas tran vdout0_201ck150 FIND v(dout0_201) AT=80.025n

.meas tran vdout0_202ck150 FIND v(dout0_202) AT=80.025n

.meas tran vdout0_203ck150 FIND v(dout0_203) AT=80.025n

.meas tran vdout0_204ck150 FIND v(dout0_204) AT=80.025n

.meas tran vdout0_205ck150 FIND v(dout0_205) AT=80.025n

.meas tran vdout0_206ck150 FIND v(dout0_206) AT=80.025n

.meas tran vdout0_207ck150 FIND v(dout0_207) AT=80.025n

.meas tran vdout0_208ck150 FIND v(dout0_208) AT=80.025n

.meas tran vdout0_209ck150 FIND v(dout0_209) AT=80.025n

.meas tran vdout0_210ck150 FIND v(dout0_210) AT=80.025n

.meas tran vdout0_211ck150 FIND v(dout0_211) AT=80.025n

.meas tran vdout0_212ck150 FIND v(dout0_212) AT=80.025n

.meas tran vdout0_213ck150 FIND v(dout0_213) AT=80.025n

.meas tran vdout0_214ck150 FIND v(dout0_214) AT=80.025n

.meas tran vdout0_215ck150 FIND v(dout0_215) AT=80.025n

.meas tran vdout0_216ck150 FIND v(dout0_216) AT=80.025n

.meas tran vdout0_217ck150 FIND v(dout0_217) AT=80.025n

.meas tran vdout0_218ck150 FIND v(dout0_218) AT=80.025n

.meas tran vdout0_219ck150 FIND v(dout0_219) AT=80.025n

.meas tran vdout0_220ck150 FIND v(dout0_220) AT=80.025n

.meas tran vdout0_221ck150 FIND v(dout0_221) AT=80.025n

.meas tran vdout0_222ck150 FIND v(dout0_222) AT=80.025n

.meas tran vdout0_223ck150 FIND v(dout0_223) AT=80.025n

.meas tran vdout0_224ck150 FIND v(dout0_224) AT=80.025n

.meas tran vdout0_225ck150 FIND v(dout0_225) AT=80.025n

.meas tran vdout0_226ck150 FIND v(dout0_226) AT=80.025n

.meas tran vdout0_227ck150 FIND v(dout0_227) AT=80.025n

.meas tran vdout0_228ck150 FIND v(dout0_228) AT=80.025n

.meas tran vdout0_229ck150 FIND v(dout0_229) AT=80.025n

.meas tran vdout0_230ck150 FIND v(dout0_230) AT=80.025n

.meas tran vdout0_231ck150 FIND v(dout0_231) AT=80.025n

.meas tran vdout0_232ck150 FIND v(dout0_232) AT=80.025n

.meas tran vdout0_233ck150 FIND v(dout0_233) AT=80.025n

.meas tran vdout0_234ck150 FIND v(dout0_234) AT=80.025n

.meas tran vdout0_235ck150 FIND v(dout0_235) AT=80.025n

.meas tran vdout0_236ck150 FIND v(dout0_236) AT=80.025n

.meas tran vdout0_237ck150 FIND v(dout0_237) AT=80.025n

.meas tran vdout0_238ck150 FIND v(dout0_238) AT=80.025n

.meas tran vdout0_239ck150 FIND v(dout0_239) AT=80.025n

.meas tran vdout0_240ck150 FIND v(dout0_240) AT=80.025n

.meas tran vdout0_241ck150 FIND v(dout0_241) AT=80.025n

.meas tran vdout0_242ck150 FIND v(dout0_242) AT=80.025n

.meas tran vdout0_243ck150 FIND v(dout0_243) AT=80.025n

.meas tran vdout0_244ck150 FIND v(dout0_244) AT=80.025n

.meas tran vdout0_245ck150 FIND v(dout0_245) AT=80.025n

.meas tran vdout0_246ck150 FIND v(dout0_246) AT=80.025n

.meas tran vdout0_247ck150 FIND v(dout0_247) AT=80.025n

.meas tran vdout0_248ck150 FIND v(dout0_248) AT=80.025n

.meas tran vdout0_249ck150 FIND v(dout0_249) AT=80.025n

.meas tran vdout0_250ck150 FIND v(dout0_250) AT=80.025n

.meas tran vdout0_251ck150 FIND v(dout0_251) AT=80.025n

.meas tran vdout0_252ck150 FIND v(dout0_252) AT=80.025n

.meas tran vdout0_253ck150 FIND v(dout0_253) AT=80.025n

.meas tran vdout0_254ck150 FIND v(dout0_254) AT=80.025n

.meas tran vdout0_255ck150 FIND v(dout0_255) AT=80.025n

.meas tran vdout0_0ck190 FIND v(dout0_0) AT=100.025n

.meas tran vdout0_1ck190 FIND v(dout0_1) AT=100.025n

.meas tran vdout0_2ck190 FIND v(dout0_2) AT=100.025n

.meas tran vdout0_3ck190 FIND v(dout0_3) AT=100.025n

.meas tran vdout0_4ck190 FIND v(dout0_4) AT=100.025n

.meas tran vdout0_5ck190 FIND v(dout0_5) AT=100.025n

.meas tran vdout0_6ck190 FIND v(dout0_6) AT=100.025n

.meas tran vdout0_7ck190 FIND v(dout0_7) AT=100.025n

.meas tran vdout0_8ck190 FIND v(dout0_8) AT=100.025n

.meas tran vdout0_9ck190 FIND v(dout0_9) AT=100.025n

.meas tran vdout0_10ck190 FIND v(dout0_10) AT=100.025n

.meas tran vdout0_11ck190 FIND v(dout0_11) AT=100.025n

.meas tran vdout0_12ck190 FIND v(dout0_12) AT=100.025n

.meas tran vdout0_13ck190 FIND v(dout0_13) AT=100.025n

.meas tran vdout0_14ck190 FIND v(dout0_14) AT=100.025n

.meas tran vdout0_15ck190 FIND v(dout0_15) AT=100.025n

.meas tran vdout0_16ck190 FIND v(dout0_16) AT=100.025n

.meas tran vdout0_17ck190 FIND v(dout0_17) AT=100.025n

.meas tran vdout0_18ck190 FIND v(dout0_18) AT=100.025n

.meas tran vdout0_19ck190 FIND v(dout0_19) AT=100.025n

.meas tran vdout0_20ck190 FIND v(dout0_20) AT=100.025n

.meas tran vdout0_21ck190 FIND v(dout0_21) AT=100.025n

.meas tran vdout0_22ck190 FIND v(dout0_22) AT=100.025n

.meas tran vdout0_23ck190 FIND v(dout0_23) AT=100.025n

.meas tran vdout0_24ck190 FIND v(dout0_24) AT=100.025n

.meas tran vdout0_25ck190 FIND v(dout0_25) AT=100.025n

.meas tran vdout0_26ck190 FIND v(dout0_26) AT=100.025n

.meas tran vdout0_27ck190 FIND v(dout0_27) AT=100.025n

.meas tran vdout0_28ck190 FIND v(dout0_28) AT=100.025n

.meas tran vdout0_29ck190 FIND v(dout0_29) AT=100.025n

.meas tran vdout0_30ck190 FIND v(dout0_30) AT=100.025n

.meas tran vdout0_31ck190 FIND v(dout0_31) AT=100.025n

.meas tran vdout0_32ck190 FIND v(dout0_32) AT=100.025n

.meas tran vdout0_33ck190 FIND v(dout0_33) AT=100.025n

.meas tran vdout0_34ck190 FIND v(dout0_34) AT=100.025n

.meas tran vdout0_35ck190 FIND v(dout0_35) AT=100.025n

.meas tran vdout0_36ck190 FIND v(dout0_36) AT=100.025n

.meas tran vdout0_37ck190 FIND v(dout0_37) AT=100.025n

.meas tran vdout0_38ck190 FIND v(dout0_38) AT=100.025n

.meas tran vdout0_39ck190 FIND v(dout0_39) AT=100.025n

.meas tran vdout0_40ck190 FIND v(dout0_40) AT=100.025n

.meas tran vdout0_41ck190 FIND v(dout0_41) AT=100.025n

.meas tran vdout0_42ck190 FIND v(dout0_42) AT=100.025n

.meas tran vdout0_43ck190 FIND v(dout0_43) AT=100.025n

.meas tran vdout0_44ck190 FIND v(dout0_44) AT=100.025n

.meas tran vdout0_45ck190 FIND v(dout0_45) AT=100.025n

.meas tran vdout0_46ck190 FIND v(dout0_46) AT=100.025n

.meas tran vdout0_47ck190 FIND v(dout0_47) AT=100.025n

.meas tran vdout0_48ck190 FIND v(dout0_48) AT=100.025n

.meas tran vdout0_49ck190 FIND v(dout0_49) AT=100.025n

.meas tran vdout0_50ck190 FIND v(dout0_50) AT=100.025n

.meas tran vdout0_51ck190 FIND v(dout0_51) AT=100.025n

.meas tran vdout0_52ck190 FIND v(dout0_52) AT=100.025n

.meas tran vdout0_53ck190 FIND v(dout0_53) AT=100.025n

.meas tran vdout0_54ck190 FIND v(dout0_54) AT=100.025n

.meas tran vdout0_55ck190 FIND v(dout0_55) AT=100.025n

.meas tran vdout0_56ck190 FIND v(dout0_56) AT=100.025n

.meas tran vdout0_57ck190 FIND v(dout0_57) AT=100.025n

.meas tran vdout0_58ck190 FIND v(dout0_58) AT=100.025n

.meas tran vdout0_59ck190 FIND v(dout0_59) AT=100.025n

.meas tran vdout0_60ck190 FIND v(dout0_60) AT=100.025n

.meas tran vdout0_61ck190 FIND v(dout0_61) AT=100.025n

.meas tran vdout0_62ck190 FIND v(dout0_62) AT=100.025n

.meas tran vdout0_63ck190 FIND v(dout0_63) AT=100.025n

.meas tran vdout0_64ck190 FIND v(dout0_64) AT=100.025n

.meas tran vdout0_65ck190 FIND v(dout0_65) AT=100.025n

.meas tran vdout0_66ck190 FIND v(dout0_66) AT=100.025n

.meas tran vdout0_67ck190 FIND v(dout0_67) AT=100.025n

.meas tran vdout0_68ck190 FIND v(dout0_68) AT=100.025n

.meas tran vdout0_69ck190 FIND v(dout0_69) AT=100.025n

.meas tran vdout0_70ck190 FIND v(dout0_70) AT=100.025n

.meas tran vdout0_71ck190 FIND v(dout0_71) AT=100.025n

.meas tran vdout0_72ck190 FIND v(dout0_72) AT=100.025n

.meas tran vdout0_73ck190 FIND v(dout0_73) AT=100.025n

.meas tran vdout0_74ck190 FIND v(dout0_74) AT=100.025n

.meas tran vdout0_75ck190 FIND v(dout0_75) AT=100.025n

.meas tran vdout0_76ck190 FIND v(dout0_76) AT=100.025n

.meas tran vdout0_77ck190 FIND v(dout0_77) AT=100.025n

.meas tran vdout0_78ck190 FIND v(dout0_78) AT=100.025n

.meas tran vdout0_79ck190 FIND v(dout0_79) AT=100.025n

.meas tran vdout0_80ck190 FIND v(dout0_80) AT=100.025n

.meas tran vdout0_81ck190 FIND v(dout0_81) AT=100.025n

.meas tran vdout0_82ck190 FIND v(dout0_82) AT=100.025n

.meas tran vdout0_83ck190 FIND v(dout0_83) AT=100.025n

.meas tran vdout0_84ck190 FIND v(dout0_84) AT=100.025n

.meas tran vdout0_85ck190 FIND v(dout0_85) AT=100.025n

.meas tran vdout0_86ck190 FIND v(dout0_86) AT=100.025n

.meas tran vdout0_87ck190 FIND v(dout0_87) AT=100.025n

.meas tran vdout0_88ck190 FIND v(dout0_88) AT=100.025n

.meas tran vdout0_89ck190 FIND v(dout0_89) AT=100.025n

.meas tran vdout0_90ck190 FIND v(dout0_90) AT=100.025n

.meas tran vdout0_91ck190 FIND v(dout0_91) AT=100.025n

.meas tran vdout0_92ck190 FIND v(dout0_92) AT=100.025n

.meas tran vdout0_93ck190 FIND v(dout0_93) AT=100.025n

.meas tran vdout0_94ck190 FIND v(dout0_94) AT=100.025n

.meas tran vdout0_95ck190 FIND v(dout0_95) AT=100.025n

.meas tran vdout0_96ck190 FIND v(dout0_96) AT=100.025n

.meas tran vdout0_97ck190 FIND v(dout0_97) AT=100.025n

.meas tran vdout0_98ck190 FIND v(dout0_98) AT=100.025n

.meas tran vdout0_99ck190 FIND v(dout0_99) AT=100.025n

.meas tran vdout0_100ck190 FIND v(dout0_100) AT=100.025n

.meas tran vdout0_101ck190 FIND v(dout0_101) AT=100.025n

.meas tran vdout0_102ck190 FIND v(dout0_102) AT=100.025n

.meas tran vdout0_103ck190 FIND v(dout0_103) AT=100.025n

.meas tran vdout0_104ck190 FIND v(dout0_104) AT=100.025n

.meas tran vdout0_105ck190 FIND v(dout0_105) AT=100.025n

.meas tran vdout0_106ck190 FIND v(dout0_106) AT=100.025n

.meas tran vdout0_107ck190 FIND v(dout0_107) AT=100.025n

.meas tran vdout0_108ck190 FIND v(dout0_108) AT=100.025n

.meas tran vdout0_109ck190 FIND v(dout0_109) AT=100.025n

.meas tran vdout0_110ck190 FIND v(dout0_110) AT=100.025n

.meas tran vdout0_111ck190 FIND v(dout0_111) AT=100.025n

.meas tran vdout0_112ck190 FIND v(dout0_112) AT=100.025n

.meas tran vdout0_113ck190 FIND v(dout0_113) AT=100.025n

.meas tran vdout0_114ck190 FIND v(dout0_114) AT=100.025n

.meas tran vdout0_115ck190 FIND v(dout0_115) AT=100.025n

.meas tran vdout0_116ck190 FIND v(dout0_116) AT=100.025n

.meas tran vdout0_117ck190 FIND v(dout0_117) AT=100.025n

.meas tran vdout0_118ck190 FIND v(dout0_118) AT=100.025n

.meas tran vdout0_119ck190 FIND v(dout0_119) AT=100.025n

.meas tran vdout0_120ck190 FIND v(dout0_120) AT=100.025n

.meas tran vdout0_121ck190 FIND v(dout0_121) AT=100.025n

.meas tran vdout0_122ck190 FIND v(dout0_122) AT=100.025n

.meas tran vdout0_123ck190 FIND v(dout0_123) AT=100.025n

.meas tran vdout0_124ck190 FIND v(dout0_124) AT=100.025n

.meas tran vdout0_125ck190 FIND v(dout0_125) AT=100.025n

.meas tran vdout0_126ck190 FIND v(dout0_126) AT=100.025n

.meas tran vdout0_127ck190 FIND v(dout0_127) AT=100.025n

.meas tran vdout0_128ck190 FIND v(dout0_128) AT=100.025n

.meas tran vdout0_129ck190 FIND v(dout0_129) AT=100.025n

.meas tran vdout0_130ck190 FIND v(dout0_130) AT=100.025n

.meas tran vdout0_131ck190 FIND v(dout0_131) AT=100.025n

.meas tran vdout0_132ck190 FIND v(dout0_132) AT=100.025n

.meas tran vdout0_133ck190 FIND v(dout0_133) AT=100.025n

.meas tran vdout0_134ck190 FIND v(dout0_134) AT=100.025n

.meas tran vdout0_135ck190 FIND v(dout0_135) AT=100.025n

.meas tran vdout0_136ck190 FIND v(dout0_136) AT=100.025n

.meas tran vdout0_137ck190 FIND v(dout0_137) AT=100.025n

.meas tran vdout0_138ck190 FIND v(dout0_138) AT=100.025n

.meas tran vdout0_139ck190 FIND v(dout0_139) AT=100.025n

.meas tran vdout0_140ck190 FIND v(dout0_140) AT=100.025n

.meas tran vdout0_141ck190 FIND v(dout0_141) AT=100.025n

.meas tran vdout0_142ck190 FIND v(dout0_142) AT=100.025n

.meas tran vdout0_143ck190 FIND v(dout0_143) AT=100.025n

.meas tran vdout0_144ck190 FIND v(dout0_144) AT=100.025n

.meas tran vdout0_145ck190 FIND v(dout0_145) AT=100.025n

.meas tran vdout0_146ck190 FIND v(dout0_146) AT=100.025n

.meas tran vdout0_147ck190 FIND v(dout0_147) AT=100.025n

.meas tran vdout0_148ck190 FIND v(dout0_148) AT=100.025n

.meas tran vdout0_149ck190 FIND v(dout0_149) AT=100.025n

.meas tran vdout0_150ck190 FIND v(dout0_150) AT=100.025n

.meas tran vdout0_151ck190 FIND v(dout0_151) AT=100.025n

.meas tran vdout0_152ck190 FIND v(dout0_152) AT=100.025n

.meas tran vdout0_153ck190 FIND v(dout0_153) AT=100.025n

.meas tran vdout0_154ck190 FIND v(dout0_154) AT=100.025n

.meas tran vdout0_155ck190 FIND v(dout0_155) AT=100.025n

.meas tran vdout0_156ck190 FIND v(dout0_156) AT=100.025n

.meas tran vdout0_157ck190 FIND v(dout0_157) AT=100.025n

.meas tran vdout0_158ck190 FIND v(dout0_158) AT=100.025n

.meas tran vdout0_159ck190 FIND v(dout0_159) AT=100.025n

.meas tran vdout0_160ck190 FIND v(dout0_160) AT=100.025n

.meas tran vdout0_161ck190 FIND v(dout0_161) AT=100.025n

.meas tran vdout0_162ck190 FIND v(dout0_162) AT=100.025n

.meas tran vdout0_163ck190 FIND v(dout0_163) AT=100.025n

.meas tran vdout0_164ck190 FIND v(dout0_164) AT=100.025n

.meas tran vdout0_165ck190 FIND v(dout0_165) AT=100.025n

.meas tran vdout0_166ck190 FIND v(dout0_166) AT=100.025n

.meas tran vdout0_167ck190 FIND v(dout0_167) AT=100.025n

.meas tran vdout0_168ck190 FIND v(dout0_168) AT=100.025n

.meas tran vdout0_169ck190 FIND v(dout0_169) AT=100.025n

.meas tran vdout0_170ck190 FIND v(dout0_170) AT=100.025n

.meas tran vdout0_171ck190 FIND v(dout0_171) AT=100.025n

.meas tran vdout0_172ck190 FIND v(dout0_172) AT=100.025n

.meas tran vdout0_173ck190 FIND v(dout0_173) AT=100.025n

.meas tran vdout0_174ck190 FIND v(dout0_174) AT=100.025n

.meas tran vdout0_175ck190 FIND v(dout0_175) AT=100.025n

.meas tran vdout0_176ck190 FIND v(dout0_176) AT=100.025n

.meas tran vdout0_177ck190 FIND v(dout0_177) AT=100.025n

.meas tran vdout0_178ck190 FIND v(dout0_178) AT=100.025n

.meas tran vdout0_179ck190 FIND v(dout0_179) AT=100.025n

.meas tran vdout0_180ck190 FIND v(dout0_180) AT=100.025n

.meas tran vdout0_181ck190 FIND v(dout0_181) AT=100.025n

.meas tran vdout0_182ck190 FIND v(dout0_182) AT=100.025n

.meas tran vdout0_183ck190 FIND v(dout0_183) AT=100.025n

.meas tran vdout0_184ck190 FIND v(dout0_184) AT=100.025n

.meas tran vdout0_185ck190 FIND v(dout0_185) AT=100.025n

.meas tran vdout0_186ck190 FIND v(dout0_186) AT=100.025n

.meas tran vdout0_187ck190 FIND v(dout0_187) AT=100.025n

.meas tran vdout0_188ck190 FIND v(dout0_188) AT=100.025n

.meas tran vdout0_189ck190 FIND v(dout0_189) AT=100.025n

.meas tran vdout0_190ck190 FIND v(dout0_190) AT=100.025n

.meas tran vdout0_191ck190 FIND v(dout0_191) AT=100.025n

.meas tran vdout0_192ck190 FIND v(dout0_192) AT=100.025n

.meas tran vdout0_193ck190 FIND v(dout0_193) AT=100.025n

.meas tran vdout0_194ck190 FIND v(dout0_194) AT=100.025n

.meas tran vdout0_195ck190 FIND v(dout0_195) AT=100.025n

.meas tran vdout0_196ck190 FIND v(dout0_196) AT=100.025n

.meas tran vdout0_197ck190 FIND v(dout0_197) AT=100.025n

.meas tran vdout0_198ck190 FIND v(dout0_198) AT=100.025n

.meas tran vdout0_199ck190 FIND v(dout0_199) AT=100.025n

.meas tran vdout0_200ck190 FIND v(dout0_200) AT=100.025n

.meas tran vdout0_201ck190 FIND v(dout0_201) AT=100.025n

.meas tran vdout0_202ck190 FIND v(dout0_202) AT=100.025n

.meas tran vdout0_203ck190 FIND v(dout0_203) AT=100.025n

.meas tran vdout0_204ck190 FIND v(dout0_204) AT=100.025n

.meas tran vdout0_205ck190 FIND v(dout0_205) AT=100.025n

.meas tran vdout0_206ck190 FIND v(dout0_206) AT=100.025n

.meas tran vdout0_207ck190 FIND v(dout0_207) AT=100.025n

.meas tran vdout0_208ck190 FIND v(dout0_208) AT=100.025n

.meas tran vdout0_209ck190 FIND v(dout0_209) AT=100.025n

.meas tran vdout0_210ck190 FIND v(dout0_210) AT=100.025n

.meas tran vdout0_211ck190 FIND v(dout0_211) AT=100.025n

.meas tran vdout0_212ck190 FIND v(dout0_212) AT=100.025n

.meas tran vdout0_213ck190 FIND v(dout0_213) AT=100.025n

.meas tran vdout0_214ck190 FIND v(dout0_214) AT=100.025n

.meas tran vdout0_215ck190 FIND v(dout0_215) AT=100.025n

.meas tran vdout0_216ck190 FIND v(dout0_216) AT=100.025n

.meas tran vdout0_217ck190 FIND v(dout0_217) AT=100.025n

.meas tran vdout0_218ck190 FIND v(dout0_218) AT=100.025n

.meas tran vdout0_219ck190 FIND v(dout0_219) AT=100.025n

.meas tran vdout0_220ck190 FIND v(dout0_220) AT=100.025n

.meas tran vdout0_221ck190 FIND v(dout0_221) AT=100.025n

.meas tran vdout0_222ck190 FIND v(dout0_222) AT=100.025n

.meas tran vdout0_223ck190 FIND v(dout0_223) AT=100.025n

.meas tran vdout0_224ck190 FIND v(dout0_224) AT=100.025n

.meas tran vdout0_225ck190 FIND v(dout0_225) AT=100.025n

.meas tran vdout0_226ck190 FIND v(dout0_226) AT=100.025n

.meas tran vdout0_227ck190 FIND v(dout0_227) AT=100.025n

.meas tran vdout0_228ck190 FIND v(dout0_228) AT=100.025n

.meas tran vdout0_229ck190 FIND v(dout0_229) AT=100.025n

.meas tran vdout0_230ck190 FIND v(dout0_230) AT=100.025n

.meas tran vdout0_231ck190 FIND v(dout0_231) AT=100.025n

.meas tran vdout0_232ck190 FIND v(dout0_232) AT=100.025n

.meas tran vdout0_233ck190 FIND v(dout0_233) AT=100.025n

.meas tran vdout0_234ck190 FIND v(dout0_234) AT=100.025n

.meas tran vdout0_235ck190 FIND v(dout0_235) AT=100.025n

.meas tran vdout0_236ck190 FIND v(dout0_236) AT=100.025n

.meas tran vdout0_237ck190 FIND v(dout0_237) AT=100.025n

.meas tran vdout0_238ck190 FIND v(dout0_238) AT=100.025n

.meas tran vdout0_239ck190 FIND v(dout0_239) AT=100.025n

.meas tran vdout0_240ck190 FIND v(dout0_240) AT=100.025n

.meas tran vdout0_241ck190 FIND v(dout0_241) AT=100.025n

.meas tran vdout0_242ck190 FIND v(dout0_242) AT=100.025n

.meas tran vdout0_243ck190 FIND v(dout0_243) AT=100.025n

.meas tran vdout0_244ck190 FIND v(dout0_244) AT=100.025n

.meas tran vdout0_245ck190 FIND v(dout0_245) AT=100.025n

.meas tran vdout0_246ck190 FIND v(dout0_246) AT=100.025n

.meas tran vdout0_247ck190 FIND v(dout0_247) AT=100.025n

.meas tran vdout0_248ck190 FIND v(dout0_248) AT=100.025n

.meas tran vdout0_249ck190 FIND v(dout0_249) AT=100.025n

.meas tran vdout0_250ck190 FIND v(dout0_250) AT=100.025n

.meas tran vdout0_251ck190 FIND v(dout0_251) AT=100.025n

.meas tran vdout0_252ck190 FIND v(dout0_252) AT=100.025n

.meas tran vdout0_253ck190 FIND v(dout0_253) AT=100.025n

.meas tran vdout0_254ck190 FIND v(dout0_254) AT=100.025n

.meas tran vdout0_255ck190 FIND v(dout0_255) AT=100.025n

.meas tran vdout0_0ck260 FIND v(dout0_0) AT=135.025n

.meas tran vdout0_1ck260 FIND v(dout0_1) AT=135.025n

.meas tran vdout0_2ck260 FIND v(dout0_2) AT=135.025n

.meas tran vdout0_3ck260 FIND v(dout0_3) AT=135.025n

.meas tran vdout0_4ck260 FIND v(dout0_4) AT=135.025n

.meas tran vdout0_5ck260 FIND v(dout0_5) AT=135.025n

.meas tran vdout0_6ck260 FIND v(dout0_6) AT=135.025n

.meas tran vdout0_7ck260 FIND v(dout0_7) AT=135.025n

.meas tran vdout0_8ck260 FIND v(dout0_8) AT=135.025n

.meas tran vdout0_9ck260 FIND v(dout0_9) AT=135.025n

.meas tran vdout0_10ck260 FIND v(dout0_10) AT=135.025n

.meas tran vdout0_11ck260 FIND v(dout0_11) AT=135.025n

.meas tran vdout0_12ck260 FIND v(dout0_12) AT=135.025n

.meas tran vdout0_13ck260 FIND v(dout0_13) AT=135.025n

.meas tran vdout0_14ck260 FIND v(dout0_14) AT=135.025n

.meas tran vdout0_15ck260 FIND v(dout0_15) AT=135.025n

.meas tran vdout0_16ck260 FIND v(dout0_16) AT=135.025n

.meas tran vdout0_17ck260 FIND v(dout0_17) AT=135.025n

.meas tran vdout0_18ck260 FIND v(dout0_18) AT=135.025n

.meas tran vdout0_19ck260 FIND v(dout0_19) AT=135.025n

.meas tran vdout0_20ck260 FIND v(dout0_20) AT=135.025n

.meas tran vdout0_21ck260 FIND v(dout0_21) AT=135.025n

.meas tran vdout0_22ck260 FIND v(dout0_22) AT=135.025n

.meas tran vdout0_23ck260 FIND v(dout0_23) AT=135.025n

.meas tran vdout0_24ck260 FIND v(dout0_24) AT=135.025n

.meas tran vdout0_25ck260 FIND v(dout0_25) AT=135.025n

.meas tran vdout0_26ck260 FIND v(dout0_26) AT=135.025n

.meas tran vdout0_27ck260 FIND v(dout0_27) AT=135.025n

.meas tran vdout0_28ck260 FIND v(dout0_28) AT=135.025n

.meas tran vdout0_29ck260 FIND v(dout0_29) AT=135.025n

.meas tran vdout0_30ck260 FIND v(dout0_30) AT=135.025n

.meas tran vdout0_31ck260 FIND v(dout0_31) AT=135.025n

.meas tran vdout0_32ck260 FIND v(dout0_32) AT=135.025n

.meas tran vdout0_33ck260 FIND v(dout0_33) AT=135.025n

.meas tran vdout0_34ck260 FIND v(dout0_34) AT=135.025n

.meas tran vdout0_35ck260 FIND v(dout0_35) AT=135.025n

.meas tran vdout0_36ck260 FIND v(dout0_36) AT=135.025n

.meas tran vdout0_37ck260 FIND v(dout0_37) AT=135.025n

.meas tran vdout0_38ck260 FIND v(dout0_38) AT=135.025n

.meas tran vdout0_39ck260 FIND v(dout0_39) AT=135.025n

.meas tran vdout0_40ck260 FIND v(dout0_40) AT=135.025n

.meas tran vdout0_41ck260 FIND v(dout0_41) AT=135.025n

.meas tran vdout0_42ck260 FIND v(dout0_42) AT=135.025n

.meas tran vdout0_43ck260 FIND v(dout0_43) AT=135.025n

.meas tran vdout0_44ck260 FIND v(dout0_44) AT=135.025n

.meas tran vdout0_45ck260 FIND v(dout0_45) AT=135.025n

.meas tran vdout0_46ck260 FIND v(dout0_46) AT=135.025n

.meas tran vdout0_47ck260 FIND v(dout0_47) AT=135.025n

.meas tran vdout0_48ck260 FIND v(dout0_48) AT=135.025n

.meas tran vdout0_49ck260 FIND v(dout0_49) AT=135.025n

.meas tran vdout0_50ck260 FIND v(dout0_50) AT=135.025n

.meas tran vdout0_51ck260 FIND v(dout0_51) AT=135.025n

.meas tran vdout0_52ck260 FIND v(dout0_52) AT=135.025n

.meas tran vdout0_53ck260 FIND v(dout0_53) AT=135.025n

.meas tran vdout0_54ck260 FIND v(dout0_54) AT=135.025n

.meas tran vdout0_55ck260 FIND v(dout0_55) AT=135.025n

.meas tran vdout0_56ck260 FIND v(dout0_56) AT=135.025n

.meas tran vdout0_57ck260 FIND v(dout0_57) AT=135.025n

.meas tran vdout0_58ck260 FIND v(dout0_58) AT=135.025n

.meas tran vdout0_59ck260 FIND v(dout0_59) AT=135.025n

.meas tran vdout0_60ck260 FIND v(dout0_60) AT=135.025n

.meas tran vdout0_61ck260 FIND v(dout0_61) AT=135.025n

.meas tran vdout0_62ck260 FIND v(dout0_62) AT=135.025n

.meas tran vdout0_63ck260 FIND v(dout0_63) AT=135.025n

.meas tran vdout0_64ck260 FIND v(dout0_64) AT=135.025n

.meas tran vdout0_65ck260 FIND v(dout0_65) AT=135.025n

.meas tran vdout0_66ck260 FIND v(dout0_66) AT=135.025n

.meas tran vdout0_67ck260 FIND v(dout0_67) AT=135.025n

.meas tran vdout0_68ck260 FIND v(dout0_68) AT=135.025n

.meas tran vdout0_69ck260 FIND v(dout0_69) AT=135.025n

.meas tran vdout0_70ck260 FIND v(dout0_70) AT=135.025n

.meas tran vdout0_71ck260 FIND v(dout0_71) AT=135.025n

.meas tran vdout0_72ck260 FIND v(dout0_72) AT=135.025n

.meas tran vdout0_73ck260 FIND v(dout0_73) AT=135.025n

.meas tran vdout0_74ck260 FIND v(dout0_74) AT=135.025n

.meas tran vdout0_75ck260 FIND v(dout0_75) AT=135.025n

.meas tran vdout0_76ck260 FIND v(dout0_76) AT=135.025n

.meas tran vdout0_77ck260 FIND v(dout0_77) AT=135.025n

.meas tran vdout0_78ck260 FIND v(dout0_78) AT=135.025n

.meas tran vdout0_79ck260 FIND v(dout0_79) AT=135.025n

.meas tran vdout0_80ck260 FIND v(dout0_80) AT=135.025n

.meas tran vdout0_81ck260 FIND v(dout0_81) AT=135.025n

.meas tran vdout0_82ck260 FIND v(dout0_82) AT=135.025n

.meas tran vdout0_83ck260 FIND v(dout0_83) AT=135.025n

.meas tran vdout0_84ck260 FIND v(dout0_84) AT=135.025n

.meas tran vdout0_85ck260 FIND v(dout0_85) AT=135.025n

.meas tran vdout0_86ck260 FIND v(dout0_86) AT=135.025n

.meas tran vdout0_87ck260 FIND v(dout0_87) AT=135.025n

.meas tran vdout0_88ck260 FIND v(dout0_88) AT=135.025n

.meas tran vdout0_89ck260 FIND v(dout0_89) AT=135.025n

.meas tran vdout0_90ck260 FIND v(dout0_90) AT=135.025n

.meas tran vdout0_91ck260 FIND v(dout0_91) AT=135.025n

.meas tran vdout0_92ck260 FIND v(dout0_92) AT=135.025n

.meas tran vdout0_93ck260 FIND v(dout0_93) AT=135.025n

.meas tran vdout0_94ck260 FIND v(dout0_94) AT=135.025n

.meas tran vdout0_95ck260 FIND v(dout0_95) AT=135.025n

.meas tran vdout0_96ck260 FIND v(dout0_96) AT=135.025n

.meas tran vdout0_97ck260 FIND v(dout0_97) AT=135.025n

.meas tran vdout0_98ck260 FIND v(dout0_98) AT=135.025n

.meas tran vdout0_99ck260 FIND v(dout0_99) AT=135.025n

.meas tran vdout0_100ck260 FIND v(dout0_100) AT=135.025n

.meas tran vdout0_101ck260 FIND v(dout0_101) AT=135.025n

.meas tran vdout0_102ck260 FIND v(dout0_102) AT=135.025n

.meas tran vdout0_103ck260 FIND v(dout0_103) AT=135.025n

.meas tran vdout0_104ck260 FIND v(dout0_104) AT=135.025n

.meas tran vdout0_105ck260 FIND v(dout0_105) AT=135.025n

.meas tran vdout0_106ck260 FIND v(dout0_106) AT=135.025n

.meas tran vdout0_107ck260 FIND v(dout0_107) AT=135.025n

.meas tran vdout0_108ck260 FIND v(dout0_108) AT=135.025n

.meas tran vdout0_109ck260 FIND v(dout0_109) AT=135.025n

.meas tran vdout0_110ck260 FIND v(dout0_110) AT=135.025n

.meas tran vdout0_111ck260 FIND v(dout0_111) AT=135.025n

.meas tran vdout0_112ck260 FIND v(dout0_112) AT=135.025n

.meas tran vdout0_113ck260 FIND v(dout0_113) AT=135.025n

.meas tran vdout0_114ck260 FIND v(dout0_114) AT=135.025n

.meas tran vdout0_115ck260 FIND v(dout0_115) AT=135.025n

.meas tran vdout0_116ck260 FIND v(dout0_116) AT=135.025n

.meas tran vdout0_117ck260 FIND v(dout0_117) AT=135.025n

.meas tran vdout0_118ck260 FIND v(dout0_118) AT=135.025n

.meas tran vdout0_119ck260 FIND v(dout0_119) AT=135.025n

.meas tran vdout0_120ck260 FIND v(dout0_120) AT=135.025n

.meas tran vdout0_121ck260 FIND v(dout0_121) AT=135.025n

.meas tran vdout0_122ck260 FIND v(dout0_122) AT=135.025n

.meas tran vdout0_123ck260 FIND v(dout0_123) AT=135.025n

.meas tran vdout0_124ck260 FIND v(dout0_124) AT=135.025n

.meas tran vdout0_125ck260 FIND v(dout0_125) AT=135.025n

.meas tran vdout0_126ck260 FIND v(dout0_126) AT=135.025n

.meas tran vdout0_127ck260 FIND v(dout0_127) AT=135.025n

.meas tran vdout0_128ck260 FIND v(dout0_128) AT=135.025n

.meas tran vdout0_129ck260 FIND v(dout0_129) AT=135.025n

.meas tran vdout0_130ck260 FIND v(dout0_130) AT=135.025n

.meas tran vdout0_131ck260 FIND v(dout0_131) AT=135.025n

.meas tran vdout0_132ck260 FIND v(dout0_132) AT=135.025n

.meas tran vdout0_133ck260 FIND v(dout0_133) AT=135.025n

.meas tran vdout0_134ck260 FIND v(dout0_134) AT=135.025n

.meas tran vdout0_135ck260 FIND v(dout0_135) AT=135.025n

.meas tran vdout0_136ck260 FIND v(dout0_136) AT=135.025n

.meas tran vdout0_137ck260 FIND v(dout0_137) AT=135.025n

.meas tran vdout0_138ck260 FIND v(dout0_138) AT=135.025n

.meas tran vdout0_139ck260 FIND v(dout0_139) AT=135.025n

.meas tran vdout0_140ck260 FIND v(dout0_140) AT=135.025n

.meas tran vdout0_141ck260 FIND v(dout0_141) AT=135.025n

.meas tran vdout0_142ck260 FIND v(dout0_142) AT=135.025n

.meas tran vdout0_143ck260 FIND v(dout0_143) AT=135.025n

.meas tran vdout0_144ck260 FIND v(dout0_144) AT=135.025n

.meas tran vdout0_145ck260 FIND v(dout0_145) AT=135.025n

.meas tran vdout0_146ck260 FIND v(dout0_146) AT=135.025n

.meas tran vdout0_147ck260 FIND v(dout0_147) AT=135.025n

.meas tran vdout0_148ck260 FIND v(dout0_148) AT=135.025n

.meas tran vdout0_149ck260 FIND v(dout0_149) AT=135.025n

.meas tran vdout0_150ck260 FIND v(dout0_150) AT=135.025n

.meas tran vdout0_151ck260 FIND v(dout0_151) AT=135.025n

.meas tran vdout0_152ck260 FIND v(dout0_152) AT=135.025n

.meas tran vdout0_153ck260 FIND v(dout0_153) AT=135.025n

.meas tran vdout0_154ck260 FIND v(dout0_154) AT=135.025n

.meas tran vdout0_155ck260 FIND v(dout0_155) AT=135.025n

.meas tran vdout0_156ck260 FIND v(dout0_156) AT=135.025n

.meas tran vdout0_157ck260 FIND v(dout0_157) AT=135.025n

.meas tran vdout0_158ck260 FIND v(dout0_158) AT=135.025n

.meas tran vdout0_159ck260 FIND v(dout0_159) AT=135.025n

.meas tran vdout0_160ck260 FIND v(dout0_160) AT=135.025n

.meas tran vdout0_161ck260 FIND v(dout0_161) AT=135.025n

.meas tran vdout0_162ck260 FIND v(dout0_162) AT=135.025n

.meas tran vdout0_163ck260 FIND v(dout0_163) AT=135.025n

.meas tran vdout0_164ck260 FIND v(dout0_164) AT=135.025n

.meas tran vdout0_165ck260 FIND v(dout0_165) AT=135.025n

.meas tran vdout0_166ck260 FIND v(dout0_166) AT=135.025n

.meas tran vdout0_167ck260 FIND v(dout0_167) AT=135.025n

.meas tran vdout0_168ck260 FIND v(dout0_168) AT=135.025n

.meas tran vdout0_169ck260 FIND v(dout0_169) AT=135.025n

.meas tran vdout0_170ck260 FIND v(dout0_170) AT=135.025n

.meas tran vdout0_171ck260 FIND v(dout0_171) AT=135.025n

.meas tran vdout0_172ck260 FIND v(dout0_172) AT=135.025n

.meas tran vdout0_173ck260 FIND v(dout0_173) AT=135.025n

.meas tran vdout0_174ck260 FIND v(dout0_174) AT=135.025n

.meas tran vdout0_175ck260 FIND v(dout0_175) AT=135.025n

.meas tran vdout0_176ck260 FIND v(dout0_176) AT=135.025n

.meas tran vdout0_177ck260 FIND v(dout0_177) AT=135.025n

.meas tran vdout0_178ck260 FIND v(dout0_178) AT=135.025n

.meas tran vdout0_179ck260 FIND v(dout0_179) AT=135.025n

.meas tran vdout0_180ck260 FIND v(dout0_180) AT=135.025n

.meas tran vdout0_181ck260 FIND v(dout0_181) AT=135.025n

.meas tran vdout0_182ck260 FIND v(dout0_182) AT=135.025n

.meas tran vdout0_183ck260 FIND v(dout0_183) AT=135.025n

.meas tran vdout0_184ck260 FIND v(dout0_184) AT=135.025n

.meas tran vdout0_185ck260 FIND v(dout0_185) AT=135.025n

.meas tran vdout0_186ck260 FIND v(dout0_186) AT=135.025n

.meas tran vdout0_187ck260 FIND v(dout0_187) AT=135.025n

.meas tran vdout0_188ck260 FIND v(dout0_188) AT=135.025n

.meas tran vdout0_189ck260 FIND v(dout0_189) AT=135.025n

.meas tran vdout0_190ck260 FIND v(dout0_190) AT=135.025n

.meas tran vdout0_191ck260 FIND v(dout0_191) AT=135.025n

.meas tran vdout0_192ck260 FIND v(dout0_192) AT=135.025n

.meas tran vdout0_193ck260 FIND v(dout0_193) AT=135.025n

.meas tran vdout0_194ck260 FIND v(dout0_194) AT=135.025n

.meas tran vdout0_195ck260 FIND v(dout0_195) AT=135.025n

.meas tran vdout0_196ck260 FIND v(dout0_196) AT=135.025n

.meas tran vdout0_197ck260 FIND v(dout0_197) AT=135.025n

.meas tran vdout0_198ck260 FIND v(dout0_198) AT=135.025n

.meas tran vdout0_199ck260 FIND v(dout0_199) AT=135.025n

.meas tran vdout0_200ck260 FIND v(dout0_200) AT=135.025n

.meas tran vdout0_201ck260 FIND v(dout0_201) AT=135.025n

.meas tran vdout0_202ck260 FIND v(dout0_202) AT=135.025n

.meas tran vdout0_203ck260 FIND v(dout0_203) AT=135.025n

.meas tran vdout0_204ck260 FIND v(dout0_204) AT=135.025n

.meas tran vdout0_205ck260 FIND v(dout0_205) AT=135.025n

.meas tran vdout0_206ck260 FIND v(dout0_206) AT=135.025n

.meas tran vdout0_207ck260 FIND v(dout0_207) AT=135.025n

.meas tran vdout0_208ck260 FIND v(dout0_208) AT=135.025n

.meas tran vdout0_209ck260 FIND v(dout0_209) AT=135.025n

.meas tran vdout0_210ck260 FIND v(dout0_210) AT=135.025n

.meas tran vdout0_211ck260 FIND v(dout0_211) AT=135.025n

.meas tran vdout0_212ck260 FIND v(dout0_212) AT=135.025n

.meas tran vdout0_213ck260 FIND v(dout0_213) AT=135.025n

.meas tran vdout0_214ck260 FIND v(dout0_214) AT=135.025n

.meas tran vdout0_215ck260 FIND v(dout0_215) AT=135.025n

.meas tran vdout0_216ck260 FIND v(dout0_216) AT=135.025n

.meas tran vdout0_217ck260 FIND v(dout0_217) AT=135.025n

.meas tran vdout0_218ck260 FIND v(dout0_218) AT=135.025n

.meas tran vdout0_219ck260 FIND v(dout0_219) AT=135.025n

.meas tran vdout0_220ck260 FIND v(dout0_220) AT=135.025n

.meas tran vdout0_221ck260 FIND v(dout0_221) AT=135.025n

.meas tran vdout0_222ck260 FIND v(dout0_222) AT=135.025n

.meas tran vdout0_223ck260 FIND v(dout0_223) AT=135.025n

.meas tran vdout0_224ck260 FIND v(dout0_224) AT=135.025n

.meas tran vdout0_225ck260 FIND v(dout0_225) AT=135.025n

.meas tran vdout0_226ck260 FIND v(dout0_226) AT=135.025n

.meas tran vdout0_227ck260 FIND v(dout0_227) AT=135.025n

.meas tran vdout0_228ck260 FIND v(dout0_228) AT=135.025n

.meas tran vdout0_229ck260 FIND v(dout0_229) AT=135.025n

.meas tran vdout0_230ck260 FIND v(dout0_230) AT=135.025n

.meas tran vdout0_231ck260 FIND v(dout0_231) AT=135.025n

.meas tran vdout0_232ck260 FIND v(dout0_232) AT=135.025n

.meas tran vdout0_233ck260 FIND v(dout0_233) AT=135.025n

.meas tran vdout0_234ck260 FIND v(dout0_234) AT=135.025n

.meas tran vdout0_235ck260 FIND v(dout0_235) AT=135.025n

.meas tran vdout0_236ck260 FIND v(dout0_236) AT=135.025n

.meas tran vdout0_237ck260 FIND v(dout0_237) AT=135.025n

.meas tran vdout0_238ck260 FIND v(dout0_238) AT=135.025n

.meas tran vdout0_239ck260 FIND v(dout0_239) AT=135.025n

.meas tran vdout0_240ck260 FIND v(dout0_240) AT=135.025n

.meas tran vdout0_241ck260 FIND v(dout0_241) AT=135.025n

.meas tran vdout0_242ck260 FIND v(dout0_242) AT=135.025n

.meas tran vdout0_243ck260 FIND v(dout0_243) AT=135.025n

.meas tran vdout0_244ck260 FIND v(dout0_244) AT=135.025n

.meas tran vdout0_245ck260 FIND v(dout0_245) AT=135.025n

.meas tran vdout0_246ck260 FIND v(dout0_246) AT=135.025n

.meas tran vdout0_247ck260 FIND v(dout0_247) AT=135.025n

.meas tran vdout0_248ck260 FIND v(dout0_248) AT=135.025n

.meas tran vdout0_249ck260 FIND v(dout0_249) AT=135.025n

.meas tran vdout0_250ck260 FIND v(dout0_250) AT=135.025n

.meas tran vdout0_251ck260 FIND v(dout0_251) AT=135.025n

.meas tran vdout0_252ck260 FIND v(dout0_252) AT=135.025n

.meas tran vdout0_253ck260 FIND v(dout0_253) AT=135.025n

.meas tran vdout0_254ck260 FIND v(dout0_254) AT=135.025n

.meas tran vdout0_255ck260 FIND v(dout0_255) AT=135.025n

.meas tran vdout0_0ck280 FIND v(dout0_0) AT=145.025n

.meas tran vdout0_1ck280 FIND v(dout0_1) AT=145.025n

.meas tran vdout0_2ck280 FIND v(dout0_2) AT=145.025n

.meas tran vdout0_3ck280 FIND v(dout0_3) AT=145.025n

.meas tran vdout0_4ck280 FIND v(dout0_4) AT=145.025n

.meas tran vdout0_5ck280 FIND v(dout0_5) AT=145.025n

.meas tran vdout0_6ck280 FIND v(dout0_6) AT=145.025n

.meas tran vdout0_7ck280 FIND v(dout0_7) AT=145.025n

.meas tran vdout0_8ck280 FIND v(dout0_8) AT=145.025n

.meas tran vdout0_9ck280 FIND v(dout0_9) AT=145.025n

.meas tran vdout0_10ck280 FIND v(dout0_10) AT=145.025n

.meas tran vdout0_11ck280 FIND v(dout0_11) AT=145.025n

.meas tran vdout0_12ck280 FIND v(dout0_12) AT=145.025n

.meas tran vdout0_13ck280 FIND v(dout0_13) AT=145.025n

.meas tran vdout0_14ck280 FIND v(dout0_14) AT=145.025n

.meas tran vdout0_15ck280 FIND v(dout0_15) AT=145.025n

.meas tran vdout0_16ck280 FIND v(dout0_16) AT=145.025n

.meas tran vdout0_17ck280 FIND v(dout0_17) AT=145.025n

.meas tran vdout0_18ck280 FIND v(dout0_18) AT=145.025n

.meas tran vdout0_19ck280 FIND v(dout0_19) AT=145.025n

.meas tran vdout0_20ck280 FIND v(dout0_20) AT=145.025n

.meas tran vdout0_21ck280 FIND v(dout0_21) AT=145.025n

.meas tran vdout0_22ck280 FIND v(dout0_22) AT=145.025n

.meas tran vdout0_23ck280 FIND v(dout0_23) AT=145.025n

.meas tran vdout0_24ck280 FIND v(dout0_24) AT=145.025n

.meas tran vdout0_25ck280 FIND v(dout0_25) AT=145.025n

.meas tran vdout0_26ck280 FIND v(dout0_26) AT=145.025n

.meas tran vdout0_27ck280 FIND v(dout0_27) AT=145.025n

.meas tran vdout0_28ck280 FIND v(dout0_28) AT=145.025n

.meas tran vdout0_29ck280 FIND v(dout0_29) AT=145.025n

.meas tran vdout0_30ck280 FIND v(dout0_30) AT=145.025n

.meas tran vdout0_31ck280 FIND v(dout0_31) AT=145.025n

.meas tran vdout0_32ck280 FIND v(dout0_32) AT=145.025n

.meas tran vdout0_33ck280 FIND v(dout0_33) AT=145.025n

.meas tran vdout0_34ck280 FIND v(dout0_34) AT=145.025n

.meas tran vdout0_35ck280 FIND v(dout0_35) AT=145.025n

.meas tran vdout0_36ck280 FIND v(dout0_36) AT=145.025n

.meas tran vdout0_37ck280 FIND v(dout0_37) AT=145.025n

.meas tran vdout0_38ck280 FIND v(dout0_38) AT=145.025n

.meas tran vdout0_39ck280 FIND v(dout0_39) AT=145.025n

.meas tran vdout0_40ck280 FIND v(dout0_40) AT=145.025n

.meas tran vdout0_41ck280 FIND v(dout0_41) AT=145.025n

.meas tran vdout0_42ck280 FIND v(dout0_42) AT=145.025n

.meas tran vdout0_43ck280 FIND v(dout0_43) AT=145.025n

.meas tran vdout0_44ck280 FIND v(dout0_44) AT=145.025n

.meas tran vdout0_45ck280 FIND v(dout0_45) AT=145.025n

.meas tran vdout0_46ck280 FIND v(dout0_46) AT=145.025n

.meas tran vdout0_47ck280 FIND v(dout0_47) AT=145.025n

.meas tran vdout0_48ck280 FIND v(dout0_48) AT=145.025n

.meas tran vdout0_49ck280 FIND v(dout0_49) AT=145.025n

.meas tran vdout0_50ck280 FIND v(dout0_50) AT=145.025n

.meas tran vdout0_51ck280 FIND v(dout0_51) AT=145.025n

.meas tran vdout0_52ck280 FIND v(dout0_52) AT=145.025n

.meas tran vdout0_53ck280 FIND v(dout0_53) AT=145.025n

.meas tran vdout0_54ck280 FIND v(dout0_54) AT=145.025n

.meas tran vdout0_55ck280 FIND v(dout0_55) AT=145.025n

.meas tran vdout0_56ck280 FIND v(dout0_56) AT=145.025n

.meas tran vdout0_57ck280 FIND v(dout0_57) AT=145.025n

.meas tran vdout0_58ck280 FIND v(dout0_58) AT=145.025n

.meas tran vdout0_59ck280 FIND v(dout0_59) AT=145.025n

.meas tran vdout0_60ck280 FIND v(dout0_60) AT=145.025n

.meas tran vdout0_61ck280 FIND v(dout0_61) AT=145.025n

.meas tran vdout0_62ck280 FIND v(dout0_62) AT=145.025n

.meas tran vdout0_63ck280 FIND v(dout0_63) AT=145.025n

.meas tran vdout0_64ck280 FIND v(dout0_64) AT=145.025n

.meas tran vdout0_65ck280 FIND v(dout0_65) AT=145.025n

.meas tran vdout0_66ck280 FIND v(dout0_66) AT=145.025n

.meas tran vdout0_67ck280 FIND v(dout0_67) AT=145.025n

.meas tran vdout0_68ck280 FIND v(dout0_68) AT=145.025n

.meas tran vdout0_69ck280 FIND v(dout0_69) AT=145.025n

.meas tran vdout0_70ck280 FIND v(dout0_70) AT=145.025n

.meas tran vdout0_71ck280 FIND v(dout0_71) AT=145.025n

.meas tran vdout0_72ck280 FIND v(dout0_72) AT=145.025n

.meas tran vdout0_73ck280 FIND v(dout0_73) AT=145.025n

.meas tran vdout0_74ck280 FIND v(dout0_74) AT=145.025n

.meas tran vdout0_75ck280 FIND v(dout0_75) AT=145.025n

.meas tran vdout0_76ck280 FIND v(dout0_76) AT=145.025n

.meas tran vdout0_77ck280 FIND v(dout0_77) AT=145.025n

.meas tran vdout0_78ck280 FIND v(dout0_78) AT=145.025n

.meas tran vdout0_79ck280 FIND v(dout0_79) AT=145.025n

.meas tran vdout0_80ck280 FIND v(dout0_80) AT=145.025n

.meas tran vdout0_81ck280 FIND v(dout0_81) AT=145.025n

.meas tran vdout0_82ck280 FIND v(dout0_82) AT=145.025n

.meas tran vdout0_83ck280 FIND v(dout0_83) AT=145.025n

.meas tran vdout0_84ck280 FIND v(dout0_84) AT=145.025n

.meas tran vdout0_85ck280 FIND v(dout0_85) AT=145.025n

.meas tran vdout0_86ck280 FIND v(dout0_86) AT=145.025n

.meas tran vdout0_87ck280 FIND v(dout0_87) AT=145.025n

.meas tran vdout0_88ck280 FIND v(dout0_88) AT=145.025n

.meas tran vdout0_89ck280 FIND v(dout0_89) AT=145.025n

.meas tran vdout0_90ck280 FIND v(dout0_90) AT=145.025n

.meas tran vdout0_91ck280 FIND v(dout0_91) AT=145.025n

.meas tran vdout0_92ck280 FIND v(dout0_92) AT=145.025n

.meas tran vdout0_93ck280 FIND v(dout0_93) AT=145.025n

.meas tran vdout0_94ck280 FIND v(dout0_94) AT=145.025n

.meas tran vdout0_95ck280 FIND v(dout0_95) AT=145.025n

.meas tran vdout0_96ck280 FIND v(dout0_96) AT=145.025n

.meas tran vdout0_97ck280 FIND v(dout0_97) AT=145.025n

.meas tran vdout0_98ck280 FIND v(dout0_98) AT=145.025n

.meas tran vdout0_99ck280 FIND v(dout0_99) AT=145.025n

.meas tran vdout0_100ck280 FIND v(dout0_100) AT=145.025n

.meas tran vdout0_101ck280 FIND v(dout0_101) AT=145.025n

.meas tran vdout0_102ck280 FIND v(dout0_102) AT=145.025n

.meas tran vdout0_103ck280 FIND v(dout0_103) AT=145.025n

.meas tran vdout0_104ck280 FIND v(dout0_104) AT=145.025n

.meas tran vdout0_105ck280 FIND v(dout0_105) AT=145.025n

.meas tran vdout0_106ck280 FIND v(dout0_106) AT=145.025n

.meas tran vdout0_107ck280 FIND v(dout0_107) AT=145.025n

.meas tran vdout0_108ck280 FIND v(dout0_108) AT=145.025n

.meas tran vdout0_109ck280 FIND v(dout0_109) AT=145.025n

.meas tran vdout0_110ck280 FIND v(dout0_110) AT=145.025n

.meas tran vdout0_111ck280 FIND v(dout0_111) AT=145.025n

.meas tran vdout0_112ck280 FIND v(dout0_112) AT=145.025n

.meas tran vdout0_113ck280 FIND v(dout0_113) AT=145.025n

.meas tran vdout0_114ck280 FIND v(dout0_114) AT=145.025n

.meas tran vdout0_115ck280 FIND v(dout0_115) AT=145.025n

.meas tran vdout0_116ck280 FIND v(dout0_116) AT=145.025n

.meas tran vdout0_117ck280 FIND v(dout0_117) AT=145.025n

.meas tran vdout0_118ck280 FIND v(dout0_118) AT=145.025n

.meas tran vdout0_119ck280 FIND v(dout0_119) AT=145.025n

.meas tran vdout0_120ck280 FIND v(dout0_120) AT=145.025n

.meas tran vdout0_121ck280 FIND v(dout0_121) AT=145.025n

.meas tran vdout0_122ck280 FIND v(dout0_122) AT=145.025n

.meas tran vdout0_123ck280 FIND v(dout0_123) AT=145.025n

.meas tran vdout0_124ck280 FIND v(dout0_124) AT=145.025n

.meas tran vdout0_125ck280 FIND v(dout0_125) AT=145.025n

.meas tran vdout0_126ck280 FIND v(dout0_126) AT=145.025n

.meas tran vdout0_127ck280 FIND v(dout0_127) AT=145.025n

.meas tran vdout0_128ck280 FIND v(dout0_128) AT=145.025n

.meas tran vdout0_129ck280 FIND v(dout0_129) AT=145.025n

.meas tran vdout0_130ck280 FIND v(dout0_130) AT=145.025n

.meas tran vdout0_131ck280 FIND v(dout0_131) AT=145.025n

.meas tran vdout0_132ck280 FIND v(dout0_132) AT=145.025n

.meas tran vdout0_133ck280 FIND v(dout0_133) AT=145.025n

.meas tran vdout0_134ck280 FIND v(dout0_134) AT=145.025n

.meas tran vdout0_135ck280 FIND v(dout0_135) AT=145.025n

.meas tran vdout0_136ck280 FIND v(dout0_136) AT=145.025n

.meas tran vdout0_137ck280 FIND v(dout0_137) AT=145.025n

.meas tran vdout0_138ck280 FIND v(dout0_138) AT=145.025n

.meas tran vdout0_139ck280 FIND v(dout0_139) AT=145.025n

.meas tran vdout0_140ck280 FIND v(dout0_140) AT=145.025n

.meas tran vdout0_141ck280 FIND v(dout0_141) AT=145.025n

.meas tran vdout0_142ck280 FIND v(dout0_142) AT=145.025n

.meas tran vdout0_143ck280 FIND v(dout0_143) AT=145.025n

.meas tran vdout0_144ck280 FIND v(dout0_144) AT=145.025n

.meas tran vdout0_145ck280 FIND v(dout0_145) AT=145.025n

.meas tran vdout0_146ck280 FIND v(dout0_146) AT=145.025n

.meas tran vdout0_147ck280 FIND v(dout0_147) AT=145.025n

.meas tran vdout0_148ck280 FIND v(dout0_148) AT=145.025n

.meas tran vdout0_149ck280 FIND v(dout0_149) AT=145.025n

.meas tran vdout0_150ck280 FIND v(dout0_150) AT=145.025n

.meas tran vdout0_151ck280 FIND v(dout0_151) AT=145.025n

.meas tran vdout0_152ck280 FIND v(dout0_152) AT=145.025n

.meas tran vdout0_153ck280 FIND v(dout0_153) AT=145.025n

.meas tran vdout0_154ck280 FIND v(dout0_154) AT=145.025n

.meas tran vdout0_155ck280 FIND v(dout0_155) AT=145.025n

.meas tran vdout0_156ck280 FIND v(dout0_156) AT=145.025n

.meas tran vdout0_157ck280 FIND v(dout0_157) AT=145.025n

.meas tran vdout0_158ck280 FIND v(dout0_158) AT=145.025n

.meas tran vdout0_159ck280 FIND v(dout0_159) AT=145.025n

.meas tran vdout0_160ck280 FIND v(dout0_160) AT=145.025n

.meas tran vdout0_161ck280 FIND v(dout0_161) AT=145.025n

.meas tran vdout0_162ck280 FIND v(dout0_162) AT=145.025n

.meas tran vdout0_163ck280 FIND v(dout0_163) AT=145.025n

.meas tran vdout0_164ck280 FIND v(dout0_164) AT=145.025n

.meas tran vdout0_165ck280 FIND v(dout0_165) AT=145.025n

.meas tran vdout0_166ck280 FIND v(dout0_166) AT=145.025n

.meas tran vdout0_167ck280 FIND v(dout0_167) AT=145.025n

.meas tran vdout0_168ck280 FIND v(dout0_168) AT=145.025n

.meas tran vdout0_169ck280 FIND v(dout0_169) AT=145.025n

.meas tran vdout0_170ck280 FIND v(dout0_170) AT=145.025n

.meas tran vdout0_171ck280 FIND v(dout0_171) AT=145.025n

.meas tran vdout0_172ck280 FIND v(dout0_172) AT=145.025n

.meas tran vdout0_173ck280 FIND v(dout0_173) AT=145.025n

.meas tran vdout0_174ck280 FIND v(dout0_174) AT=145.025n

.meas tran vdout0_175ck280 FIND v(dout0_175) AT=145.025n

.meas tran vdout0_176ck280 FIND v(dout0_176) AT=145.025n

.meas tran vdout0_177ck280 FIND v(dout0_177) AT=145.025n

.meas tran vdout0_178ck280 FIND v(dout0_178) AT=145.025n

.meas tran vdout0_179ck280 FIND v(dout0_179) AT=145.025n

.meas tran vdout0_180ck280 FIND v(dout0_180) AT=145.025n

.meas tran vdout0_181ck280 FIND v(dout0_181) AT=145.025n

.meas tran vdout0_182ck280 FIND v(dout0_182) AT=145.025n

.meas tran vdout0_183ck280 FIND v(dout0_183) AT=145.025n

.meas tran vdout0_184ck280 FIND v(dout0_184) AT=145.025n

.meas tran vdout0_185ck280 FIND v(dout0_185) AT=145.025n

.meas tran vdout0_186ck280 FIND v(dout0_186) AT=145.025n

.meas tran vdout0_187ck280 FIND v(dout0_187) AT=145.025n

.meas tran vdout0_188ck280 FIND v(dout0_188) AT=145.025n

.meas tran vdout0_189ck280 FIND v(dout0_189) AT=145.025n

.meas tran vdout0_190ck280 FIND v(dout0_190) AT=145.025n

.meas tran vdout0_191ck280 FIND v(dout0_191) AT=145.025n

.meas tran vdout0_192ck280 FIND v(dout0_192) AT=145.025n

.meas tran vdout0_193ck280 FIND v(dout0_193) AT=145.025n

.meas tran vdout0_194ck280 FIND v(dout0_194) AT=145.025n

.meas tran vdout0_195ck280 FIND v(dout0_195) AT=145.025n

.meas tran vdout0_196ck280 FIND v(dout0_196) AT=145.025n

.meas tran vdout0_197ck280 FIND v(dout0_197) AT=145.025n

.meas tran vdout0_198ck280 FIND v(dout0_198) AT=145.025n

.meas tran vdout0_199ck280 FIND v(dout0_199) AT=145.025n

.meas tran vdout0_200ck280 FIND v(dout0_200) AT=145.025n

.meas tran vdout0_201ck280 FIND v(dout0_201) AT=145.025n

.meas tran vdout0_202ck280 FIND v(dout0_202) AT=145.025n

.meas tran vdout0_203ck280 FIND v(dout0_203) AT=145.025n

.meas tran vdout0_204ck280 FIND v(dout0_204) AT=145.025n

.meas tran vdout0_205ck280 FIND v(dout0_205) AT=145.025n

.meas tran vdout0_206ck280 FIND v(dout0_206) AT=145.025n

.meas tran vdout0_207ck280 FIND v(dout0_207) AT=145.025n

.meas tran vdout0_208ck280 FIND v(dout0_208) AT=145.025n

.meas tran vdout0_209ck280 FIND v(dout0_209) AT=145.025n

.meas tran vdout0_210ck280 FIND v(dout0_210) AT=145.025n

.meas tran vdout0_211ck280 FIND v(dout0_211) AT=145.025n

.meas tran vdout0_212ck280 FIND v(dout0_212) AT=145.025n

.meas tran vdout0_213ck280 FIND v(dout0_213) AT=145.025n

.meas tran vdout0_214ck280 FIND v(dout0_214) AT=145.025n

.meas tran vdout0_215ck280 FIND v(dout0_215) AT=145.025n

.meas tran vdout0_216ck280 FIND v(dout0_216) AT=145.025n

.meas tran vdout0_217ck280 FIND v(dout0_217) AT=145.025n

.meas tran vdout0_218ck280 FIND v(dout0_218) AT=145.025n

.meas tran vdout0_219ck280 FIND v(dout0_219) AT=145.025n

.meas tran vdout0_220ck280 FIND v(dout0_220) AT=145.025n

.meas tran vdout0_221ck280 FIND v(dout0_221) AT=145.025n

.meas tran vdout0_222ck280 FIND v(dout0_222) AT=145.025n

.meas tran vdout0_223ck280 FIND v(dout0_223) AT=145.025n

.meas tran vdout0_224ck280 FIND v(dout0_224) AT=145.025n

.meas tran vdout0_225ck280 FIND v(dout0_225) AT=145.025n

.meas tran vdout0_226ck280 FIND v(dout0_226) AT=145.025n

.meas tran vdout0_227ck280 FIND v(dout0_227) AT=145.025n

.meas tran vdout0_228ck280 FIND v(dout0_228) AT=145.025n

.meas tran vdout0_229ck280 FIND v(dout0_229) AT=145.025n

.meas tran vdout0_230ck280 FIND v(dout0_230) AT=145.025n

.meas tran vdout0_231ck280 FIND v(dout0_231) AT=145.025n

.meas tran vdout0_232ck280 FIND v(dout0_232) AT=145.025n

.meas tran vdout0_233ck280 FIND v(dout0_233) AT=145.025n

.meas tran vdout0_234ck280 FIND v(dout0_234) AT=145.025n

.meas tran vdout0_235ck280 FIND v(dout0_235) AT=145.025n

.meas tran vdout0_236ck280 FIND v(dout0_236) AT=145.025n

.meas tran vdout0_237ck280 FIND v(dout0_237) AT=145.025n

.meas tran vdout0_238ck280 FIND v(dout0_238) AT=145.025n

.meas tran vdout0_239ck280 FIND v(dout0_239) AT=145.025n

.meas tran vdout0_240ck280 FIND v(dout0_240) AT=145.025n

.meas tran vdout0_241ck280 FIND v(dout0_241) AT=145.025n

.meas tran vdout0_242ck280 FIND v(dout0_242) AT=145.025n

.meas tran vdout0_243ck280 FIND v(dout0_243) AT=145.025n

.meas tran vdout0_244ck280 FIND v(dout0_244) AT=145.025n

.meas tran vdout0_245ck280 FIND v(dout0_245) AT=145.025n

.meas tran vdout0_246ck280 FIND v(dout0_246) AT=145.025n

.meas tran vdout0_247ck280 FIND v(dout0_247) AT=145.025n

.meas tran vdout0_248ck280 FIND v(dout0_248) AT=145.025n

.meas tran vdout0_249ck280 FIND v(dout0_249) AT=145.025n

.meas tran vdout0_250ck280 FIND v(dout0_250) AT=145.025n

.meas tran vdout0_251ck280 FIND v(dout0_251) AT=145.025n

.meas tran vdout0_252ck280 FIND v(dout0_252) AT=145.025n

.meas tran vdout0_253ck280 FIND v(dout0_253) AT=145.025n

.meas tran vdout0_254ck280 FIND v(dout0_254) AT=145.025n

.meas tran vdout0_255ck280 FIND v(dout0_255) AT=145.025n

.meas tran vdout0_0ck290 FIND v(dout0_0) AT=150.025n

.meas tran vdout0_1ck290 FIND v(dout0_1) AT=150.025n

.meas tran vdout0_2ck290 FIND v(dout0_2) AT=150.025n

.meas tran vdout0_3ck290 FIND v(dout0_3) AT=150.025n

.meas tran vdout0_4ck290 FIND v(dout0_4) AT=150.025n

.meas tran vdout0_5ck290 FIND v(dout0_5) AT=150.025n

.meas tran vdout0_6ck290 FIND v(dout0_6) AT=150.025n

.meas tran vdout0_7ck290 FIND v(dout0_7) AT=150.025n

.meas tran vdout0_8ck290 FIND v(dout0_8) AT=150.025n

.meas tran vdout0_9ck290 FIND v(dout0_9) AT=150.025n

.meas tran vdout0_10ck290 FIND v(dout0_10) AT=150.025n

.meas tran vdout0_11ck290 FIND v(dout0_11) AT=150.025n

.meas tran vdout0_12ck290 FIND v(dout0_12) AT=150.025n

.meas tran vdout0_13ck290 FIND v(dout0_13) AT=150.025n

.meas tran vdout0_14ck290 FIND v(dout0_14) AT=150.025n

.meas tran vdout0_15ck290 FIND v(dout0_15) AT=150.025n

.meas tran vdout0_16ck290 FIND v(dout0_16) AT=150.025n

.meas tran vdout0_17ck290 FIND v(dout0_17) AT=150.025n

.meas tran vdout0_18ck290 FIND v(dout0_18) AT=150.025n

.meas tran vdout0_19ck290 FIND v(dout0_19) AT=150.025n

.meas tran vdout0_20ck290 FIND v(dout0_20) AT=150.025n

.meas tran vdout0_21ck290 FIND v(dout0_21) AT=150.025n

.meas tran vdout0_22ck290 FIND v(dout0_22) AT=150.025n

.meas tran vdout0_23ck290 FIND v(dout0_23) AT=150.025n

.meas tran vdout0_24ck290 FIND v(dout0_24) AT=150.025n

.meas tran vdout0_25ck290 FIND v(dout0_25) AT=150.025n

.meas tran vdout0_26ck290 FIND v(dout0_26) AT=150.025n

.meas tran vdout0_27ck290 FIND v(dout0_27) AT=150.025n

.meas tran vdout0_28ck290 FIND v(dout0_28) AT=150.025n

.meas tran vdout0_29ck290 FIND v(dout0_29) AT=150.025n

.meas tran vdout0_30ck290 FIND v(dout0_30) AT=150.025n

.meas tran vdout0_31ck290 FIND v(dout0_31) AT=150.025n

.meas tran vdout0_32ck290 FIND v(dout0_32) AT=150.025n

.meas tran vdout0_33ck290 FIND v(dout0_33) AT=150.025n

.meas tran vdout0_34ck290 FIND v(dout0_34) AT=150.025n

.meas tran vdout0_35ck290 FIND v(dout0_35) AT=150.025n

.meas tran vdout0_36ck290 FIND v(dout0_36) AT=150.025n

.meas tran vdout0_37ck290 FIND v(dout0_37) AT=150.025n

.meas tran vdout0_38ck290 FIND v(dout0_38) AT=150.025n

.meas tran vdout0_39ck290 FIND v(dout0_39) AT=150.025n

.meas tran vdout0_40ck290 FIND v(dout0_40) AT=150.025n

.meas tran vdout0_41ck290 FIND v(dout0_41) AT=150.025n

.meas tran vdout0_42ck290 FIND v(dout0_42) AT=150.025n

.meas tran vdout0_43ck290 FIND v(dout0_43) AT=150.025n

.meas tran vdout0_44ck290 FIND v(dout0_44) AT=150.025n

.meas tran vdout0_45ck290 FIND v(dout0_45) AT=150.025n

.meas tran vdout0_46ck290 FIND v(dout0_46) AT=150.025n

.meas tran vdout0_47ck290 FIND v(dout0_47) AT=150.025n

.meas tran vdout0_48ck290 FIND v(dout0_48) AT=150.025n

.meas tran vdout0_49ck290 FIND v(dout0_49) AT=150.025n

.meas tran vdout0_50ck290 FIND v(dout0_50) AT=150.025n

.meas tran vdout0_51ck290 FIND v(dout0_51) AT=150.025n

.meas tran vdout0_52ck290 FIND v(dout0_52) AT=150.025n

.meas tran vdout0_53ck290 FIND v(dout0_53) AT=150.025n

.meas tran vdout0_54ck290 FIND v(dout0_54) AT=150.025n

.meas tran vdout0_55ck290 FIND v(dout0_55) AT=150.025n

.meas tran vdout0_56ck290 FIND v(dout0_56) AT=150.025n

.meas tran vdout0_57ck290 FIND v(dout0_57) AT=150.025n

.meas tran vdout0_58ck290 FIND v(dout0_58) AT=150.025n

.meas tran vdout0_59ck290 FIND v(dout0_59) AT=150.025n

.meas tran vdout0_60ck290 FIND v(dout0_60) AT=150.025n

.meas tran vdout0_61ck290 FIND v(dout0_61) AT=150.025n

.meas tran vdout0_62ck290 FIND v(dout0_62) AT=150.025n

.meas tran vdout0_63ck290 FIND v(dout0_63) AT=150.025n

.meas tran vdout0_64ck290 FIND v(dout0_64) AT=150.025n

.meas tran vdout0_65ck290 FIND v(dout0_65) AT=150.025n

.meas tran vdout0_66ck290 FIND v(dout0_66) AT=150.025n

.meas tran vdout0_67ck290 FIND v(dout0_67) AT=150.025n

.meas tran vdout0_68ck290 FIND v(dout0_68) AT=150.025n

.meas tran vdout0_69ck290 FIND v(dout0_69) AT=150.025n

.meas tran vdout0_70ck290 FIND v(dout0_70) AT=150.025n

.meas tran vdout0_71ck290 FIND v(dout0_71) AT=150.025n

.meas tran vdout0_72ck290 FIND v(dout0_72) AT=150.025n

.meas tran vdout0_73ck290 FIND v(dout0_73) AT=150.025n

.meas tran vdout0_74ck290 FIND v(dout0_74) AT=150.025n

.meas tran vdout0_75ck290 FIND v(dout0_75) AT=150.025n

.meas tran vdout0_76ck290 FIND v(dout0_76) AT=150.025n

.meas tran vdout0_77ck290 FIND v(dout0_77) AT=150.025n

.meas tran vdout0_78ck290 FIND v(dout0_78) AT=150.025n

.meas tran vdout0_79ck290 FIND v(dout0_79) AT=150.025n

.meas tran vdout0_80ck290 FIND v(dout0_80) AT=150.025n

.meas tran vdout0_81ck290 FIND v(dout0_81) AT=150.025n

.meas tran vdout0_82ck290 FIND v(dout0_82) AT=150.025n

.meas tran vdout0_83ck290 FIND v(dout0_83) AT=150.025n

.meas tran vdout0_84ck290 FIND v(dout0_84) AT=150.025n

.meas tran vdout0_85ck290 FIND v(dout0_85) AT=150.025n

.meas tran vdout0_86ck290 FIND v(dout0_86) AT=150.025n

.meas tran vdout0_87ck290 FIND v(dout0_87) AT=150.025n

.meas tran vdout0_88ck290 FIND v(dout0_88) AT=150.025n

.meas tran vdout0_89ck290 FIND v(dout0_89) AT=150.025n

.meas tran vdout0_90ck290 FIND v(dout0_90) AT=150.025n

.meas tran vdout0_91ck290 FIND v(dout0_91) AT=150.025n

.meas tran vdout0_92ck290 FIND v(dout0_92) AT=150.025n

.meas tran vdout0_93ck290 FIND v(dout0_93) AT=150.025n

.meas tran vdout0_94ck290 FIND v(dout0_94) AT=150.025n

.meas tran vdout0_95ck290 FIND v(dout0_95) AT=150.025n

.meas tran vdout0_96ck290 FIND v(dout0_96) AT=150.025n

.meas tran vdout0_97ck290 FIND v(dout0_97) AT=150.025n

.meas tran vdout0_98ck290 FIND v(dout0_98) AT=150.025n

.meas tran vdout0_99ck290 FIND v(dout0_99) AT=150.025n

.meas tran vdout0_100ck290 FIND v(dout0_100) AT=150.025n

.meas tran vdout0_101ck290 FIND v(dout0_101) AT=150.025n

.meas tran vdout0_102ck290 FIND v(dout0_102) AT=150.025n

.meas tran vdout0_103ck290 FIND v(dout0_103) AT=150.025n

.meas tran vdout0_104ck290 FIND v(dout0_104) AT=150.025n

.meas tran vdout0_105ck290 FIND v(dout0_105) AT=150.025n

.meas tran vdout0_106ck290 FIND v(dout0_106) AT=150.025n

.meas tran vdout0_107ck290 FIND v(dout0_107) AT=150.025n

.meas tran vdout0_108ck290 FIND v(dout0_108) AT=150.025n

.meas tran vdout0_109ck290 FIND v(dout0_109) AT=150.025n

.meas tran vdout0_110ck290 FIND v(dout0_110) AT=150.025n

.meas tran vdout0_111ck290 FIND v(dout0_111) AT=150.025n

.meas tran vdout0_112ck290 FIND v(dout0_112) AT=150.025n

.meas tran vdout0_113ck290 FIND v(dout0_113) AT=150.025n

.meas tran vdout0_114ck290 FIND v(dout0_114) AT=150.025n

.meas tran vdout0_115ck290 FIND v(dout0_115) AT=150.025n

.meas tran vdout0_116ck290 FIND v(dout0_116) AT=150.025n

.meas tran vdout0_117ck290 FIND v(dout0_117) AT=150.025n

.meas tran vdout0_118ck290 FIND v(dout0_118) AT=150.025n

.meas tran vdout0_119ck290 FIND v(dout0_119) AT=150.025n

.meas tran vdout0_120ck290 FIND v(dout0_120) AT=150.025n

.meas tran vdout0_121ck290 FIND v(dout0_121) AT=150.025n

.meas tran vdout0_122ck290 FIND v(dout0_122) AT=150.025n

.meas tran vdout0_123ck290 FIND v(dout0_123) AT=150.025n

.meas tran vdout0_124ck290 FIND v(dout0_124) AT=150.025n

.meas tran vdout0_125ck290 FIND v(dout0_125) AT=150.025n

.meas tran vdout0_126ck290 FIND v(dout0_126) AT=150.025n

.meas tran vdout0_127ck290 FIND v(dout0_127) AT=150.025n

.meas tran vdout0_128ck290 FIND v(dout0_128) AT=150.025n

.meas tran vdout0_129ck290 FIND v(dout0_129) AT=150.025n

.meas tran vdout0_130ck290 FIND v(dout0_130) AT=150.025n

.meas tran vdout0_131ck290 FIND v(dout0_131) AT=150.025n

.meas tran vdout0_132ck290 FIND v(dout0_132) AT=150.025n

.meas tran vdout0_133ck290 FIND v(dout0_133) AT=150.025n

.meas tran vdout0_134ck290 FIND v(dout0_134) AT=150.025n

.meas tran vdout0_135ck290 FIND v(dout0_135) AT=150.025n

.meas tran vdout0_136ck290 FIND v(dout0_136) AT=150.025n

.meas tran vdout0_137ck290 FIND v(dout0_137) AT=150.025n

.meas tran vdout0_138ck290 FIND v(dout0_138) AT=150.025n

.meas tran vdout0_139ck290 FIND v(dout0_139) AT=150.025n

.meas tran vdout0_140ck290 FIND v(dout0_140) AT=150.025n

.meas tran vdout0_141ck290 FIND v(dout0_141) AT=150.025n

.meas tran vdout0_142ck290 FIND v(dout0_142) AT=150.025n

.meas tran vdout0_143ck290 FIND v(dout0_143) AT=150.025n

.meas tran vdout0_144ck290 FIND v(dout0_144) AT=150.025n

.meas tran vdout0_145ck290 FIND v(dout0_145) AT=150.025n

.meas tran vdout0_146ck290 FIND v(dout0_146) AT=150.025n

.meas tran vdout0_147ck290 FIND v(dout0_147) AT=150.025n

.meas tran vdout0_148ck290 FIND v(dout0_148) AT=150.025n

.meas tran vdout0_149ck290 FIND v(dout0_149) AT=150.025n

.meas tran vdout0_150ck290 FIND v(dout0_150) AT=150.025n

.meas tran vdout0_151ck290 FIND v(dout0_151) AT=150.025n

.meas tran vdout0_152ck290 FIND v(dout0_152) AT=150.025n

.meas tran vdout0_153ck290 FIND v(dout0_153) AT=150.025n

.meas tran vdout0_154ck290 FIND v(dout0_154) AT=150.025n

.meas tran vdout0_155ck290 FIND v(dout0_155) AT=150.025n

.meas tran vdout0_156ck290 FIND v(dout0_156) AT=150.025n

.meas tran vdout0_157ck290 FIND v(dout0_157) AT=150.025n

.meas tran vdout0_158ck290 FIND v(dout0_158) AT=150.025n

.meas tran vdout0_159ck290 FIND v(dout0_159) AT=150.025n

.meas tran vdout0_160ck290 FIND v(dout0_160) AT=150.025n

.meas tran vdout0_161ck290 FIND v(dout0_161) AT=150.025n

.meas tran vdout0_162ck290 FIND v(dout0_162) AT=150.025n

.meas tran vdout0_163ck290 FIND v(dout0_163) AT=150.025n

.meas tran vdout0_164ck290 FIND v(dout0_164) AT=150.025n

.meas tran vdout0_165ck290 FIND v(dout0_165) AT=150.025n

.meas tran vdout0_166ck290 FIND v(dout0_166) AT=150.025n

.meas tran vdout0_167ck290 FIND v(dout0_167) AT=150.025n

.meas tran vdout0_168ck290 FIND v(dout0_168) AT=150.025n

.meas tran vdout0_169ck290 FIND v(dout0_169) AT=150.025n

.meas tran vdout0_170ck290 FIND v(dout0_170) AT=150.025n

.meas tran vdout0_171ck290 FIND v(dout0_171) AT=150.025n

.meas tran vdout0_172ck290 FIND v(dout0_172) AT=150.025n

.meas tran vdout0_173ck290 FIND v(dout0_173) AT=150.025n

.meas tran vdout0_174ck290 FIND v(dout0_174) AT=150.025n

.meas tran vdout0_175ck290 FIND v(dout0_175) AT=150.025n

.meas tran vdout0_176ck290 FIND v(dout0_176) AT=150.025n

.meas tran vdout0_177ck290 FIND v(dout0_177) AT=150.025n

.meas tran vdout0_178ck290 FIND v(dout0_178) AT=150.025n

.meas tran vdout0_179ck290 FIND v(dout0_179) AT=150.025n

.meas tran vdout0_180ck290 FIND v(dout0_180) AT=150.025n

.meas tran vdout0_181ck290 FIND v(dout0_181) AT=150.025n

.meas tran vdout0_182ck290 FIND v(dout0_182) AT=150.025n

.meas tran vdout0_183ck290 FIND v(dout0_183) AT=150.025n

.meas tran vdout0_184ck290 FIND v(dout0_184) AT=150.025n

.meas tran vdout0_185ck290 FIND v(dout0_185) AT=150.025n

.meas tran vdout0_186ck290 FIND v(dout0_186) AT=150.025n

.meas tran vdout0_187ck290 FIND v(dout0_187) AT=150.025n

.meas tran vdout0_188ck290 FIND v(dout0_188) AT=150.025n

.meas tran vdout0_189ck290 FIND v(dout0_189) AT=150.025n

.meas tran vdout0_190ck290 FIND v(dout0_190) AT=150.025n

.meas tran vdout0_191ck290 FIND v(dout0_191) AT=150.025n

.meas tran vdout0_192ck290 FIND v(dout0_192) AT=150.025n

.meas tran vdout0_193ck290 FIND v(dout0_193) AT=150.025n

.meas tran vdout0_194ck290 FIND v(dout0_194) AT=150.025n

.meas tran vdout0_195ck290 FIND v(dout0_195) AT=150.025n

.meas tran vdout0_196ck290 FIND v(dout0_196) AT=150.025n

.meas tran vdout0_197ck290 FIND v(dout0_197) AT=150.025n

.meas tran vdout0_198ck290 FIND v(dout0_198) AT=150.025n

.meas tran vdout0_199ck290 FIND v(dout0_199) AT=150.025n

.meas tran vdout0_200ck290 FIND v(dout0_200) AT=150.025n

.meas tran vdout0_201ck290 FIND v(dout0_201) AT=150.025n

.meas tran vdout0_202ck290 FIND v(dout0_202) AT=150.025n

.meas tran vdout0_203ck290 FIND v(dout0_203) AT=150.025n

.meas tran vdout0_204ck290 FIND v(dout0_204) AT=150.025n

.meas tran vdout0_205ck290 FIND v(dout0_205) AT=150.025n

.meas tran vdout0_206ck290 FIND v(dout0_206) AT=150.025n

.meas tran vdout0_207ck290 FIND v(dout0_207) AT=150.025n

.meas tran vdout0_208ck290 FIND v(dout0_208) AT=150.025n

.meas tran vdout0_209ck290 FIND v(dout0_209) AT=150.025n

.meas tran vdout0_210ck290 FIND v(dout0_210) AT=150.025n

.meas tran vdout0_211ck290 FIND v(dout0_211) AT=150.025n

.meas tran vdout0_212ck290 FIND v(dout0_212) AT=150.025n

.meas tran vdout0_213ck290 FIND v(dout0_213) AT=150.025n

.meas tran vdout0_214ck290 FIND v(dout0_214) AT=150.025n

.meas tran vdout0_215ck290 FIND v(dout0_215) AT=150.025n

.meas tran vdout0_216ck290 FIND v(dout0_216) AT=150.025n

.meas tran vdout0_217ck290 FIND v(dout0_217) AT=150.025n

.meas tran vdout0_218ck290 FIND v(dout0_218) AT=150.025n

.meas tran vdout0_219ck290 FIND v(dout0_219) AT=150.025n

.meas tran vdout0_220ck290 FIND v(dout0_220) AT=150.025n

.meas tran vdout0_221ck290 FIND v(dout0_221) AT=150.025n

.meas tran vdout0_222ck290 FIND v(dout0_222) AT=150.025n

.meas tran vdout0_223ck290 FIND v(dout0_223) AT=150.025n

.meas tran vdout0_224ck290 FIND v(dout0_224) AT=150.025n

.meas tran vdout0_225ck290 FIND v(dout0_225) AT=150.025n

.meas tran vdout0_226ck290 FIND v(dout0_226) AT=150.025n

.meas tran vdout0_227ck290 FIND v(dout0_227) AT=150.025n

.meas tran vdout0_228ck290 FIND v(dout0_228) AT=150.025n

.meas tran vdout0_229ck290 FIND v(dout0_229) AT=150.025n

.meas tran vdout0_230ck290 FIND v(dout0_230) AT=150.025n

.meas tran vdout0_231ck290 FIND v(dout0_231) AT=150.025n

.meas tran vdout0_232ck290 FIND v(dout0_232) AT=150.025n

.meas tran vdout0_233ck290 FIND v(dout0_233) AT=150.025n

.meas tran vdout0_234ck290 FIND v(dout0_234) AT=150.025n

.meas tran vdout0_235ck290 FIND v(dout0_235) AT=150.025n

.meas tran vdout0_236ck290 FIND v(dout0_236) AT=150.025n

.meas tran vdout0_237ck290 FIND v(dout0_237) AT=150.025n

.meas tran vdout0_238ck290 FIND v(dout0_238) AT=150.025n

.meas tran vdout0_239ck290 FIND v(dout0_239) AT=150.025n

.meas tran vdout0_240ck290 FIND v(dout0_240) AT=150.025n

.meas tran vdout0_241ck290 FIND v(dout0_241) AT=150.025n

.meas tran vdout0_242ck290 FIND v(dout0_242) AT=150.025n

.meas tran vdout0_243ck290 FIND v(dout0_243) AT=150.025n

.meas tran vdout0_244ck290 FIND v(dout0_244) AT=150.025n

.meas tran vdout0_245ck290 FIND v(dout0_245) AT=150.025n

.meas tran vdout0_246ck290 FIND v(dout0_246) AT=150.025n

.meas tran vdout0_247ck290 FIND v(dout0_247) AT=150.025n

.meas tran vdout0_248ck290 FIND v(dout0_248) AT=150.025n

.meas tran vdout0_249ck290 FIND v(dout0_249) AT=150.025n

.meas tran vdout0_250ck290 FIND v(dout0_250) AT=150.025n

.meas tran vdout0_251ck290 FIND v(dout0_251) AT=150.025n

.meas tran vdout0_252ck290 FIND v(dout0_252) AT=150.025n

.meas tran vdout0_253ck290 FIND v(dout0_253) AT=150.025n

.meas tran vdout0_254ck290 FIND v(dout0_254) AT=150.025n

.meas tran vdout0_255ck290 FIND v(dout0_255) AT=150.025n

.meas tran vdout0_0ck350 FIND v(dout0_0) AT=180.025n

.meas tran vdout0_1ck350 FIND v(dout0_1) AT=180.025n

.meas tran vdout0_2ck350 FIND v(dout0_2) AT=180.025n

.meas tran vdout0_3ck350 FIND v(dout0_3) AT=180.025n

.meas tran vdout0_4ck350 FIND v(dout0_4) AT=180.025n

.meas tran vdout0_5ck350 FIND v(dout0_5) AT=180.025n

.meas tran vdout0_6ck350 FIND v(dout0_6) AT=180.025n

.meas tran vdout0_7ck350 FIND v(dout0_7) AT=180.025n

.meas tran vdout0_8ck350 FIND v(dout0_8) AT=180.025n

.meas tran vdout0_9ck350 FIND v(dout0_9) AT=180.025n

.meas tran vdout0_10ck350 FIND v(dout0_10) AT=180.025n

.meas tran vdout0_11ck350 FIND v(dout0_11) AT=180.025n

.meas tran vdout0_12ck350 FIND v(dout0_12) AT=180.025n

.meas tran vdout0_13ck350 FIND v(dout0_13) AT=180.025n

.meas tran vdout0_14ck350 FIND v(dout0_14) AT=180.025n

.meas tran vdout0_15ck350 FIND v(dout0_15) AT=180.025n

.meas tran vdout0_16ck350 FIND v(dout0_16) AT=180.025n

.meas tran vdout0_17ck350 FIND v(dout0_17) AT=180.025n

.meas tran vdout0_18ck350 FIND v(dout0_18) AT=180.025n

.meas tran vdout0_19ck350 FIND v(dout0_19) AT=180.025n

.meas tran vdout0_20ck350 FIND v(dout0_20) AT=180.025n

.meas tran vdout0_21ck350 FIND v(dout0_21) AT=180.025n

.meas tran vdout0_22ck350 FIND v(dout0_22) AT=180.025n

.meas tran vdout0_23ck350 FIND v(dout0_23) AT=180.025n

.meas tran vdout0_24ck350 FIND v(dout0_24) AT=180.025n

.meas tran vdout0_25ck350 FIND v(dout0_25) AT=180.025n

.meas tran vdout0_26ck350 FIND v(dout0_26) AT=180.025n

.meas tran vdout0_27ck350 FIND v(dout0_27) AT=180.025n

.meas tran vdout0_28ck350 FIND v(dout0_28) AT=180.025n

.meas tran vdout0_29ck350 FIND v(dout0_29) AT=180.025n

.meas tran vdout0_30ck350 FIND v(dout0_30) AT=180.025n

.meas tran vdout0_31ck350 FIND v(dout0_31) AT=180.025n

.meas tran vdout0_32ck350 FIND v(dout0_32) AT=180.025n

.meas tran vdout0_33ck350 FIND v(dout0_33) AT=180.025n

.meas tran vdout0_34ck350 FIND v(dout0_34) AT=180.025n

.meas tran vdout0_35ck350 FIND v(dout0_35) AT=180.025n

.meas tran vdout0_36ck350 FIND v(dout0_36) AT=180.025n

.meas tran vdout0_37ck350 FIND v(dout0_37) AT=180.025n

.meas tran vdout0_38ck350 FIND v(dout0_38) AT=180.025n

.meas tran vdout0_39ck350 FIND v(dout0_39) AT=180.025n

.meas tran vdout0_40ck350 FIND v(dout0_40) AT=180.025n

.meas tran vdout0_41ck350 FIND v(dout0_41) AT=180.025n

.meas tran vdout0_42ck350 FIND v(dout0_42) AT=180.025n

.meas tran vdout0_43ck350 FIND v(dout0_43) AT=180.025n

.meas tran vdout0_44ck350 FIND v(dout0_44) AT=180.025n

.meas tran vdout0_45ck350 FIND v(dout0_45) AT=180.025n

.meas tran vdout0_46ck350 FIND v(dout0_46) AT=180.025n

.meas tran vdout0_47ck350 FIND v(dout0_47) AT=180.025n

.meas tran vdout0_48ck350 FIND v(dout0_48) AT=180.025n

.meas tran vdout0_49ck350 FIND v(dout0_49) AT=180.025n

.meas tran vdout0_50ck350 FIND v(dout0_50) AT=180.025n

.meas tran vdout0_51ck350 FIND v(dout0_51) AT=180.025n

.meas tran vdout0_52ck350 FIND v(dout0_52) AT=180.025n

.meas tran vdout0_53ck350 FIND v(dout0_53) AT=180.025n

.meas tran vdout0_54ck350 FIND v(dout0_54) AT=180.025n

.meas tran vdout0_55ck350 FIND v(dout0_55) AT=180.025n

.meas tran vdout0_56ck350 FIND v(dout0_56) AT=180.025n

.meas tran vdout0_57ck350 FIND v(dout0_57) AT=180.025n

.meas tran vdout0_58ck350 FIND v(dout0_58) AT=180.025n

.meas tran vdout0_59ck350 FIND v(dout0_59) AT=180.025n

.meas tran vdout0_60ck350 FIND v(dout0_60) AT=180.025n

.meas tran vdout0_61ck350 FIND v(dout0_61) AT=180.025n

.meas tran vdout0_62ck350 FIND v(dout0_62) AT=180.025n

.meas tran vdout0_63ck350 FIND v(dout0_63) AT=180.025n

.meas tran vdout0_64ck350 FIND v(dout0_64) AT=180.025n

.meas tran vdout0_65ck350 FIND v(dout0_65) AT=180.025n

.meas tran vdout0_66ck350 FIND v(dout0_66) AT=180.025n

.meas tran vdout0_67ck350 FIND v(dout0_67) AT=180.025n

.meas tran vdout0_68ck350 FIND v(dout0_68) AT=180.025n

.meas tran vdout0_69ck350 FIND v(dout0_69) AT=180.025n

.meas tran vdout0_70ck350 FIND v(dout0_70) AT=180.025n

.meas tran vdout0_71ck350 FIND v(dout0_71) AT=180.025n

.meas tran vdout0_72ck350 FIND v(dout0_72) AT=180.025n

.meas tran vdout0_73ck350 FIND v(dout0_73) AT=180.025n

.meas tran vdout0_74ck350 FIND v(dout0_74) AT=180.025n

.meas tran vdout0_75ck350 FIND v(dout0_75) AT=180.025n

.meas tran vdout0_76ck350 FIND v(dout0_76) AT=180.025n

.meas tran vdout0_77ck350 FIND v(dout0_77) AT=180.025n

.meas tran vdout0_78ck350 FIND v(dout0_78) AT=180.025n

.meas tran vdout0_79ck350 FIND v(dout0_79) AT=180.025n

.meas tran vdout0_80ck350 FIND v(dout0_80) AT=180.025n

.meas tran vdout0_81ck350 FIND v(dout0_81) AT=180.025n

.meas tran vdout0_82ck350 FIND v(dout0_82) AT=180.025n

.meas tran vdout0_83ck350 FIND v(dout0_83) AT=180.025n

.meas tran vdout0_84ck350 FIND v(dout0_84) AT=180.025n

.meas tran vdout0_85ck350 FIND v(dout0_85) AT=180.025n

.meas tran vdout0_86ck350 FIND v(dout0_86) AT=180.025n

.meas tran vdout0_87ck350 FIND v(dout0_87) AT=180.025n

.meas tran vdout0_88ck350 FIND v(dout0_88) AT=180.025n

.meas tran vdout0_89ck350 FIND v(dout0_89) AT=180.025n

.meas tran vdout0_90ck350 FIND v(dout0_90) AT=180.025n

.meas tran vdout0_91ck350 FIND v(dout0_91) AT=180.025n

.meas tran vdout0_92ck350 FIND v(dout0_92) AT=180.025n

.meas tran vdout0_93ck350 FIND v(dout0_93) AT=180.025n

.meas tran vdout0_94ck350 FIND v(dout0_94) AT=180.025n

.meas tran vdout0_95ck350 FIND v(dout0_95) AT=180.025n

.meas tran vdout0_96ck350 FIND v(dout0_96) AT=180.025n

.meas tran vdout0_97ck350 FIND v(dout0_97) AT=180.025n

.meas tran vdout0_98ck350 FIND v(dout0_98) AT=180.025n

.meas tran vdout0_99ck350 FIND v(dout0_99) AT=180.025n

.meas tran vdout0_100ck350 FIND v(dout0_100) AT=180.025n

.meas tran vdout0_101ck350 FIND v(dout0_101) AT=180.025n

.meas tran vdout0_102ck350 FIND v(dout0_102) AT=180.025n

.meas tran vdout0_103ck350 FIND v(dout0_103) AT=180.025n

.meas tran vdout0_104ck350 FIND v(dout0_104) AT=180.025n

.meas tran vdout0_105ck350 FIND v(dout0_105) AT=180.025n

.meas tran vdout0_106ck350 FIND v(dout0_106) AT=180.025n

.meas tran vdout0_107ck350 FIND v(dout0_107) AT=180.025n

.meas tran vdout0_108ck350 FIND v(dout0_108) AT=180.025n

.meas tran vdout0_109ck350 FIND v(dout0_109) AT=180.025n

.meas tran vdout0_110ck350 FIND v(dout0_110) AT=180.025n

.meas tran vdout0_111ck350 FIND v(dout0_111) AT=180.025n

.meas tran vdout0_112ck350 FIND v(dout0_112) AT=180.025n

.meas tran vdout0_113ck350 FIND v(dout0_113) AT=180.025n

.meas tran vdout0_114ck350 FIND v(dout0_114) AT=180.025n

.meas tran vdout0_115ck350 FIND v(dout0_115) AT=180.025n

.meas tran vdout0_116ck350 FIND v(dout0_116) AT=180.025n

.meas tran vdout0_117ck350 FIND v(dout0_117) AT=180.025n

.meas tran vdout0_118ck350 FIND v(dout0_118) AT=180.025n

.meas tran vdout0_119ck350 FIND v(dout0_119) AT=180.025n

.meas tran vdout0_120ck350 FIND v(dout0_120) AT=180.025n

.meas tran vdout0_121ck350 FIND v(dout0_121) AT=180.025n

.meas tran vdout0_122ck350 FIND v(dout0_122) AT=180.025n

.meas tran vdout0_123ck350 FIND v(dout0_123) AT=180.025n

.meas tran vdout0_124ck350 FIND v(dout0_124) AT=180.025n

.meas tran vdout0_125ck350 FIND v(dout0_125) AT=180.025n

.meas tran vdout0_126ck350 FIND v(dout0_126) AT=180.025n

.meas tran vdout0_127ck350 FIND v(dout0_127) AT=180.025n

.meas tran vdout0_128ck350 FIND v(dout0_128) AT=180.025n

.meas tran vdout0_129ck350 FIND v(dout0_129) AT=180.025n

.meas tran vdout0_130ck350 FIND v(dout0_130) AT=180.025n

.meas tran vdout0_131ck350 FIND v(dout0_131) AT=180.025n

.meas tran vdout0_132ck350 FIND v(dout0_132) AT=180.025n

.meas tran vdout0_133ck350 FIND v(dout0_133) AT=180.025n

.meas tran vdout0_134ck350 FIND v(dout0_134) AT=180.025n

.meas tran vdout0_135ck350 FIND v(dout0_135) AT=180.025n

.meas tran vdout0_136ck350 FIND v(dout0_136) AT=180.025n

.meas tran vdout0_137ck350 FIND v(dout0_137) AT=180.025n

.meas tran vdout0_138ck350 FIND v(dout0_138) AT=180.025n

.meas tran vdout0_139ck350 FIND v(dout0_139) AT=180.025n

.meas tran vdout0_140ck350 FIND v(dout0_140) AT=180.025n

.meas tran vdout0_141ck350 FIND v(dout0_141) AT=180.025n

.meas tran vdout0_142ck350 FIND v(dout0_142) AT=180.025n

.meas tran vdout0_143ck350 FIND v(dout0_143) AT=180.025n

.meas tran vdout0_144ck350 FIND v(dout0_144) AT=180.025n

.meas tran vdout0_145ck350 FIND v(dout0_145) AT=180.025n

.meas tran vdout0_146ck350 FIND v(dout0_146) AT=180.025n

.meas tran vdout0_147ck350 FIND v(dout0_147) AT=180.025n

.meas tran vdout0_148ck350 FIND v(dout0_148) AT=180.025n

.meas tran vdout0_149ck350 FIND v(dout0_149) AT=180.025n

.meas tran vdout0_150ck350 FIND v(dout0_150) AT=180.025n

.meas tran vdout0_151ck350 FIND v(dout0_151) AT=180.025n

.meas tran vdout0_152ck350 FIND v(dout0_152) AT=180.025n

.meas tran vdout0_153ck350 FIND v(dout0_153) AT=180.025n

.meas tran vdout0_154ck350 FIND v(dout0_154) AT=180.025n

.meas tran vdout0_155ck350 FIND v(dout0_155) AT=180.025n

.meas tran vdout0_156ck350 FIND v(dout0_156) AT=180.025n

.meas tran vdout0_157ck350 FIND v(dout0_157) AT=180.025n

.meas tran vdout0_158ck350 FIND v(dout0_158) AT=180.025n

.meas tran vdout0_159ck350 FIND v(dout0_159) AT=180.025n

.meas tran vdout0_160ck350 FIND v(dout0_160) AT=180.025n

.meas tran vdout0_161ck350 FIND v(dout0_161) AT=180.025n

.meas tran vdout0_162ck350 FIND v(dout0_162) AT=180.025n

.meas tran vdout0_163ck350 FIND v(dout0_163) AT=180.025n

.meas tran vdout0_164ck350 FIND v(dout0_164) AT=180.025n

.meas tran vdout0_165ck350 FIND v(dout0_165) AT=180.025n

.meas tran vdout0_166ck350 FIND v(dout0_166) AT=180.025n

.meas tran vdout0_167ck350 FIND v(dout0_167) AT=180.025n

.meas tran vdout0_168ck350 FIND v(dout0_168) AT=180.025n

.meas tran vdout0_169ck350 FIND v(dout0_169) AT=180.025n

.meas tran vdout0_170ck350 FIND v(dout0_170) AT=180.025n

.meas tran vdout0_171ck350 FIND v(dout0_171) AT=180.025n

.meas tran vdout0_172ck350 FIND v(dout0_172) AT=180.025n

.meas tran vdout0_173ck350 FIND v(dout0_173) AT=180.025n

.meas tran vdout0_174ck350 FIND v(dout0_174) AT=180.025n

.meas tran vdout0_175ck350 FIND v(dout0_175) AT=180.025n

.meas tran vdout0_176ck350 FIND v(dout0_176) AT=180.025n

.meas tran vdout0_177ck350 FIND v(dout0_177) AT=180.025n

.meas tran vdout0_178ck350 FIND v(dout0_178) AT=180.025n

.meas tran vdout0_179ck350 FIND v(dout0_179) AT=180.025n

.meas tran vdout0_180ck350 FIND v(dout0_180) AT=180.025n

.meas tran vdout0_181ck350 FIND v(dout0_181) AT=180.025n

.meas tran vdout0_182ck350 FIND v(dout0_182) AT=180.025n

.meas tran vdout0_183ck350 FIND v(dout0_183) AT=180.025n

.meas tran vdout0_184ck350 FIND v(dout0_184) AT=180.025n

.meas tran vdout0_185ck350 FIND v(dout0_185) AT=180.025n

.meas tran vdout0_186ck350 FIND v(dout0_186) AT=180.025n

.meas tran vdout0_187ck350 FIND v(dout0_187) AT=180.025n

.meas tran vdout0_188ck350 FIND v(dout0_188) AT=180.025n

.meas tran vdout0_189ck350 FIND v(dout0_189) AT=180.025n

.meas tran vdout0_190ck350 FIND v(dout0_190) AT=180.025n

.meas tran vdout0_191ck350 FIND v(dout0_191) AT=180.025n

.meas tran vdout0_192ck350 FIND v(dout0_192) AT=180.025n

.meas tran vdout0_193ck350 FIND v(dout0_193) AT=180.025n

.meas tran vdout0_194ck350 FIND v(dout0_194) AT=180.025n

.meas tran vdout0_195ck350 FIND v(dout0_195) AT=180.025n

.meas tran vdout0_196ck350 FIND v(dout0_196) AT=180.025n

.meas tran vdout0_197ck350 FIND v(dout0_197) AT=180.025n

.meas tran vdout0_198ck350 FIND v(dout0_198) AT=180.025n

.meas tran vdout0_199ck350 FIND v(dout0_199) AT=180.025n

.meas tran vdout0_200ck350 FIND v(dout0_200) AT=180.025n

.meas tran vdout0_201ck350 FIND v(dout0_201) AT=180.025n

.meas tran vdout0_202ck350 FIND v(dout0_202) AT=180.025n

.meas tran vdout0_203ck350 FIND v(dout0_203) AT=180.025n

.meas tran vdout0_204ck350 FIND v(dout0_204) AT=180.025n

.meas tran vdout0_205ck350 FIND v(dout0_205) AT=180.025n

.meas tran vdout0_206ck350 FIND v(dout0_206) AT=180.025n

.meas tran vdout0_207ck350 FIND v(dout0_207) AT=180.025n

.meas tran vdout0_208ck350 FIND v(dout0_208) AT=180.025n

.meas tran vdout0_209ck350 FIND v(dout0_209) AT=180.025n

.meas tran vdout0_210ck350 FIND v(dout0_210) AT=180.025n

.meas tran vdout0_211ck350 FIND v(dout0_211) AT=180.025n

.meas tran vdout0_212ck350 FIND v(dout0_212) AT=180.025n

.meas tran vdout0_213ck350 FIND v(dout0_213) AT=180.025n

.meas tran vdout0_214ck350 FIND v(dout0_214) AT=180.025n

.meas tran vdout0_215ck350 FIND v(dout0_215) AT=180.025n

.meas tran vdout0_216ck350 FIND v(dout0_216) AT=180.025n

.meas tran vdout0_217ck350 FIND v(dout0_217) AT=180.025n

.meas tran vdout0_218ck350 FIND v(dout0_218) AT=180.025n

.meas tran vdout0_219ck350 FIND v(dout0_219) AT=180.025n

.meas tran vdout0_220ck350 FIND v(dout0_220) AT=180.025n

.meas tran vdout0_221ck350 FIND v(dout0_221) AT=180.025n

.meas tran vdout0_222ck350 FIND v(dout0_222) AT=180.025n

.meas tran vdout0_223ck350 FIND v(dout0_223) AT=180.025n

.meas tran vdout0_224ck350 FIND v(dout0_224) AT=180.025n

.meas tran vdout0_225ck350 FIND v(dout0_225) AT=180.025n

.meas tran vdout0_226ck350 FIND v(dout0_226) AT=180.025n

.meas tran vdout0_227ck350 FIND v(dout0_227) AT=180.025n

.meas tran vdout0_228ck350 FIND v(dout0_228) AT=180.025n

.meas tran vdout0_229ck350 FIND v(dout0_229) AT=180.025n

.meas tran vdout0_230ck350 FIND v(dout0_230) AT=180.025n

.meas tran vdout0_231ck350 FIND v(dout0_231) AT=180.025n

.meas tran vdout0_232ck350 FIND v(dout0_232) AT=180.025n

.meas tran vdout0_233ck350 FIND v(dout0_233) AT=180.025n

.meas tran vdout0_234ck350 FIND v(dout0_234) AT=180.025n

.meas tran vdout0_235ck350 FIND v(dout0_235) AT=180.025n

.meas tran vdout0_236ck350 FIND v(dout0_236) AT=180.025n

.meas tran vdout0_237ck350 FIND v(dout0_237) AT=180.025n

.meas tran vdout0_238ck350 FIND v(dout0_238) AT=180.025n

.meas tran vdout0_239ck350 FIND v(dout0_239) AT=180.025n

.meas tran vdout0_240ck350 FIND v(dout0_240) AT=180.025n

.meas tran vdout0_241ck350 FIND v(dout0_241) AT=180.025n

.meas tran vdout0_242ck350 FIND v(dout0_242) AT=180.025n

.meas tran vdout0_243ck350 FIND v(dout0_243) AT=180.025n

.meas tran vdout0_244ck350 FIND v(dout0_244) AT=180.025n

.meas tran vdout0_245ck350 FIND v(dout0_245) AT=180.025n

.meas tran vdout0_246ck350 FIND v(dout0_246) AT=180.025n

.meas tran vdout0_247ck350 FIND v(dout0_247) AT=180.025n

.meas tran vdout0_248ck350 FIND v(dout0_248) AT=180.025n

.meas tran vdout0_249ck350 FIND v(dout0_249) AT=180.025n

.meas tran vdout0_250ck350 FIND v(dout0_250) AT=180.025n

.meas tran vdout0_251ck350 FIND v(dout0_251) AT=180.025n

.meas tran vdout0_252ck350 FIND v(dout0_252) AT=180.025n

.meas tran vdout0_253ck350 FIND v(dout0_253) AT=180.025n

.meas tran vdout0_254ck350 FIND v(dout0_254) AT=180.025n

.meas tran vdout0_255ck350 FIND v(dout0_255) AT=180.025n

.meas tran vdout0_0ck360 FIND v(dout0_0) AT=185.025n

.meas tran vdout0_1ck360 FIND v(dout0_1) AT=185.025n

.meas tran vdout0_2ck360 FIND v(dout0_2) AT=185.025n

.meas tran vdout0_3ck360 FIND v(dout0_3) AT=185.025n

.meas tran vdout0_4ck360 FIND v(dout0_4) AT=185.025n

.meas tran vdout0_5ck360 FIND v(dout0_5) AT=185.025n

.meas tran vdout0_6ck360 FIND v(dout0_6) AT=185.025n

.meas tran vdout0_7ck360 FIND v(dout0_7) AT=185.025n

.meas tran vdout0_8ck360 FIND v(dout0_8) AT=185.025n

.meas tran vdout0_9ck360 FIND v(dout0_9) AT=185.025n

.meas tran vdout0_10ck360 FIND v(dout0_10) AT=185.025n

.meas tran vdout0_11ck360 FIND v(dout0_11) AT=185.025n

.meas tran vdout0_12ck360 FIND v(dout0_12) AT=185.025n

.meas tran vdout0_13ck360 FIND v(dout0_13) AT=185.025n

.meas tran vdout0_14ck360 FIND v(dout0_14) AT=185.025n

.meas tran vdout0_15ck360 FIND v(dout0_15) AT=185.025n

.meas tran vdout0_16ck360 FIND v(dout0_16) AT=185.025n

.meas tran vdout0_17ck360 FIND v(dout0_17) AT=185.025n

.meas tran vdout0_18ck360 FIND v(dout0_18) AT=185.025n

.meas tran vdout0_19ck360 FIND v(dout0_19) AT=185.025n

.meas tran vdout0_20ck360 FIND v(dout0_20) AT=185.025n

.meas tran vdout0_21ck360 FIND v(dout0_21) AT=185.025n

.meas tran vdout0_22ck360 FIND v(dout0_22) AT=185.025n

.meas tran vdout0_23ck360 FIND v(dout0_23) AT=185.025n

.meas tran vdout0_24ck360 FIND v(dout0_24) AT=185.025n

.meas tran vdout0_25ck360 FIND v(dout0_25) AT=185.025n

.meas tran vdout0_26ck360 FIND v(dout0_26) AT=185.025n

.meas tran vdout0_27ck360 FIND v(dout0_27) AT=185.025n

.meas tran vdout0_28ck360 FIND v(dout0_28) AT=185.025n

.meas tran vdout0_29ck360 FIND v(dout0_29) AT=185.025n

.meas tran vdout0_30ck360 FIND v(dout0_30) AT=185.025n

.meas tran vdout0_31ck360 FIND v(dout0_31) AT=185.025n

.meas tran vdout0_32ck360 FIND v(dout0_32) AT=185.025n

.meas tran vdout0_33ck360 FIND v(dout0_33) AT=185.025n

.meas tran vdout0_34ck360 FIND v(dout0_34) AT=185.025n

.meas tran vdout0_35ck360 FIND v(dout0_35) AT=185.025n

.meas tran vdout0_36ck360 FIND v(dout0_36) AT=185.025n

.meas tran vdout0_37ck360 FIND v(dout0_37) AT=185.025n

.meas tran vdout0_38ck360 FIND v(dout0_38) AT=185.025n

.meas tran vdout0_39ck360 FIND v(dout0_39) AT=185.025n

.meas tran vdout0_40ck360 FIND v(dout0_40) AT=185.025n

.meas tran vdout0_41ck360 FIND v(dout0_41) AT=185.025n

.meas tran vdout0_42ck360 FIND v(dout0_42) AT=185.025n

.meas tran vdout0_43ck360 FIND v(dout0_43) AT=185.025n

.meas tran vdout0_44ck360 FIND v(dout0_44) AT=185.025n

.meas tran vdout0_45ck360 FIND v(dout0_45) AT=185.025n

.meas tran vdout0_46ck360 FIND v(dout0_46) AT=185.025n

.meas tran vdout0_47ck360 FIND v(dout0_47) AT=185.025n

.meas tran vdout0_48ck360 FIND v(dout0_48) AT=185.025n

.meas tran vdout0_49ck360 FIND v(dout0_49) AT=185.025n

.meas tran vdout0_50ck360 FIND v(dout0_50) AT=185.025n

.meas tran vdout0_51ck360 FIND v(dout0_51) AT=185.025n

.meas tran vdout0_52ck360 FIND v(dout0_52) AT=185.025n

.meas tran vdout0_53ck360 FIND v(dout0_53) AT=185.025n

.meas tran vdout0_54ck360 FIND v(dout0_54) AT=185.025n

.meas tran vdout0_55ck360 FIND v(dout0_55) AT=185.025n

.meas tran vdout0_56ck360 FIND v(dout0_56) AT=185.025n

.meas tran vdout0_57ck360 FIND v(dout0_57) AT=185.025n

.meas tran vdout0_58ck360 FIND v(dout0_58) AT=185.025n

.meas tran vdout0_59ck360 FIND v(dout0_59) AT=185.025n

.meas tran vdout0_60ck360 FIND v(dout0_60) AT=185.025n

.meas tran vdout0_61ck360 FIND v(dout0_61) AT=185.025n

.meas tran vdout0_62ck360 FIND v(dout0_62) AT=185.025n

.meas tran vdout0_63ck360 FIND v(dout0_63) AT=185.025n

.meas tran vdout0_64ck360 FIND v(dout0_64) AT=185.025n

.meas tran vdout0_65ck360 FIND v(dout0_65) AT=185.025n

.meas tran vdout0_66ck360 FIND v(dout0_66) AT=185.025n

.meas tran vdout0_67ck360 FIND v(dout0_67) AT=185.025n

.meas tran vdout0_68ck360 FIND v(dout0_68) AT=185.025n

.meas tran vdout0_69ck360 FIND v(dout0_69) AT=185.025n

.meas tran vdout0_70ck360 FIND v(dout0_70) AT=185.025n

.meas tran vdout0_71ck360 FIND v(dout0_71) AT=185.025n

.meas tran vdout0_72ck360 FIND v(dout0_72) AT=185.025n

.meas tran vdout0_73ck360 FIND v(dout0_73) AT=185.025n

.meas tran vdout0_74ck360 FIND v(dout0_74) AT=185.025n

.meas tran vdout0_75ck360 FIND v(dout0_75) AT=185.025n

.meas tran vdout0_76ck360 FIND v(dout0_76) AT=185.025n

.meas tran vdout0_77ck360 FIND v(dout0_77) AT=185.025n

.meas tran vdout0_78ck360 FIND v(dout0_78) AT=185.025n

.meas tran vdout0_79ck360 FIND v(dout0_79) AT=185.025n

.meas tran vdout0_80ck360 FIND v(dout0_80) AT=185.025n

.meas tran vdout0_81ck360 FIND v(dout0_81) AT=185.025n

.meas tran vdout0_82ck360 FIND v(dout0_82) AT=185.025n

.meas tran vdout0_83ck360 FIND v(dout0_83) AT=185.025n

.meas tran vdout0_84ck360 FIND v(dout0_84) AT=185.025n

.meas tran vdout0_85ck360 FIND v(dout0_85) AT=185.025n

.meas tran vdout0_86ck360 FIND v(dout0_86) AT=185.025n

.meas tran vdout0_87ck360 FIND v(dout0_87) AT=185.025n

.meas tran vdout0_88ck360 FIND v(dout0_88) AT=185.025n

.meas tran vdout0_89ck360 FIND v(dout0_89) AT=185.025n

.meas tran vdout0_90ck360 FIND v(dout0_90) AT=185.025n

.meas tran vdout0_91ck360 FIND v(dout0_91) AT=185.025n

.meas tran vdout0_92ck360 FIND v(dout0_92) AT=185.025n

.meas tran vdout0_93ck360 FIND v(dout0_93) AT=185.025n

.meas tran vdout0_94ck360 FIND v(dout0_94) AT=185.025n

.meas tran vdout0_95ck360 FIND v(dout0_95) AT=185.025n

.meas tran vdout0_96ck360 FIND v(dout0_96) AT=185.025n

.meas tran vdout0_97ck360 FIND v(dout0_97) AT=185.025n

.meas tran vdout0_98ck360 FIND v(dout0_98) AT=185.025n

.meas tran vdout0_99ck360 FIND v(dout0_99) AT=185.025n

.meas tran vdout0_100ck360 FIND v(dout0_100) AT=185.025n

.meas tran vdout0_101ck360 FIND v(dout0_101) AT=185.025n

.meas tran vdout0_102ck360 FIND v(dout0_102) AT=185.025n

.meas tran vdout0_103ck360 FIND v(dout0_103) AT=185.025n

.meas tran vdout0_104ck360 FIND v(dout0_104) AT=185.025n

.meas tran vdout0_105ck360 FIND v(dout0_105) AT=185.025n

.meas tran vdout0_106ck360 FIND v(dout0_106) AT=185.025n

.meas tran vdout0_107ck360 FIND v(dout0_107) AT=185.025n

.meas tran vdout0_108ck360 FIND v(dout0_108) AT=185.025n

.meas tran vdout0_109ck360 FIND v(dout0_109) AT=185.025n

.meas tran vdout0_110ck360 FIND v(dout0_110) AT=185.025n

.meas tran vdout0_111ck360 FIND v(dout0_111) AT=185.025n

.meas tran vdout0_112ck360 FIND v(dout0_112) AT=185.025n

.meas tran vdout0_113ck360 FIND v(dout0_113) AT=185.025n

.meas tran vdout0_114ck360 FIND v(dout0_114) AT=185.025n

.meas tran vdout0_115ck360 FIND v(dout0_115) AT=185.025n

.meas tran vdout0_116ck360 FIND v(dout0_116) AT=185.025n

.meas tran vdout0_117ck360 FIND v(dout0_117) AT=185.025n

.meas tran vdout0_118ck360 FIND v(dout0_118) AT=185.025n

.meas tran vdout0_119ck360 FIND v(dout0_119) AT=185.025n

.meas tran vdout0_120ck360 FIND v(dout0_120) AT=185.025n

.meas tran vdout0_121ck360 FIND v(dout0_121) AT=185.025n

.meas tran vdout0_122ck360 FIND v(dout0_122) AT=185.025n

.meas tran vdout0_123ck360 FIND v(dout0_123) AT=185.025n

.meas tran vdout0_124ck360 FIND v(dout0_124) AT=185.025n

.meas tran vdout0_125ck360 FIND v(dout0_125) AT=185.025n

.meas tran vdout0_126ck360 FIND v(dout0_126) AT=185.025n

.meas tran vdout0_127ck360 FIND v(dout0_127) AT=185.025n

.meas tran vdout0_128ck360 FIND v(dout0_128) AT=185.025n

.meas tran vdout0_129ck360 FIND v(dout0_129) AT=185.025n

.meas tran vdout0_130ck360 FIND v(dout0_130) AT=185.025n

.meas tran vdout0_131ck360 FIND v(dout0_131) AT=185.025n

.meas tran vdout0_132ck360 FIND v(dout0_132) AT=185.025n

.meas tran vdout0_133ck360 FIND v(dout0_133) AT=185.025n

.meas tran vdout0_134ck360 FIND v(dout0_134) AT=185.025n

.meas tran vdout0_135ck360 FIND v(dout0_135) AT=185.025n

.meas tran vdout0_136ck360 FIND v(dout0_136) AT=185.025n

.meas tran vdout0_137ck360 FIND v(dout0_137) AT=185.025n

.meas tran vdout0_138ck360 FIND v(dout0_138) AT=185.025n

.meas tran vdout0_139ck360 FIND v(dout0_139) AT=185.025n

.meas tran vdout0_140ck360 FIND v(dout0_140) AT=185.025n

.meas tran vdout0_141ck360 FIND v(dout0_141) AT=185.025n

.meas tran vdout0_142ck360 FIND v(dout0_142) AT=185.025n

.meas tran vdout0_143ck360 FIND v(dout0_143) AT=185.025n

.meas tran vdout0_144ck360 FIND v(dout0_144) AT=185.025n

.meas tran vdout0_145ck360 FIND v(dout0_145) AT=185.025n

.meas tran vdout0_146ck360 FIND v(dout0_146) AT=185.025n

.meas tran vdout0_147ck360 FIND v(dout0_147) AT=185.025n

.meas tran vdout0_148ck360 FIND v(dout0_148) AT=185.025n

.meas tran vdout0_149ck360 FIND v(dout0_149) AT=185.025n

.meas tran vdout0_150ck360 FIND v(dout0_150) AT=185.025n

.meas tran vdout0_151ck360 FIND v(dout0_151) AT=185.025n

.meas tran vdout0_152ck360 FIND v(dout0_152) AT=185.025n

.meas tran vdout0_153ck360 FIND v(dout0_153) AT=185.025n

.meas tran vdout0_154ck360 FIND v(dout0_154) AT=185.025n

.meas tran vdout0_155ck360 FIND v(dout0_155) AT=185.025n

.meas tran vdout0_156ck360 FIND v(dout0_156) AT=185.025n

.meas tran vdout0_157ck360 FIND v(dout0_157) AT=185.025n

.meas tran vdout0_158ck360 FIND v(dout0_158) AT=185.025n

.meas tran vdout0_159ck360 FIND v(dout0_159) AT=185.025n

.meas tran vdout0_160ck360 FIND v(dout0_160) AT=185.025n

.meas tran vdout0_161ck360 FIND v(dout0_161) AT=185.025n

.meas tran vdout0_162ck360 FIND v(dout0_162) AT=185.025n

.meas tran vdout0_163ck360 FIND v(dout0_163) AT=185.025n

.meas tran vdout0_164ck360 FIND v(dout0_164) AT=185.025n

.meas tran vdout0_165ck360 FIND v(dout0_165) AT=185.025n

.meas tran vdout0_166ck360 FIND v(dout0_166) AT=185.025n

.meas tran vdout0_167ck360 FIND v(dout0_167) AT=185.025n

.meas tran vdout0_168ck360 FIND v(dout0_168) AT=185.025n

.meas tran vdout0_169ck360 FIND v(dout0_169) AT=185.025n

.meas tran vdout0_170ck360 FIND v(dout0_170) AT=185.025n

.meas tran vdout0_171ck360 FIND v(dout0_171) AT=185.025n

.meas tran vdout0_172ck360 FIND v(dout0_172) AT=185.025n

.meas tran vdout0_173ck360 FIND v(dout0_173) AT=185.025n

.meas tran vdout0_174ck360 FIND v(dout0_174) AT=185.025n

.meas tran vdout0_175ck360 FIND v(dout0_175) AT=185.025n

.meas tran vdout0_176ck360 FIND v(dout0_176) AT=185.025n

.meas tran vdout0_177ck360 FIND v(dout0_177) AT=185.025n

.meas tran vdout0_178ck360 FIND v(dout0_178) AT=185.025n

.meas tran vdout0_179ck360 FIND v(dout0_179) AT=185.025n

.meas tran vdout0_180ck360 FIND v(dout0_180) AT=185.025n

.meas tran vdout0_181ck360 FIND v(dout0_181) AT=185.025n

.meas tran vdout0_182ck360 FIND v(dout0_182) AT=185.025n

.meas tran vdout0_183ck360 FIND v(dout0_183) AT=185.025n

.meas tran vdout0_184ck360 FIND v(dout0_184) AT=185.025n

.meas tran vdout0_185ck360 FIND v(dout0_185) AT=185.025n

.meas tran vdout0_186ck360 FIND v(dout0_186) AT=185.025n

.meas tran vdout0_187ck360 FIND v(dout0_187) AT=185.025n

.meas tran vdout0_188ck360 FIND v(dout0_188) AT=185.025n

.meas tran vdout0_189ck360 FIND v(dout0_189) AT=185.025n

.meas tran vdout0_190ck360 FIND v(dout0_190) AT=185.025n

.meas tran vdout0_191ck360 FIND v(dout0_191) AT=185.025n

.meas tran vdout0_192ck360 FIND v(dout0_192) AT=185.025n

.meas tran vdout0_193ck360 FIND v(dout0_193) AT=185.025n

.meas tran vdout0_194ck360 FIND v(dout0_194) AT=185.025n

.meas tran vdout0_195ck360 FIND v(dout0_195) AT=185.025n

.meas tran vdout0_196ck360 FIND v(dout0_196) AT=185.025n

.meas tran vdout0_197ck360 FIND v(dout0_197) AT=185.025n

.meas tran vdout0_198ck360 FIND v(dout0_198) AT=185.025n

.meas tran vdout0_199ck360 FIND v(dout0_199) AT=185.025n

.meas tran vdout0_200ck360 FIND v(dout0_200) AT=185.025n

.meas tran vdout0_201ck360 FIND v(dout0_201) AT=185.025n

.meas tran vdout0_202ck360 FIND v(dout0_202) AT=185.025n

.meas tran vdout0_203ck360 FIND v(dout0_203) AT=185.025n

.meas tran vdout0_204ck360 FIND v(dout0_204) AT=185.025n

.meas tran vdout0_205ck360 FIND v(dout0_205) AT=185.025n

.meas tran vdout0_206ck360 FIND v(dout0_206) AT=185.025n

.meas tran vdout0_207ck360 FIND v(dout0_207) AT=185.025n

.meas tran vdout0_208ck360 FIND v(dout0_208) AT=185.025n

.meas tran vdout0_209ck360 FIND v(dout0_209) AT=185.025n

.meas tran vdout0_210ck360 FIND v(dout0_210) AT=185.025n

.meas tran vdout0_211ck360 FIND v(dout0_211) AT=185.025n

.meas tran vdout0_212ck360 FIND v(dout0_212) AT=185.025n

.meas tran vdout0_213ck360 FIND v(dout0_213) AT=185.025n

.meas tran vdout0_214ck360 FIND v(dout0_214) AT=185.025n

.meas tran vdout0_215ck360 FIND v(dout0_215) AT=185.025n

.meas tran vdout0_216ck360 FIND v(dout0_216) AT=185.025n

.meas tran vdout0_217ck360 FIND v(dout0_217) AT=185.025n

.meas tran vdout0_218ck360 FIND v(dout0_218) AT=185.025n

.meas tran vdout0_219ck360 FIND v(dout0_219) AT=185.025n

.meas tran vdout0_220ck360 FIND v(dout0_220) AT=185.025n

.meas tran vdout0_221ck360 FIND v(dout0_221) AT=185.025n

.meas tran vdout0_222ck360 FIND v(dout0_222) AT=185.025n

.meas tran vdout0_223ck360 FIND v(dout0_223) AT=185.025n

.meas tran vdout0_224ck360 FIND v(dout0_224) AT=185.025n

.meas tran vdout0_225ck360 FIND v(dout0_225) AT=185.025n

.meas tran vdout0_226ck360 FIND v(dout0_226) AT=185.025n

.meas tran vdout0_227ck360 FIND v(dout0_227) AT=185.025n

.meas tran vdout0_228ck360 FIND v(dout0_228) AT=185.025n

.meas tran vdout0_229ck360 FIND v(dout0_229) AT=185.025n

.meas tran vdout0_230ck360 FIND v(dout0_230) AT=185.025n

.meas tran vdout0_231ck360 FIND v(dout0_231) AT=185.025n

.meas tran vdout0_232ck360 FIND v(dout0_232) AT=185.025n

.meas tran vdout0_233ck360 FIND v(dout0_233) AT=185.025n

.meas tran vdout0_234ck360 FIND v(dout0_234) AT=185.025n

.meas tran vdout0_235ck360 FIND v(dout0_235) AT=185.025n

.meas tran vdout0_236ck360 FIND v(dout0_236) AT=185.025n

.meas tran vdout0_237ck360 FIND v(dout0_237) AT=185.025n

.meas tran vdout0_238ck360 FIND v(dout0_238) AT=185.025n

.meas tran vdout0_239ck360 FIND v(dout0_239) AT=185.025n

.meas tran vdout0_240ck360 FIND v(dout0_240) AT=185.025n

.meas tran vdout0_241ck360 FIND v(dout0_241) AT=185.025n

.meas tran vdout0_242ck360 FIND v(dout0_242) AT=185.025n

.meas tran vdout0_243ck360 FIND v(dout0_243) AT=185.025n

.meas tran vdout0_244ck360 FIND v(dout0_244) AT=185.025n

.meas tran vdout0_245ck360 FIND v(dout0_245) AT=185.025n

.meas tran vdout0_246ck360 FIND v(dout0_246) AT=185.025n

.meas tran vdout0_247ck360 FIND v(dout0_247) AT=185.025n

.meas tran vdout0_248ck360 FIND v(dout0_248) AT=185.025n

.meas tran vdout0_249ck360 FIND v(dout0_249) AT=185.025n

.meas tran vdout0_250ck360 FIND v(dout0_250) AT=185.025n

.meas tran vdout0_251ck360 FIND v(dout0_251) AT=185.025n

.meas tran vdout0_252ck360 FIND v(dout0_252) AT=185.025n

.meas tran vdout0_253ck360 FIND v(dout0_253) AT=185.025n

.meas tran vdout0_254ck360 FIND v(dout0_254) AT=185.025n

.meas tran vdout0_255ck360 FIND v(dout0_255) AT=185.025n

.meas tran vdout0_0ck370 FIND v(dout0_0) AT=190.025n

.meas tran vdout0_1ck370 FIND v(dout0_1) AT=190.025n

.meas tran vdout0_2ck370 FIND v(dout0_2) AT=190.025n

.meas tran vdout0_3ck370 FIND v(dout0_3) AT=190.025n

.meas tran vdout0_4ck370 FIND v(dout0_4) AT=190.025n

.meas tran vdout0_5ck370 FIND v(dout0_5) AT=190.025n

.meas tran vdout0_6ck370 FIND v(dout0_6) AT=190.025n

.meas tran vdout0_7ck370 FIND v(dout0_7) AT=190.025n

.meas tran vdout0_8ck370 FIND v(dout0_8) AT=190.025n

.meas tran vdout0_9ck370 FIND v(dout0_9) AT=190.025n

.meas tran vdout0_10ck370 FIND v(dout0_10) AT=190.025n

.meas tran vdout0_11ck370 FIND v(dout0_11) AT=190.025n

.meas tran vdout0_12ck370 FIND v(dout0_12) AT=190.025n

.meas tran vdout0_13ck370 FIND v(dout0_13) AT=190.025n

.meas tran vdout0_14ck370 FIND v(dout0_14) AT=190.025n

.meas tran vdout0_15ck370 FIND v(dout0_15) AT=190.025n

.meas tran vdout0_16ck370 FIND v(dout0_16) AT=190.025n

.meas tran vdout0_17ck370 FIND v(dout0_17) AT=190.025n

.meas tran vdout0_18ck370 FIND v(dout0_18) AT=190.025n

.meas tran vdout0_19ck370 FIND v(dout0_19) AT=190.025n

.meas tran vdout0_20ck370 FIND v(dout0_20) AT=190.025n

.meas tran vdout0_21ck370 FIND v(dout0_21) AT=190.025n

.meas tran vdout0_22ck370 FIND v(dout0_22) AT=190.025n

.meas tran vdout0_23ck370 FIND v(dout0_23) AT=190.025n

.meas tran vdout0_24ck370 FIND v(dout0_24) AT=190.025n

.meas tran vdout0_25ck370 FIND v(dout0_25) AT=190.025n

.meas tran vdout0_26ck370 FIND v(dout0_26) AT=190.025n

.meas tran vdout0_27ck370 FIND v(dout0_27) AT=190.025n

.meas tran vdout0_28ck370 FIND v(dout0_28) AT=190.025n

.meas tran vdout0_29ck370 FIND v(dout0_29) AT=190.025n

.meas tran vdout0_30ck370 FIND v(dout0_30) AT=190.025n

.meas tran vdout0_31ck370 FIND v(dout0_31) AT=190.025n

.meas tran vdout0_32ck370 FIND v(dout0_32) AT=190.025n

.meas tran vdout0_33ck370 FIND v(dout0_33) AT=190.025n

.meas tran vdout0_34ck370 FIND v(dout0_34) AT=190.025n

.meas tran vdout0_35ck370 FIND v(dout0_35) AT=190.025n

.meas tran vdout0_36ck370 FIND v(dout0_36) AT=190.025n

.meas tran vdout0_37ck370 FIND v(dout0_37) AT=190.025n

.meas tran vdout0_38ck370 FIND v(dout0_38) AT=190.025n

.meas tran vdout0_39ck370 FIND v(dout0_39) AT=190.025n

.meas tran vdout0_40ck370 FIND v(dout0_40) AT=190.025n

.meas tran vdout0_41ck370 FIND v(dout0_41) AT=190.025n

.meas tran vdout0_42ck370 FIND v(dout0_42) AT=190.025n

.meas tran vdout0_43ck370 FIND v(dout0_43) AT=190.025n

.meas tran vdout0_44ck370 FIND v(dout0_44) AT=190.025n

.meas tran vdout0_45ck370 FIND v(dout0_45) AT=190.025n

.meas tran vdout0_46ck370 FIND v(dout0_46) AT=190.025n

.meas tran vdout0_47ck370 FIND v(dout0_47) AT=190.025n

.meas tran vdout0_48ck370 FIND v(dout0_48) AT=190.025n

.meas tran vdout0_49ck370 FIND v(dout0_49) AT=190.025n

.meas tran vdout0_50ck370 FIND v(dout0_50) AT=190.025n

.meas tran vdout0_51ck370 FIND v(dout0_51) AT=190.025n

.meas tran vdout0_52ck370 FIND v(dout0_52) AT=190.025n

.meas tran vdout0_53ck370 FIND v(dout0_53) AT=190.025n

.meas tran vdout0_54ck370 FIND v(dout0_54) AT=190.025n

.meas tran vdout0_55ck370 FIND v(dout0_55) AT=190.025n

.meas tran vdout0_56ck370 FIND v(dout0_56) AT=190.025n

.meas tran vdout0_57ck370 FIND v(dout0_57) AT=190.025n

.meas tran vdout0_58ck370 FIND v(dout0_58) AT=190.025n

.meas tran vdout0_59ck370 FIND v(dout0_59) AT=190.025n

.meas tran vdout0_60ck370 FIND v(dout0_60) AT=190.025n

.meas tran vdout0_61ck370 FIND v(dout0_61) AT=190.025n

.meas tran vdout0_62ck370 FIND v(dout0_62) AT=190.025n

.meas tran vdout0_63ck370 FIND v(dout0_63) AT=190.025n

.meas tran vdout0_64ck370 FIND v(dout0_64) AT=190.025n

.meas tran vdout0_65ck370 FIND v(dout0_65) AT=190.025n

.meas tran vdout0_66ck370 FIND v(dout0_66) AT=190.025n

.meas tran vdout0_67ck370 FIND v(dout0_67) AT=190.025n

.meas tran vdout0_68ck370 FIND v(dout0_68) AT=190.025n

.meas tran vdout0_69ck370 FIND v(dout0_69) AT=190.025n

.meas tran vdout0_70ck370 FIND v(dout0_70) AT=190.025n

.meas tran vdout0_71ck370 FIND v(dout0_71) AT=190.025n

.meas tran vdout0_72ck370 FIND v(dout0_72) AT=190.025n

.meas tran vdout0_73ck370 FIND v(dout0_73) AT=190.025n

.meas tran vdout0_74ck370 FIND v(dout0_74) AT=190.025n

.meas tran vdout0_75ck370 FIND v(dout0_75) AT=190.025n

.meas tran vdout0_76ck370 FIND v(dout0_76) AT=190.025n

.meas tran vdout0_77ck370 FIND v(dout0_77) AT=190.025n

.meas tran vdout0_78ck370 FIND v(dout0_78) AT=190.025n

.meas tran vdout0_79ck370 FIND v(dout0_79) AT=190.025n

.meas tran vdout0_80ck370 FIND v(dout0_80) AT=190.025n

.meas tran vdout0_81ck370 FIND v(dout0_81) AT=190.025n

.meas tran vdout0_82ck370 FIND v(dout0_82) AT=190.025n

.meas tran vdout0_83ck370 FIND v(dout0_83) AT=190.025n

.meas tran vdout0_84ck370 FIND v(dout0_84) AT=190.025n

.meas tran vdout0_85ck370 FIND v(dout0_85) AT=190.025n

.meas tran vdout0_86ck370 FIND v(dout0_86) AT=190.025n

.meas tran vdout0_87ck370 FIND v(dout0_87) AT=190.025n

.meas tran vdout0_88ck370 FIND v(dout0_88) AT=190.025n

.meas tran vdout0_89ck370 FIND v(dout0_89) AT=190.025n

.meas tran vdout0_90ck370 FIND v(dout0_90) AT=190.025n

.meas tran vdout0_91ck370 FIND v(dout0_91) AT=190.025n

.meas tran vdout0_92ck370 FIND v(dout0_92) AT=190.025n

.meas tran vdout0_93ck370 FIND v(dout0_93) AT=190.025n

.meas tran vdout0_94ck370 FIND v(dout0_94) AT=190.025n

.meas tran vdout0_95ck370 FIND v(dout0_95) AT=190.025n

.meas tran vdout0_96ck370 FIND v(dout0_96) AT=190.025n

.meas tran vdout0_97ck370 FIND v(dout0_97) AT=190.025n

.meas tran vdout0_98ck370 FIND v(dout0_98) AT=190.025n

.meas tran vdout0_99ck370 FIND v(dout0_99) AT=190.025n

.meas tran vdout0_100ck370 FIND v(dout0_100) AT=190.025n

.meas tran vdout0_101ck370 FIND v(dout0_101) AT=190.025n

.meas tran vdout0_102ck370 FIND v(dout0_102) AT=190.025n

.meas tran vdout0_103ck370 FIND v(dout0_103) AT=190.025n

.meas tran vdout0_104ck370 FIND v(dout0_104) AT=190.025n

.meas tran vdout0_105ck370 FIND v(dout0_105) AT=190.025n

.meas tran vdout0_106ck370 FIND v(dout0_106) AT=190.025n

.meas tran vdout0_107ck370 FIND v(dout0_107) AT=190.025n

.meas tran vdout0_108ck370 FIND v(dout0_108) AT=190.025n

.meas tran vdout0_109ck370 FIND v(dout0_109) AT=190.025n

.meas tran vdout0_110ck370 FIND v(dout0_110) AT=190.025n

.meas tran vdout0_111ck370 FIND v(dout0_111) AT=190.025n

.meas tran vdout0_112ck370 FIND v(dout0_112) AT=190.025n

.meas tran vdout0_113ck370 FIND v(dout0_113) AT=190.025n

.meas tran vdout0_114ck370 FIND v(dout0_114) AT=190.025n

.meas tran vdout0_115ck370 FIND v(dout0_115) AT=190.025n

.meas tran vdout0_116ck370 FIND v(dout0_116) AT=190.025n

.meas tran vdout0_117ck370 FIND v(dout0_117) AT=190.025n

.meas tran vdout0_118ck370 FIND v(dout0_118) AT=190.025n

.meas tran vdout0_119ck370 FIND v(dout0_119) AT=190.025n

.meas tran vdout0_120ck370 FIND v(dout0_120) AT=190.025n

.meas tran vdout0_121ck370 FIND v(dout0_121) AT=190.025n

.meas tran vdout0_122ck370 FIND v(dout0_122) AT=190.025n

.meas tran vdout0_123ck370 FIND v(dout0_123) AT=190.025n

.meas tran vdout0_124ck370 FIND v(dout0_124) AT=190.025n

.meas tran vdout0_125ck370 FIND v(dout0_125) AT=190.025n

.meas tran vdout0_126ck370 FIND v(dout0_126) AT=190.025n

.meas tran vdout0_127ck370 FIND v(dout0_127) AT=190.025n

.meas tran vdout0_128ck370 FIND v(dout0_128) AT=190.025n

.meas tran vdout0_129ck370 FIND v(dout0_129) AT=190.025n

.meas tran vdout0_130ck370 FIND v(dout0_130) AT=190.025n

.meas tran vdout0_131ck370 FIND v(dout0_131) AT=190.025n

.meas tran vdout0_132ck370 FIND v(dout0_132) AT=190.025n

.meas tran vdout0_133ck370 FIND v(dout0_133) AT=190.025n

.meas tran vdout0_134ck370 FIND v(dout0_134) AT=190.025n

.meas tran vdout0_135ck370 FIND v(dout0_135) AT=190.025n

.meas tran vdout0_136ck370 FIND v(dout0_136) AT=190.025n

.meas tran vdout0_137ck370 FIND v(dout0_137) AT=190.025n

.meas tran vdout0_138ck370 FIND v(dout0_138) AT=190.025n

.meas tran vdout0_139ck370 FIND v(dout0_139) AT=190.025n

.meas tran vdout0_140ck370 FIND v(dout0_140) AT=190.025n

.meas tran vdout0_141ck370 FIND v(dout0_141) AT=190.025n

.meas tran vdout0_142ck370 FIND v(dout0_142) AT=190.025n

.meas tran vdout0_143ck370 FIND v(dout0_143) AT=190.025n

.meas tran vdout0_144ck370 FIND v(dout0_144) AT=190.025n

.meas tran vdout0_145ck370 FIND v(dout0_145) AT=190.025n

.meas tran vdout0_146ck370 FIND v(dout0_146) AT=190.025n

.meas tran vdout0_147ck370 FIND v(dout0_147) AT=190.025n

.meas tran vdout0_148ck370 FIND v(dout0_148) AT=190.025n

.meas tran vdout0_149ck370 FIND v(dout0_149) AT=190.025n

.meas tran vdout0_150ck370 FIND v(dout0_150) AT=190.025n

.meas tran vdout0_151ck370 FIND v(dout0_151) AT=190.025n

.meas tran vdout0_152ck370 FIND v(dout0_152) AT=190.025n

.meas tran vdout0_153ck370 FIND v(dout0_153) AT=190.025n

.meas tran vdout0_154ck370 FIND v(dout0_154) AT=190.025n

.meas tran vdout0_155ck370 FIND v(dout0_155) AT=190.025n

.meas tran vdout0_156ck370 FIND v(dout0_156) AT=190.025n

.meas tran vdout0_157ck370 FIND v(dout0_157) AT=190.025n

.meas tran vdout0_158ck370 FIND v(dout0_158) AT=190.025n

.meas tran vdout0_159ck370 FIND v(dout0_159) AT=190.025n

.meas tran vdout0_160ck370 FIND v(dout0_160) AT=190.025n

.meas tran vdout0_161ck370 FIND v(dout0_161) AT=190.025n

.meas tran vdout0_162ck370 FIND v(dout0_162) AT=190.025n

.meas tran vdout0_163ck370 FIND v(dout0_163) AT=190.025n

.meas tran vdout0_164ck370 FIND v(dout0_164) AT=190.025n

.meas tran vdout0_165ck370 FIND v(dout0_165) AT=190.025n

.meas tran vdout0_166ck370 FIND v(dout0_166) AT=190.025n

.meas tran vdout0_167ck370 FIND v(dout0_167) AT=190.025n

.meas tran vdout0_168ck370 FIND v(dout0_168) AT=190.025n

.meas tran vdout0_169ck370 FIND v(dout0_169) AT=190.025n

.meas tran vdout0_170ck370 FIND v(dout0_170) AT=190.025n

.meas tran vdout0_171ck370 FIND v(dout0_171) AT=190.025n

.meas tran vdout0_172ck370 FIND v(dout0_172) AT=190.025n

.meas tran vdout0_173ck370 FIND v(dout0_173) AT=190.025n

.meas tran vdout0_174ck370 FIND v(dout0_174) AT=190.025n

.meas tran vdout0_175ck370 FIND v(dout0_175) AT=190.025n

.meas tran vdout0_176ck370 FIND v(dout0_176) AT=190.025n

.meas tran vdout0_177ck370 FIND v(dout0_177) AT=190.025n

.meas tran vdout0_178ck370 FIND v(dout0_178) AT=190.025n

.meas tran vdout0_179ck370 FIND v(dout0_179) AT=190.025n

.meas tran vdout0_180ck370 FIND v(dout0_180) AT=190.025n

.meas tran vdout0_181ck370 FIND v(dout0_181) AT=190.025n

.meas tran vdout0_182ck370 FIND v(dout0_182) AT=190.025n

.meas tran vdout0_183ck370 FIND v(dout0_183) AT=190.025n

.meas tran vdout0_184ck370 FIND v(dout0_184) AT=190.025n

.meas tran vdout0_185ck370 FIND v(dout0_185) AT=190.025n

.meas tran vdout0_186ck370 FIND v(dout0_186) AT=190.025n

.meas tran vdout0_187ck370 FIND v(dout0_187) AT=190.025n

.meas tran vdout0_188ck370 FIND v(dout0_188) AT=190.025n

.meas tran vdout0_189ck370 FIND v(dout0_189) AT=190.025n

.meas tran vdout0_190ck370 FIND v(dout0_190) AT=190.025n

.meas tran vdout0_191ck370 FIND v(dout0_191) AT=190.025n

.meas tran vdout0_192ck370 FIND v(dout0_192) AT=190.025n

.meas tran vdout0_193ck370 FIND v(dout0_193) AT=190.025n

.meas tran vdout0_194ck370 FIND v(dout0_194) AT=190.025n

.meas tran vdout0_195ck370 FIND v(dout0_195) AT=190.025n

.meas tran vdout0_196ck370 FIND v(dout0_196) AT=190.025n

.meas tran vdout0_197ck370 FIND v(dout0_197) AT=190.025n

.meas tran vdout0_198ck370 FIND v(dout0_198) AT=190.025n

.meas tran vdout0_199ck370 FIND v(dout0_199) AT=190.025n

.meas tran vdout0_200ck370 FIND v(dout0_200) AT=190.025n

.meas tran vdout0_201ck370 FIND v(dout0_201) AT=190.025n

.meas tran vdout0_202ck370 FIND v(dout0_202) AT=190.025n

.meas tran vdout0_203ck370 FIND v(dout0_203) AT=190.025n

.meas tran vdout0_204ck370 FIND v(dout0_204) AT=190.025n

.meas tran vdout0_205ck370 FIND v(dout0_205) AT=190.025n

.meas tran vdout0_206ck370 FIND v(dout0_206) AT=190.025n

.meas tran vdout0_207ck370 FIND v(dout0_207) AT=190.025n

.meas tran vdout0_208ck370 FIND v(dout0_208) AT=190.025n

.meas tran vdout0_209ck370 FIND v(dout0_209) AT=190.025n

.meas tran vdout0_210ck370 FIND v(dout0_210) AT=190.025n

.meas tran vdout0_211ck370 FIND v(dout0_211) AT=190.025n

.meas tran vdout0_212ck370 FIND v(dout0_212) AT=190.025n

.meas tran vdout0_213ck370 FIND v(dout0_213) AT=190.025n

.meas tran vdout0_214ck370 FIND v(dout0_214) AT=190.025n

.meas tran vdout0_215ck370 FIND v(dout0_215) AT=190.025n

.meas tran vdout0_216ck370 FIND v(dout0_216) AT=190.025n

.meas tran vdout0_217ck370 FIND v(dout0_217) AT=190.025n

.meas tran vdout0_218ck370 FIND v(dout0_218) AT=190.025n

.meas tran vdout0_219ck370 FIND v(dout0_219) AT=190.025n

.meas tran vdout0_220ck370 FIND v(dout0_220) AT=190.025n

.meas tran vdout0_221ck370 FIND v(dout0_221) AT=190.025n

.meas tran vdout0_222ck370 FIND v(dout0_222) AT=190.025n

.meas tran vdout0_223ck370 FIND v(dout0_223) AT=190.025n

.meas tran vdout0_224ck370 FIND v(dout0_224) AT=190.025n

.meas tran vdout0_225ck370 FIND v(dout0_225) AT=190.025n

.meas tran vdout0_226ck370 FIND v(dout0_226) AT=190.025n

.meas tran vdout0_227ck370 FIND v(dout0_227) AT=190.025n

.meas tran vdout0_228ck370 FIND v(dout0_228) AT=190.025n

.meas tran vdout0_229ck370 FIND v(dout0_229) AT=190.025n

.meas tran vdout0_230ck370 FIND v(dout0_230) AT=190.025n

.meas tran vdout0_231ck370 FIND v(dout0_231) AT=190.025n

.meas tran vdout0_232ck370 FIND v(dout0_232) AT=190.025n

.meas tran vdout0_233ck370 FIND v(dout0_233) AT=190.025n

.meas tran vdout0_234ck370 FIND v(dout0_234) AT=190.025n

.meas tran vdout0_235ck370 FIND v(dout0_235) AT=190.025n

.meas tran vdout0_236ck370 FIND v(dout0_236) AT=190.025n

.meas tran vdout0_237ck370 FIND v(dout0_237) AT=190.025n

.meas tran vdout0_238ck370 FIND v(dout0_238) AT=190.025n

.meas tran vdout0_239ck370 FIND v(dout0_239) AT=190.025n

.meas tran vdout0_240ck370 FIND v(dout0_240) AT=190.025n

.meas tran vdout0_241ck370 FIND v(dout0_241) AT=190.025n

.meas tran vdout0_242ck370 FIND v(dout0_242) AT=190.025n

.meas tran vdout0_243ck370 FIND v(dout0_243) AT=190.025n

.meas tran vdout0_244ck370 FIND v(dout0_244) AT=190.025n

.meas tran vdout0_245ck370 FIND v(dout0_245) AT=190.025n

.meas tran vdout0_246ck370 FIND v(dout0_246) AT=190.025n

.meas tran vdout0_247ck370 FIND v(dout0_247) AT=190.025n

.meas tran vdout0_248ck370 FIND v(dout0_248) AT=190.025n

.meas tran vdout0_249ck370 FIND v(dout0_249) AT=190.025n

.meas tran vdout0_250ck370 FIND v(dout0_250) AT=190.025n

.meas tran vdout0_251ck370 FIND v(dout0_251) AT=190.025n

.meas tran vdout0_252ck370 FIND v(dout0_252) AT=190.025n

.meas tran vdout0_253ck370 FIND v(dout0_253) AT=190.025n

.meas tran vdout0_254ck370 FIND v(dout0_254) AT=190.025n

.meas tran vdout0_255ck370 FIND v(dout0_255) AT=190.025n

.meas tran vdout0_0ck410 FIND v(dout0_0) AT=210.025n

.meas tran vdout0_1ck410 FIND v(dout0_1) AT=210.025n

.meas tran vdout0_2ck410 FIND v(dout0_2) AT=210.025n

.meas tran vdout0_3ck410 FIND v(dout0_3) AT=210.025n

.meas tran vdout0_4ck410 FIND v(dout0_4) AT=210.025n

.meas tran vdout0_5ck410 FIND v(dout0_5) AT=210.025n

.meas tran vdout0_6ck410 FIND v(dout0_6) AT=210.025n

.meas tran vdout0_7ck410 FIND v(dout0_7) AT=210.025n

.meas tran vdout0_8ck410 FIND v(dout0_8) AT=210.025n

.meas tran vdout0_9ck410 FIND v(dout0_9) AT=210.025n

.meas tran vdout0_10ck410 FIND v(dout0_10) AT=210.025n

.meas tran vdout0_11ck410 FIND v(dout0_11) AT=210.025n

.meas tran vdout0_12ck410 FIND v(dout0_12) AT=210.025n

.meas tran vdout0_13ck410 FIND v(dout0_13) AT=210.025n

.meas tran vdout0_14ck410 FIND v(dout0_14) AT=210.025n

.meas tran vdout0_15ck410 FIND v(dout0_15) AT=210.025n

.meas tran vdout0_16ck410 FIND v(dout0_16) AT=210.025n

.meas tran vdout0_17ck410 FIND v(dout0_17) AT=210.025n

.meas tran vdout0_18ck410 FIND v(dout0_18) AT=210.025n

.meas tran vdout0_19ck410 FIND v(dout0_19) AT=210.025n

.meas tran vdout0_20ck410 FIND v(dout0_20) AT=210.025n

.meas tran vdout0_21ck410 FIND v(dout0_21) AT=210.025n

.meas tran vdout0_22ck410 FIND v(dout0_22) AT=210.025n

.meas tran vdout0_23ck410 FIND v(dout0_23) AT=210.025n

.meas tran vdout0_24ck410 FIND v(dout0_24) AT=210.025n

.meas tran vdout0_25ck410 FIND v(dout0_25) AT=210.025n

.meas tran vdout0_26ck410 FIND v(dout0_26) AT=210.025n

.meas tran vdout0_27ck410 FIND v(dout0_27) AT=210.025n

.meas tran vdout0_28ck410 FIND v(dout0_28) AT=210.025n

.meas tran vdout0_29ck410 FIND v(dout0_29) AT=210.025n

.meas tran vdout0_30ck410 FIND v(dout0_30) AT=210.025n

.meas tran vdout0_31ck410 FIND v(dout0_31) AT=210.025n

.meas tran vdout0_32ck410 FIND v(dout0_32) AT=210.025n

.meas tran vdout0_33ck410 FIND v(dout0_33) AT=210.025n

.meas tran vdout0_34ck410 FIND v(dout0_34) AT=210.025n

.meas tran vdout0_35ck410 FIND v(dout0_35) AT=210.025n

.meas tran vdout0_36ck410 FIND v(dout0_36) AT=210.025n

.meas tran vdout0_37ck410 FIND v(dout0_37) AT=210.025n

.meas tran vdout0_38ck410 FIND v(dout0_38) AT=210.025n

.meas tran vdout0_39ck410 FIND v(dout0_39) AT=210.025n

.meas tran vdout0_40ck410 FIND v(dout0_40) AT=210.025n

.meas tran vdout0_41ck410 FIND v(dout0_41) AT=210.025n

.meas tran vdout0_42ck410 FIND v(dout0_42) AT=210.025n

.meas tran vdout0_43ck410 FIND v(dout0_43) AT=210.025n

.meas tran vdout0_44ck410 FIND v(dout0_44) AT=210.025n

.meas tran vdout0_45ck410 FIND v(dout0_45) AT=210.025n

.meas tran vdout0_46ck410 FIND v(dout0_46) AT=210.025n

.meas tran vdout0_47ck410 FIND v(dout0_47) AT=210.025n

.meas tran vdout0_48ck410 FIND v(dout0_48) AT=210.025n

.meas tran vdout0_49ck410 FIND v(dout0_49) AT=210.025n

.meas tran vdout0_50ck410 FIND v(dout0_50) AT=210.025n

.meas tran vdout0_51ck410 FIND v(dout0_51) AT=210.025n

.meas tran vdout0_52ck410 FIND v(dout0_52) AT=210.025n

.meas tran vdout0_53ck410 FIND v(dout0_53) AT=210.025n

.meas tran vdout0_54ck410 FIND v(dout0_54) AT=210.025n

.meas tran vdout0_55ck410 FIND v(dout0_55) AT=210.025n

.meas tran vdout0_56ck410 FIND v(dout0_56) AT=210.025n

.meas tran vdout0_57ck410 FIND v(dout0_57) AT=210.025n

.meas tran vdout0_58ck410 FIND v(dout0_58) AT=210.025n

.meas tran vdout0_59ck410 FIND v(dout0_59) AT=210.025n

.meas tran vdout0_60ck410 FIND v(dout0_60) AT=210.025n

.meas tran vdout0_61ck410 FIND v(dout0_61) AT=210.025n

.meas tran vdout0_62ck410 FIND v(dout0_62) AT=210.025n

.meas tran vdout0_63ck410 FIND v(dout0_63) AT=210.025n

.meas tran vdout0_64ck410 FIND v(dout0_64) AT=210.025n

.meas tran vdout0_65ck410 FIND v(dout0_65) AT=210.025n

.meas tran vdout0_66ck410 FIND v(dout0_66) AT=210.025n

.meas tran vdout0_67ck410 FIND v(dout0_67) AT=210.025n

.meas tran vdout0_68ck410 FIND v(dout0_68) AT=210.025n

.meas tran vdout0_69ck410 FIND v(dout0_69) AT=210.025n

.meas tran vdout0_70ck410 FIND v(dout0_70) AT=210.025n

.meas tran vdout0_71ck410 FIND v(dout0_71) AT=210.025n

.meas tran vdout0_72ck410 FIND v(dout0_72) AT=210.025n

.meas tran vdout0_73ck410 FIND v(dout0_73) AT=210.025n

.meas tran vdout0_74ck410 FIND v(dout0_74) AT=210.025n

.meas tran vdout0_75ck410 FIND v(dout0_75) AT=210.025n

.meas tran vdout0_76ck410 FIND v(dout0_76) AT=210.025n

.meas tran vdout0_77ck410 FIND v(dout0_77) AT=210.025n

.meas tran vdout0_78ck410 FIND v(dout0_78) AT=210.025n

.meas tran vdout0_79ck410 FIND v(dout0_79) AT=210.025n

.meas tran vdout0_80ck410 FIND v(dout0_80) AT=210.025n

.meas tran vdout0_81ck410 FIND v(dout0_81) AT=210.025n

.meas tran vdout0_82ck410 FIND v(dout0_82) AT=210.025n

.meas tran vdout0_83ck410 FIND v(dout0_83) AT=210.025n

.meas tran vdout0_84ck410 FIND v(dout0_84) AT=210.025n

.meas tran vdout0_85ck410 FIND v(dout0_85) AT=210.025n

.meas tran vdout0_86ck410 FIND v(dout0_86) AT=210.025n

.meas tran vdout0_87ck410 FIND v(dout0_87) AT=210.025n

.meas tran vdout0_88ck410 FIND v(dout0_88) AT=210.025n

.meas tran vdout0_89ck410 FIND v(dout0_89) AT=210.025n

.meas tran vdout0_90ck410 FIND v(dout0_90) AT=210.025n

.meas tran vdout0_91ck410 FIND v(dout0_91) AT=210.025n

.meas tran vdout0_92ck410 FIND v(dout0_92) AT=210.025n

.meas tran vdout0_93ck410 FIND v(dout0_93) AT=210.025n

.meas tran vdout0_94ck410 FIND v(dout0_94) AT=210.025n

.meas tran vdout0_95ck410 FIND v(dout0_95) AT=210.025n

.meas tran vdout0_96ck410 FIND v(dout0_96) AT=210.025n

.meas tran vdout0_97ck410 FIND v(dout0_97) AT=210.025n

.meas tran vdout0_98ck410 FIND v(dout0_98) AT=210.025n

.meas tran vdout0_99ck410 FIND v(dout0_99) AT=210.025n

.meas tran vdout0_100ck410 FIND v(dout0_100) AT=210.025n

.meas tran vdout0_101ck410 FIND v(dout0_101) AT=210.025n

.meas tran vdout0_102ck410 FIND v(dout0_102) AT=210.025n

.meas tran vdout0_103ck410 FIND v(dout0_103) AT=210.025n

.meas tran vdout0_104ck410 FIND v(dout0_104) AT=210.025n

.meas tran vdout0_105ck410 FIND v(dout0_105) AT=210.025n

.meas tran vdout0_106ck410 FIND v(dout0_106) AT=210.025n

.meas tran vdout0_107ck410 FIND v(dout0_107) AT=210.025n

.meas tran vdout0_108ck410 FIND v(dout0_108) AT=210.025n

.meas tran vdout0_109ck410 FIND v(dout0_109) AT=210.025n

.meas tran vdout0_110ck410 FIND v(dout0_110) AT=210.025n

.meas tran vdout0_111ck410 FIND v(dout0_111) AT=210.025n

.meas tran vdout0_112ck410 FIND v(dout0_112) AT=210.025n

.meas tran vdout0_113ck410 FIND v(dout0_113) AT=210.025n

.meas tran vdout0_114ck410 FIND v(dout0_114) AT=210.025n

.meas tran vdout0_115ck410 FIND v(dout0_115) AT=210.025n

.meas tran vdout0_116ck410 FIND v(dout0_116) AT=210.025n

.meas tran vdout0_117ck410 FIND v(dout0_117) AT=210.025n

.meas tran vdout0_118ck410 FIND v(dout0_118) AT=210.025n

.meas tran vdout0_119ck410 FIND v(dout0_119) AT=210.025n

.meas tran vdout0_120ck410 FIND v(dout0_120) AT=210.025n

.meas tran vdout0_121ck410 FIND v(dout0_121) AT=210.025n

.meas tran vdout0_122ck410 FIND v(dout0_122) AT=210.025n

.meas tran vdout0_123ck410 FIND v(dout0_123) AT=210.025n

.meas tran vdout0_124ck410 FIND v(dout0_124) AT=210.025n

.meas tran vdout0_125ck410 FIND v(dout0_125) AT=210.025n

.meas tran vdout0_126ck410 FIND v(dout0_126) AT=210.025n

.meas tran vdout0_127ck410 FIND v(dout0_127) AT=210.025n

.meas tran vdout0_128ck410 FIND v(dout0_128) AT=210.025n

.meas tran vdout0_129ck410 FIND v(dout0_129) AT=210.025n

.meas tran vdout0_130ck410 FIND v(dout0_130) AT=210.025n

.meas tran vdout0_131ck410 FIND v(dout0_131) AT=210.025n

.meas tran vdout0_132ck410 FIND v(dout0_132) AT=210.025n

.meas tran vdout0_133ck410 FIND v(dout0_133) AT=210.025n

.meas tran vdout0_134ck410 FIND v(dout0_134) AT=210.025n

.meas tran vdout0_135ck410 FIND v(dout0_135) AT=210.025n

.meas tran vdout0_136ck410 FIND v(dout0_136) AT=210.025n

.meas tran vdout0_137ck410 FIND v(dout0_137) AT=210.025n

.meas tran vdout0_138ck410 FIND v(dout0_138) AT=210.025n

.meas tran vdout0_139ck410 FIND v(dout0_139) AT=210.025n

.meas tran vdout0_140ck410 FIND v(dout0_140) AT=210.025n

.meas tran vdout0_141ck410 FIND v(dout0_141) AT=210.025n

.meas tran vdout0_142ck410 FIND v(dout0_142) AT=210.025n

.meas tran vdout0_143ck410 FIND v(dout0_143) AT=210.025n

.meas tran vdout0_144ck410 FIND v(dout0_144) AT=210.025n

.meas tran vdout0_145ck410 FIND v(dout0_145) AT=210.025n

.meas tran vdout0_146ck410 FIND v(dout0_146) AT=210.025n

.meas tran vdout0_147ck410 FIND v(dout0_147) AT=210.025n

.meas tran vdout0_148ck410 FIND v(dout0_148) AT=210.025n

.meas tran vdout0_149ck410 FIND v(dout0_149) AT=210.025n

.meas tran vdout0_150ck410 FIND v(dout0_150) AT=210.025n

.meas tran vdout0_151ck410 FIND v(dout0_151) AT=210.025n

.meas tran vdout0_152ck410 FIND v(dout0_152) AT=210.025n

.meas tran vdout0_153ck410 FIND v(dout0_153) AT=210.025n

.meas tran vdout0_154ck410 FIND v(dout0_154) AT=210.025n

.meas tran vdout0_155ck410 FIND v(dout0_155) AT=210.025n

.meas tran vdout0_156ck410 FIND v(dout0_156) AT=210.025n

.meas tran vdout0_157ck410 FIND v(dout0_157) AT=210.025n

.meas tran vdout0_158ck410 FIND v(dout0_158) AT=210.025n

.meas tran vdout0_159ck410 FIND v(dout0_159) AT=210.025n

.meas tran vdout0_160ck410 FIND v(dout0_160) AT=210.025n

.meas tran vdout0_161ck410 FIND v(dout0_161) AT=210.025n

.meas tran vdout0_162ck410 FIND v(dout0_162) AT=210.025n

.meas tran vdout0_163ck410 FIND v(dout0_163) AT=210.025n

.meas tran vdout0_164ck410 FIND v(dout0_164) AT=210.025n

.meas tran vdout0_165ck410 FIND v(dout0_165) AT=210.025n

.meas tran vdout0_166ck410 FIND v(dout0_166) AT=210.025n

.meas tran vdout0_167ck410 FIND v(dout0_167) AT=210.025n

.meas tran vdout0_168ck410 FIND v(dout0_168) AT=210.025n

.meas tran vdout0_169ck410 FIND v(dout0_169) AT=210.025n

.meas tran vdout0_170ck410 FIND v(dout0_170) AT=210.025n

.meas tran vdout0_171ck410 FIND v(dout0_171) AT=210.025n

.meas tran vdout0_172ck410 FIND v(dout0_172) AT=210.025n

.meas tran vdout0_173ck410 FIND v(dout0_173) AT=210.025n

.meas tran vdout0_174ck410 FIND v(dout0_174) AT=210.025n

.meas tran vdout0_175ck410 FIND v(dout0_175) AT=210.025n

.meas tran vdout0_176ck410 FIND v(dout0_176) AT=210.025n

.meas tran vdout0_177ck410 FIND v(dout0_177) AT=210.025n

.meas tran vdout0_178ck410 FIND v(dout0_178) AT=210.025n

.meas tran vdout0_179ck410 FIND v(dout0_179) AT=210.025n

.meas tran vdout0_180ck410 FIND v(dout0_180) AT=210.025n

.meas tran vdout0_181ck410 FIND v(dout0_181) AT=210.025n

.meas tran vdout0_182ck410 FIND v(dout0_182) AT=210.025n

.meas tran vdout0_183ck410 FIND v(dout0_183) AT=210.025n

.meas tran vdout0_184ck410 FIND v(dout0_184) AT=210.025n

.meas tran vdout0_185ck410 FIND v(dout0_185) AT=210.025n

.meas tran vdout0_186ck410 FIND v(dout0_186) AT=210.025n

.meas tran vdout0_187ck410 FIND v(dout0_187) AT=210.025n

.meas tran vdout0_188ck410 FIND v(dout0_188) AT=210.025n

.meas tran vdout0_189ck410 FIND v(dout0_189) AT=210.025n

.meas tran vdout0_190ck410 FIND v(dout0_190) AT=210.025n

.meas tran vdout0_191ck410 FIND v(dout0_191) AT=210.025n

.meas tran vdout0_192ck410 FIND v(dout0_192) AT=210.025n

.meas tran vdout0_193ck410 FIND v(dout0_193) AT=210.025n

.meas tran vdout0_194ck410 FIND v(dout0_194) AT=210.025n

.meas tran vdout0_195ck410 FIND v(dout0_195) AT=210.025n

.meas tran vdout0_196ck410 FIND v(dout0_196) AT=210.025n

.meas tran vdout0_197ck410 FIND v(dout0_197) AT=210.025n

.meas tran vdout0_198ck410 FIND v(dout0_198) AT=210.025n

.meas tran vdout0_199ck410 FIND v(dout0_199) AT=210.025n

.meas tran vdout0_200ck410 FIND v(dout0_200) AT=210.025n

.meas tran vdout0_201ck410 FIND v(dout0_201) AT=210.025n

.meas tran vdout0_202ck410 FIND v(dout0_202) AT=210.025n

.meas tran vdout0_203ck410 FIND v(dout0_203) AT=210.025n

.meas tran vdout0_204ck410 FIND v(dout0_204) AT=210.025n

.meas tran vdout0_205ck410 FIND v(dout0_205) AT=210.025n

.meas tran vdout0_206ck410 FIND v(dout0_206) AT=210.025n

.meas tran vdout0_207ck410 FIND v(dout0_207) AT=210.025n

.meas tran vdout0_208ck410 FIND v(dout0_208) AT=210.025n

.meas tran vdout0_209ck410 FIND v(dout0_209) AT=210.025n

.meas tran vdout0_210ck410 FIND v(dout0_210) AT=210.025n

.meas tran vdout0_211ck410 FIND v(dout0_211) AT=210.025n

.meas tran vdout0_212ck410 FIND v(dout0_212) AT=210.025n

.meas tran vdout0_213ck410 FIND v(dout0_213) AT=210.025n

.meas tran vdout0_214ck410 FIND v(dout0_214) AT=210.025n

.meas tran vdout0_215ck410 FIND v(dout0_215) AT=210.025n

.meas tran vdout0_216ck410 FIND v(dout0_216) AT=210.025n

.meas tran vdout0_217ck410 FIND v(dout0_217) AT=210.025n

.meas tran vdout0_218ck410 FIND v(dout0_218) AT=210.025n

.meas tran vdout0_219ck410 FIND v(dout0_219) AT=210.025n

.meas tran vdout0_220ck410 FIND v(dout0_220) AT=210.025n

.meas tran vdout0_221ck410 FIND v(dout0_221) AT=210.025n

.meas tran vdout0_222ck410 FIND v(dout0_222) AT=210.025n

.meas tran vdout0_223ck410 FIND v(dout0_223) AT=210.025n

.meas tran vdout0_224ck410 FIND v(dout0_224) AT=210.025n

.meas tran vdout0_225ck410 FIND v(dout0_225) AT=210.025n

.meas tran vdout0_226ck410 FIND v(dout0_226) AT=210.025n

.meas tran vdout0_227ck410 FIND v(dout0_227) AT=210.025n

.meas tran vdout0_228ck410 FIND v(dout0_228) AT=210.025n

.meas tran vdout0_229ck410 FIND v(dout0_229) AT=210.025n

.meas tran vdout0_230ck410 FIND v(dout0_230) AT=210.025n

.meas tran vdout0_231ck410 FIND v(dout0_231) AT=210.025n

.meas tran vdout0_232ck410 FIND v(dout0_232) AT=210.025n

.meas tran vdout0_233ck410 FIND v(dout0_233) AT=210.025n

.meas tran vdout0_234ck410 FIND v(dout0_234) AT=210.025n

.meas tran vdout0_235ck410 FIND v(dout0_235) AT=210.025n

.meas tran vdout0_236ck410 FIND v(dout0_236) AT=210.025n

.meas tran vdout0_237ck410 FIND v(dout0_237) AT=210.025n

.meas tran vdout0_238ck410 FIND v(dout0_238) AT=210.025n

.meas tran vdout0_239ck410 FIND v(dout0_239) AT=210.025n

.meas tran vdout0_240ck410 FIND v(dout0_240) AT=210.025n

.meas tran vdout0_241ck410 FIND v(dout0_241) AT=210.025n

.meas tran vdout0_242ck410 FIND v(dout0_242) AT=210.025n

.meas tran vdout0_243ck410 FIND v(dout0_243) AT=210.025n

.meas tran vdout0_244ck410 FIND v(dout0_244) AT=210.025n

.meas tran vdout0_245ck410 FIND v(dout0_245) AT=210.025n

.meas tran vdout0_246ck410 FIND v(dout0_246) AT=210.025n

.meas tran vdout0_247ck410 FIND v(dout0_247) AT=210.025n

.meas tran vdout0_248ck410 FIND v(dout0_248) AT=210.025n

.meas tran vdout0_249ck410 FIND v(dout0_249) AT=210.025n

.meas tran vdout0_250ck410 FIND v(dout0_250) AT=210.025n

.meas tran vdout0_251ck410 FIND v(dout0_251) AT=210.025n

.meas tran vdout0_252ck410 FIND v(dout0_252) AT=210.025n

.meas tran vdout0_253ck410 FIND v(dout0_253) AT=210.025n

.meas tran vdout0_254ck410 FIND v(dout0_254) AT=210.025n

.meas tran vdout0_255ck410 FIND v(dout0_255) AT=210.025n

.meas tran vdout0_0ck440 FIND v(dout0_0) AT=225.025n

.meas tran vdout0_1ck440 FIND v(dout0_1) AT=225.025n

.meas tran vdout0_2ck440 FIND v(dout0_2) AT=225.025n

.meas tran vdout0_3ck440 FIND v(dout0_3) AT=225.025n

.meas tran vdout0_4ck440 FIND v(dout0_4) AT=225.025n

.meas tran vdout0_5ck440 FIND v(dout0_5) AT=225.025n

.meas tran vdout0_6ck440 FIND v(dout0_6) AT=225.025n

.meas tran vdout0_7ck440 FIND v(dout0_7) AT=225.025n

.meas tran vdout0_8ck440 FIND v(dout0_8) AT=225.025n

.meas tran vdout0_9ck440 FIND v(dout0_9) AT=225.025n

.meas tran vdout0_10ck440 FIND v(dout0_10) AT=225.025n

.meas tran vdout0_11ck440 FIND v(dout0_11) AT=225.025n

.meas tran vdout0_12ck440 FIND v(dout0_12) AT=225.025n

.meas tran vdout0_13ck440 FIND v(dout0_13) AT=225.025n

.meas tran vdout0_14ck440 FIND v(dout0_14) AT=225.025n

.meas tran vdout0_15ck440 FIND v(dout0_15) AT=225.025n

.meas tran vdout0_16ck440 FIND v(dout0_16) AT=225.025n

.meas tran vdout0_17ck440 FIND v(dout0_17) AT=225.025n

.meas tran vdout0_18ck440 FIND v(dout0_18) AT=225.025n

.meas tran vdout0_19ck440 FIND v(dout0_19) AT=225.025n

.meas tran vdout0_20ck440 FIND v(dout0_20) AT=225.025n

.meas tran vdout0_21ck440 FIND v(dout0_21) AT=225.025n

.meas tran vdout0_22ck440 FIND v(dout0_22) AT=225.025n

.meas tran vdout0_23ck440 FIND v(dout0_23) AT=225.025n

.meas tran vdout0_24ck440 FIND v(dout0_24) AT=225.025n

.meas tran vdout0_25ck440 FIND v(dout0_25) AT=225.025n

.meas tran vdout0_26ck440 FIND v(dout0_26) AT=225.025n

.meas tran vdout0_27ck440 FIND v(dout0_27) AT=225.025n

.meas tran vdout0_28ck440 FIND v(dout0_28) AT=225.025n

.meas tran vdout0_29ck440 FIND v(dout0_29) AT=225.025n

.meas tran vdout0_30ck440 FIND v(dout0_30) AT=225.025n

.meas tran vdout0_31ck440 FIND v(dout0_31) AT=225.025n

.meas tran vdout0_32ck440 FIND v(dout0_32) AT=225.025n

.meas tran vdout0_33ck440 FIND v(dout0_33) AT=225.025n

.meas tran vdout0_34ck440 FIND v(dout0_34) AT=225.025n

.meas tran vdout0_35ck440 FIND v(dout0_35) AT=225.025n

.meas tran vdout0_36ck440 FIND v(dout0_36) AT=225.025n

.meas tran vdout0_37ck440 FIND v(dout0_37) AT=225.025n

.meas tran vdout0_38ck440 FIND v(dout0_38) AT=225.025n

.meas tran vdout0_39ck440 FIND v(dout0_39) AT=225.025n

.meas tran vdout0_40ck440 FIND v(dout0_40) AT=225.025n

.meas tran vdout0_41ck440 FIND v(dout0_41) AT=225.025n

.meas tran vdout0_42ck440 FIND v(dout0_42) AT=225.025n

.meas tran vdout0_43ck440 FIND v(dout0_43) AT=225.025n

.meas tran vdout0_44ck440 FIND v(dout0_44) AT=225.025n

.meas tran vdout0_45ck440 FIND v(dout0_45) AT=225.025n

.meas tran vdout0_46ck440 FIND v(dout0_46) AT=225.025n

.meas tran vdout0_47ck440 FIND v(dout0_47) AT=225.025n

.meas tran vdout0_48ck440 FIND v(dout0_48) AT=225.025n

.meas tran vdout0_49ck440 FIND v(dout0_49) AT=225.025n

.meas tran vdout0_50ck440 FIND v(dout0_50) AT=225.025n

.meas tran vdout0_51ck440 FIND v(dout0_51) AT=225.025n

.meas tran vdout0_52ck440 FIND v(dout0_52) AT=225.025n

.meas tran vdout0_53ck440 FIND v(dout0_53) AT=225.025n

.meas tran vdout0_54ck440 FIND v(dout0_54) AT=225.025n

.meas tran vdout0_55ck440 FIND v(dout0_55) AT=225.025n

.meas tran vdout0_56ck440 FIND v(dout0_56) AT=225.025n

.meas tran vdout0_57ck440 FIND v(dout0_57) AT=225.025n

.meas tran vdout0_58ck440 FIND v(dout0_58) AT=225.025n

.meas tran vdout0_59ck440 FIND v(dout0_59) AT=225.025n

.meas tran vdout0_60ck440 FIND v(dout0_60) AT=225.025n

.meas tran vdout0_61ck440 FIND v(dout0_61) AT=225.025n

.meas tran vdout0_62ck440 FIND v(dout0_62) AT=225.025n

.meas tran vdout0_63ck440 FIND v(dout0_63) AT=225.025n

.meas tran vdout0_64ck440 FIND v(dout0_64) AT=225.025n

.meas tran vdout0_65ck440 FIND v(dout0_65) AT=225.025n

.meas tran vdout0_66ck440 FIND v(dout0_66) AT=225.025n

.meas tran vdout0_67ck440 FIND v(dout0_67) AT=225.025n

.meas tran vdout0_68ck440 FIND v(dout0_68) AT=225.025n

.meas tran vdout0_69ck440 FIND v(dout0_69) AT=225.025n

.meas tran vdout0_70ck440 FIND v(dout0_70) AT=225.025n

.meas tran vdout0_71ck440 FIND v(dout0_71) AT=225.025n

.meas tran vdout0_72ck440 FIND v(dout0_72) AT=225.025n

.meas tran vdout0_73ck440 FIND v(dout0_73) AT=225.025n

.meas tran vdout0_74ck440 FIND v(dout0_74) AT=225.025n

.meas tran vdout0_75ck440 FIND v(dout0_75) AT=225.025n

.meas tran vdout0_76ck440 FIND v(dout0_76) AT=225.025n

.meas tran vdout0_77ck440 FIND v(dout0_77) AT=225.025n

.meas tran vdout0_78ck440 FIND v(dout0_78) AT=225.025n

.meas tran vdout0_79ck440 FIND v(dout0_79) AT=225.025n

.meas tran vdout0_80ck440 FIND v(dout0_80) AT=225.025n

.meas tran vdout0_81ck440 FIND v(dout0_81) AT=225.025n

.meas tran vdout0_82ck440 FIND v(dout0_82) AT=225.025n

.meas tran vdout0_83ck440 FIND v(dout0_83) AT=225.025n

.meas tran vdout0_84ck440 FIND v(dout0_84) AT=225.025n

.meas tran vdout0_85ck440 FIND v(dout0_85) AT=225.025n

.meas tran vdout0_86ck440 FIND v(dout0_86) AT=225.025n

.meas tran vdout0_87ck440 FIND v(dout0_87) AT=225.025n

.meas tran vdout0_88ck440 FIND v(dout0_88) AT=225.025n

.meas tran vdout0_89ck440 FIND v(dout0_89) AT=225.025n

.meas tran vdout0_90ck440 FIND v(dout0_90) AT=225.025n

.meas tran vdout0_91ck440 FIND v(dout0_91) AT=225.025n

.meas tran vdout0_92ck440 FIND v(dout0_92) AT=225.025n

.meas tran vdout0_93ck440 FIND v(dout0_93) AT=225.025n

.meas tran vdout0_94ck440 FIND v(dout0_94) AT=225.025n

.meas tran vdout0_95ck440 FIND v(dout0_95) AT=225.025n

.meas tran vdout0_96ck440 FIND v(dout0_96) AT=225.025n

.meas tran vdout0_97ck440 FIND v(dout0_97) AT=225.025n

.meas tran vdout0_98ck440 FIND v(dout0_98) AT=225.025n

.meas tran vdout0_99ck440 FIND v(dout0_99) AT=225.025n

.meas tran vdout0_100ck440 FIND v(dout0_100) AT=225.025n

.meas tran vdout0_101ck440 FIND v(dout0_101) AT=225.025n

.meas tran vdout0_102ck440 FIND v(dout0_102) AT=225.025n

.meas tran vdout0_103ck440 FIND v(dout0_103) AT=225.025n

.meas tran vdout0_104ck440 FIND v(dout0_104) AT=225.025n

.meas tran vdout0_105ck440 FIND v(dout0_105) AT=225.025n

.meas tran vdout0_106ck440 FIND v(dout0_106) AT=225.025n

.meas tran vdout0_107ck440 FIND v(dout0_107) AT=225.025n

.meas tran vdout0_108ck440 FIND v(dout0_108) AT=225.025n

.meas tran vdout0_109ck440 FIND v(dout0_109) AT=225.025n

.meas tran vdout0_110ck440 FIND v(dout0_110) AT=225.025n

.meas tran vdout0_111ck440 FIND v(dout0_111) AT=225.025n

.meas tran vdout0_112ck440 FIND v(dout0_112) AT=225.025n

.meas tran vdout0_113ck440 FIND v(dout0_113) AT=225.025n

.meas tran vdout0_114ck440 FIND v(dout0_114) AT=225.025n

.meas tran vdout0_115ck440 FIND v(dout0_115) AT=225.025n

.meas tran vdout0_116ck440 FIND v(dout0_116) AT=225.025n

.meas tran vdout0_117ck440 FIND v(dout0_117) AT=225.025n

.meas tran vdout0_118ck440 FIND v(dout0_118) AT=225.025n

.meas tran vdout0_119ck440 FIND v(dout0_119) AT=225.025n

.meas tran vdout0_120ck440 FIND v(dout0_120) AT=225.025n

.meas tran vdout0_121ck440 FIND v(dout0_121) AT=225.025n

.meas tran vdout0_122ck440 FIND v(dout0_122) AT=225.025n

.meas tran vdout0_123ck440 FIND v(dout0_123) AT=225.025n

.meas tran vdout0_124ck440 FIND v(dout0_124) AT=225.025n

.meas tran vdout0_125ck440 FIND v(dout0_125) AT=225.025n

.meas tran vdout0_126ck440 FIND v(dout0_126) AT=225.025n

.meas tran vdout0_127ck440 FIND v(dout0_127) AT=225.025n

.meas tran vdout0_128ck440 FIND v(dout0_128) AT=225.025n

.meas tran vdout0_129ck440 FIND v(dout0_129) AT=225.025n

.meas tran vdout0_130ck440 FIND v(dout0_130) AT=225.025n

.meas tran vdout0_131ck440 FIND v(dout0_131) AT=225.025n

.meas tran vdout0_132ck440 FIND v(dout0_132) AT=225.025n

.meas tran vdout0_133ck440 FIND v(dout0_133) AT=225.025n

.meas tran vdout0_134ck440 FIND v(dout0_134) AT=225.025n

.meas tran vdout0_135ck440 FIND v(dout0_135) AT=225.025n

.meas tran vdout0_136ck440 FIND v(dout0_136) AT=225.025n

.meas tran vdout0_137ck440 FIND v(dout0_137) AT=225.025n

.meas tran vdout0_138ck440 FIND v(dout0_138) AT=225.025n

.meas tran vdout0_139ck440 FIND v(dout0_139) AT=225.025n

.meas tran vdout0_140ck440 FIND v(dout0_140) AT=225.025n

.meas tran vdout0_141ck440 FIND v(dout0_141) AT=225.025n

.meas tran vdout0_142ck440 FIND v(dout0_142) AT=225.025n

.meas tran vdout0_143ck440 FIND v(dout0_143) AT=225.025n

.meas tran vdout0_144ck440 FIND v(dout0_144) AT=225.025n

.meas tran vdout0_145ck440 FIND v(dout0_145) AT=225.025n

.meas tran vdout0_146ck440 FIND v(dout0_146) AT=225.025n

.meas tran vdout0_147ck440 FIND v(dout0_147) AT=225.025n

.meas tran vdout0_148ck440 FIND v(dout0_148) AT=225.025n

.meas tran vdout0_149ck440 FIND v(dout0_149) AT=225.025n

.meas tran vdout0_150ck440 FIND v(dout0_150) AT=225.025n

.meas tran vdout0_151ck440 FIND v(dout0_151) AT=225.025n

.meas tran vdout0_152ck440 FIND v(dout0_152) AT=225.025n

.meas tran vdout0_153ck440 FIND v(dout0_153) AT=225.025n

.meas tran vdout0_154ck440 FIND v(dout0_154) AT=225.025n

.meas tran vdout0_155ck440 FIND v(dout0_155) AT=225.025n

.meas tran vdout0_156ck440 FIND v(dout0_156) AT=225.025n

.meas tran vdout0_157ck440 FIND v(dout0_157) AT=225.025n

.meas tran vdout0_158ck440 FIND v(dout0_158) AT=225.025n

.meas tran vdout0_159ck440 FIND v(dout0_159) AT=225.025n

.meas tran vdout0_160ck440 FIND v(dout0_160) AT=225.025n

.meas tran vdout0_161ck440 FIND v(dout0_161) AT=225.025n

.meas tran vdout0_162ck440 FIND v(dout0_162) AT=225.025n

.meas tran vdout0_163ck440 FIND v(dout0_163) AT=225.025n

.meas tran vdout0_164ck440 FIND v(dout0_164) AT=225.025n

.meas tran vdout0_165ck440 FIND v(dout0_165) AT=225.025n

.meas tran vdout0_166ck440 FIND v(dout0_166) AT=225.025n

.meas tran vdout0_167ck440 FIND v(dout0_167) AT=225.025n

.meas tran vdout0_168ck440 FIND v(dout0_168) AT=225.025n

.meas tran vdout0_169ck440 FIND v(dout0_169) AT=225.025n

.meas tran vdout0_170ck440 FIND v(dout0_170) AT=225.025n

.meas tran vdout0_171ck440 FIND v(dout0_171) AT=225.025n

.meas tran vdout0_172ck440 FIND v(dout0_172) AT=225.025n

.meas tran vdout0_173ck440 FIND v(dout0_173) AT=225.025n

.meas tran vdout0_174ck440 FIND v(dout0_174) AT=225.025n

.meas tran vdout0_175ck440 FIND v(dout0_175) AT=225.025n

.meas tran vdout0_176ck440 FIND v(dout0_176) AT=225.025n

.meas tran vdout0_177ck440 FIND v(dout0_177) AT=225.025n

.meas tran vdout0_178ck440 FIND v(dout0_178) AT=225.025n

.meas tran vdout0_179ck440 FIND v(dout0_179) AT=225.025n

.meas tran vdout0_180ck440 FIND v(dout0_180) AT=225.025n

.meas tran vdout0_181ck440 FIND v(dout0_181) AT=225.025n

.meas tran vdout0_182ck440 FIND v(dout0_182) AT=225.025n

.meas tran vdout0_183ck440 FIND v(dout0_183) AT=225.025n

.meas tran vdout0_184ck440 FIND v(dout0_184) AT=225.025n

.meas tran vdout0_185ck440 FIND v(dout0_185) AT=225.025n

.meas tran vdout0_186ck440 FIND v(dout0_186) AT=225.025n

.meas tran vdout0_187ck440 FIND v(dout0_187) AT=225.025n

.meas tran vdout0_188ck440 FIND v(dout0_188) AT=225.025n

.meas tran vdout0_189ck440 FIND v(dout0_189) AT=225.025n

.meas tran vdout0_190ck440 FIND v(dout0_190) AT=225.025n

.meas tran vdout0_191ck440 FIND v(dout0_191) AT=225.025n

.meas tran vdout0_192ck440 FIND v(dout0_192) AT=225.025n

.meas tran vdout0_193ck440 FIND v(dout0_193) AT=225.025n

.meas tran vdout0_194ck440 FIND v(dout0_194) AT=225.025n

.meas tran vdout0_195ck440 FIND v(dout0_195) AT=225.025n

.meas tran vdout0_196ck440 FIND v(dout0_196) AT=225.025n

.meas tran vdout0_197ck440 FIND v(dout0_197) AT=225.025n

.meas tran vdout0_198ck440 FIND v(dout0_198) AT=225.025n

.meas tran vdout0_199ck440 FIND v(dout0_199) AT=225.025n

.meas tran vdout0_200ck440 FIND v(dout0_200) AT=225.025n

.meas tran vdout0_201ck440 FIND v(dout0_201) AT=225.025n

.meas tran vdout0_202ck440 FIND v(dout0_202) AT=225.025n

.meas tran vdout0_203ck440 FIND v(dout0_203) AT=225.025n

.meas tran vdout0_204ck440 FIND v(dout0_204) AT=225.025n

.meas tran vdout0_205ck440 FIND v(dout0_205) AT=225.025n

.meas tran vdout0_206ck440 FIND v(dout0_206) AT=225.025n

.meas tran vdout0_207ck440 FIND v(dout0_207) AT=225.025n

.meas tran vdout0_208ck440 FIND v(dout0_208) AT=225.025n

.meas tran vdout0_209ck440 FIND v(dout0_209) AT=225.025n

.meas tran vdout0_210ck440 FIND v(dout0_210) AT=225.025n

.meas tran vdout0_211ck440 FIND v(dout0_211) AT=225.025n

.meas tran vdout0_212ck440 FIND v(dout0_212) AT=225.025n

.meas tran vdout0_213ck440 FIND v(dout0_213) AT=225.025n

.meas tran vdout0_214ck440 FIND v(dout0_214) AT=225.025n

.meas tran vdout0_215ck440 FIND v(dout0_215) AT=225.025n

.meas tran vdout0_216ck440 FIND v(dout0_216) AT=225.025n

.meas tran vdout0_217ck440 FIND v(dout0_217) AT=225.025n

.meas tran vdout0_218ck440 FIND v(dout0_218) AT=225.025n

.meas tran vdout0_219ck440 FIND v(dout0_219) AT=225.025n

.meas tran vdout0_220ck440 FIND v(dout0_220) AT=225.025n

.meas tran vdout0_221ck440 FIND v(dout0_221) AT=225.025n

.meas tran vdout0_222ck440 FIND v(dout0_222) AT=225.025n

.meas tran vdout0_223ck440 FIND v(dout0_223) AT=225.025n

.meas tran vdout0_224ck440 FIND v(dout0_224) AT=225.025n

.meas tran vdout0_225ck440 FIND v(dout0_225) AT=225.025n

.meas tran vdout0_226ck440 FIND v(dout0_226) AT=225.025n

.meas tran vdout0_227ck440 FIND v(dout0_227) AT=225.025n

.meas tran vdout0_228ck440 FIND v(dout0_228) AT=225.025n

.meas tran vdout0_229ck440 FIND v(dout0_229) AT=225.025n

.meas tran vdout0_230ck440 FIND v(dout0_230) AT=225.025n

.meas tran vdout0_231ck440 FIND v(dout0_231) AT=225.025n

.meas tran vdout0_232ck440 FIND v(dout0_232) AT=225.025n

.meas tran vdout0_233ck440 FIND v(dout0_233) AT=225.025n

.meas tran vdout0_234ck440 FIND v(dout0_234) AT=225.025n

.meas tran vdout0_235ck440 FIND v(dout0_235) AT=225.025n

.meas tran vdout0_236ck440 FIND v(dout0_236) AT=225.025n

.meas tran vdout0_237ck440 FIND v(dout0_237) AT=225.025n

.meas tran vdout0_238ck440 FIND v(dout0_238) AT=225.025n

.meas tran vdout0_239ck440 FIND v(dout0_239) AT=225.025n

.meas tran vdout0_240ck440 FIND v(dout0_240) AT=225.025n

.meas tran vdout0_241ck440 FIND v(dout0_241) AT=225.025n

.meas tran vdout0_242ck440 FIND v(dout0_242) AT=225.025n

.meas tran vdout0_243ck440 FIND v(dout0_243) AT=225.025n

.meas tran vdout0_244ck440 FIND v(dout0_244) AT=225.025n

.meas tran vdout0_245ck440 FIND v(dout0_245) AT=225.025n

.meas tran vdout0_246ck440 FIND v(dout0_246) AT=225.025n

.meas tran vdout0_247ck440 FIND v(dout0_247) AT=225.025n

.meas tran vdout0_248ck440 FIND v(dout0_248) AT=225.025n

.meas tran vdout0_249ck440 FIND v(dout0_249) AT=225.025n

.meas tran vdout0_250ck440 FIND v(dout0_250) AT=225.025n

.meas tran vdout0_251ck440 FIND v(dout0_251) AT=225.025n

.meas tran vdout0_252ck440 FIND v(dout0_252) AT=225.025n

.meas tran vdout0_253ck440 FIND v(dout0_253) AT=225.025n

.meas tran vdout0_254ck440 FIND v(dout0_254) AT=225.025n

.meas tran vdout0_255ck440 FIND v(dout0_255) AT=225.025n

.meas tran vdout0_0ck450 FIND v(dout0_0) AT=230.025n

.meas tran vdout0_1ck450 FIND v(dout0_1) AT=230.025n

.meas tran vdout0_2ck450 FIND v(dout0_2) AT=230.025n

.meas tran vdout0_3ck450 FIND v(dout0_3) AT=230.025n

.meas tran vdout0_4ck450 FIND v(dout0_4) AT=230.025n

.meas tran vdout0_5ck450 FIND v(dout0_5) AT=230.025n

.meas tran vdout0_6ck450 FIND v(dout0_6) AT=230.025n

.meas tran vdout0_7ck450 FIND v(dout0_7) AT=230.025n

.meas tran vdout0_8ck450 FIND v(dout0_8) AT=230.025n

.meas tran vdout0_9ck450 FIND v(dout0_9) AT=230.025n

.meas tran vdout0_10ck450 FIND v(dout0_10) AT=230.025n

.meas tran vdout0_11ck450 FIND v(dout0_11) AT=230.025n

.meas tran vdout0_12ck450 FIND v(dout0_12) AT=230.025n

.meas tran vdout0_13ck450 FIND v(dout0_13) AT=230.025n

.meas tran vdout0_14ck450 FIND v(dout0_14) AT=230.025n

.meas tran vdout0_15ck450 FIND v(dout0_15) AT=230.025n

.meas tran vdout0_16ck450 FIND v(dout0_16) AT=230.025n

.meas tran vdout0_17ck450 FIND v(dout0_17) AT=230.025n

.meas tran vdout0_18ck450 FIND v(dout0_18) AT=230.025n

.meas tran vdout0_19ck450 FIND v(dout0_19) AT=230.025n

.meas tran vdout0_20ck450 FIND v(dout0_20) AT=230.025n

.meas tran vdout0_21ck450 FIND v(dout0_21) AT=230.025n

.meas tran vdout0_22ck450 FIND v(dout0_22) AT=230.025n

.meas tran vdout0_23ck450 FIND v(dout0_23) AT=230.025n

.meas tran vdout0_24ck450 FIND v(dout0_24) AT=230.025n

.meas tran vdout0_25ck450 FIND v(dout0_25) AT=230.025n

.meas tran vdout0_26ck450 FIND v(dout0_26) AT=230.025n

.meas tran vdout0_27ck450 FIND v(dout0_27) AT=230.025n

.meas tran vdout0_28ck450 FIND v(dout0_28) AT=230.025n

.meas tran vdout0_29ck450 FIND v(dout0_29) AT=230.025n

.meas tran vdout0_30ck450 FIND v(dout0_30) AT=230.025n

.meas tran vdout0_31ck450 FIND v(dout0_31) AT=230.025n

.meas tran vdout0_32ck450 FIND v(dout0_32) AT=230.025n

.meas tran vdout0_33ck450 FIND v(dout0_33) AT=230.025n

.meas tran vdout0_34ck450 FIND v(dout0_34) AT=230.025n

.meas tran vdout0_35ck450 FIND v(dout0_35) AT=230.025n

.meas tran vdout0_36ck450 FIND v(dout0_36) AT=230.025n

.meas tran vdout0_37ck450 FIND v(dout0_37) AT=230.025n

.meas tran vdout0_38ck450 FIND v(dout0_38) AT=230.025n

.meas tran vdout0_39ck450 FIND v(dout0_39) AT=230.025n

.meas tran vdout0_40ck450 FIND v(dout0_40) AT=230.025n

.meas tran vdout0_41ck450 FIND v(dout0_41) AT=230.025n

.meas tran vdout0_42ck450 FIND v(dout0_42) AT=230.025n

.meas tran vdout0_43ck450 FIND v(dout0_43) AT=230.025n

.meas tran vdout0_44ck450 FIND v(dout0_44) AT=230.025n

.meas tran vdout0_45ck450 FIND v(dout0_45) AT=230.025n

.meas tran vdout0_46ck450 FIND v(dout0_46) AT=230.025n

.meas tran vdout0_47ck450 FIND v(dout0_47) AT=230.025n

.meas tran vdout0_48ck450 FIND v(dout0_48) AT=230.025n

.meas tran vdout0_49ck450 FIND v(dout0_49) AT=230.025n

.meas tran vdout0_50ck450 FIND v(dout0_50) AT=230.025n

.meas tran vdout0_51ck450 FIND v(dout0_51) AT=230.025n

.meas tran vdout0_52ck450 FIND v(dout0_52) AT=230.025n

.meas tran vdout0_53ck450 FIND v(dout0_53) AT=230.025n

.meas tran vdout0_54ck450 FIND v(dout0_54) AT=230.025n

.meas tran vdout0_55ck450 FIND v(dout0_55) AT=230.025n

.meas tran vdout0_56ck450 FIND v(dout0_56) AT=230.025n

.meas tran vdout0_57ck450 FIND v(dout0_57) AT=230.025n

.meas tran vdout0_58ck450 FIND v(dout0_58) AT=230.025n

.meas tran vdout0_59ck450 FIND v(dout0_59) AT=230.025n

.meas tran vdout0_60ck450 FIND v(dout0_60) AT=230.025n

.meas tran vdout0_61ck450 FIND v(dout0_61) AT=230.025n

.meas tran vdout0_62ck450 FIND v(dout0_62) AT=230.025n

.meas tran vdout0_63ck450 FIND v(dout0_63) AT=230.025n

.meas tran vdout0_64ck450 FIND v(dout0_64) AT=230.025n

.meas tran vdout0_65ck450 FIND v(dout0_65) AT=230.025n

.meas tran vdout0_66ck450 FIND v(dout0_66) AT=230.025n

.meas tran vdout0_67ck450 FIND v(dout0_67) AT=230.025n

.meas tran vdout0_68ck450 FIND v(dout0_68) AT=230.025n

.meas tran vdout0_69ck450 FIND v(dout0_69) AT=230.025n

.meas tran vdout0_70ck450 FIND v(dout0_70) AT=230.025n

.meas tran vdout0_71ck450 FIND v(dout0_71) AT=230.025n

.meas tran vdout0_72ck450 FIND v(dout0_72) AT=230.025n

.meas tran vdout0_73ck450 FIND v(dout0_73) AT=230.025n

.meas tran vdout0_74ck450 FIND v(dout0_74) AT=230.025n

.meas tran vdout0_75ck450 FIND v(dout0_75) AT=230.025n

.meas tran vdout0_76ck450 FIND v(dout0_76) AT=230.025n

.meas tran vdout0_77ck450 FIND v(dout0_77) AT=230.025n

.meas tran vdout0_78ck450 FIND v(dout0_78) AT=230.025n

.meas tran vdout0_79ck450 FIND v(dout0_79) AT=230.025n

.meas tran vdout0_80ck450 FIND v(dout0_80) AT=230.025n

.meas tran vdout0_81ck450 FIND v(dout0_81) AT=230.025n

.meas tran vdout0_82ck450 FIND v(dout0_82) AT=230.025n

.meas tran vdout0_83ck450 FIND v(dout0_83) AT=230.025n

.meas tran vdout0_84ck450 FIND v(dout0_84) AT=230.025n

.meas tran vdout0_85ck450 FIND v(dout0_85) AT=230.025n

.meas tran vdout0_86ck450 FIND v(dout0_86) AT=230.025n

.meas tran vdout0_87ck450 FIND v(dout0_87) AT=230.025n

.meas tran vdout0_88ck450 FIND v(dout0_88) AT=230.025n

.meas tran vdout0_89ck450 FIND v(dout0_89) AT=230.025n

.meas tran vdout0_90ck450 FIND v(dout0_90) AT=230.025n

.meas tran vdout0_91ck450 FIND v(dout0_91) AT=230.025n

.meas tran vdout0_92ck450 FIND v(dout0_92) AT=230.025n

.meas tran vdout0_93ck450 FIND v(dout0_93) AT=230.025n

.meas tran vdout0_94ck450 FIND v(dout0_94) AT=230.025n

.meas tran vdout0_95ck450 FIND v(dout0_95) AT=230.025n

.meas tran vdout0_96ck450 FIND v(dout0_96) AT=230.025n

.meas tran vdout0_97ck450 FIND v(dout0_97) AT=230.025n

.meas tran vdout0_98ck450 FIND v(dout0_98) AT=230.025n

.meas tran vdout0_99ck450 FIND v(dout0_99) AT=230.025n

.meas tran vdout0_100ck450 FIND v(dout0_100) AT=230.025n

.meas tran vdout0_101ck450 FIND v(dout0_101) AT=230.025n

.meas tran vdout0_102ck450 FIND v(dout0_102) AT=230.025n

.meas tran vdout0_103ck450 FIND v(dout0_103) AT=230.025n

.meas tran vdout0_104ck450 FIND v(dout0_104) AT=230.025n

.meas tran vdout0_105ck450 FIND v(dout0_105) AT=230.025n

.meas tran vdout0_106ck450 FIND v(dout0_106) AT=230.025n

.meas tran vdout0_107ck450 FIND v(dout0_107) AT=230.025n

.meas tran vdout0_108ck450 FIND v(dout0_108) AT=230.025n

.meas tran vdout0_109ck450 FIND v(dout0_109) AT=230.025n

.meas tran vdout0_110ck450 FIND v(dout0_110) AT=230.025n

.meas tran vdout0_111ck450 FIND v(dout0_111) AT=230.025n

.meas tran vdout0_112ck450 FIND v(dout0_112) AT=230.025n

.meas tran vdout0_113ck450 FIND v(dout0_113) AT=230.025n

.meas tran vdout0_114ck450 FIND v(dout0_114) AT=230.025n

.meas tran vdout0_115ck450 FIND v(dout0_115) AT=230.025n

.meas tran vdout0_116ck450 FIND v(dout0_116) AT=230.025n

.meas tran vdout0_117ck450 FIND v(dout0_117) AT=230.025n

.meas tran vdout0_118ck450 FIND v(dout0_118) AT=230.025n

.meas tran vdout0_119ck450 FIND v(dout0_119) AT=230.025n

.meas tran vdout0_120ck450 FIND v(dout0_120) AT=230.025n

.meas tran vdout0_121ck450 FIND v(dout0_121) AT=230.025n

.meas tran vdout0_122ck450 FIND v(dout0_122) AT=230.025n

.meas tran vdout0_123ck450 FIND v(dout0_123) AT=230.025n

.meas tran vdout0_124ck450 FIND v(dout0_124) AT=230.025n

.meas tran vdout0_125ck450 FIND v(dout0_125) AT=230.025n

.meas tran vdout0_126ck450 FIND v(dout0_126) AT=230.025n

.meas tran vdout0_127ck450 FIND v(dout0_127) AT=230.025n

.meas tran vdout0_128ck450 FIND v(dout0_128) AT=230.025n

.meas tran vdout0_129ck450 FIND v(dout0_129) AT=230.025n

.meas tran vdout0_130ck450 FIND v(dout0_130) AT=230.025n

.meas tran vdout0_131ck450 FIND v(dout0_131) AT=230.025n

.meas tran vdout0_132ck450 FIND v(dout0_132) AT=230.025n

.meas tran vdout0_133ck450 FIND v(dout0_133) AT=230.025n

.meas tran vdout0_134ck450 FIND v(dout0_134) AT=230.025n

.meas tran vdout0_135ck450 FIND v(dout0_135) AT=230.025n

.meas tran vdout0_136ck450 FIND v(dout0_136) AT=230.025n

.meas tran vdout0_137ck450 FIND v(dout0_137) AT=230.025n

.meas tran vdout0_138ck450 FIND v(dout0_138) AT=230.025n

.meas tran vdout0_139ck450 FIND v(dout0_139) AT=230.025n

.meas tran vdout0_140ck450 FIND v(dout0_140) AT=230.025n

.meas tran vdout0_141ck450 FIND v(dout0_141) AT=230.025n

.meas tran vdout0_142ck450 FIND v(dout0_142) AT=230.025n

.meas tran vdout0_143ck450 FIND v(dout0_143) AT=230.025n

.meas tran vdout0_144ck450 FIND v(dout0_144) AT=230.025n

.meas tran vdout0_145ck450 FIND v(dout0_145) AT=230.025n

.meas tran vdout0_146ck450 FIND v(dout0_146) AT=230.025n

.meas tran vdout0_147ck450 FIND v(dout0_147) AT=230.025n

.meas tran vdout0_148ck450 FIND v(dout0_148) AT=230.025n

.meas tran vdout0_149ck450 FIND v(dout0_149) AT=230.025n

.meas tran vdout0_150ck450 FIND v(dout0_150) AT=230.025n

.meas tran vdout0_151ck450 FIND v(dout0_151) AT=230.025n

.meas tran vdout0_152ck450 FIND v(dout0_152) AT=230.025n

.meas tran vdout0_153ck450 FIND v(dout0_153) AT=230.025n

.meas tran vdout0_154ck450 FIND v(dout0_154) AT=230.025n

.meas tran vdout0_155ck450 FIND v(dout0_155) AT=230.025n

.meas tran vdout0_156ck450 FIND v(dout0_156) AT=230.025n

.meas tran vdout0_157ck450 FIND v(dout0_157) AT=230.025n

.meas tran vdout0_158ck450 FIND v(dout0_158) AT=230.025n

.meas tran vdout0_159ck450 FIND v(dout0_159) AT=230.025n

.meas tran vdout0_160ck450 FIND v(dout0_160) AT=230.025n

.meas tran vdout0_161ck450 FIND v(dout0_161) AT=230.025n

.meas tran vdout0_162ck450 FIND v(dout0_162) AT=230.025n

.meas tran vdout0_163ck450 FIND v(dout0_163) AT=230.025n

.meas tran vdout0_164ck450 FIND v(dout0_164) AT=230.025n

.meas tran vdout0_165ck450 FIND v(dout0_165) AT=230.025n

.meas tran vdout0_166ck450 FIND v(dout0_166) AT=230.025n

.meas tran vdout0_167ck450 FIND v(dout0_167) AT=230.025n

.meas tran vdout0_168ck450 FIND v(dout0_168) AT=230.025n

.meas tran vdout0_169ck450 FIND v(dout0_169) AT=230.025n

.meas tran vdout0_170ck450 FIND v(dout0_170) AT=230.025n

.meas tran vdout0_171ck450 FIND v(dout0_171) AT=230.025n

.meas tran vdout0_172ck450 FIND v(dout0_172) AT=230.025n

.meas tran vdout0_173ck450 FIND v(dout0_173) AT=230.025n

.meas tran vdout0_174ck450 FIND v(dout0_174) AT=230.025n

.meas tran vdout0_175ck450 FIND v(dout0_175) AT=230.025n

.meas tran vdout0_176ck450 FIND v(dout0_176) AT=230.025n

.meas tran vdout0_177ck450 FIND v(dout0_177) AT=230.025n

.meas tran vdout0_178ck450 FIND v(dout0_178) AT=230.025n

.meas tran vdout0_179ck450 FIND v(dout0_179) AT=230.025n

.meas tran vdout0_180ck450 FIND v(dout0_180) AT=230.025n

.meas tran vdout0_181ck450 FIND v(dout0_181) AT=230.025n

.meas tran vdout0_182ck450 FIND v(dout0_182) AT=230.025n

.meas tran vdout0_183ck450 FIND v(dout0_183) AT=230.025n

.meas tran vdout0_184ck450 FIND v(dout0_184) AT=230.025n

.meas tran vdout0_185ck450 FIND v(dout0_185) AT=230.025n

.meas tran vdout0_186ck450 FIND v(dout0_186) AT=230.025n

.meas tran vdout0_187ck450 FIND v(dout0_187) AT=230.025n

.meas tran vdout0_188ck450 FIND v(dout0_188) AT=230.025n

.meas tran vdout0_189ck450 FIND v(dout0_189) AT=230.025n

.meas tran vdout0_190ck450 FIND v(dout0_190) AT=230.025n

.meas tran vdout0_191ck450 FIND v(dout0_191) AT=230.025n

.meas tran vdout0_192ck450 FIND v(dout0_192) AT=230.025n

.meas tran vdout0_193ck450 FIND v(dout0_193) AT=230.025n

.meas tran vdout0_194ck450 FIND v(dout0_194) AT=230.025n

.meas tran vdout0_195ck450 FIND v(dout0_195) AT=230.025n

.meas tran vdout0_196ck450 FIND v(dout0_196) AT=230.025n

.meas tran vdout0_197ck450 FIND v(dout0_197) AT=230.025n

.meas tran vdout0_198ck450 FIND v(dout0_198) AT=230.025n

.meas tran vdout0_199ck450 FIND v(dout0_199) AT=230.025n

.meas tran vdout0_200ck450 FIND v(dout0_200) AT=230.025n

.meas tran vdout0_201ck450 FIND v(dout0_201) AT=230.025n

.meas tran vdout0_202ck450 FIND v(dout0_202) AT=230.025n

.meas tran vdout0_203ck450 FIND v(dout0_203) AT=230.025n

.meas tran vdout0_204ck450 FIND v(dout0_204) AT=230.025n

.meas tran vdout0_205ck450 FIND v(dout0_205) AT=230.025n

.meas tran vdout0_206ck450 FIND v(dout0_206) AT=230.025n

.meas tran vdout0_207ck450 FIND v(dout0_207) AT=230.025n

.meas tran vdout0_208ck450 FIND v(dout0_208) AT=230.025n

.meas tran vdout0_209ck450 FIND v(dout0_209) AT=230.025n

.meas tran vdout0_210ck450 FIND v(dout0_210) AT=230.025n

.meas tran vdout0_211ck450 FIND v(dout0_211) AT=230.025n

.meas tran vdout0_212ck450 FIND v(dout0_212) AT=230.025n

.meas tran vdout0_213ck450 FIND v(dout0_213) AT=230.025n

.meas tran vdout0_214ck450 FIND v(dout0_214) AT=230.025n

.meas tran vdout0_215ck450 FIND v(dout0_215) AT=230.025n

.meas tran vdout0_216ck450 FIND v(dout0_216) AT=230.025n

.meas tran vdout0_217ck450 FIND v(dout0_217) AT=230.025n

.meas tran vdout0_218ck450 FIND v(dout0_218) AT=230.025n

.meas tran vdout0_219ck450 FIND v(dout0_219) AT=230.025n

.meas tran vdout0_220ck450 FIND v(dout0_220) AT=230.025n

.meas tran vdout0_221ck450 FIND v(dout0_221) AT=230.025n

.meas tran vdout0_222ck450 FIND v(dout0_222) AT=230.025n

.meas tran vdout0_223ck450 FIND v(dout0_223) AT=230.025n

.meas tran vdout0_224ck450 FIND v(dout0_224) AT=230.025n

.meas tran vdout0_225ck450 FIND v(dout0_225) AT=230.025n

.meas tran vdout0_226ck450 FIND v(dout0_226) AT=230.025n

.meas tran vdout0_227ck450 FIND v(dout0_227) AT=230.025n

.meas tran vdout0_228ck450 FIND v(dout0_228) AT=230.025n

.meas tran vdout0_229ck450 FIND v(dout0_229) AT=230.025n

.meas tran vdout0_230ck450 FIND v(dout0_230) AT=230.025n

.meas tran vdout0_231ck450 FIND v(dout0_231) AT=230.025n

.meas tran vdout0_232ck450 FIND v(dout0_232) AT=230.025n

.meas tran vdout0_233ck450 FIND v(dout0_233) AT=230.025n

.meas tran vdout0_234ck450 FIND v(dout0_234) AT=230.025n

.meas tran vdout0_235ck450 FIND v(dout0_235) AT=230.025n

.meas tran vdout0_236ck450 FIND v(dout0_236) AT=230.025n

.meas tran vdout0_237ck450 FIND v(dout0_237) AT=230.025n

.meas tran vdout0_238ck450 FIND v(dout0_238) AT=230.025n

.meas tran vdout0_239ck450 FIND v(dout0_239) AT=230.025n

.meas tran vdout0_240ck450 FIND v(dout0_240) AT=230.025n

.meas tran vdout0_241ck450 FIND v(dout0_241) AT=230.025n

.meas tran vdout0_242ck450 FIND v(dout0_242) AT=230.025n

.meas tran vdout0_243ck450 FIND v(dout0_243) AT=230.025n

.meas tran vdout0_244ck450 FIND v(dout0_244) AT=230.025n

.meas tran vdout0_245ck450 FIND v(dout0_245) AT=230.025n

.meas tran vdout0_246ck450 FIND v(dout0_246) AT=230.025n

.meas tran vdout0_247ck450 FIND v(dout0_247) AT=230.025n

.meas tran vdout0_248ck450 FIND v(dout0_248) AT=230.025n

.meas tran vdout0_249ck450 FIND v(dout0_249) AT=230.025n

.meas tran vdout0_250ck450 FIND v(dout0_250) AT=230.025n

.meas tran vdout0_251ck450 FIND v(dout0_251) AT=230.025n

.meas tran vdout0_252ck450 FIND v(dout0_252) AT=230.025n

.meas tran vdout0_253ck450 FIND v(dout0_253) AT=230.025n

.meas tran vdout0_254ck450 FIND v(dout0_254) AT=230.025n

.meas tran vdout0_255ck450 FIND v(dout0_255) AT=230.025n

.meas tran vdout0_0ck480 FIND v(dout0_0) AT=245.025n

.meas tran vdout0_1ck480 FIND v(dout0_1) AT=245.025n

.meas tran vdout0_2ck480 FIND v(dout0_2) AT=245.025n

.meas tran vdout0_3ck480 FIND v(dout0_3) AT=245.025n

.meas tran vdout0_4ck480 FIND v(dout0_4) AT=245.025n

.meas tran vdout0_5ck480 FIND v(dout0_5) AT=245.025n

.meas tran vdout0_6ck480 FIND v(dout0_6) AT=245.025n

.meas tran vdout0_7ck480 FIND v(dout0_7) AT=245.025n

.meas tran vdout0_8ck480 FIND v(dout0_8) AT=245.025n

.meas tran vdout0_9ck480 FIND v(dout0_9) AT=245.025n

.meas tran vdout0_10ck480 FIND v(dout0_10) AT=245.025n

.meas tran vdout0_11ck480 FIND v(dout0_11) AT=245.025n

.meas tran vdout0_12ck480 FIND v(dout0_12) AT=245.025n

.meas tran vdout0_13ck480 FIND v(dout0_13) AT=245.025n

.meas tran vdout0_14ck480 FIND v(dout0_14) AT=245.025n

.meas tran vdout0_15ck480 FIND v(dout0_15) AT=245.025n

.meas tran vdout0_16ck480 FIND v(dout0_16) AT=245.025n

.meas tran vdout0_17ck480 FIND v(dout0_17) AT=245.025n

.meas tran vdout0_18ck480 FIND v(dout0_18) AT=245.025n

.meas tran vdout0_19ck480 FIND v(dout0_19) AT=245.025n

.meas tran vdout0_20ck480 FIND v(dout0_20) AT=245.025n

.meas tran vdout0_21ck480 FIND v(dout0_21) AT=245.025n

.meas tran vdout0_22ck480 FIND v(dout0_22) AT=245.025n

.meas tran vdout0_23ck480 FIND v(dout0_23) AT=245.025n

.meas tran vdout0_24ck480 FIND v(dout0_24) AT=245.025n

.meas tran vdout0_25ck480 FIND v(dout0_25) AT=245.025n

.meas tran vdout0_26ck480 FIND v(dout0_26) AT=245.025n

.meas tran vdout0_27ck480 FIND v(dout0_27) AT=245.025n

.meas tran vdout0_28ck480 FIND v(dout0_28) AT=245.025n

.meas tran vdout0_29ck480 FIND v(dout0_29) AT=245.025n

.meas tran vdout0_30ck480 FIND v(dout0_30) AT=245.025n

.meas tran vdout0_31ck480 FIND v(dout0_31) AT=245.025n

.meas tran vdout0_32ck480 FIND v(dout0_32) AT=245.025n

.meas tran vdout0_33ck480 FIND v(dout0_33) AT=245.025n

.meas tran vdout0_34ck480 FIND v(dout0_34) AT=245.025n

.meas tran vdout0_35ck480 FIND v(dout0_35) AT=245.025n

.meas tran vdout0_36ck480 FIND v(dout0_36) AT=245.025n

.meas tran vdout0_37ck480 FIND v(dout0_37) AT=245.025n

.meas tran vdout0_38ck480 FIND v(dout0_38) AT=245.025n

.meas tran vdout0_39ck480 FIND v(dout0_39) AT=245.025n

.meas tran vdout0_40ck480 FIND v(dout0_40) AT=245.025n

.meas tran vdout0_41ck480 FIND v(dout0_41) AT=245.025n

.meas tran vdout0_42ck480 FIND v(dout0_42) AT=245.025n

.meas tran vdout0_43ck480 FIND v(dout0_43) AT=245.025n

.meas tran vdout0_44ck480 FIND v(dout0_44) AT=245.025n

.meas tran vdout0_45ck480 FIND v(dout0_45) AT=245.025n

.meas tran vdout0_46ck480 FIND v(dout0_46) AT=245.025n

.meas tran vdout0_47ck480 FIND v(dout0_47) AT=245.025n

.meas tran vdout0_48ck480 FIND v(dout0_48) AT=245.025n

.meas tran vdout0_49ck480 FIND v(dout0_49) AT=245.025n

.meas tran vdout0_50ck480 FIND v(dout0_50) AT=245.025n

.meas tran vdout0_51ck480 FIND v(dout0_51) AT=245.025n

.meas tran vdout0_52ck480 FIND v(dout0_52) AT=245.025n

.meas tran vdout0_53ck480 FIND v(dout0_53) AT=245.025n

.meas tran vdout0_54ck480 FIND v(dout0_54) AT=245.025n

.meas tran vdout0_55ck480 FIND v(dout0_55) AT=245.025n

.meas tran vdout0_56ck480 FIND v(dout0_56) AT=245.025n

.meas tran vdout0_57ck480 FIND v(dout0_57) AT=245.025n

.meas tran vdout0_58ck480 FIND v(dout0_58) AT=245.025n

.meas tran vdout0_59ck480 FIND v(dout0_59) AT=245.025n

.meas tran vdout0_60ck480 FIND v(dout0_60) AT=245.025n

.meas tran vdout0_61ck480 FIND v(dout0_61) AT=245.025n

.meas tran vdout0_62ck480 FIND v(dout0_62) AT=245.025n

.meas tran vdout0_63ck480 FIND v(dout0_63) AT=245.025n

.meas tran vdout0_64ck480 FIND v(dout0_64) AT=245.025n

.meas tran vdout0_65ck480 FIND v(dout0_65) AT=245.025n

.meas tran vdout0_66ck480 FIND v(dout0_66) AT=245.025n

.meas tran vdout0_67ck480 FIND v(dout0_67) AT=245.025n

.meas tran vdout0_68ck480 FIND v(dout0_68) AT=245.025n

.meas tran vdout0_69ck480 FIND v(dout0_69) AT=245.025n

.meas tran vdout0_70ck480 FIND v(dout0_70) AT=245.025n

.meas tran vdout0_71ck480 FIND v(dout0_71) AT=245.025n

.meas tran vdout0_72ck480 FIND v(dout0_72) AT=245.025n

.meas tran vdout0_73ck480 FIND v(dout0_73) AT=245.025n

.meas tran vdout0_74ck480 FIND v(dout0_74) AT=245.025n

.meas tran vdout0_75ck480 FIND v(dout0_75) AT=245.025n

.meas tran vdout0_76ck480 FIND v(dout0_76) AT=245.025n

.meas tran vdout0_77ck480 FIND v(dout0_77) AT=245.025n

.meas tran vdout0_78ck480 FIND v(dout0_78) AT=245.025n

.meas tran vdout0_79ck480 FIND v(dout0_79) AT=245.025n

.meas tran vdout0_80ck480 FIND v(dout0_80) AT=245.025n

.meas tran vdout0_81ck480 FIND v(dout0_81) AT=245.025n

.meas tran vdout0_82ck480 FIND v(dout0_82) AT=245.025n

.meas tran vdout0_83ck480 FIND v(dout0_83) AT=245.025n

.meas tran vdout0_84ck480 FIND v(dout0_84) AT=245.025n

.meas tran vdout0_85ck480 FIND v(dout0_85) AT=245.025n

.meas tran vdout0_86ck480 FIND v(dout0_86) AT=245.025n

.meas tran vdout0_87ck480 FIND v(dout0_87) AT=245.025n

.meas tran vdout0_88ck480 FIND v(dout0_88) AT=245.025n

.meas tran vdout0_89ck480 FIND v(dout0_89) AT=245.025n

.meas tran vdout0_90ck480 FIND v(dout0_90) AT=245.025n

.meas tran vdout0_91ck480 FIND v(dout0_91) AT=245.025n

.meas tran vdout0_92ck480 FIND v(dout0_92) AT=245.025n

.meas tran vdout0_93ck480 FIND v(dout0_93) AT=245.025n

.meas tran vdout0_94ck480 FIND v(dout0_94) AT=245.025n

.meas tran vdout0_95ck480 FIND v(dout0_95) AT=245.025n

.meas tran vdout0_96ck480 FIND v(dout0_96) AT=245.025n

.meas tran vdout0_97ck480 FIND v(dout0_97) AT=245.025n

.meas tran vdout0_98ck480 FIND v(dout0_98) AT=245.025n

.meas tran vdout0_99ck480 FIND v(dout0_99) AT=245.025n

.meas tran vdout0_100ck480 FIND v(dout0_100) AT=245.025n

.meas tran vdout0_101ck480 FIND v(dout0_101) AT=245.025n

.meas tran vdout0_102ck480 FIND v(dout0_102) AT=245.025n

.meas tran vdout0_103ck480 FIND v(dout0_103) AT=245.025n

.meas tran vdout0_104ck480 FIND v(dout0_104) AT=245.025n

.meas tran vdout0_105ck480 FIND v(dout0_105) AT=245.025n

.meas tran vdout0_106ck480 FIND v(dout0_106) AT=245.025n

.meas tran vdout0_107ck480 FIND v(dout0_107) AT=245.025n

.meas tran vdout0_108ck480 FIND v(dout0_108) AT=245.025n

.meas tran vdout0_109ck480 FIND v(dout0_109) AT=245.025n

.meas tran vdout0_110ck480 FIND v(dout0_110) AT=245.025n

.meas tran vdout0_111ck480 FIND v(dout0_111) AT=245.025n

.meas tran vdout0_112ck480 FIND v(dout0_112) AT=245.025n

.meas tran vdout0_113ck480 FIND v(dout0_113) AT=245.025n

.meas tran vdout0_114ck480 FIND v(dout0_114) AT=245.025n

.meas tran vdout0_115ck480 FIND v(dout0_115) AT=245.025n

.meas tran vdout0_116ck480 FIND v(dout0_116) AT=245.025n

.meas tran vdout0_117ck480 FIND v(dout0_117) AT=245.025n

.meas tran vdout0_118ck480 FIND v(dout0_118) AT=245.025n

.meas tran vdout0_119ck480 FIND v(dout0_119) AT=245.025n

.meas tran vdout0_120ck480 FIND v(dout0_120) AT=245.025n

.meas tran vdout0_121ck480 FIND v(dout0_121) AT=245.025n

.meas tran vdout0_122ck480 FIND v(dout0_122) AT=245.025n

.meas tran vdout0_123ck480 FIND v(dout0_123) AT=245.025n

.meas tran vdout0_124ck480 FIND v(dout0_124) AT=245.025n

.meas tran vdout0_125ck480 FIND v(dout0_125) AT=245.025n

.meas tran vdout0_126ck480 FIND v(dout0_126) AT=245.025n

.meas tran vdout0_127ck480 FIND v(dout0_127) AT=245.025n

.meas tran vdout0_128ck480 FIND v(dout0_128) AT=245.025n

.meas tran vdout0_129ck480 FIND v(dout0_129) AT=245.025n

.meas tran vdout0_130ck480 FIND v(dout0_130) AT=245.025n

.meas tran vdout0_131ck480 FIND v(dout0_131) AT=245.025n

.meas tran vdout0_132ck480 FIND v(dout0_132) AT=245.025n

.meas tran vdout0_133ck480 FIND v(dout0_133) AT=245.025n

.meas tran vdout0_134ck480 FIND v(dout0_134) AT=245.025n

.meas tran vdout0_135ck480 FIND v(dout0_135) AT=245.025n

.meas tran vdout0_136ck480 FIND v(dout0_136) AT=245.025n

.meas tran vdout0_137ck480 FIND v(dout0_137) AT=245.025n

.meas tran vdout0_138ck480 FIND v(dout0_138) AT=245.025n

.meas tran vdout0_139ck480 FIND v(dout0_139) AT=245.025n

.meas tran vdout0_140ck480 FIND v(dout0_140) AT=245.025n

.meas tran vdout0_141ck480 FIND v(dout0_141) AT=245.025n

.meas tran vdout0_142ck480 FIND v(dout0_142) AT=245.025n

.meas tran vdout0_143ck480 FIND v(dout0_143) AT=245.025n

.meas tran vdout0_144ck480 FIND v(dout0_144) AT=245.025n

.meas tran vdout0_145ck480 FIND v(dout0_145) AT=245.025n

.meas tran vdout0_146ck480 FIND v(dout0_146) AT=245.025n

.meas tran vdout0_147ck480 FIND v(dout0_147) AT=245.025n

.meas tran vdout0_148ck480 FIND v(dout0_148) AT=245.025n

.meas tran vdout0_149ck480 FIND v(dout0_149) AT=245.025n

.meas tran vdout0_150ck480 FIND v(dout0_150) AT=245.025n

.meas tran vdout0_151ck480 FIND v(dout0_151) AT=245.025n

.meas tran vdout0_152ck480 FIND v(dout0_152) AT=245.025n

.meas tran vdout0_153ck480 FIND v(dout0_153) AT=245.025n

.meas tran vdout0_154ck480 FIND v(dout0_154) AT=245.025n

.meas tran vdout0_155ck480 FIND v(dout0_155) AT=245.025n

.meas tran vdout0_156ck480 FIND v(dout0_156) AT=245.025n

.meas tran vdout0_157ck480 FIND v(dout0_157) AT=245.025n

.meas tran vdout0_158ck480 FIND v(dout0_158) AT=245.025n

.meas tran vdout0_159ck480 FIND v(dout0_159) AT=245.025n

.meas tran vdout0_160ck480 FIND v(dout0_160) AT=245.025n

.meas tran vdout0_161ck480 FIND v(dout0_161) AT=245.025n

.meas tran vdout0_162ck480 FIND v(dout0_162) AT=245.025n

.meas tran vdout0_163ck480 FIND v(dout0_163) AT=245.025n

.meas tran vdout0_164ck480 FIND v(dout0_164) AT=245.025n

.meas tran vdout0_165ck480 FIND v(dout0_165) AT=245.025n

.meas tran vdout0_166ck480 FIND v(dout0_166) AT=245.025n

.meas tran vdout0_167ck480 FIND v(dout0_167) AT=245.025n

.meas tran vdout0_168ck480 FIND v(dout0_168) AT=245.025n

.meas tran vdout0_169ck480 FIND v(dout0_169) AT=245.025n

.meas tran vdout0_170ck480 FIND v(dout0_170) AT=245.025n

.meas tran vdout0_171ck480 FIND v(dout0_171) AT=245.025n

.meas tran vdout0_172ck480 FIND v(dout0_172) AT=245.025n

.meas tran vdout0_173ck480 FIND v(dout0_173) AT=245.025n

.meas tran vdout0_174ck480 FIND v(dout0_174) AT=245.025n

.meas tran vdout0_175ck480 FIND v(dout0_175) AT=245.025n

.meas tran vdout0_176ck480 FIND v(dout0_176) AT=245.025n

.meas tran vdout0_177ck480 FIND v(dout0_177) AT=245.025n

.meas tran vdout0_178ck480 FIND v(dout0_178) AT=245.025n

.meas tran vdout0_179ck480 FIND v(dout0_179) AT=245.025n

.meas tran vdout0_180ck480 FIND v(dout0_180) AT=245.025n

.meas tran vdout0_181ck480 FIND v(dout0_181) AT=245.025n

.meas tran vdout0_182ck480 FIND v(dout0_182) AT=245.025n

.meas tran vdout0_183ck480 FIND v(dout0_183) AT=245.025n

.meas tran vdout0_184ck480 FIND v(dout0_184) AT=245.025n

.meas tran vdout0_185ck480 FIND v(dout0_185) AT=245.025n

.meas tran vdout0_186ck480 FIND v(dout0_186) AT=245.025n

.meas tran vdout0_187ck480 FIND v(dout0_187) AT=245.025n

.meas tran vdout0_188ck480 FIND v(dout0_188) AT=245.025n

.meas tran vdout0_189ck480 FIND v(dout0_189) AT=245.025n

.meas tran vdout0_190ck480 FIND v(dout0_190) AT=245.025n

.meas tran vdout0_191ck480 FIND v(dout0_191) AT=245.025n

.meas tran vdout0_192ck480 FIND v(dout0_192) AT=245.025n

.meas tran vdout0_193ck480 FIND v(dout0_193) AT=245.025n

.meas tran vdout0_194ck480 FIND v(dout0_194) AT=245.025n

.meas tran vdout0_195ck480 FIND v(dout0_195) AT=245.025n

.meas tran vdout0_196ck480 FIND v(dout0_196) AT=245.025n

.meas tran vdout0_197ck480 FIND v(dout0_197) AT=245.025n

.meas tran vdout0_198ck480 FIND v(dout0_198) AT=245.025n

.meas tran vdout0_199ck480 FIND v(dout0_199) AT=245.025n

.meas tran vdout0_200ck480 FIND v(dout0_200) AT=245.025n

.meas tran vdout0_201ck480 FIND v(dout0_201) AT=245.025n

.meas tran vdout0_202ck480 FIND v(dout0_202) AT=245.025n

.meas tran vdout0_203ck480 FIND v(dout0_203) AT=245.025n

.meas tran vdout0_204ck480 FIND v(dout0_204) AT=245.025n

.meas tran vdout0_205ck480 FIND v(dout0_205) AT=245.025n

.meas tran vdout0_206ck480 FIND v(dout0_206) AT=245.025n

.meas tran vdout0_207ck480 FIND v(dout0_207) AT=245.025n

.meas tran vdout0_208ck480 FIND v(dout0_208) AT=245.025n

.meas tran vdout0_209ck480 FIND v(dout0_209) AT=245.025n

.meas tran vdout0_210ck480 FIND v(dout0_210) AT=245.025n

.meas tran vdout0_211ck480 FIND v(dout0_211) AT=245.025n

.meas tran vdout0_212ck480 FIND v(dout0_212) AT=245.025n

.meas tran vdout0_213ck480 FIND v(dout0_213) AT=245.025n

.meas tran vdout0_214ck480 FIND v(dout0_214) AT=245.025n

.meas tran vdout0_215ck480 FIND v(dout0_215) AT=245.025n

.meas tran vdout0_216ck480 FIND v(dout0_216) AT=245.025n

.meas tran vdout0_217ck480 FIND v(dout0_217) AT=245.025n

.meas tran vdout0_218ck480 FIND v(dout0_218) AT=245.025n

.meas tran vdout0_219ck480 FIND v(dout0_219) AT=245.025n

.meas tran vdout0_220ck480 FIND v(dout0_220) AT=245.025n

.meas tran vdout0_221ck480 FIND v(dout0_221) AT=245.025n

.meas tran vdout0_222ck480 FIND v(dout0_222) AT=245.025n

.meas tran vdout0_223ck480 FIND v(dout0_223) AT=245.025n

.meas tran vdout0_224ck480 FIND v(dout0_224) AT=245.025n

.meas tran vdout0_225ck480 FIND v(dout0_225) AT=245.025n

.meas tran vdout0_226ck480 FIND v(dout0_226) AT=245.025n

.meas tran vdout0_227ck480 FIND v(dout0_227) AT=245.025n

.meas tran vdout0_228ck480 FIND v(dout0_228) AT=245.025n

.meas tran vdout0_229ck480 FIND v(dout0_229) AT=245.025n

.meas tran vdout0_230ck480 FIND v(dout0_230) AT=245.025n

.meas tran vdout0_231ck480 FIND v(dout0_231) AT=245.025n

.meas tran vdout0_232ck480 FIND v(dout0_232) AT=245.025n

.meas tran vdout0_233ck480 FIND v(dout0_233) AT=245.025n

.meas tran vdout0_234ck480 FIND v(dout0_234) AT=245.025n

.meas tran vdout0_235ck480 FIND v(dout0_235) AT=245.025n

.meas tran vdout0_236ck480 FIND v(dout0_236) AT=245.025n

.meas tran vdout0_237ck480 FIND v(dout0_237) AT=245.025n

.meas tran vdout0_238ck480 FIND v(dout0_238) AT=245.025n

.meas tran vdout0_239ck480 FIND v(dout0_239) AT=245.025n

.meas tran vdout0_240ck480 FIND v(dout0_240) AT=245.025n

.meas tran vdout0_241ck480 FIND v(dout0_241) AT=245.025n

.meas tran vdout0_242ck480 FIND v(dout0_242) AT=245.025n

.meas tran vdout0_243ck480 FIND v(dout0_243) AT=245.025n

.meas tran vdout0_244ck480 FIND v(dout0_244) AT=245.025n

.meas tran vdout0_245ck480 FIND v(dout0_245) AT=245.025n

.meas tran vdout0_246ck480 FIND v(dout0_246) AT=245.025n

.meas tran vdout0_247ck480 FIND v(dout0_247) AT=245.025n

.meas tran vdout0_248ck480 FIND v(dout0_248) AT=245.025n

.meas tran vdout0_249ck480 FIND v(dout0_249) AT=245.025n

.meas tran vdout0_250ck480 FIND v(dout0_250) AT=245.025n

.meas tran vdout0_251ck480 FIND v(dout0_251) AT=245.025n

.meas tran vdout0_252ck480 FIND v(dout0_252) AT=245.025n

.meas tran vdout0_253ck480 FIND v(dout0_253) AT=245.025n

.meas tran vdout0_254ck480 FIND v(dout0_254) AT=245.025n

.meas tran vdout0_255ck480 FIND v(dout0_255) AT=245.025n

.meas tran vdout0_0ck500 FIND v(dout0_0) AT=255.025n

.meas tran vdout0_1ck500 FIND v(dout0_1) AT=255.025n

.meas tran vdout0_2ck500 FIND v(dout0_2) AT=255.025n

.meas tran vdout0_3ck500 FIND v(dout0_3) AT=255.025n

.meas tran vdout0_4ck500 FIND v(dout0_4) AT=255.025n

.meas tran vdout0_5ck500 FIND v(dout0_5) AT=255.025n

.meas tran vdout0_6ck500 FIND v(dout0_6) AT=255.025n

.meas tran vdout0_7ck500 FIND v(dout0_7) AT=255.025n

.meas tran vdout0_8ck500 FIND v(dout0_8) AT=255.025n

.meas tran vdout0_9ck500 FIND v(dout0_9) AT=255.025n

.meas tran vdout0_10ck500 FIND v(dout0_10) AT=255.025n

.meas tran vdout0_11ck500 FIND v(dout0_11) AT=255.025n

.meas tran vdout0_12ck500 FIND v(dout0_12) AT=255.025n

.meas tran vdout0_13ck500 FIND v(dout0_13) AT=255.025n

.meas tran vdout0_14ck500 FIND v(dout0_14) AT=255.025n

.meas tran vdout0_15ck500 FIND v(dout0_15) AT=255.025n

.meas tran vdout0_16ck500 FIND v(dout0_16) AT=255.025n

.meas tran vdout0_17ck500 FIND v(dout0_17) AT=255.025n

.meas tran vdout0_18ck500 FIND v(dout0_18) AT=255.025n

.meas tran vdout0_19ck500 FIND v(dout0_19) AT=255.025n

.meas tran vdout0_20ck500 FIND v(dout0_20) AT=255.025n

.meas tran vdout0_21ck500 FIND v(dout0_21) AT=255.025n

.meas tran vdout0_22ck500 FIND v(dout0_22) AT=255.025n

.meas tran vdout0_23ck500 FIND v(dout0_23) AT=255.025n

.meas tran vdout0_24ck500 FIND v(dout0_24) AT=255.025n

.meas tran vdout0_25ck500 FIND v(dout0_25) AT=255.025n

.meas tran vdout0_26ck500 FIND v(dout0_26) AT=255.025n

.meas tran vdout0_27ck500 FIND v(dout0_27) AT=255.025n

.meas tran vdout0_28ck500 FIND v(dout0_28) AT=255.025n

.meas tran vdout0_29ck500 FIND v(dout0_29) AT=255.025n

.meas tran vdout0_30ck500 FIND v(dout0_30) AT=255.025n

.meas tran vdout0_31ck500 FIND v(dout0_31) AT=255.025n

.meas tran vdout0_32ck500 FIND v(dout0_32) AT=255.025n

.meas tran vdout0_33ck500 FIND v(dout0_33) AT=255.025n

.meas tran vdout0_34ck500 FIND v(dout0_34) AT=255.025n

.meas tran vdout0_35ck500 FIND v(dout0_35) AT=255.025n

.meas tran vdout0_36ck500 FIND v(dout0_36) AT=255.025n

.meas tran vdout0_37ck500 FIND v(dout0_37) AT=255.025n

.meas tran vdout0_38ck500 FIND v(dout0_38) AT=255.025n

.meas tran vdout0_39ck500 FIND v(dout0_39) AT=255.025n

.meas tran vdout0_40ck500 FIND v(dout0_40) AT=255.025n

.meas tran vdout0_41ck500 FIND v(dout0_41) AT=255.025n

.meas tran vdout0_42ck500 FIND v(dout0_42) AT=255.025n

.meas tran vdout0_43ck500 FIND v(dout0_43) AT=255.025n

.meas tran vdout0_44ck500 FIND v(dout0_44) AT=255.025n

.meas tran vdout0_45ck500 FIND v(dout0_45) AT=255.025n

.meas tran vdout0_46ck500 FIND v(dout0_46) AT=255.025n

.meas tran vdout0_47ck500 FIND v(dout0_47) AT=255.025n

.meas tran vdout0_48ck500 FIND v(dout0_48) AT=255.025n

.meas tran vdout0_49ck500 FIND v(dout0_49) AT=255.025n

.meas tran vdout0_50ck500 FIND v(dout0_50) AT=255.025n

.meas tran vdout0_51ck500 FIND v(dout0_51) AT=255.025n

.meas tran vdout0_52ck500 FIND v(dout0_52) AT=255.025n

.meas tran vdout0_53ck500 FIND v(dout0_53) AT=255.025n

.meas tran vdout0_54ck500 FIND v(dout0_54) AT=255.025n

.meas tran vdout0_55ck500 FIND v(dout0_55) AT=255.025n

.meas tran vdout0_56ck500 FIND v(dout0_56) AT=255.025n

.meas tran vdout0_57ck500 FIND v(dout0_57) AT=255.025n

.meas tran vdout0_58ck500 FIND v(dout0_58) AT=255.025n

.meas tran vdout0_59ck500 FIND v(dout0_59) AT=255.025n

.meas tran vdout0_60ck500 FIND v(dout0_60) AT=255.025n

.meas tran vdout0_61ck500 FIND v(dout0_61) AT=255.025n

.meas tran vdout0_62ck500 FIND v(dout0_62) AT=255.025n

.meas tran vdout0_63ck500 FIND v(dout0_63) AT=255.025n

.meas tran vdout0_64ck500 FIND v(dout0_64) AT=255.025n

.meas tran vdout0_65ck500 FIND v(dout0_65) AT=255.025n

.meas tran vdout0_66ck500 FIND v(dout0_66) AT=255.025n

.meas tran vdout0_67ck500 FIND v(dout0_67) AT=255.025n

.meas tran vdout0_68ck500 FIND v(dout0_68) AT=255.025n

.meas tran vdout0_69ck500 FIND v(dout0_69) AT=255.025n

.meas tran vdout0_70ck500 FIND v(dout0_70) AT=255.025n

.meas tran vdout0_71ck500 FIND v(dout0_71) AT=255.025n

.meas tran vdout0_72ck500 FIND v(dout0_72) AT=255.025n

.meas tran vdout0_73ck500 FIND v(dout0_73) AT=255.025n

.meas tran vdout0_74ck500 FIND v(dout0_74) AT=255.025n

.meas tran vdout0_75ck500 FIND v(dout0_75) AT=255.025n

.meas tran vdout0_76ck500 FIND v(dout0_76) AT=255.025n

.meas tran vdout0_77ck500 FIND v(dout0_77) AT=255.025n

.meas tran vdout0_78ck500 FIND v(dout0_78) AT=255.025n

.meas tran vdout0_79ck500 FIND v(dout0_79) AT=255.025n

.meas tran vdout0_80ck500 FIND v(dout0_80) AT=255.025n

.meas tran vdout0_81ck500 FIND v(dout0_81) AT=255.025n

.meas tran vdout0_82ck500 FIND v(dout0_82) AT=255.025n

.meas tran vdout0_83ck500 FIND v(dout0_83) AT=255.025n

.meas tran vdout0_84ck500 FIND v(dout0_84) AT=255.025n

.meas tran vdout0_85ck500 FIND v(dout0_85) AT=255.025n

.meas tran vdout0_86ck500 FIND v(dout0_86) AT=255.025n

.meas tran vdout0_87ck500 FIND v(dout0_87) AT=255.025n

.meas tran vdout0_88ck500 FIND v(dout0_88) AT=255.025n

.meas tran vdout0_89ck500 FIND v(dout0_89) AT=255.025n

.meas tran vdout0_90ck500 FIND v(dout0_90) AT=255.025n

.meas tran vdout0_91ck500 FIND v(dout0_91) AT=255.025n

.meas tran vdout0_92ck500 FIND v(dout0_92) AT=255.025n

.meas tran vdout0_93ck500 FIND v(dout0_93) AT=255.025n

.meas tran vdout0_94ck500 FIND v(dout0_94) AT=255.025n

.meas tran vdout0_95ck500 FIND v(dout0_95) AT=255.025n

.meas tran vdout0_96ck500 FIND v(dout0_96) AT=255.025n

.meas tran vdout0_97ck500 FIND v(dout0_97) AT=255.025n

.meas tran vdout0_98ck500 FIND v(dout0_98) AT=255.025n

.meas tran vdout0_99ck500 FIND v(dout0_99) AT=255.025n

.meas tran vdout0_100ck500 FIND v(dout0_100) AT=255.025n

.meas tran vdout0_101ck500 FIND v(dout0_101) AT=255.025n

.meas tran vdout0_102ck500 FIND v(dout0_102) AT=255.025n

.meas tran vdout0_103ck500 FIND v(dout0_103) AT=255.025n

.meas tran vdout0_104ck500 FIND v(dout0_104) AT=255.025n

.meas tran vdout0_105ck500 FIND v(dout0_105) AT=255.025n

.meas tran vdout0_106ck500 FIND v(dout0_106) AT=255.025n

.meas tran vdout0_107ck500 FIND v(dout0_107) AT=255.025n

.meas tran vdout0_108ck500 FIND v(dout0_108) AT=255.025n

.meas tran vdout0_109ck500 FIND v(dout0_109) AT=255.025n

.meas tran vdout0_110ck500 FIND v(dout0_110) AT=255.025n

.meas tran vdout0_111ck500 FIND v(dout0_111) AT=255.025n

.meas tran vdout0_112ck500 FIND v(dout0_112) AT=255.025n

.meas tran vdout0_113ck500 FIND v(dout0_113) AT=255.025n

.meas tran vdout0_114ck500 FIND v(dout0_114) AT=255.025n

.meas tran vdout0_115ck500 FIND v(dout0_115) AT=255.025n

.meas tran vdout0_116ck500 FIND v(dout0_116) AT=255.025n

.meas tran vdout0_117ck500 FIND v(dout0_117) AT=255.025n

.meas tran vdout0_118ck500 FIND v(dout0_118) AT=255.025n

.meas tran vdout0_119ck500 FIND v(dout0_119) AT=255.025n

.meas tran vdout0_120ck500 FIND v(dout0_120) AT=255.025n

.meas tran vdout0_121ck500 FIND v(dout0_121) AT=255.025n

.meas tran vdout0_122ck500 FIND v(dout0_122) AT=255.025n

.meas tran vdout0_123ck500 FIND v(dout0_123) AT=255.025n

.meas tran vdout0_124ck500 FIND v(dout0_124) AT=255.025n

.meas tran vdout0_125ck500 FIND v(dout0_125) AT=255.025n

.meas tran vdout0_126ck500 FIND v(dout0_126) AT=255.025n

.meas tran vdout0_127ck500 FIND v(dout0_127) AT=255.025n

.meas tran vdout0_128ck500 FIND v(dout0_128) AT=255.025n

.meas tran vdout0_129ck500 FIND v(dout0_129) AT=255.025n

.meas tran vdout0_130ck500 FIND v(dout0_130) AT=255.025n

.meas tran vdout0_131ck500 FIND v(dout0_131) AT=255.025n

.meas tran vdout0_132ck500 FIND v(dout0_132) AT=255.025n

.meas tran vdout0_133ck500 FIND v(dout0_133) AT=255.025n

.meas tran vdout0_134ck500 FIND v(dout0_134) AT=255.025n

.meas tran vdout0_135ck500 FIND v(dout0_135) AT=255.025n

.meas tran vdout0_136ck500 FIND v(dout0_136) AT=255.025n

.meas tran vdout0_137ck500 FIND v(dout0_137) AT=255.025n

.meas tran vdout0_138ck500 FIND v(dout0_138) AT=255.025n

.meas tran vdout0_139ck500 FIND v(dout0_139) AT=255.025n

.meas tran vdout0_140ck500 FIND v(dout0_140) AT=255.025n

.meas tran vdout0_141ck500 FIND v(dout0_141) AT=255.025n

.meas tran vdout0_142ck500 FIND v(dout0_142) AT=255.025n

.meas tran vdout0_143ck500 FIND v(dout0_143) AT=255.025n

.meas tran vdout0_144ck500 FIND v(dout0_144) AT=255.025n

.meas tran vdout0_145ck500 FIND v(dout0_145) AT=255.025n

.meas tran vdout0_146ck500 FIND v(dout0_146) AT=255.025n

.meas tran vdout0_147ck500 FIND v(dout0_147) AT=255.025n

.meas tran vdout0_148ck500 FIND v(dout0_148) AT=255.025n

.meas tran vdout0_149ck500 FIND v(dout0_149) AT=255.025n

.meas tran vdout0_150ck500 FIND v(dout0_150) AT=255.025n

.meas tran vdout0_151ck500 FIND v(dout0_151) AT=255.025n

.meas tran vdout0_152ck500 FIND v(dout0_152) AT=255.025n

.meas tran vdout0_153ck500 FIND v(dout0_153) AT=255.025n

.meas tran vdout0_154ck500 FIND v(dout0_154) AT=255.025n

.meas tran vdout0_155ck500 FIND v(dout0_155) AT=255.025n

.meas tran vdout0_156ck500 FIND v(dout0_156) AT=255.025n

.meas tran vdout0_157ck500 FIND v(dout0_157) AT=255.025n

.meas tran vdout0_158ck500 FIND v(dout0_158) AT=255.025n

.meas tran vdout0_159ck500 FIND v(dout0_159) AT=255.025n

.meas tran vdout0_160ck500 FIND v(dout0_160) AT=255.025n

.meas tran vdout0_161ck500 FIND v(dout0_161) AT=255.025n

.meas tran vdout0_162ck500 FIND v(dout0_162) AT=255.025n

.meas tran vdout0_163ck500 FIND v(dout0_163) AT=255.025n

.meas tran vdout0_164ck500 FIND v(dout0_164) AT=255.025n

.meas tran vdout0_165ck500 FIND v(dout0_165) AT=255.025n

.meas tran vdout0_166ck500 FIND v(dout0_166) AT=255.025n

.meas tran vdout0_167ck500 FIND v(dout0_167) AT=255.025n

.meas tran vdout0_168ck500 FIND v(dout0_168) AT=255.025n

.meas tran vdout0_169ck500 FIND v(dout0_169) AT=255.025n

.meas tran vdout0_170ck500 FIND v(dout0_170) AT=255.025n

.meas tran vdout0_171ck500 FIND v(dout0_171) AT=255.025n

.meas tran vdout0_172ck500 FIND v(dout0_172) AT=255.025n

.meas tran vdout0_173ck500 FIND v(dout0_173) AT=255.025n

.meas tran vdout0_174ck500 FIND v(dout0_174) AT=255.025n

.meas tran vdout0_175ck500 FIND v(dout0_175) AT=255.025n

.meas tran vdout0_176ck500 FIND v(dout0_176) AT=255.025n

.meas tran vdout0_177ck500 FIND v(dout0_177) AT=255.025n

.meas tran vdout0_178ck500 FIND v(dout0_178) AT=255.025n

.meas tran vdout0_179ck500 FIND v(dout0_179) AT=255.025n

.meas tran vdout0_180ck500 FIND v(dout0_180) AT=255.025n

.meas tran vdout0_181ck500 FIND v(dout0_181) AT=255.025n

.meas tran vdout0_182ck500 FIND v(dout0_182) AT=255.025n

.meas tran vdout0_183ck500 FIND v(dout0_183) AT=255.025n

.meas tran vdout0_184ck500 FIND v(dout0_184) AT=255.025n

.meas tran vdout0_185ck500 FIND v(dout0_185) AT=255.025n

.meas tran vdout0_186ck500 FIND v(dout0_186) AT=255.025n

.meas tran vdout0_187ck500 FIND v(dout0_187) AT=255.025n

.meas tran vdout0_188ck500 FIND v(dout0_188) AT=255.025n

.meas tran vdout0_189ck500 FIND v(dout0_189) AT=255.025n

.meas tran vdout0_190ck500 FIND v(dout0_190) AT=255.025n

.meas tran vdout0_191ck500 FIND v(dout0_191) AT=255.025n

.meas tran vdout0_192ck500 FIND v(dout0_192) AT=255.025n

.meas tran vdout0_193ck500 FIND v(dout0_193) AT=255.025n

.meas tran vdout0_194ck500 FIND v(dout0_194) AT=255.025n

.meas tran vdout0_195ck500 FIND v(dout0_195) AT=255.025n

.meas tran vdout0_196ck500 FIND v(dout0_196) AT=255.025n

.meas tran vdout0_197ck500 FIND v(dout0_197) AT=255.025n

.meas tran vdout0_198ck500 FIND v(dout0_198) AT=255.025n

.meas tran vdout0_199ck500 FIND v(dout0_199) AT=255.025n

.meas tran vdout0_200ck500 FIND v(dout0_200) AT=255.025n

.meas tran vdout0_201ck500 FIND v(dout0_201) AT=255.025n

.meas tran vdout0_202ck500 FIND v(dout0_202) AT=255.025n

.meas tran vdout0_203ck500 FIND v(dout0_203) AT=255.025n

.meas tran vdout0_204ck500 FIND v(dout0_204) AT=255.025n

.meas tran vdout0_205ck500 FIND v(dout0_205) AT=255.025n

.meas tran vdout0_206ck500 FIND v(dout0_206) AT=255.025n

.meas tran vdout0_207ck500 FIND v(dout0_207) AT=255.025n

.meas tran vdout0_208ck500 FIND v(dout0_208) AT=255.025n

.meas tran vdout0_209ck500 FIND v(dout0_209) AT=255.025n

.meas tran vdout0_210ck500 FIND v(dout0_210) AT=255.025n

.meas tran vdout0_211ck500 FIND v(dout0_211) AT=255.025n

.meas tran vdout0_212ck500 FIND v(dout0_212) AT=255.025n

.meas tran vdout0_213ck500 FIND v(dout0_213) AT=255.025n

.meas tran vdout0_214ck500 FIND v(dout0_214) AT=255.025n

.meas tran vdout0_215ck500 FIND v(dout0_215) AT=255.025n

.meas tran vdout0_216ck500 FIND v(dout0_216) AT=255.025n

.meas tran vdout0_217ck500 FIND v(dout0_217) AT=255.025n

.meas tran vdout0_218ck500 FIND v(dout0_218) AT=255.025n

.meas tran vdout0_219ck500 FIND v(dout0_219) AT=255.025n

.meas tran vdout0_220ck500 FIND v(dout0_220) AT=255.025n

.meas tran vdout0_221ck500 FIND v(dout0_221) AT=255.025n

.meas tran vdout0_222ck500 FIND v(dout0_222) AT=255.025n

.meas tran vdout0_223ck500 FIND v(dout0_223) AT=255.025n

.meas tran vdout0_224ck500 FIND v(dout0_224) AT=255.025n

.meas tran vdout0_225ck500 FIND v(dout0_225) AT=255.025n

.meas tran vdout0_226ck500 FIND v(dout0_226) AT=255.025n

.meas tran vdout0_227ck500 FIND v(dout0_227) AT=255.025n

.meas tran vdout0_228ck500 FIND v(dout0_228) AT=255.025n

.meas tran vdout0_229ck500 FIND v(dout0_229) AT=255.025n

.meas tran vdout0_230ck500 FIND v(dout0_230) AT=255.025n

.meas tran vdout0_231ck500 FIND v(dout0_231) AT=255.025n

.meas tran vdout0_232ck500 FIND v(dout0_232) AT=255.025n

.meas tran vdout0_233ck500 FIND v(dout0_233) AT=255.025n

.meas tran vdout0_234ck500 FIND v(dout0_234) AT=255.025n

.meas tran vdout0_235ck500 FIND v(dout0_235) AT=255.025n

.meas tran vdout0_236ck500 FIND v(dout0_236) AT=255.025n

.meas tran vdout0_237ck500 FIND v(dout0_237) AT=255.025n

.meas tran vdout0_238ck500 FIND v(dout0_238) AT=255.025n

.meas tran vdout0_239ck500 FIND v(dout0_239) AT=255.025n

.meas tran vdout0_240ck500 FIND v(dout0_240) AT=255.025n

.meas tran vdout0_241ck500 FIND v(dout0_241) AT=255.025n

.meas tran vdout0_242ck500 FIND v(dout0_242) AT=255.025n

.meas tran vdout0_243ck500 FIND v(dout0_243) AT=255.025n

.meas tran vdout0_244ck500 FIND v(dout0_244) AT=255.025n

.meas tran vdout0_245ck500 FIND v(dout0_245) AT=255.025n

.meas tran vdout0_246ck500 FIND v(dout0_246) AT=255.025n

.meas tran vdout0_247ck500 FIND v(dout0_247) AT=255.025n

.meas tran vdout0_248ck500 FIND v(dout0_248) AT=255.025n

.meas tran vdout0_249ck500 FIND v(dout0_249) AT=255.025n

.meas tran vdout0_250ck500 FIND v(dout0_250) AT=255.025n

.meas tran vdout0_251ck500 FIND v(dout0_251) AT=255.025n

.meas tran vdout0_252ck500 FIND v(dout0_252) AT=255.025n

.meas tran vdout0_253ck500 FIND v(dout0_253) AT=255.025n

.meas tran vdout0_254ck500 FIND v(dout0_254) AT=255.025n

.meas tran vdout0_255ck500 FIND v(dout0_255) AT=255.025n

.meas tran vdout0_0ck510 FIND v(dout0_0) AT=260.025n

.meas tran vdout0_1ck510 FIND v(dout0_1) AT=260.025n

.meas tran vdout0_2ck510 FIND v(dout0_2) AT=260.025n

.meas tran vdout0_3ck510 FIND v(dout0_3) AT=260.025n

.meas tran vdout0_4ck510 FIND v(dout0_4) AT=260.025n

.meas tran vdout0_5ck510 FIND v(dout0_5) AT=260.025n

.meas tran vdout0_6ck510 FIND v(dout0_6) AT=260.025n

.meas tran vdout0_7ck510 FIND v(dout0_7) AT=260.025n

.meas tran vdout0_8ck510 FIND v(dout0_8) AT=260.025n

.meas tran vdout0_9ck510 FIND v(dout0_9) AT=260.025n

.meas tran vdout0_10ck510 FIND v(dout0_10) AT=260.025n

.meas tran vdout0_11ck510 FIND v(dout0_11) AT=260.025n

.meas tran vdout0_12ck510 FIND v(dout0_12) AT=260.025n

.meas tran vdout0_13ck510 FIND v(dout0_13) AT=260.025n

.meas tran vdout0_14ck510 FIND v(dout0_14) AT=260.025n

.meas tran vdout0_15ck510 FIND v(dout0_15) AT=260.025n

.meas tran vdout0_16ck510 FIND v(dout0_16) AT=260.025n

.meas tran vdout0_17ck510 FIND v(dout0_17) AT=260.025n

.meas tran vdout0_18ck510 FIND v(dout0_18) AT=260.025n

.meas tran vdout0_19ck510 FIND v(dout0_19) AT=260.025n

.meas tran vdout0_20ck510 FIND v(dout0_20) AT=260.025n

.meas tran vdout0_21ck510 FIND v(dout0_21) AT=260.025n

.meas tran vdout0_22ck510 FIND v(dout0_22) AT=260.025n

.meas tran vdout0_23ck510 FIND v(dout0_23) AT=260.025n

.meas tran vdout0_24ck510 FIND v(dout0_24) AT=260.025n

.meas tran vdout0_25ck510 FIND v(dout0_25) AT=260.025n

.meas tran vdout0_26ck510 FIND v(dout0_26) AT=260.025n

.meas tran vdout0_27ck510 FIND v(dout0_27) AT=260.025n

.meas tran vdout0_28ck510 FIND v(dout0_28) AT=260.025n

.meas tran vdout0_29ck510 FIND v(dout0_29) AT=260.025n

.meas tran vdout0_30ck510 FIND v(dout0_30) AT=260.025n

.meas tran vdout0_31ck510 FIND v(dout0_31) AT=260.025n

.meas tran vdout0_32ck510 FIND v(dout0_32) AT=260.025n

.meas tran vdout0_33ck510 FIND v(dout0_33) AT=260.025n

.meas tran vdout0_34ck510 FIND v(dout0_34) AT=260.025n

.meas tran vdout0_35ck510 FIND v(dout0_35) AT=260.025n

.meas tran vdout0_36ck510 FIND v(dout0_36) AT=260.025n

.meas tran vdout0_37ck510 FIND v(dout0_37) AT=260.025n

.meas tran vdout0_38ck510 FIND v(dout0_38) AT=260.025n

.meas tran vdout0_39ck510 FIND v(dout0_39) AT=260.025n

.meas tran vdout0_40ck510 FIND v(dout0_40) AT=260.025n

.meas tran vdout0_41ck510 FIND v(dout0_41) AT=260.025n

.meas tran vdout0_42ck510 FIND v(dout0_42) AT=260.025n

.meas tran vdout0_43ck510 FIND v(dout0_43) AT=260.025n

.meas tran vdout0_44ck510 FIND v(dout0_44) AT=260.025n

.meas tran vdout0_45ck510 FIND v(dout0_45) AT=260.025n

.meas tran vdout0_46ck510 FIND v(dout0_46) AT=260.025n

.meas tran vdout0_47ck510 FIND v(dout0_47) AT=260.025n

.meas tran vdout0_48ck510 FIND v(dout0_48) AT=260.025n

.meas tran vdout0_49ck510 FIND v(dout0_49) AT=260.025n

.meas tran vdout0_50ck510 FIND v(dout0_50) AT=260.025n

.meas tran vdout0_51ck510 FIND v(dout0_51) AT=260.025n

.meas tran vdout0_52ck510 FIND v(dout0_52) AT=260.025n

.meas tran vdout0_53ck510 FIND v(dout0_53) AT=260.025n

.meas tran vdout0_54ck510 FIND v(dout0_54) AT=260.025n

.meas tran vdout0_55ck510 FIND v(dout0_55) AT=260.025n

.meas tran vdout0_56ck510 FIND v(dout0_56) AT=260.025n

.meas tran vdout0_57ck510 FIND v(dout0_57) AT=260.025n

.meas tran vdout0_58ck510 FIND v(dout0_58) AT=260.025n

.meas tran vdout0_59ck510 FIND v(dout0_59) AT=260.025n

.meas tran vdout0_60ck510 FIND v(dout0_60) AT=260.025n

.meas tran vdout0_61ck510 FIND v(dout0_61) AT=260.025n

.meas tran vdout0_62ck510 FIND v(dout0_62) AT=260.025n

.meas tran vdout0_63ck510 FIND v(dout0_63) AT=260.025n

.meas tran vdout0_64ck510 FIND v(dout0_64) AT=260.025n

.meas tran vdout0_65ck510 FIND v(dout0_65) AT=260.025n

.meas tran vdout0_66ck510 FIND v(dout0_66) AT=260.025n

.meas tran vdout0_67ck510 FIND v(dout0_67) AT=260.025n

.meas tran vdout0_68ck510 FIND v(dout0_68) AT=260.025n

.meas tran vdout0_69ck510 FIND v(dout0_69) AT=260.025n

.meas tran vdout0_70ck510 FIND v(dout0_70) AT=260.025n

.meas tran vdout0_71ck510 FIND v(dout0_71) AT=260.025n

.meas tran vdout0_72ck510 FIND v(dout0_72) AT=260.025n

.meas tran vdout0_73ck510 FIND v(dout0_73) AT=260.025n

.meas tran vdout0_74ck510 FIND v(dout0_74) AT=260.025n

.meas tran vdout0_75ck510 FIND v(dout0_75) AT=260.025n

.meas tran vdout0_76ck510 FIND v(dout0_76) AT=260.025n

.meas tran vdout0_77ck510 FIND v(dout0_77) AT=260.025n

.meas tran vdout0_78ck510 FIND v(dout0_78) AT=260.025n

.meas tran vdout0_79ck510 FIND v(dout0_79) AT=260.025n

.meas tran vdout0_80ck510 FIND v(dout0_80) AT=260.025n

.meas tran vdout0_81ck510 FIND v(dout0_81) AT=260.025n

.meas tran vdout0_82ck510 FIND v(dout0_82) AT=260.025n

.meas tran vdout0_83ck510 FIND v(dout0_83) AT=260.025n

.meas tran vdout0_84ck510 FIND v(dout0_84) AT=260.025n

.meas tran vdout0_85ck510 FIND v(dout0_85) AT=260.025n

.meas tran vdout0_86ck510 FIND v(dout0_86) AT=260.025n

.meas tran vdout0_87ck510 FIND v(dout0_87) AT=260.025n

.meas tran vdout0_88ck510 FIND v(dout0_88) AT=260.025n

.meas tran vdout0_89ck510 FIND v(dout0_89) AT=260.025n

.meas tran vdout0_90ck510 FIND v(dout0_90) AT=260.025n

.meas tran vdout0_91ck510 FIND v(dout0_91) AT=260.025n

.meas tran vdout0_92ck510 FIND v(dout0_92) AT=260.025n

.meas tran vdout0_93ck510 FIND v(dout0_93) AT=260.025n

.meas tran vdout0_94ck510 FIND v(dout0_94) AT=260.025n

.meas tran vdout0_95ck510 FIND v(dout0_95) AT=260.025n

.meas tran vdout0_96ck510 FIND v(dout0_96) AT=260.025n

.meas tran vdout0_97ck510 FIND v(dout0_97) AT=260.025n

.meas tran vdout0_98ck510 FIND v(dout0_98) AT=260.025n

.meas tran vdout0_99ck510 FIND v(dout0_99) AT=260.025n

.meas tran vdout0_100ck510 FIND v(dout0_100) AT=260.025n

.meas tran vdout0_101ck510 FIND v(dout0_101) AT=260.025n

.meas tran vdout0_102ck510 FIND v(dout0_102) AT=260.025n

.meas tran vdout0_103ck510 FIND v(dout0_103) AT=260.025n

.meas tran vdout0_104ck510 FIND v(dout0_104) AT=260.025n

.meas tran vdout0_105ck510 FIND v(dout0_105) AT=260.025n

.meas tran vdout0_106ck510 FIND v(dout0_106) AT=260.025n

.meas tran vdout0_107ck510 FIND v(dout0_107) AT=260.025n

.meas tran vdout0_108ck510 FIND v(dout0_108) AT=260.025n

.meas tran vdout0_109ck510 FIND v(dout0_109) AT=260.025n

.meas tran vdout0_110ck510 FIND v(dout0_110) AT=260.025n

.meas tran vdout0_111ck510 FIND v(dout0_111) AT=260.025n

.meas tran vdout0_112ck510 FIND v(dout0_112) AT=260.025n

.meas tran vdout0_113ck510 FIND v(dout0_113) AT=260.025n

.meas tran vdout0_114ck510 FIND v(dout0_114) AT=260.025n

.meas tran vdout0_115ck510 FIND v(dout0_115) AT=260.025n

.meas tran vdout0_116ck510 FIND v(dout0_116) AT=260.025n

.meas tran vdout0_117ck510 FIND v(dout0_117) AT=260.025n

.meas tran vdout0_118ck510 FIND v(dout0_118) AT=260.025n

.meas tran vdout0_119ck510 FIND v(dout0_119) AT=260.025n

.meas tran vdout0_120ck510 FIND v(dout0_120) AT=260.025n

.meas tran vdout0_121ck510 FIND v(dout0_121) AT=260.025n

.meas tran vdout0_122ck510 FIND v(dout0_122) AT=260.025n

.meas tran vdout0_123ck510 FIND v(dout0_123) AT=260.025n

.meas tran vdout0_124ck510 FIND v(dout0_124) AT=260.025n

.meas tran vdout0_125ck510 FIND v(dout0_125) AT=260.025n

.meas tran vdout0_126ck510 FIND v(dout0_126) AT=260.025n

.meas tran vdout0_127ck510 FIND v(dout0_127) AT=260.025n

.meas tran vdout0_128ck510 FIND v(dout0_128) AT=260.025n

.meas tran vdout0_129ck510 FIND v(dout0_129) AT=260.025n

.meas tran vdout0_130ck510 FIND v(dout0_130) AT=260.025n

.meas tran vdout0_131ck510 FIND v(dout0_131) AT=260.025n

.meas tran vdout0_132ck510 FIND v(dout0_132) AT=260.025n

.meas tran vdout0_133ck510 FIND v(dout0_133) AT=260.025n

.meas tran vdout0_134ck510 FIND v(dout0_134) AT=260.025n

.meas tran vdout0_135ck510 FIND v(dout0_135) AT=260.025n

.meas tran vdout0_136ck510 FIND v(dout0_136) AT=260.025n

.meas tran vdout0_137ck510 FIND v(dout0_137) AT=260.025n

.meas tran vdout0_138ck510 FIND v(dout0_138) AT=260.025n

.meas tran vdout0_139ck510 FIND v(dout0_139) AT=260.025n

.meas tran vdout0_140ck510 FIND v(dout0_140) AT=260.025n

.meas tran vdout0_141ck510 FIND v(dout0_141) AT=260.025n

.meas tran vdout0_142ck510 FIND v(dout0_142) AT=260.025n

.meas tran vdout0_143ck510 FIND v(dout0_143) AT=260.025n

.meas tran vdout0_144ck510 FIND v(dout0_144) AT=260.025n

.meas tran vdout0_145ck510 FIND v(dout0_145) AT=260.025n

.meas tran vdout0_146ck510 FIND v(dout0_146) AT=260.025n

.meas tran vdout0_147ck510 FIND v(dout0_147) AT=260.025n

.meas tran vdout0_148ck510 FIND v(dout0_148) AT=260.025n

.meas tran vdout0_149ck510 FIND v(dout0_149) AT=260.025n

.meas tran vdout0_150ck510 FIND v(dout0_150) AT=260.025n

.meas tran vdout0_151ck510 FIND v(dout0_151) AT=260.025n

.meas tran vdout0_152ck510 FIND v(dout0_152) AT=260.025n

.meas tran vdout0_153ck510 FIND v(dout0_153) AT=260.025n

.meas tran vdout0_154ck510 FIND v(dout0_154) AT=260.025n

.meas tran vdout0_155ck510 FIND v(dout0_155) AT=260.025n

.meas tran vdout0_156ck510 FIND v(dout0_156) AT=260.025n

.meas tran vdout0_157ck510 FIND v(dout0_157) AT=260.025n

.meas tran vdout0_158ck510 FIND v(dout0_158) AT=260.025n

.meas tran vdout0_159ck510 FIND v(dout0_159) AT=260.025n

.meas tran vdout0_160ck510 FIND v(dout0_160) AT=260.025n

.meas tran vdout0_161ck510 FIND v(dout0_161) AT=260.025n

.meas tran vdout0_162ck510 FIND v(dout0_162) AT=260.025n

.meas tran vdout0_163ck510 FIND v(dout0_163) AT=260.025n

.meas tran vdout0_164ck510 FIND v(dout0_164) AT=260.025n

.meas tran vdout0_165ck510 FIND v(dout0_165) AT=260.025n

.meas tran vdout0_166ck510 FIND v(dout0_166) AT=260.025n

.meas tran vdout0_167ck510 FIND v(dout0_167) AT=260.025n

.meas tran vdout0_168ck510 FIND v(dout0_168) AT=260.025n

.meas tran vdout0_169ck510 FIND v(dout0_169) AT=260.025n

.meas tran vdout0_170ck510 FIND v(dout0_170) AT=260.025n

.meas tran vdout0_171ck510 FIND v(dout0_171) AT=260.025n

.meas tran vdout0_172ck510 FIND v(dout0_172) AT=260.025n

.meas tran vdout0_173ck510 FIND v(dout0_173) AT=260.025n

.meas tran vdout0_174ck510 FIND v(dout0_174) AT=260.025n

.meas tran vdout0_175ck510 FIND v(dout0_175) AT=260.025n

.meas tran vdout0_176ck510 FIND v(dout0_176) AT=260.025n

.meas tran vdout0_177ck510 FIND v(dout0_177) AT=260.025n

.meas tran vdout0_178ck510 FIND v(dout0_178) AT=260.025n

.meas tran vdout0_179ck510 FIND v(dout0_179) AT=260.025n

.meas tran vdout0_180ck510 FIND v(dout0_180) AT=260.025n

.meas tran vdout0_181ck510 FIND v(dout0_181) AT=260.025n

.meas tran vdout0_182ck510 FIND v(dout0_182) AT=260.025n

.meas tran vdout0_183ck510 FIND v(dout0_183) AT=260.025n

.meas tran vdout0_184ck510 FIND v(dout0_184) AT=260.025n

.meas tran vdout0_185ck510 FIND v(dout0_185) AT=260.025n

.meas tran vdout0_186ck510 FIND v(dout0_186) AT=260.025n

.meas tran vdout0_187ck510 FIND v(dout0_187) AT=260.025n

.meas tran vdout0_188ck510 FIND v(dout0_188) AT=260.025n

.meas tran vdout0_189ck510 FIND v(dout0_189) AT=260.025n

.meas tran vdout0_190ck510 FIND v(dout0_190) AT=260.025n

.meas tran vdout0_191ck510 FIND v(dout0_191) AT=260.025n

.meas tran vdout0_192ck510 FIND v(dout0_192) AT=260.025n

.meas tran vdout0_193ck510 FIND v(dout0_193) AT=260.025n

.meas tran vdout0_194ck510 FIND v(dout0_194) AT=260.025n

.meas tran vdout0_195ck510 FIND v(dout0_195) AT=260.025n

.meas tran vdout0_196ck510 FIND v(dout0_196) AT=260.025n

.meas tran vdout0_197ck510 FIND v(dout0_197) AT=260.025n

.meas tran vdout0_198ck510 FIND v(dout0_198) AT=260.025n

.meas tran vdout0_199ck510 FIND v(dout0_199) AT=260.025n

.meas tran vdout0_200ck510 FIND v(dout0_200) AT=260.025n

.meas tran vdout0_201ck510 FIND v(dout0_201) AT=260.025n

.meas tran vdout0_202ck510 FIND v(dout0_202) AT=260.025n

.meas tran vdout0_203ck510 FIND v(dout0_203) AT=260.025n

.meas tran vdout0_204ck510 FIND v(dout0_204) AT=260.025n

.meas tran vdout0_205ck510 FIND v(dout0_205) AT=260.025n

.meas tran vdout0_206ck510 FIND v(dout0_206) AT=260.025n

.meas tran vdout0_207ck510 FIND v(dout0_207) AT=260.025n

.meas tran vdout0_208ck510 FIND v(dout0_208) AT=260.025n

.meas tran vdout0_209ck510 FIND v(dout0_209) AT=260.025n

.meas tran vdout0_210ck510 FIND v(dout0_210) AT=260.025n

.meas tran vdout0_211ck510 FIND v(dout0_211) AT=260.025n

.meas tran vdout0_212ck510 FIND v(dout0_212) AT=260.025n

.meas tran vdout0_213ck510 FIND v(dout0_213) AT=260.025n

.meas tran vdout0_214ck510 FIND v(dout0_214) AT=260.025n

.meas tran vdout0_215ck510 FIND v(dout0_215) AT=260.025n

.meas tran vdout0_216ck510 FIND v(dout0_216) AT=260.025n

.meas tran vdout0_217ck510 FIND v(dout0_217) AT=260.025n

.meas tran vdout0_218ck510 FIND v(dout0_218) AT=260.025n

.meas tran vdout0_219ck510 FIND v(dout0_219) AT=260.025n

.meas tran vdout0_220ck510 FIND v(dout0_220) AT=260.025n

.meas tran vdout0_221ck510 FIND v(dout0_221) AT=260.025n

.meas tran vdout0_222ck510 FIND v(dout0_222) AT=260.025n

.meas tran vdout0_223ck510 FIND v(dout0_223) AT=260.025n

.meas tran vdout0_224ck510 FIND v(dout0_224) AT=260.025n

.meas tran vdout0_225ck510 FIND v(dout0_225) AT=260.025n

.meas tran vdout0_226ck510 FIND v(dout0_226) AT=260.025n

.meas tran vdout0_227ck510 FIND v(dout0_227) AT=260.025n

.meas tran vdout0_228ck510 FIND v(dout0_228) AT=260.025n

.meas tran vdout0_229ck510 FIND v(dout0_229) AT=260.025n

.meas tran vdout0_230ck510 FIND v(dout0_230) AT=260.025n

.meas tran vdout0_231ck510 FIND v(dout0_231) AT=260.025n

.meas tran vdout0_232ck510 FIND v(dout0_232) AT=260.025n

.meas tran vdout0_233ck510 FIND v(dout0_233) AT=260.025n

.meas tran vdout0_234ck510 FIND v(dout0_234) AT=260.025n

.meas tran vdout0_235ck510 FIND v(dout0_235) AT=260.025n

.meas tran vdout0_236ck510 FIND v(dout0_236) AT=260.025n

.meas tran vdout0_237ck510 FIND v(dout0_237) AT=260.025n

.meas tran vdout0_238ck510 FIND v(dout0_238) AT=260.025n

.meas tran vdout0_239ck510 FIND v(dout0_239) AT=260.025n

.meas tran vdout0_240ck510 FIND v(dout0_240) AT=260.025n

.meas tran vdout0_241ck510 FIND v(dout0_241) AT=260.025n

.meas tran vdout0_242ck510 FIND v(dout0_242) AT=260.025n

.meas tran vdout0_243ck510 FIND v(dout0_243) AT=260.025n

.meas tran vdout0_244ck510 FIND v(dout0_244) AT=260.025n

.meas tran vdout0_245ck510 FIND v(dout0_245) AT=260.025n

.meas tran vdout0_246ck510 FIND v(dout0_246) AT=260.025n

.meas tran vdout0_247ck510 FIND v(dout0_247) AT=260.025n

.meas tran vdout0_248ck510 FIND v(dout0_248) AT=260.025n

.meas tran vdout0_249ck510 FIND v(dout0_249) AT=260.025n

.meas tran vdout0_250ck510 FIND v(dout0_250) AT=260.025n

.meas tran vdout0_251ck510 FIND v(dout0_251) AT=260.025n

.meas tran vdout0_252ck510 FIND v(dout0_252) AT=260.025n

.meas tran vdout0_253ck510 FIND v(dout0_253) AT=260.025n

.meas tran vdout0_254ck510 FIND v(dout0_254) AT=260.025n

.meas tran vdout0_255ck510 FIND v(dout0_255) AT=260.025n

.meas tran vdout0_0ck550 FIND v(dout0_0) AT=280.025n

.meas tran vdout0_1ck550 FIND v(dout0_1) AT=280.025n

.meas tran vdout0_2ck550 FIND v(dout0_2) AT=280.025n

.meas tran vdout0_3ck550 FIND v(dout0_3) AT=280.025n

.meas tran vdout0_4ck550 FIND v(dout0_4) AT=280.025n

.meas tran vdout0_5ck550 FIND v(dout0_5) AT=280.025n

.meas tran vdout0_6ck550 FIND v(dout0_6) AT=280.025n

.meas tran vdout0_7ck550 FIND v(dout0_7) AT=280.025n

.meas tran vdout0_8ck550 FIND v(dout0_8) AT=280.025n

.meas tran vdout0_9ck550 FIND v(dout0_9) AT=280.025n

.meas tran vdout0_10ck550 FIND v(dout0_10) AT=280.025n

.meas tran vdout0_11ck550 FIND v(dout0_11) AT=280.025n

.meas tran vdout0_12ck550 FIND v(dout0_12) AT=280.025n

.meas tran vdout0_13ck550 FIND v(dout0_13) AT=280.025n

.meas tran vdout0_14ck550 FIND v(dout0_14) AT=280.025n

.meas tran vdout0_15ck550 FIND v(dout0_15) AT=280.025n

.meas tran vdout0_16ck550 FIND v(dout0_16) AT=280.025n

.meas tran vdout0_17ck550 FIND v(dout0_17) AT=280.025n

.meas tran vdout0_18ck550 FIND v(dout0_18) AT=280.025n

.meas tran vdout0_19ck550 FIND v(dout0_19) AT=280.025n

.meas tran vdout0_20ck550 FIND v(dout0_20) AT=280.025n

.meas tran vdout0_21ck550 FIND v(dout0_21) AT=280.025n

.meas tran vdout0_22ck550 FIND v(dout0_22) AT=280.025n

.meas tran vdout0_23ck550 FIND v(dout0_23) AT=280.025n

.meas tran vdout0_24ck550 FIND v(dout0_24) AT=280.025n

.meas tran vdout0_25ck550 FIND v(dout0_25) AT=280.025n

.meas tran vdout0_26ck550 FIND v(dout0_26) AT=280.025n

.meas tran vdout0_27ck550 FIND v(dout0_27) AT=280.025n

.meas tran vdout0_28ck550 FIND v(dout0_28) AT=280.025n

.meas tran vdout0_29ck550 FIND v(dout0_29) AT=280.025n

.meas tran vdout0_30ck550 FIND v(dout0_30) AT=280.025n

.meas tran vdout0_31ck550 FIND v(dout0_31) AT=280.025n

.meas tran vdout0_32ck550 FIND v(dout0_32) AT=280.025n

.meas tran vdout0_33ck550 FIND v(dout0_33) AT=280.025n

.meas tran vdout0_34ck550 FIND v(dout0_34) AT=280.025n

.meas tran vdout0_35ck550 FIND v(dout0_35) AT=280.025n

.meas tran vdout0_36ck550 FIND v(dout0_36) AT=280.025n

.meas tran vdout0_37ck550 FIND v(dout0_37) AT=280.025n

.meas tran vdout0_38ck550 FIND v(dout0_38) AT=280.025n

.meas tran vdout0_39ck550 FIND v(dout0_39) AT=280.025n

.meas tran vdout0_40ck550 FIND v(dout0_40) AT=280.025n

.meas tran vdout0_41ck550 FIND v(dout0_41) AT=280.025n

.meas tran vdout0_42ck550 FIND v(dout0_42) AT=280.025n

.meas tran vdout0_43ck550 FIND v(dout0_43) AT=280.025n

.meas tran vdout0_44ck550 FIND v(dout0_44) AT=280.025n

.meas tran vdout0_45ck550 FIND v(dout0_45) AT=280.025n

.meas tran vdout0_46ck550 FIND v(dout0_46) AT=280.025n

.meas tran vdout0_47ck550 FIND v(dout0_47) AT=280.025n

.meas tran vdout0_48ck550 FIND v(dout0_48) AT=280.025n

.meas tran vdout0_49ck550 FIND v(dout0_49) AT=280.025n

.meas tran vdout0_50ck550 FIND v(dout0_50) AT=280.025n

.meas tran vdout0_51ck550 FIND v(dout0_51) AT=280.025n

.meas tran vdout0_52ck550 FIND v(dout0_52) AT=280.025n

.meas tran vdout0_53ck550 FIND v(dout0_53) AT=280.025n

.meas tran vdout0_54ck550 FIND v(dout0_54) AT=280.025n

.meas tran vdout0_55ck550 FIND v(dout0_55) AT=280.025n

.meas tran vdout0_56ck550 FIND v(dout0_56) AT=280.025n

.meas tran vdout0_57ck550 FIND v(dout0_57) AT=280.025n

.meas tran vdout0_58ck550 FIND v(dout0_58) AT=280.025n

.meas tran vdout0_59ck550 FIND v(dout0_59) AT=280.025n

.meas tran vdout0_60ck550 FIND v(dout0_60) AT=280.025n

.meas tran vdout0_61ck550 FIND v(dout0_61) AT=280.025n

.meas tran vdout0_62ck550 FIND v(dout0_62) AT=280.025n

.meas tran vdout0_63ck550 FIND v(dout0_63) AT=280.025n

.meas tran vdout0_64ck550 FIND v(dout0_64) AT=280.025n

.meas tran vdout0_65ck550 FIND v(dout0_65) AT=280.025n

.meas tran vdout0_66ck550 FIND v(dout0_66) AT=280.025n

.meas tran vdout0_67ck550 FIND v(dout0_67) AT=280.025n

.meas tran vdout0_68ck550 FIND v(dout0_68) AT=280.025n

.meas tran vdout0_69ck550 FIND v(dout0_69) AT=280.025n

.meas tran vdout0_70ck550 FIND v(dout0_70) AT=280.025n

.meas tran vdout0_71ck550 FIND v(dout0_71) AT=280.025n

.meas tran vdout0_72ck550 FIND v(dout0_72) AT=280.025n

.meas tran vdout0_73ck550 FIND v(dout0_73) AT=280.025n

.meas tran vdout0_74ck550 FIND v(dout0_74) AT=280.025n

.meas tran vdout0_75ck550 FIND v(dout0_75) AT=280.025n

.meas tran vdout0_76ck550 FIND v(dout0_76) AT=280.025n

.meas tran vdout0_77ck550 FIND v(dout0_77) AT=280.025n

.meas tran vdout0_78ck550 FIND v(dout0_78) AT=280.025n

.meas tran vdout0_79ck550 FIND v(dout0_79) AT=280.025n

.meas tran vdout0_80ck550 FIND v(dout0_80) AT=280.025n

.meas tran vdout0_81ck550 FIND v(dout0_81) AT=280.025n

.meas tran vdout0_82ck550 FIND v(dout0_82) AT=280.025n

.meas tran vdout0_83ck550 FIND v(dout0_83) AT=280.025n

.meas tran vdout0_84ck550 FIND v(dout0_84) AT=280.025n

.meas tran vdout0_85ck550 FIND v(dout0_85) AT=280.025n

.meas tran vdout0_86ck550 FIND v(dout0_86) AT=280.025n

.meas tran vdout0_87ck550 FIND v(dout0_87) AT=280.025n

.meas tran vdout0_88ck550 FIND v(dout0_88) AT=280.025n

.meas tran vdout0_89ck550 FIND v(dout0_89) AT=280.025n

.meas tran vdout0_90ck550 FIND v(dout0_90) AT=280.025n

.meas tran vdout0_91ck550 FIND v(dout0_91) AT=280.025n

.meas tran vdout0_92ck550 FIND v(dout0_92) AT=280.025n

.meas tran vdout0_93ck550 FIND v(dout0_93) AT=280.025n

.meas tran vdout0_94ck550 FIND v(dout0_94) AT=280.025n

.meas tran vdout0_95ck550 FIND v(dout0_95) AT=280.025n

.meas tran vdout0_96ck550 FIND v(dout0_96) AT=280.025n

.meas tran vdout0_97ck550 FIND v(dout0_97) AT=280.025n

.meas tran vdout0_98ck550 FIND v(dout0_98) AT=280.025n

.meas tran vdout0_99ck550 FIND v(dout0_99) AT=280.025n

.meas tran vdout0_100ck550 FIND v(dout0_100) AT=280.025n

.meas tran vdout0_101ck550 FIND v(dout0_101) AT=280.025n

.meas tran vdout0_102ck550 FIND v(dout0_102) AT=280.025n

.meas tran vdout0_103ck550 FIND v(dout0_103) AT=280.025n

.meas tran vdout0_104ck550 FIND v(dout0_104) AT=280.025n

.meas tran vdout0_105ck550 FIND v(dout0_105) AT=280.025n

.meas tran vdout0_106ck550 FIND v(dout0_106) AT=280.025n

.meas tran vdout0_107ck550 FIND v(dout0_107) AT=280.025n

.meas tran vdout0_108ck550 FIND v(dout0_108) AT=280.025n

.meas tran vdout0_109ck550 FIND v(dout0_109) AT=280.025n

.meas tran vdout0_110ck550 FIND v(dout0_110) AT=280.025n

.meas tran vdout0_111ck550 FIND v(dout0_111) AT=280.025n

.meas tran vdout0_112ck550 FIND v(dout0_112) AT=280.025n

.meas tran vdout0_113ck550 FIND v(dout0_113) AT=280.025n

.meas tran vdout0_114ck550 FIND v(dout0_114) AT=280.025n

.meas tran vdout0_115ck550 FIND v(dout0_115) AT=280.025n

.meas tran vdout0_116ck550 FIND v(dout0_116) AT=280.025n

.meas tran vdout0_117ck550 FIND v(dout0_117) AT=280.025n

.meas tran vdout0_118ck550 FIND v(dout0_118) AT=280.025n

.meas tran vdout0_119ck550 FIND v(dout0_119) AT=280.025n

.meas tran vdout0_120ck550 FIND v(dout0_120) AT=280.025n

.meas tran vdout0_121ck550 FIND v(dout0_121) AT=280.025n

.meas tran vdout0_122ck550 FIND v(dout0_122) AT=280.025n

.meas tran vdout0_123ck550 FIND v(dout0_123) AT=280.025n

.meas tran vdout0_124ck550 FIND v(dout0_124) AT=280.025n

.meas tran vdout0_125ck550 FIND v(dout0_125) AT=280.025n

.meas tran vdout0_126ck550 FIND v(dout0_126) AT=280.025n

.meas tran vdout0_127ck550 FIND v(dout0_127) AT=280.025n

.meas tran vdout0_128ck550 FIND v(dout0_128) AT=280.025n

.meas tran vdout0_129ck550 FIND v(dout0_129) AT=280.025n

.meas tran vdout0_130ck550 FIND v(dout0_130) AT=280.025n

.meas tran vdout0_131ck550 FIND v(dout0_131) AT=280.025n

.meas tran vdout0_132ck550 FIND v(dout0_132) AT=280.025n

.meas tran vdout0_133ck550 FIND v(dout0_133) AT=280.025n

.meas tran vdout0_134ck550 FIND v(dout0_134) AT=280.025n

.meas tran vdout0_135ck550 FIND v(dout0_135) AT=280.025n

.meas tran vdout0_136ck550 FIND v(dout0_136) AT=280.025n

.meas tran vdout0_137ck550 FIND v(dout0_137) AT=280.025n

.meas tran vdout0_138ck550 FIND v(dout0_138) AT=280.025n

.meas tran vdout0_139ck550 FIND v(dout0_139) AT=280.025n

.meas tran vdout0_140ck550 FIND v(dout0_140) AT=280.025n

.meas tran vdout0_141ck550 FIND v(dout0_141) AT=280.025n

.meas tran vdout0_142ck550 FIND v(dout0_142) AT=280.025n

.meas tran vdout0_143ck550 FIND v(dout0_143) AT=280.025n

.meas tran vdout0_144ck550 FIND v(dout0_144) AT=280.025n

.meas tran vdout0_145ck550 FIND v(dout0_145) AT=280.025n

.meas tran vdout0_146ck550 FIND v(dout0_146) AT=280.025n

.meas tran vdout0_147ck550 FIND v(dout0_147) AT=280.025n

.meas tran vdout0_148ck550 FIND v(dout0_148) AT=280.025n

.meas tran vdout0_149ck550 FIND v(dout0_149) AT=280.025n

.meas tran vdout0_150ck550 FIND v(dout0_150) AT=280.025n

.meas tran vdout0_151ck550 FIND v(dout0_151) AT=280.025n

.meas tran vdout0_152ck550 FIND v(dout0_152) AT=280.025n

.meas tran vdout0_153ck550 FIND v(dout0_153) AT=280.025n

.meas tran vdout0_154ck550 FIND v(dout0_154) AT=280.025n

.meas tran vdout0_155ck550 FIND v(dout0_155) AT=280.025n

.meas tran vdout0_156ck550 FIND v(dout0_156) AT=280.025n

.meas tran vdout0_157ck550 FIND v(dout0_157) AT=280.025n

.meas tran vdout0_158ck550 FIND v(dout0_158) AT=280.025n

.meas tran vdout0_159ck550 FIND v(dout0_159) AT=280.025n

.meas tran vdout0_160ck550 FIND v(dout0_160) AT=280.025n

.meas tran vdout0_161ck550 FIND v(dout0_161) AT=280.025n

.meas tran vdout0_162ck550 FIND v(dout0_162) AT=280.025n

.meas tran vdout0_163ck550 FIND v(dout0_163) AT=280.025n

.meas tran vdout0_164ck550 FIND v(dout0_164) AT=280.025n

.meas tran vdout0_165ck550 FIND v(dout0_165) AT=280.025n

.meas tran vdout0_166ck550 FIND v(dout0_166) AT=280.025n

.meas tran vdout0_167ck550 FIND v(dout0_167) AT=280.025n

.meas tran vdout0_168ck550 FIND v(dout0_168) AT=280.025n

.meas tran vdout0_169ck550 FIND v(dout0_169) AT=280.025n

.meas tran vdout0_170ck550 FIND v(dout0_170) AT=280.025n

.meas tran vdout0_171ck550 FIND v(dout0_171) AT=280.025n

.meas tran vdout0_172ck550 FIND v(dout0_172) AT=280.025n

.meas tran vdout0_173ck550 FIND v(dout0_173) AT=280.025n

.meas tran vdout0_174ck550 FIND v(dout0_174) AT=280.025n

.meas tran vdout0_175ck550 FIND v(dout0_175) AT=280.025n

.meas tran vdout0_176ck550 FIND v(dout0_176) AT=280.025n

.meas tran vdout0_177ck550 FIND v(dout0_177) AT=280.025n

.meas tran vdout0_178ck550 FIND v(dout0_178) AT=280.025n

.meas tran vdout0_179ck550 FIND v(dout0_179) AT=280.025n

.meas tran vdout0_180ck550 FIND v(dout0_180) AT=280.025n

.meas tran vdout0_181ck550 FIND v(dout0_181) AT=280.025n

.meas tran vdout0_182ck550 FIND v(dout0_182) AT=280.025n

.meas tran vdout0_183ck550 FIND v(dout0_183) AT=280.025n

.meas tran vdout0_184ck550 FIND v(dout0_184) AT=280.025n

.meas tran vdout0_185ck550 FIND v(dout0_185) AT=280.025n

.meas tran vdout0_186ck550 FIND v(dout0_186) AT=280.025n

.meas tran vdout0_187ck550 FIND v(dout0_187) AT=280.025n

.meas tran vdout0_188ck550 FIND v(dout0_188) AT=280.025n

.meas tran vdout0_189ck550 FIND v(dout0_189) AT=280.025n

.meas tran vdout0_190ck550 FIND v(dout0_190) AT=280.025n

.meas tran vdout0_191ck550 FIND v(dout0_191) AT=280.025n

.meas tran vdout0_192ck550 FIND v(dout0_192) AT=280.025n

.meas tran vdout0_193ck550 FIND v(dout0_193) AT=280.025n

.meas tran vdout0_194ck550 FIND v(dout0_194) AT=280.025n

.meas tran vdout0_195ck550 FIND v(dout0_195) AT=280.025n

.meas tran vdout0_196ck550 FIND v(dout0_196) AT=280.025n

.meas tran vdout0_197ck550 FIND v(dout0_197) AT=280.025n

.meas tran vdout0_198ck550 FIND v(dout0_198) AT=280.025n

.meas tran vdout0_199ck550 FIND v(dout0_199) AT=280.025n

.meas tran vdout0_200ck550 FIND v(dout0_200) AT=280.025n

.meas tran vdout0_201ck550 FIND v(dout0_201) AT=280.025n

.meas tran vdout0_202ck550 FIND v(dout0_202) AT=280.025n

.meas tran vdout0_203ck550 FIND v(dout0_203) AT=280.025n

.meas tran vdout0_204ck550 FIND v(dout0_204) AT=280.025n

.meas tran vdout0_205ck550 FIND v(dout0_205) AT=280.025n

.meas tran vdout0_206ck550 FIND v(dout0_206) AT=280.025n

.meas tran vdout0_207ck550 FIND v(dout0_207) AT=280.025n

.meas tran vdout0_208ck550 FIND v(dout0_208) AT=280.025n

.meas tran vdout0_209ck550 FIND v(dout0_209) AT=280.025n

.meas tran vdout0_210ck550 FIND v(dout0_210) AT=280.025n

.meas tran vdout0_211ck550 FIND v(dout0_211) AT=280.025n

.meas tran vdout0_212ck550 FIND v(dout0_212) AT=280.025n

.meas tran vdout0_213ck550 FIND v(dout0_213) AT=280.025n

.meas tran vdout0_214ck550 FIND v(dout0_214) AT=280.025n

.meas tran vdout0_215ck550 FIND v(dout0_215) AT=280.025n

.meas tran vdout0_216ck550 FIND v(dout0_216) AT=280.025n

.meas tran vdout0_217ck550 FIND v(dout0_217) AT=280.025n

.meas tran vdout0_218ck550 FIND v(dout0_218) AT=280.025n

.meas tran vdout0_219ck550 FIND v(dout0_219) AT=280.025n

.meas tran vdout0_220ck550 FIND v(dout0_220) AT=280.025n

.meas tran vdout0_221ck550 FIND v(dout0_221) AT=280.025n

.meas tran vdout0_222ck550 FIND v(dout0_222) AT=280.025n

.meas tran vdout0_223ck550 FIND v(dout0_223) AT=280.025n

.meas tran vdout0_224ck550 FIND v(dout0_224) AT=280.025n

.meas tran vdout0_225ck550 FIND v(dout0_225) AT=280.025n

.meas tran vdout0_226ck550 FIND v(dout0_226) AT=280.025n

.meas tran vdout0_227ck550 FIND v(dout0_227) AT=280.025n

.meas tran vdout0_228ck550 FIND v(dout0_228) AT=280.025n

.meas tran vdout0_229ck550 FIND v(dout0_229) AT=280.025n

.meas tran vdout0_230ck550 FIND v(dout0_230) AT=280.025n

.meas tran vdout0_231ck550 FIND v(dout0_231) AT=280.025n

.meas tran vdout0_232ck550 FIND v(dout0_232) AT=280.025n

.meas tran vdout0_233ck550 FIND v(dout0_233) AT=280.025n

.meas tran vdout0_234ck550 FIND v(dout0_234) AT=280.025n

.meas tran vdout0_235ck550 FIND v(dout0_235) AT=280.025n

.meas tran vdout0_236ck550 FIND v(dout0_236) AT=280.025n

.meas tran vdout0_237ck550 FIND v(dout0_237) AT=280.025n

.meas tran vdout0_238ck550 FIND v(dout0_238) AT=280.025n

.meas tran vdout0_239ck550 FIND v(dout0_239) AT=280.025n

.meas tran vdout0_240ck550 FIND v(dout0_240) AT=280.025n

.meas tran vdout0_241ck550 FIND v(dout0_241) AT=280.025n

.meas tran vdout0_242ck550 FIND v(dout0_242) AT=280.025n

.meas tran vdout0_243ck550 FIND v(dout0_243) AT=280.025n

.meas tran vdout0_244ck550 FIND v(dout0_244) AT=280.025n

.meas tran vdout0_245ck550 FIND v(dout0_245) AT=280.025n

.meas tran vdout0_246ck550 FIND v(dout0_246) AT=280.025n

.meas tran vdout0_247ck550 FIND v(dout0_247) AT=280.025n

.meas tran vdout0_248ck550 FIND v(dout0_248) AT=280.025n

.meas tran vdout0_249ck550 FIND v(dout0_249) AT=280.025n

.meas tran vdout0_250ck550 FIND v(dout0_250) AT=280.025n

.meas tran vdout0_251ck550 FIND v(dout0_251) AT=280.025n

.meas tran vdout0_252ck550 FIND v(dout0_252) AT=280.025n

.meas tran vdout0_253ck550 FIND v(dout0_253) AT=280.025n

.meas tran vdout0_254ck550 FIND v(dout0_254) AT=280.025n

.meas tran vdout0_255ck550 FIND v(dout0_255) AT=280.025n

.meas tran vdout0_0ck580 FIND v(dout0_0) AT=295.025n

.meas tran vdout0_1ck580 FIND v(dout0_1) AT=295.025n

.meas tran vdout0_2ck580 FIND v(dout0_2) AT=295.025n

.meas tran vdout0_3ck580 FIND v(dout0_3) AT=295.025n

.meas tran vdout0_4ck580 FIND v(dout0_4) AT=295.025n

.meas tran vdout0_5ck580 FIND v(dout0_5) AT=295.025n

.meas tran vdout0_6ck580 FIND v(dout0_6) AT=295.025n

.meas tran vdout0_7ck580 FIND v(dout0_7) AT=295.025n

.meas tran vdout0_8ck580 FIND v(dout0_8) AT=295.025n

.meas tran vdout0_9ck580 FIND v(dout0_9) AT=295.025n

.meas tran vdout0_10ck580 FIND v(dout0_10) AT=295.025n

.meas tran vdout0_11ck580 FIND v(dout0_11) AT=295.025n

.meas tran vdout0_12ck580 FIND v(dout0_12) AT=295.025n

.meas tran vdout0_13ck580 FIND v(dout0_13) AT=295.025n

.meas tran vdout0_14ck580 FIND v(dout0_14) AT=295.025n

.meas tran vdout0_15ck580 FIND v(dout0_15) AT=295.025n

.meas tran vdout0_16ck580 FIND v(dout0_16) AT=295.025n

.meas tran vdout0_17ck580 FIND v(dout0_17) AT=295.025n

.meas tran vdout0_18ck580 FIND v(dout0_18) AT=295.025n

.meas tran vdout0_19ck580 FIND v(dout0_19) AT=295.025n

.meas tran vdout0_20ck580 FIND v(dout0_20) AT=295.025n

.meas tran vdout0_21ck580 FIND v(dout0_21) AT=295.025n

.meas tran vdout0_22ck580 FIND v(dout0_22) AT=295.025n

.meas tran vdout0_23ck580 FIND v(dout0_23) AT=295.025n

.meas tran vdout0_24ck580 FIND v(dout0_24) AT=295.025n

.meas tran vdout0_25ck580 FIND v(dout0_25) AT=295.025n

.meas tran vdout0_26ck580 FIND v(dout0_26) AT=295.025n

.meas tran vdout0_27ck580 FIND v(dout0_27) AT=295.025n

.meas tran vdout0_28ck580 FIND v(dout0_28) AT=295.025n

.meas tran vdout0_29ck580 FIND v(dout0_29) AT=295.025n

.meas tran vdout0_30ck580 FIND v(dout0_30) AT=295.025n

.meas tran vdout0_31ck580 FIND v(dout0_31) AT=295.025n

.meas tran vdout0_32ck580 FIND v(dout0_32) AT=295.025n

.meas tran vdout0_33ck580 FIND v(dout0_33) AT=295.025n

.meas tran vdout0_34ck580 FIND v(dout0_34) AT=295.025n

.meas tran vdout0_35ck580 FIND v(dout0_35) AT=295.025n

.meas tran vdout0_36ck580 FIND v(dout0_36) AT=295.025n

.meas tran vdout0_37ck580 FIND v(dout0_37) AT=295.025n

.meas tran vdout0_38ck580 FIND v(dout0_38) AT=295.025n

.meas tran vdout0_39ck580 FIND v(dout0_39) AT=295.025n

.meas tran vdout0_40ck580 FIND v(dout0_40) AT=295.025n

.meas tran vdout0_41ck580 FIND v(dout0_41) AT=295.025n

.meas tran vdout0_42ck580 FIND v(dout0_42) AT=295.025n

.meas tran vdout0_43ck580 FIND v(dout0_43) AT=295.025n

.meas tran vdout0_44ck580 FIND v(dout0_44) AT=295.025n

.meas tran vdout0_45ck580 FIND v(dout0_45) AT=295.025n

.meas tran vdout0_46ck580 FIND v(dout0_46) AT=295.025n

.meas tran vdout0_47ck580 FIND v(dout0_47) AT=295.025n

.meas tran vdout0_48ck580 FIND v(dout0_48) AT=295.025n

.meas tran vdout0_49ck580 FIND v(dout0_49) AT=295.025n

.meas tran vdout0_50ck580 FIND v(dout0_50) AT=295.025n

.meas tran vdout0_51ck580 FIND v(dout0_51) AT=295.025n

.meas tran vdout0_52ck580 FIND v(dout0_52) AT=295.025n

.meas tran vdout0_53ck580 FIND v(dout0_53) AT=295.025n

.meas tran vdout0_54ck580 FIND v(dout0_54) AT=295.025n

.meas tran vdout0_55ck580 FIND v(dout0_55) AT=295.025n

.meas tran vdout0_56ck580 FIND v(dout0_56) AT=295.025n

.meas tran vdout0_57ck580 FIND v(dout0_57) AT=295.025n

.meas tran vdout0_58ck580 FIND v(dout0_58) AT=295.025n

.meas tran vdout0_59ck580 FIND v(dout0_59) AT=295.025n

.meas tran vdout0_60ck580 FIND v(dout0_60) AT=295.025n

.meas tran vdout0_61ck580 FIND v(dout0_61) AT=295.025n

.meas tran vdout0_62ck580 FIND v(dout0_62) AT=295.025n

.meas tran vdout0_63ck580 FIND v(dout0_63) AT=295.025n

.meas tran vdout0_64ck580 FIND v(dout0_64) AT=295.025n

.meas tran vdout0_65ck580 FIND v(dout0_65) AT=295.025n

.meas tran vdout0_66ck580 FIND v(dout0_66) AT=295.025n

.meas tran vdout0_67ck580 FIND v(dout0_67) AT=295.025n

.meas tran vdout0_68ck580 FIND v(dout0_68) AT=295.025n

.meas tran vdout0_69ck580 FIND v(dout0_69) AT=295.025n

.meas tran vdout0_70ck580 FIND v(dout0_70) AT=295.025n

.meas tran vdout0_71ck580 FIND v(dout0_71) AT=295.025n

.meas tran vdout0_72ck580 FIND v(dout0_72) AT=295.025n

.meas tran vdout0_73ck580 FIND v(dout0_73) AT=295.025n

.meas tran vdout0_74ck580 FIND v(dout0_74) AT=295.025n

.meas tran vdout0_75ck580 FIND v(dout0_75) AT=295.025n

.meas tran vdout0_76ck580 FIND v(dout0_76) AT=295.025n

.meas tran vdout0_77ck580 FIND v(dout0_77) AT=295.025n

.meas tran vdout0_78ck580 FIND v(dout0_78) AT=295.025n

.meas tran vdout0_79ck580 FIND v(dout0_79) AT=295.025n

.meas tran vdout0_80ck580 FIND v(dout0_80) AT=295.025n

.meas tran vdout0_81ck580 FIND v(dout0_81) AT=295.025n

.meas tran vdout0_82ck580 FIND v(dout0_82) AT=295.025n

.meas tran vdout0_83ck580 FIND v(dout0_83) AT=295.025n

.meas tran vdout0_84ck580 FIND v(dout0_84) AT=295.025n

.meas tran vdout0_85ck580 FIND v(dout0_85) AT=295.025n

.meas tran vdout0_86ck580 FIND v(dout0_86) AT=295.025n

.meas tran vdout0_87ck580 FIND v(dout0_87) AT=295.025n

.meas tran vdout0_88ck580 FIND v(dout0_88) AT=295.025n

.meas tran vdout0_89ck580 FIND v(dout0_89) AT=295.025n

.meas tran vdout0_90ck580 FIND v(dout0_90) AT=295.025n

.meas tran vdout0_91ck580 FIND v(dout0_91) AT=295.025n

.meas tran vdout0_92ck580 FIND v(dout0_92) AT=295.025n

.meas tran vdout0_93ck580 FIND v(dout0_93) AT=295.025n

.meas tran vdout0_94ck580 FIND v(dout0_94) AT=295.025n

.meas tran vdout0_95ck580 FIND v(dout0_95) AT=295.025n

.meas tran vdout0_96ck580 FIND v(dout0_96) AT=295.025n

.meas tran vdout0_97ck580 FIND v(dout0_97) AT=295.025n

.meas tran vdout0_98ck580 FIND v(dout0_98) AT=295.025n

.meas tran vdout0_99ck580 FIND v(dout0_99) AT=295.025n

.meas tran vdout0_100ck580 FIND v(dout0_100) AT=295.025n

.meas tran vdout0_101ck580 FIND v(dout0_101) AT=295.025n

.meas tran vdout0_102ck580 FIND v(dout0_102) AT=295.025n

.meas tran vdout0_103ck580 FIND v(dout0_103) AT=295.025n

.meas tran vdout0_104ck580 FIND v(dout0_104) AT=295.025n

.meas tran vdout0_105ck580 FIND v(dout0_105) AT=295.025n

.meas tran vdout0_106ck580 FIND v(dout0_106) AT=295.025n

.meas tran vdout0_107ck580 FIND v(dout0_107) AT=295.025n

.meas tran vdout0_108ck580 FIND v(dout0_108) AT=295.025n

.meas tran vdout0_109ck580 FIND v(dout0_109) AT=295.025n

.meas tran vdout0_110ck580 FIND v(dout0_110) AT=295.025n

.meas tran vdout0_111ck580 FIND v(dout0_111) AT=295.025n

.meas tran vdout0_112ck580 FIND v(dout0_112) AT=295.025n

.meas tran vdout0_113ck580 FIND v(dout0_113) AT=295.025n

.meas tran vdout0_114ck580 FIND v(dout0_114) AT=295.025n

.meas tran vdout0_115ck580 FIND v(dout0_115) AT=295.025n

.meas tran vdout0_116ck580 FIND v(dout0_116) AT=295.025n

.meas tran vdout0_117ck580 FIND v(dout0_117) AT=295.025n

.meas tran vdout0_118ck580 FIND v(dout0_118) AT=295.025n

.meas tran vdout0_119ck580 FIND v(dout0_119) AT=295.025n

.meas tran vdout0_120ck580 FIND v(dout0_120) AT=295.025n

.meas tran vdout0_121ck580 FIND v(dout0_121) AT=295.025n

.meas tran vdout0_122ck580 FIND v(dout0_122) AT=295.025n

.meas tran vdout0_123ck580 FIND v(dout0_123) AT=295.025n

.meas tran vdout0_124ck580 FIND v(dout0_124) AT=295.025n

.meas tran vdout0_125ck580 FIND v(dout0_125) AT=295.025n

.meas tran vdout0_126ck580 FIND v(dout0_126) AT=295.025n

.meas tran vdout0_127ck580 FIND v(dout0_127) AT=295.025n

.meas tran vdout0_128ck580 FIND v(dout0_128) AT=295.025n

.meas tran vdout0_129ck580 FIND v(dout0_129) AT=295.025n

.meas tran vdout0_130ck580 FIND v(dout0_130) AT=295.025n

.meas tran vdout0_131ck580 FIND v(dout0_131) AT=295.025n

.meas tran vdout0_132ck580 FIND v(dout0_132) AT=295.025n

.meas tran vdout0_133ck580 FIND v(dout0_133) AT=295.025n

.meas tran vdout0_134ck580 FIND v(dout0_134) AT=295.025n

.meas tran vdout0_135ck580 FIND v(dout0_135) AT=295.025n

.meas tran vdout0_136ck580 FIND v(dout0_136) AT=295.025n

.meas tran vdout0_137ck580 FIND v(dout0_137) AT=295.025n

.meas tran vdout0_138ck580 FIND v(dout0_138) AT=295.025n

.meas tran vdout0_139ck580 FIND v(dout0_139) AT=295.025n

.meas tran vdout0_140ck580 FIND v(dout0_140) AT=295.025n

.meas tran vdout0_141ck580 FIND v(dout0_141) AT=295.025n

.meas tran vdout0_142ck580 FIND v(dout0_142) AT=295.025n

.meas tran vdout0_143ck580 FIND v(dout0_143) AT=295.025n

.meas tran vdout0_144ck580 FIND v(dout0_144) AT=295.025n

.meas tran vdout0_145ck580 FIND v(dout0_145) AT=295.025n

.meas tran vdout0_146ck580 FIND v(dout0_146) AT=295.025n

.meas tran vdout0_147ck580 FIND v(dout0_147) AT=295.025n

.meas tran vdout0_148ck580 FIND v(dout0_148) AT=295.025n

.meas tran vdout0_149ck580 FIND v(dout0_149) AT=295.025n

.meas tran vdout0_150ck580 FIND v(dout0_150) AT=295.025n

.meas tran vdout0_151ck580 FIND v(dout0_151) AT=295.025n

.meas tran vdout0_152ck580 FIND v(dout0_152) AT=295.025n

.meas tran vdout0_153ck580 FIND v(dout0_153) AT=295.025n

.meas tran vdout0_154ck580 FIND v(dout0_154) AT=295.025n

.meas tran vdout0_155ck580 FIND v(dout0_155) AT=295.025n

.meas tran vdout0_156ck580 FIND v(dout0_156) AT=295.025n

.meas tran vdout0_157ck580 FIND v(dout0_157) AT=295.025n

.meas tran vdout0_158ck580 FIND v(dout0_158) AT=295.025n

.meas tran vdout0_159ck580 FIND v(dout0_159) AT=295.025n

.meas tran vdout0_160ck580 FIND v(dout0_160) AT=295.025n

.meas tran vdout0_161ck580 FIND v(dout0_161) AT=295.025n

.meas tran vdout0_162ck580 FIND v(dout0_162) AT=295.025n

.meas tran vdout0_163ck580 FIND v(dout0_163) AT=295.025n

.meas tran vdout0_164ck580 FIND v(dout0_164) AT=295.025n

.meas tran vdout0_165ck580 FIND v(dout0_165) AT=295.025n

.meas tran vdout0_166ck580 FIND v(dout0_166) AT=295.025n

.meas tran vdout0_167ck580 FIND v(dout0_167) AT=295.025n

.meas tran vdout0_168ck580 FIND v(dout0_168) AT=295.025n

.meas tran vdout0_169ck580 FIND v(dout0_169) AT=295.025n

.meas tran vdout0_170ck580 FIND v(dout0_170) AT=295.025n

.meas tran vdout0_171ck580 FIND v(dout0_171) AT=295.025n

.meas tran vdout0_172ck580 FIND v(dout0_172) AT=295.025n

.meas tran vdout0_173ck580 FIND v(dout0_173) AT=295.025n

.meas tran vdout0_174ck580 FIND v(dout0_174) AT=295.025n

.meas tran vdout0_175ck580 FIND v(dout0_175) AT=295.025n

.meas tran vdout0_176ck580 FIND v(dout0_176) AT=295.025n

.meas tran vdout0_177ck580 FIND v(dout0_177) AT=295.025n

.meas tran vdout0_178ck580 FIND v(dout0_178) AT=295.025n

.meas tran vdout0_179ck580 FIND v(dout0_179) AT=295.025n

.meas tran vdout0_180ck580 FIND v(dout0_180) AT=295.025n

.meas tran vdout0_181ck580 FIND v(dout0_181) AT=295.025n

.meas tran vdout0_182ck580 FIND v(dout0_182) AT=295.025n

.meas tran vdout0_183ck580 FIND v(dout0_183) AT=295.025n

.meas tran vdout0_184ck580 FIND v(dout0_184) AT=295.025n

.meas tran vdout0_185ck580 FIND v(dout0_185) AT=295.025n

.meas tran vdout0_186ck580 FIND v(dout0_186) AT=295.025n

.meas tran vdout0_187ck580 FIND v(dout0_187) AT=295.025n

.meas tran vdout0_188ck580 FIND v(dout0_188) AT=295.025n

.meas tran vdout0_189ck580 FIND v(dout0_189) AT=295.025n

.meas tran vdout0_190ck580 FIND v(dout0_190) AT=295.025n

.meas tran vdout0_191ck580 FIND v(dout0_191) AT=295.025n

.meas tran vdout0_192ck580 FIND v(dout0_192) AT=295.025n

.meas tran vdout0_193ck580 FIND v(dout0_193) AT=295.025n

.meas tran vdout0_194ck580 FIND v(dout0_194) AT=295.025n

.meas tran vdout0_195ck580 FIND v(dout0_195) AT=295.025n

.meas tran vdout0_196ck580 FIND v(dout0_196) AT=295.025n

.meas tran vdout0_197ck580 FIND v(dout0_197) AT=295.025n

.meas tran vdout0_198ck580 FIND v(dout0_198) AT=295.025n

.meas tran vdout0_199ck580 FIND v(dout0_199) AT=295.025n

.meas tran vdout0_200ck580 FIND v(dout0_200) AT=295.025n

.meas tran vdout0_201ck580 FIND v(dout0_201) AT=295.025n

.meas tran vdout0_202ck580 FIND v(dout0_202) AT=295.025n

.meas tran vdout0_203ck580 FIND v(dout0_203) AT=295.025n

.meas tran vdout0_204ck580 FIND v(dout0_204) AT=295.025n

.meas tran vdout0_205ck580 FIND v(dout0_205) AT=295.025n

.meas tran vdout0_206ck580 FIND v(dout0_206) AT=295.025n

.meas tran vdout0_207ck580 FIND v(dout0_207) AT=295.025n

.meas tran vdout0_208ck580 FIND v(dout0_208) AT=295.025n

.meas tran vdout0_209ck580 FIND v(dout0_209) AT=295.025n

.meas tran vdout0_210ck580 FIND v(dout0_210) AT=295.025n

.meas tran vdout0_211ck580 FIND v(dout0_211) AT=295.025n

.meas tran vdout0_212ck580 FIND v(dout0_212) AT=295.025n

.meas tran vdout0_213ck580 FIND v(dout0_213) AT=295.025n

.meas tran vdout0_214ck580 FIND v(dout0_214) AT=295.025n

.meas tran vdout0_215ck580 FIND v(dout0_215) AT=295.025n

.meas tran vdout0_216ck580 FIND v(dout0_216) AT=295.025n

.meas tran vdout0_217ck580 FIND v(dout0_217) AT=295.025n

.meas tran vdout0_218ck580 FIND v(dout0_218) AT=295.025n

.meas tran vdout0_219ck580 FIND v(dout0_219) AT=295.025n

.meas tran vdout0_220ck580 FIND v(dout0_220) AT=295.025n

.meas tran vdout0_221ck580 FIND v(dout0_221) AT=295.025n

.meas tran vdout0_222ck580 FIND v(dout0_222) AT=295.025n

.meas tran vdout0_223ck580 FIND v(dout0_223) AT=295.025n

.meas tran vdout0_224ck580 FIND v(dout0_224) AT=295.025n

.meas tran vdout0_225ck580 FIND v(dout0_225) AT=295.025n

.meas tran vdout0_226ck580 FIND v(dout0_226) AT=295.025n

.meas tran vdout0_227ck580 FIND v(dout0_227) AT=295.025n

.meas tran vdout0_228ck580 FIND v(dout0_228) AT=295.025n

.meas tran vdout0_229ck580 FIND v(dout0_229) AT=295.025n

.meas tran vdout0_230ck580 FIND v(dout0_230) AT=295.025n

.meas tran vdout0_231ck580 FIND v(dout0_231) AT=295.025n

.meas tran vdout0_232ck580 FIND v(dout0_232) AT=295.025n

.meas tran vdout0_233ck580 FIND v(dout0_233) AT=295.025n

.meas tran vdout0_234ck580 FIND v(dout0_234) AT=295.025n

.meas tran vdout0_235ck580 FIND v(dout0_235) AT=295.025n

.meas tran vdout0_236ck580 FIND v(dout0_236) AT=295.025n

.meas tran vdout0_237ck580 FIND v(dout0_237) AT=295.025n

.meas tran vdout0_238ck580 FIND v(dout0_238) AT=295.025n

.meas tran vdout0_239ck580 FIND v(dout0_239) AT=295.025n

.meas tran vdout0_240ck580 FIND v(dout0_240) AT=295.025n

.meas tran vdout0_241ck580 FIND v(dout0_241) AT=295.025n

.meas tran vdout0_242ck580 FIND v(dout0_242) AT=295.025n

.meas tran vdout0_243ck580 FIND v(dout0_243) AT=295.025n

.meas tran vdout0_244ck580 FIND v(dout0_244) AT=295.025n

.meas tran vdout0_245ck580 FIND v(dout0_245) AT=295.025n

.meas tran vdout0_246ck580 FIND v(dout0_246) AT=295.025n

.meas tran vdout0_247ck580 FIND v(dout0_247) AT=295.025n

.meas tran vdout0_248ck580 FIND v(dout0_248) AT=295.025n

.meas tran vdout0_249ck580 FIND v(dout0_249) AT=295.025n

.meas tran vdout0_250ck580 FIND v(dout0_250) AT=295.025n

.meas tran vdout0_251ck580 FIND v(dout0_251) AT=295.025n

.meas tran vdout0_252ck580 FIND v(dout0_252) AT=295.025n

.meas tran vdout0_253ck580 FIND v(dout0_253) AT=295.025n

.meas tran vdout0_254ck580 FIND v(dout0_254) AT=295.025n

.meas tran vdout0_255ck580 FIND v(dout0_255) AT=295.025n

.meas tran vdout0_0ck610 FIND v(dout0_0) AT=310.025n

.meas tran vdout0_1ck610 FIND v(dout0_1) AT=310.025n

.meas tran vdout0_2ck610 FIND v(dout0_2) AT=310.025n

.meas tran vdout0_3ck610 FIND v(dout0_3) AT=310.025n

.meas tran vdout0_4ck610 FIND v(dout0_4) AT=310.025n

.meas tran vdout0_5ck610 FIND v(dout0_5) AT=310.025n

.meas tran vdout0_6ck610 FIND v(dout0_6) AT=310.025n

.meas tran vdout0_7ck610 FIND v(dout0_7) AT=310.025n

.meas tran vdout0_8ck610 FIND v(dout0_8) AT=310.025n

.meas tran vdout0_9ck610 FIND v(dout0_9) AT=310.025n

.meas tran vdout0_10ck610 FIND v(dout0_10) AT=310.025n

.meas tran vdout0_11ck610 FIND v(dout0_11) AT=310.025n

.meas tran vdout0_12ck610 FIND v(dout0_12) AT=310.025n

.meas tran vdout0_13ck610 FIND v(dout0_13) AT=310.025n

.meas tran vdout0_14ck610 FIND v(dout0_14) AT=310.025n

.meas tran vdout0_15ck610 FIND v(dout0_15) AT=310.025n

.meas tran vdout0_16ck610 FIND v(dout0_16) AT=310.025n

.meas tran vdout0_17ck610 FIND v(dout0_17) AT=310.025n

.meas tran vdout0_18ck610 FIND v(dout0_18) AT=310.025n

.meas tran vdout0_19ck610 FIND v(dout0_19) AT=310.025n

.meas tran vdout0_20ck610 FIND v(dout0_20) AT=310.025n

.meas tran vdout0_21ck610 FIND v(dout0_21) AT=310.025n

.meas tran vdout0_22ck610 FIND v(dout0_22) AT=310.025n

.meas tran vdout0_23ck610 FIND v(dout0_23) AT=310.025n

.meas tran vdout0_24ck610 FIND v(dout0_24) AT=310.025n

.meas tran vdout0_25ck610 FIND v(dout0_25) AT=310.025n

.meas tran vdout0_26ck610 FIND v(dout0_26) AT=310.025n

.meas tran vdout0_27ck610 FIND v(dout0_27) AT=310.025n

.meas tran vdout0_28ck610 FIND v(dout0_28) AT=310.025n

.meas tran vdout0_29ck610 FIND v(dout0_29) AT=310.025n

.meas tran vdout0_30ck610 FIND v(dout0_30) AT=310.025n

.meas tran vdout0_31ck610 FIND v(dout0_31) AT=310.025n

.meas tran vdout0_32ck610 FIND v(dout0_32) AT=310.025n

.meas tran vdout0_33ck610 FIND v(dout0_33) AT=310.025n

.meas tran vdout0_34ck610 FIND v(dout0_34) AT=310.025n

.meas tran vdout0_35ck610 FIND v(dout0_35) AT=310.025n

.meas tran vdout0_36ck610 FIND v(dout0_36) AT=310.025n

.meas tran vdout0_37ck610 FIND v(dout0_37) AT=310.025n

.meas tran vdout0_38ck610 FIND v(dout0_38) AT=310.025n

.meas tran vdout0_39ck610 FIND v(dout0_39) AT=310.025n

.meas tran vdout0_40ck610 FIND v(dout0_40) AT=310.025n

.meas tran vdout0_41ck610 FIND v(dout0_41) AT=310.025n

.meas tran vdout0_42ck610 FIND v(dout0_42) AT=310.025n

.meas tran vdout0_43ck610 FIND v(dout0_43) AT=310.025n

.meas tran vdout0_44ck610 FIND v(dout0_44) AT=310.025n

.meas tran vdout0_45ck610 FIND v(dout0_45) AT=310.025n

.meas tran vdout0_46ck610 FIND v(dout0_46) AT=310.025n

.meas tran vdout0_47ck610 FIND v(dout0_47) AT=310.025n

.meas tran vdout0_48ck610 FIND v(dout0_48) AT=310.025n

.meas tran vdout0_49ck610 FIND v(dout0_49) AT=310.025n

.meas tran vdout0_50ck610 FIND v(dout0_50) AT=310.025n

.meas tran vdout0_51ck610 FIND v(dout0_51) AT=310.025n

.meas tran vdout0_52ck610 FIND v(dout0_52) AT=310.025n

.meas tran vdout0_53ck610 FIND v(dout0_53) AT=310.025n

.meas tran vdout0_54ck610 FIND v(dout0_54) AT=310.025n

.meas tran vdout0_55ck610 FIND v(dout0_55) AT=310.025n

.meas tran vdout0_56ck610 FIND v(dout0_56) AT=310.025n

.meas tran vdout0_57ck610 FIND v(dout0_57) AT=310.025n

.meas tran vdout0_58ck610 FIND v(dout0_58) AT=310.025n

.meas tran vdout0_59ck610 FIND v(dout0_59) AT=310.025n

.meas tran vdout0_60ck610 FIND v(dout0_60) AT=310.025n

.meas tran vdout0_61ck610 FIND v(dout0_61) AT=310.025n

.meas tran vdout0_62ck610 FIND v(dout0_62) AT=310.025n

.meas tran vdout0_63ck610 FIND v(dout0_63) AT=310.025n

.meas tran vdout0_64ck610 FIND v(dout0_64) AT=310.025n

.meas tran vdout0_65ck610 FIND v(dout0_65) AT=310.025n

.meas tran vdout0_66ck610 FIND v(dout0_66) AT=310.025n

.meas tran vdout0_67ck610 FIND v(dout0_67) AT=310.025n

.meas tran vdout0_68ck610 FIND v(dout0_68) AT=310.025n

.meas tran vdout0_69ck610 FIND v(dout0_69) AT=310.025n

.meas tran vdout0_70ck610 FIND v(dout0_70) AT=310.025n

.meas tran vdout0_71ck610 FIND v(dout0_71) AT=310.025n

.meas tran vdout0_72ck610 FIND v(dout0_72) AT=310.025n

.meas tran vdout0_73ck610 FIND v(dout0_73) AT=310.025n

.meas tran vdout0_74ck610 FIND v(dout0_74) AT=310.025n

.meas tran vdout0_75ck610 FIND v(dout0_75) AT=310.025n

.meas tran vdout0_76ck610 FIND v(dout0_76) AT=310.025n

.meas tran vdout0_77ck610 FIND v(dout0_77) AT=310.025n

.meas tran vdout0_78ck610 FIND v(dout0_78) AT=310.025n

.meas tran vdout0_79ck610 FIND v(dout0_79) AT=310.025n

.meas tran vdout0_80ck610 FIND v(dout0_80) AT=310.025n

.meas tran vdout0_81ck610 FIND v(dout0_81) AT=310.025n

.meas tran vdout0_82ck610 FIND v(dout0_82) AT=310.025n

.meas tran vdout0_83ck610 FIND v(dout0_83) AT=310.025n

.meas tran vdout0_84ck610 FIND v(dout0_84) AT=310.025n

.meas tran vdout0_85ck610 FIND v(dout0_85) AT=310.025n

.meas tran vdout0_86ck610 FIND v(dout0_86) AT=310.025n

.meas tran vdout0_87ck610 FIND v(dout0_87) AT=310.025n

.meas tran vdout0_88ck610 FIND v(dout0_88) AT=310.025n

.meas tran vdout0_89ck610 FIND v(dout0_89) AT=310.025n

.meas tran vdout0_90ck610 FIND v(dout0_90) AT=310.025n

.meas tran vdout0_91ck610 FIND v(dout0_91) AT=310.025n

.meas tran vdout0_92ck610 FIND v(dout0_92) AT=310.025n

.meas tran vdout0_93ck610 FIND v(dout0_93) AT=310.025n

.meas tran vdout0_94ck610 FIND v(dout0_94) AT=310.025n

.meas tran vdout0_95ck610 FIND v(dout0_95) AT=310.025n

.meas tran vdout0_96ck610 FIND v(dout0_96) AT=310.025n

.meas tran vdout0_97ck610 FIND v(dout0_97) AT=310.025n

.meas tran vdout0_98ck610 FIND v(dout0_98) AT=310.025n

.meas tran vdout0_99ck610 FIND v(dout0_99) AT=310.025n

.meas tran vdout0_100ck610 FIND v(dout0_100) AT=310.025n

.meas tran vdout0_101ck610 FIND v(dout0_101) AT=310.025n

.meas tran vdout0_102ck610 FIND v(dout0_102) AT=310.025n

.meas tran vdout0_103ck610 FIND v(dout0_103) AT=310.025n

.meas tran vdout0_104ck610 FIND v(dout0_104) AT=310.025n

.meas tran vdout0_105ck610 FIND v(dout0_105) AT=310.025n

.meas tran vdout0_106ck610 FIND v(dout0_106) AT=310.025n

.meas tran vdout0_107ck610 FIND v(dout0_107) AT=310.025n

.meas tran vdout0_108ck610 FIND v(dout0_108) AT=310.025n

.meas tran vdout0_109ck610 FIND v(dout0_109) AT=310.025n

.meas tran vdout0_110ck610 FIND v(dout0_110) AT=310.025n

.meas tran vdout0_111ck610 FIND v(dout0_111) AT=310.025n

.meas tran vdout0_112ck610 FIND v(dout0_112) AT=310.025n

.meas tran vdout0_113ck610 FIND v(dout0_113) AT=310.025n

.meas tran vdout0_114ck610 FIND v(dout0_114) AT=310.025n

.meas tran vdout0_115ck610 FIND v(dout0_115) AT=310.025n

.meas tran vdout0_116ck610 FIND v(dout0_116) AT=310.025n

.meas tran vdout0_117ck610 FIND v(dout0_117) AT=310.025n

.meas tran vdout0_118ck610 FIND v(dout0_118) AT=310.025n

.meas tran vdout0_119ck610 FIND v(dout0_119) AT=310.025n

.meas tran vdout0_120ck610 FIND v(dout0_120) AT=310.025n

.meas tran vdout0_121ck610 FIND v(dout0_121) AT=310.025n

.meas tran vdout0_122ck610 FIND v(dout0_122) AT=310.025n

.meas tran vdout0_123ck610 FIND v(dout0_123) AT=310.025n

.meas tran vdout0_124ck610 FIND v(dout0_124) AT=310.025n

.meas tran vdout0_125ck610 FIND v(dout0_125) AT=310.025n

.meas tran vdout0_126ck610 FIND v(dout0_126) AT=310.025n

.meas tran vdout0_127ck610 FIND v(dout0_127) AT=310.025n

.meas tran vdout0_128ck610 FIND v(dout0_128) AT=310.025n

.meas tran vdout0_129ck610 FIND v(dout0_129) AT=310.025n

.meas tran vdout0_130ck610 FIND v(dout0_130) AT=310.025n

.meas tran vdout0_131ck610 FIND v(dout0_131) AT=310.025n

.meas tran vdout0_132ck610 FIND v(dout0_132) AT=310.025n

.meas tran vdout0_133ck610 FIND v(dout0_133) AT=310.025n

.meas tran vdout0_134ck610 FIND v(dout0_134) AT=310.025n

.meas tran vdout0_135ck610 FIND v(dout0_135) AT=310.025n

.meas tran vdout0_136ck610 FIND v(dout0_136) AT=310.025n

.meas tran vdout0_137ck610 FIND v(dout0_137) AT=310.025n

.meas tran vdout0_138ck610 FIND v(dout0_138) AT=310.025n

.meas tran vdout0_139ck610 FIND v(dout0_139) AT=310.025n

.meas tran vdout0_140ck610 FIND v(dout0_140) AT=310.025n

.meas tran vdout0_141ck610 FIND v(dout0_141) AT=310.025n

.meas tran vdout0_142ck610 FIND v(dout0_142) AT=310.025n

.meas tran vdout0_143ck610 FIND v(dout0_143) AT=310.025n

.meas tran vdout0_144ck610 FIND v(dout0_144) AT=310.025n

.meas tran vdout0_145ck610 FIND v(dout0_145) AT=310.025n

.meas tran vdout0_146ck610 FIND v(dout0_146) AT=310.025n

.meas tran vdout0_147ck610 FIND v(dout0_147) AT=310.025n

.meas tran vdout0_148ck610 FIND v(dout0_148) AT=310.025n

.meas tran vdout0_149ck610 FIND v(dout0_149) AT=310.025n

.meas tran vdout0_150ck610 FIND v(dout0_150) AT=310.025n

.meas tran vdout0_151ck610 FIND v(dout0_151) AT=310.025n

.meas tran vdout0_152ck610 FIND v(dout0_152) AT=310.025n

.meas tran vdout0_153ck610 FIND v(dout0_153) AT=310.025n

.meas tran vdout0_154ck610 FIND v(dout0_154) AT=310.025n

.meas tran vdout0_155ck610 FIND v(dout0_155) AT=310.025n

.meas tran vdout0_156ck610 FIND v(dout0_156) AT=310.025n

.meas tran vdout0_157ck610 FIND v(dout0_157) AT=310.025n

.meas tran vdout0_158ck610 FIND v(dout0_158) AT=310.025n

.meas tran vdout0_159ck610 FIND v(dout0_159) AT=310.025n

.meas tran vdout0_160ck610 FIND v(dout0_160) AT=310.025n

.meas tran vdout0_161ck610 FIND v(dout0_161) AT=310.025n

.meas tran vdout0_162ck610 FIND v(dout0_162) AT=310.025n

.meas tran vdout0_163ck610 FIND v(dout0_163) AT=310.025n

.meas tran vdout0_164ck610 FIND v(dout0_164) AT=310.025n

.meas tran vdout0_165ck610 FIND v(dout0_165) AT=310.025n

.meas tran vdout0_166ck610 FIND v(dout0_166) AT=310.025n

.meas tran vdout0_167ck610 FIND v(dout0_167) AT=310.025n

.meas tran vdout0_168ck610 FIND v(dout0_168) AT=310.025n

.meas tran vdout0_169ck610 FIND v(dout0_169) AT=310.025n

.meas tran vdout0_170ck610 FIND v(dout0_170) AT=310.025n

.meas tran vdout0_171ck610 FIND v(dout0_171) AT=310.025n

.meas tran vdout0_172ck610 FIND v(dout0_172) AT=310.025n

.meas tran vdout0_173ck610 FIND v(dout0_173) AT=310.025n

.meas tran vdout0_174ck610 FIND v(dout0_174) AT=310.025n

.meas tran vdout0_175ck610 FIND v(dout0_175) AT=310.025n

.meas tran vdout0_176ck610 FIND v(dout0_176) AT=310.025n

.meas tran vdout0_177ck610 FIND v(dout0_177) AT=310.025n

.meas tran vdout0_178ck610 FIND v(dout0_178) AT=310.025n

.meas tran vdout0_179ck610 FIND v(dout0_179) AT=310.025n

.meas tran vdout0_180ck610 FIND v(dout0_180) AT=310.025n

.meas tran vdout0_181ck610 FIND v(dout0_181) AT=310.025n

.meas tran vdout0_182ck610 FIND v(dout0_182) AT=310.025n

.meas tran vdout0_183ck610 FIND v(dout0_183) AT=310.025n

.meas tran vdout0_184ck610 FIND v(dout0_184) AT=310.025n

.meas tran vdout0_185ck610 FIND v(dout0_185) AT=310.025n

.meas tran vdout0_186ck610 FIND v(dout0_186) AT=310.025n

.meas tran vdout0_187ck610 FIND v(dout0_187) AT=310.025n

.meas tran vdout0_188ck610 FIND v(dout0_188) AT=310.025n

.meas tran vdout0_189ck610 FIND v(dout0_189) AT=310.025n

.meas tran vdout0_190ck610 FIND v(dout0_190) AT=310.025n

.meas tran vdout0_191ck610 FIND v(dout0_191) AT=310.025n

.meas tran vdout0_192ck610 FIND v(dout0_192) AT=310.025n

.meas tran vdout0_193ck610 FIND v(dout0_193) AT=310.025n

.meas tran vdout0_194ck610 FIND v(dout0_194) AT=310.025n

.meas tran vdout0_195ck610 FIND v(dout0_195) AT=310.025n

.meas tran vdout0_196ck610 FIND v(dout0_196) AT=310.025n

.meas tran vdout0_197ck610 FIND v(dout0_197) AT=310.025n

.meas tran vdout0_198ck610 FIND v(dout0_198) AT=310.025n

.meas tran vdout0_199ck610 FIND v(dout0_199) AT=310.025n

.meas tran vdout0_200ck610 FIND v(dout0_200) AT=310.025n

.meas tran vdout0_201ck610 FIND v(dout0_201) AT=310.025n

.meas tran vdout0_202ck610 FIND v(dout0_202) AT=310.025n

.meas tran vdout0_203ck610 FIND v(dout0_203) AT=310.025n

.meas tran vdout0_204ck610 FIND v(dout0_204) AT=310.025n

.meas tran vdout0_205ck610 FIND v(dout0_205) AT=310.025n

.meas tran vdout0_206ck610 FIND v(dout0_206) AT=310.025n

.meas tran vdout0_207ck610 FIND v(dout0_207) AT=310.025n

.meas tran vdout0_208ck610 FIND v(dout0_208) AT=310.025n

.meas tran vdout0_209ck610 FIND v(dout0_209) AT=310.025n

.meas tran vdout0_210ck610 FIND v(dout0_210) AT=310.025n

.meas tran vdout0_211ck610 FIND v(dout0_211) AT=310.025n

.meas tran vdout0_212ck610 FIND v(dout0_212) AT=310.025n

.meas tran vdout0_213ck610 FIND v(dout0_213) AT=310.025n

.meas tran vdout0_214ck610 FIND v(dout0_214) AT=310.025n

.meas tran vdout0_215ck610 FIND v(dout0_215) AT=310.025n

.meas tran vdout0_216ck610 FIND v(dout0_216) AT=310.025n

.meas tran vdout0_217ck610 FIND v(dout0_217) AT=310.025n

.meas tran vdout0_218ck610 FIND v(dout0_218) AT=310.025n

.meas tran vdout0_219ck610 FIND v(dout0_219) AT=310.025n

.meas tran vdout0_220ck610 FIND v(dout0_220) AT=310.025n

.meas tran vdout0_221ck610 FIND v(dout0_221) AT=310.025n

.meas tran vdout0_222ck610 FIND v(dout0_222) AT=310.025n

.meas tran vdout0_223ck610 FIND v(dout0_223) AT=310.025n

.meas tran vdout0_224ck610 FIND v(dout0_224) AT=310.025n

.meas tran vdout0_225ck610 FIND v(dout0_225) AT=310.025n

.meas tran vdout0_226ck610 FIND v(dout0_226) AT=310.025n

.meas tran vdout0_227ck610 FIND v(dout0_227) AT=310.025n

.meas tran vdout0_228ck610 FIND v(dout0_228) AT=310.025n

.meas tran vdout0_229ck610 FIND v(dout0_229) AT=310.025n

.meas tran vdout0_230ck610 FIND v(dout0_230) AT=310.025n

.meas tran vdout0_231ck610 FIND v(dout0_231) AT=310.025n

.meas tran vdout0_232ck610 FIND v(dout0_232) AT=310.025n

.meas tran vdout0_233ck610 FIND v(dout0_233) AT=310.025n

.meas tran vdout0_234ck610 FIND v(dout0_234) AT=310.025n

.meas tran vdout0_235ck610 FIND v(dout0_235) AT=310.025n

.meas tran vdout0_236ck610 FIND v(dout0_236) AT=310.025n

.meas tran vdout0_237ck610 FIND v(dout0_237) AT=310.025n

.meas tran vdout0_238ck610 FIND v(dout0_238) AT=310.025n

.meas tran vdout0_239ck610 FIND v(dout0_239) AT=310.025n

.meas tran vdout0_240ck610 FIND v(dout0_240) AT=310.025n

.meas tran vdout0_241ck610 FIND v(dout0_241) AT=310.025n

.meas tran vdout0_242ck610 FIND v(dout0_242) AT=310.025n

.meas tran vdout0_243ck610 FIND v(dout0_243) AT=310.025n

.meas tran vdout0_244ck610 FIND v(dout0_244) AT=310.025n

.meas tran vdout0_245ck610 FIND v(dout0_245) AT=310.025n

.meas tran vdout0_246ck610 FIND v(dout0_246) AT=310.025n

.meas tran vdout0_247ck610 FIND v(dout0_247) AT=310.025n

.meas tran vdout0_248ck610 FIND v(dout0_248) AT=310.025n

.meas tran vdout0_249ck610 FIND v(dout0_249) AT=310.025n

.meas tran vdout0_250ck610 FIND v(dout0_250) AT=310.025n

.meas tran vdout0_251ck610 FIND v(dout0_251) AT=310.025n

.meas tran vdout0_252ck610 FIND v(dout0_252) AT=310.025n

.meas tran vdout0_253ck610 FIND v(dout0_253) AT=310.025n

.meas tran vdout0_254ck610 FIND v(dout0_254) AT=310.025n

.meas tran vdout0_255ck610 FIND v(dout0_255) AT=310.025n

.meas tran vdout0_0ck640 FIND v(dout0_0) AT=325.025n

.meas tran vdout0_1ck640 FIND v(dout0_1) AT=325.025n

.meas tran vdout0_2ck640 FIND v(dout0_2) AT=325.025n

.meas tran vdout0_3ck640 FIND v(dout0_3) AT=325.025n

.meas tran vdout0_4ck640 FIND v(dout0_4) AT=325.025n

.meas tran vdout0_5ck640 FIND v(dout0_5) AT=325.025n

.meas tran vdout0_6ck640 FIND v(dout0_6) AT=325.025n

.meas tran vdout0_7ck640 FIND v(dout0_7) AT=325.025n

.meas tran vdout0_8ck640 FIND v(dout0_8) AT=325.025n

.meas tran vdout0_9ck640 FIND v(dout0_9) AT=325.025n

.meas tran vdout0_10ck640 FIND v(dout0_10) AT=325.025n

.meas tran vdout0_11ck640 FIND v(dout0_11) AT=325.025n

.meas tran vdout0_12ck640 FIND v(dout0_12) AT=325.025n

.meas tran vdout0_13ck640 FIND v(dout0_13) AT=325.025n

.meas tran vdout0_14ck640 FIND v(dout0_14) AT=325.025n

.meas tran vdout0_15ck640 FIND v(dout0_15) AT=325.025n

.meas tran vdout0_16ck640 FIND v(dout0_16) AT=325.025n

.meas tran vdout0_17ck640 FIND v(dout0_17) AT=325.025n

.meas tran vdout0_18ck640 FIND v(dout0_18) AT=325.025n

.meas tran vdout0_19ck640 FIND v(dout0_19) AT=325.025n

.meas tran vdout0_20ck640 FIND v(dout0_20) AT=325.025n

.meas tran vdout0_21ck640 FIND v(dout0_21) AT=325.025n

.meas tran vdout0_22ck640 FIND v(dout0_22) AT=325.025n

.meas tran vdout0_23ck640 FIND v(dout0_23) AT=325.025n

.meas tran vdout0_24ck640 FIND v(dout0_24) AT=325.025n

.meas tran vdout0_25ck640 FIND v(dout0_25) AT=325.025n

.meas tran vdout0_26ck640 FIND v(dout0_26) AT=325.025n

.meas tran vdout0_27ck640 FIND v(dout0_27) AT=325.025n

.meas tran vdout0_28ck640 FIND v(dout0_28) AT=325.025n

.meas tran vdout0_29ck640 FIND v(dout0_29) AT=325.025n

.meas tran vdout0_30ck640 FIND v(dout0_30) AT=325.025n

.meas tran vdout0_31ck640 FIND v(dout0_31) AT=325.025n

.meas tran vdout0_32ck640 FIND v(dout0_32) AT=325.025n

.meas tran vdout0_33ck640 FIND v(dout0_33) AT=325.025n

.meas tran vdout0_34ck640 FIND v(dout0_34) AT=325.025n

.meas tran vdout0_35ck640 FIND v(dout0_35) AT=325.025n

.meas tran vdout0_36ck640 FIND v(dout0_36) AT=325.025n

.meas tran vdout0_37ck640 FIND v(dout0_37) AT=325.025n

.meas tran vdout0_38ck640 FIND v(dout0_38) AT=325.025n

.meas tran vdout0_39ck640 FIND v(dout0_39) AT=325.025n

.meas tran vdout0_40ck640 FIND v(dout0_40) AT=325.025n

.meas tran vdout0_41ck640 FIND v(dout0_41) AT=325.025n

.meas tran vdout0_42ck640 FIND v(dout0_42) AT=325.025n

.meas tran vdout0_43ck640 FIND v(dout0_43) AT=325.025n

.meas tran vdout0_44ck640 FIND v(dout0_44) AT=325.025n

.meas tran vdout0_45ck640 FIND v(dout0_45) AT=325.025n

.meas tran vdout0_46ck640 FIND v(dout0_46) AT=325.025n

.meas tran vdout0_47ck640 FIND v(dout0_47) AT=325.025n

.meas tran vdout0_48ck640 FIND v(dout0_48) AT=325.025n

.meas tran vdout0_49ck640 FIND v(dout0_49) AT=325.025n

.meas tran vdout0_50ck640 FIND v(dout0_50) AT=325.025n

.meas tran vdout0_51ck640 FIND v(dout0_51) AT=325.025n

.meas tran vdout0_52ck640 FIND v(dout0_52) AT=325.025n

.meas tran vdout0_53ck640 FIND v(dout0_53) AT=325.025n

.meas tran vdout0_54ck640 FIND v(dout0_54) AT=325.025n

.meas tran vdout0_55ck640 FIND v(dout0_55) AT=325.025n

.meas tran vdout0_56ck640 FIND v(dout0_56) AT=325.025n

.meas tran vdout0_57ck640 FIND v(dout0_57) AT=325.025n

.meas tran vdout0_58ck640 FIND v(dout0_58) AT=325.025n

.meas tran vdout0_59ck640 FIND v(dout0_59) AT=325.025n

.meas tran vdout0_60ck640 FIND v(dout0_60) AT=325.025n

.meas tran vdout0_61ck640 FIND v(dout0_61) AT=325.025n

.meas tran vdout0_62ck640 FIND v(dout0_62) AT=325.025n

.meas tran vdout0_63ck640 FIND v(dout0_63) AT=325.025n

.meas tran vdout0_64ck640 FIND v(dout0_64) AT=325.025n

.meas tran vdout0_65ck640 FIND v(dout0_65) AT=325.025n

.meas tran vdout0_66ck640 FIND v(dout0_66) AT=325.025n

.meas tran vdout0_67ck640 FIND v(dout0_67) AT=325.025n

.meas tran vdout0_68ck640 FIND v(dout0_68) AT=325.025n

.meas tran vdout0_69ck640 FIND v(dout0_69) AT=325.025n

.meas tran vdout0_70ck640 FIND v(dout0_70) AT=325.025n

.meas tran vdout0_71ck640 FIND v(dout0_71) AT=325.025n

.meas tran vdout0_72ck640 FIND v(dout0_72) AT=325.025n

.meas tran vdout0_73ck640 FIND v(dout0_73) AT=325.025n

.meas tran vdout0_74ck640 FIND v(dout0_74) AT=325.025n

.meas tran vdout0_75ck640 FIND v(dout0_75) AT=325.025n

.meas tran vdout0_76ck640 FIND v(dout0_76) AT=325.025n

.meas tran vdout0_77ck640 FIND v(dout0_77) AT=325.025n

.meas tran vdout0_78ck640 FIND v(dout0_78) AT=325.025n

.meas tran vdout0_79ck640 FIND v(dout0_79) AT=325.025n

.meas tran vdout0_80ck640 FIND v(dout0_80) AT=325.025n

.meas tran vdout0_81ck640 FIND v(dout0_81) AT=325.025n

.meas tran vdout0_82ck640 FIND v(dout0_82) AT=325.025n

.meas tran vdout0_83ck640 FIND v(dout0_83) AT=325.025n

.meas tran vdout0_84ck640 FIND v(dout0_84) AT=325.025n

.meas tran vdout0_85ck640 FIND v(dout0_85) AT=325.025n

.meas tran vdout0_86ck640 FIND v(dout0_86) AT=325.025n

.meas tran vdout0_87ck640 FIND v(dout0_87) AT=325.025n

.meas tran vdout0_88ck640 FIND v(dout0_88) AT=325.025n

.meas tran vdout0_89ck640 FIND v(dout0_89) AT=325.025n

.meas tran vdout0_90ck640 FIND v(dout0_90) AT=325.025n

.meas tran vdout0_91ck640 FIND v(dout0_91) AT=325.025n

.meas tran vdout0_92ck640 FIND v(dout0_92) AT=325.025n

.meas tran vdout0_93ck640 FIND v(dout0_93) AT=325.025n

.meas tran vdout0_94ck640 FIND v(dout0_94) AT=325.025n

.meas tran vdout0_95ck640 FIND v(dout0_95) AT=325.025n

.meas tran vdout0_96ck640 FIND v(dout0_96) AT=325.025n

.meas tran vdout0_97ck640 FIND v(dout0_97) AT=325.025n

.meas tran vdout0_98ck640 FIND v(dout0_98) AT=325.025n

.meas tran vdout0_99ck640 FIND v(dout0_99) AT=325.025n

.meas tran vdout0_100ck640 FIND v(dout0_100) AT=325.025n

.meas tran vdout0_101ck640 FIND v(dout0_101) AT=325.025n

.meas tran vdout0_102ck640 FIND v(dout0_102) AT=325.025n

.meas tran vdout0_103ck640 FIND v(dout0_103) AT=325.025n

.meas tran vdout0_104ck640 FIND v(dout0_104) AT=325.025n

.meas tran vdout0_105ck640 FIND v(dout0_105) AT=325.025n

.meas tran vdout0_106ck640 FIND v(dout0_106) AT=325.025n

.meas tran vdout0_107ck640 FIND v(dout0_107) AT=325.025n

.meas tran vdout0_108ck640 FIND v(dout0_108) AT=325.025n

.meas tran vdout0_109ck640 FIND v(dout0_109) AT=325.025n

.meas tran vdout0_110ck640 FIND v(dout0_110) AT=325.025n

.meas tran vdout0_111ck640 FIND v(dout0_111) AT=325.025n

.meas tran vdout0_112ck640 FIND v(dout0_112) AT=325.025n

.meas tran vdout0_113ck640 FIND v(dout0_113) AT=325.025n

.meas tran vdout0_114ck640 FIND v(dout0_114) AT=325.025n

.meas tran vdout0_115ck640 FIND v(dout0_115) AT=325.025n

.meas tran vdout0_116ck640 FIND v(dout0_116) AT=325.025n

.meas tran vdout0_117ck640 FIND v(dout0_117) AT=325.025n

.meas tran vdout0_118ck640 FIND v(dout0_118) AT=325.025n

.meas tran vdout0_119ck640 FIND v(dout0_119) AT=325.025n

.meas tran vdout0_120ck640 FIND v(dout0_120) AT=325.025n

.meas tran vdout0_121ck640 FIND v(dout0_121) AT=325.025n

.meas tran vdout0_122ck640 FIND v(dout0_122) AT=325.025n

.meas tran vdout0_123ck640 FIND v(dout0_123) AT=325.025n

.meas tran vdout0_124ck640 FIND v(dout0_124) AT=325.025n

.meas tran vdout0_125ck640 FIND v(dout0_125) AT=325.025n

.meas tran vdout0_126ck640 FIND v(dout0_126) AT=325.025n

.meas tran vdout0_127ck640 FIND v(dout0_127) AT=325.025n

.meas tran vdout0_128ck640 FIND v(dout0_128) AT=325.025n

.meas tran vdout0_129ck640 FIND v(dout0_129) AT=325.025n

.meas tran vdout0_130ck640 FIND v(dout0_130) AT=325.025n

.meas tran vdout0_131ck640 FIND v(dout0_131) AT=325.025n

.meas tran vdout0_132ck640 FIND v(dout0_132) AT=325.025n

.meas tran vdout0_133ck640 FIND v(dout0_133) AT=325.025n

.meas tran vdout0_134ck640 FIND v(dout0_134) AT=325.025n

.meas tran vdout0_135ck640 FIND v(dout0_135) AT=325.025n

.meas tran vdout0_136ck640 FIND v(dout0_136) AT=325.025n

.meas tran vdout0_137ck640 FIND v(dout0_137) AT=325.025n

.meas tran vdout0_138ck640 FIND v(dout0_138) AT=325.025n

.meas tran vdout0_139ck640 FIND v(dout0_139) AT=325.025n

.meas tran vdout0_140ck640 FIND v(dout0_140) AT=325.025n

.meas tran vdout0_141ck640 FIND v(dout0_141) AT=325.025n

.meas tran vdout0_142ck640 FIND v(dout0_142) AT=325.025n

.meas tran vdout0_143ck640 FIND v(dout0_143) AT=325.025n

.meas tran vdout0_144ck640 FIND v(dout0_144) AT=325.025n

.meas tran vdout0_145ck640 FIND v(dout0_145) AT=325.025n

.meas tran vdout0_146ck640 FIND v(dout0_146) AT=325.025n

.meas tran vdout0_147ck640 FIND v(dout0_147) AT=325.025n

.meas tran vdout0_148ck640 FIND v(dout0_148) AT=325.025n

.meas tran vdout0_149ck640 FIND v(dout0_149) AT=325.025n

.meas tran vdout0_150ck640 FIND v(dout0_150) AT=325.025n

.meas tran vdout0_151ck640 FIND v(dout0_151) AT=325.025n

.meas tran vdout0_152ck640 FIND v(dout0_152) AT=325.025n

.meas tran vdout0_153ck640 FIND v(dout0_153) AT=325.025n

.meas tran vdout0_154ck640 FIND v(dout0_154) AT=325.025n

.meas tran vdout0_155ck640 FIND v(dout0_155) AT=325.025n

.meas tran vdout0_156ck640 FIND v(dout0_156) AT=325.025n

.meas tran vdout0_157ck640 FIND v(dout0_157) AT=325.025n

.meas tran vdout0_158ck640 FIND v(dout0_158) AT=325.025n

.meas tran vdout0_159ck640 FIND v(dout0_159) AT=325.025n

.meas tran vdout0_160ck640 FIND v(dout0_160) AT=325.025n

.meas tran vdout0_161ck640 FIND v(dout0_161) AT=325.025n

.meas tran vdout0_162ck640 FIND v(dout0_162) AT=325.025n

.meas tran vdout0_163ck640 FIND v(dout0_163) AT=325.025n

.meas tran vdout0_164ck640 FIND v(dout0_164) AT=325.025n

.meas tran vdout0_165ck640 FIND v(dout0_165) AT=325.025n

.meas tran vdout0_166ck640 FIND v(dout0_166) AT=325.025n

.meas tran vdout0_167ck640 FIND v(dout0_167) AT=325.025n

.meas tran vdout0_168ck640 FIND v(dout0_168) AT=325.025n

.meas tran vdout0_169ck640 FIND v(dout0_169) AT=325.025n

.meas tran vdout0_170ck640 FIND v(dout0_170) AT=325.025n

.meas tran vdout0_171ck640 FIND v(dout0_171) AT=325.025n

.meas tran vdout0_172ck640 FIND v(dout0_172) AT=325.025n

.meas tran vdout0_173ck640 FIND v(dout0_173) AT=325.025n

.meas tran vdout0_174ck640 FIND v(dout0_174) AT=325.025n

.meas tran vdout0_175ck640 FIND v(dout0_175) AT=325.025n

.meas tran vdout0_176ck640 FIND v(dout0_176) AT=325.025n

.meas tran vdout0_177ck640 FIND v(dout0_177) AT=325.025n

.meas tran vdout0_178ck640 FIND v(dout0_178) AT=325.025n

.meas tran vdout0_179ck640 FIND v(dout0_179) AT=325.025n

.meas tran vdout0_180ck640 FIND v(dout0_180) AT=325.025n

.meas tran vdout0_181ck640 FIND v(dout0_181) AT=325.025n

.meas tran vdout0_182ck640 FIND v(dout0_182) AT=325.025n

.meas tran vdout0_183ck640 FIND v(dout0_183) AT=325.025n

.meas tran vdout0_184ck640 FIND v(dout0_184) AT=325.025n

.meas tran vdout0_185ck640 FIND v(dout0_185) AT=325.025n

.meas tran vdout0_186ck640 FIND v(dout0_186) AT=325.025n

.meas tran vdout0_187ck640 FIND v(dout0_187) AT=325.025n

.meas tran vdout0_188ck640 FIND v(dout0_188) AT=325.025n

.meas tran vdout0_189ck640 FIND v(dout0_189) AT=325.025n

.meas tran vdout0_190ck640 FIND v(dout0_190) AT=325.025n

.meas tran vdout0_191ck640 FIND v(dout0_191) AT=325.025n

.meas tran vdout0_192ck640 FIND v(dout0_192) AT=325.025n

.meas tran vdout0_193ck640 FIND v(dout0_193) AT=325.025n

.meas tran vdout0_194ck640 FIND v(dout0_194) AT=325.025n

.meas tran vdout0_195ck640 FIND v(dout0_195) AT=325.025n

.meas tran vdout0_196ck640 FIND v(dout0_196) AT=325.025n

.meas tran vdout0_197ck640 FIND v(dout0_197) AT=325.025n

.meas tran vdout0_198ck640 FIND v(dout0_198) AT=325.025n

.meas tran vdout0_199ck640 FIND v(dout0_199) AT=325.025n

.meas tran vdout0_200ck640 FIND v(dout0_200) AT=325.025n

.meas tran vdout0_201ck640 FIND v(dout0_201) AT=325.025n

.meas tran vdout0_202ck640 FIND v(dout0_202) AT=325.025n

.meas tran vdout0_203ck640 FIND v(dout0_203) AT=325.025n

.meas tran vdout0_204ck640 FIND v(dout0_204) AT=325.025n

.meas tran vdout0_205ck640 FIND v(dout0_205) AT=325.025n

.meas tran vdout0_206ck640 FIND v(dout0_206) AT=325.025n

.meas tran vdout0_207ck640 FIND v(dout0_207) AT=325.025n

.meas tran vdout0_208ck640 FIND v(dout0_208) AT=325.025n

.meas tran vdout0_209ck640 FIND v(dout0_209) AT=325.025n

.meas tran vdout0_210ck640 FIND v(dout0_210) AT=325.025n

.meas tran vdout0_211ck640 FIND v(dout0_211) AT=325.025n

.meas tran vdout0_212ck640 FIND v(dout0_212) AT=325.025n

.meas tran vdout0_213ck640 FIND v(dout0_213) AT=325.025n

.meas tran vdout0_214ck640 FIND v(dout0_214) AT=325.025n

.meas tran vdout0_215ck640 FIND v(dout0_215) AT=325.025n

.meas tran vdout0_216ck640 FIND v(dout0_216) AT=325.025n

.meas tran vdout0_217ck640 FIND v(dout0_217) AT=325.025n

.meas tran vdout0_218ck640 FIND v(dout0_218) AT=325.025n

.meas tran vdout0_219ck640 FIND v(dout0_219) AT=325.025n

.meas tran vdout0_220ck640 FIND v(dout0_220) AT=325.025n

.meas tran vdout0_221ck640 FIND v(dout0_221) AT=325.025n

.meas tran vdout0_222ck640 FIND v(dout0_222) AT=325.025n

.meas tran vdout0_223ck640 FIND v(dout0_223) AT=325.025n

.meas tran vdout0_224ck640 FIND v(dout0_224) AT=325.025n

.meas tran vdout0_225ck640 FIND v(dout0_225) AT=325.025n

.meas tran vdout0_226ck640 FIND v(dout0_226) AT=325.025n

.meas tran vdout0_227ck640 FIND v(dout0_227) AT=325.025n

.meas tran vdout0_228ck640 FIND v(dout0_228) AT=325.025n

.meas tran vdout0_229ck640 FIND v(dout0_229) AT=325.025n

.meas tran vdout0_230ck640 FIND v(dout0_230) AT=325.025n

.meas tran vdout0_231ck640 FIND v(dout0_231) AT=325.025n

.meas tran vdout0_232ck640 FIND v(dout0_232) AT=325.025n

.meas tran vdout0_233ck640 FIND v(dout0_233) AT=325.025n

.meas tran vdout0_234ck640 FIND v(dout0_234) AT=325.025n

.meas tran vdout0_235ck640 FIND v(dout0_235) AT=325.025n

.meas tran vdout0_236ck640 FIND v(dout0_236) AT=325.025n

.meas tran vdout0_237ck640 FIND v(dout0_237) AT=325.025n

.meas tran vdout0_238ck640 FIND v(dout0_238) AT=325.025n

.meas tran vdout0_239ck640 FIND v(dout0_239) AT=325.025n

.meas tran vdout0_240ck640 FIND v(dout0_240) AT=325.025n

.meas tran vdout0_241ck640 FIND v(dout0_241) AT=325.025n

.meas tran vdout0_242ck640 FIND v(dout0_242) AT=325.025n

.meas tran vdout0_243ck640 FIND v(dout0_243) AT=325.025n

.meas tran vdout0_244ck640 FIND v(dout0_244) AT=325.025n

.meas tran vdout0_245ck640 FIND v(dout0_245) AT=325.025n

.meas tran vdout0_246ck640 FIND v(dout0_246) AT=325.025n

.meas tran vdout0_247ck640 FIND v(dout0_247) AT=325.025n

.meas tran vdout0_248ck640 FIND v(dout0_248) AT=325.025n

.meas tran vdout0_249ck640 FIND v(dout0_249) AT=325.025n

.meas tran vdout0_250ck640 FIND v(dout0_250) AT=325.025n

.meas tran vdout0_251ck640 FIND v(dout0_251) AT=325.025n

.meas tran vdout0_252ck640 FIND v(dout0_252) AT=325.025n

.meas tran vdout0_253ck640 FIND v(dout0_253) AT=325.025n

.meas tran vdout0_254ck640 FIND v(dout0_254) AT=325.025n

.meas tran vdout0_255ck640 FIND v(dout0_255) AT=325.025n

.meas tran vdout0_0ck650 FIND v(dout0_0) AT=330.025n

.meas tran vdout0_1ck650 FIND v(dout0_1) AT=330.025n

.meas tran vdout0_2ck650 FIND v(dout0_2) AT=330.025n

.meas tran vdout0_3ck650 FIND v(dout0_3) AT=330.025n

.meas tran vdout0_4ck650 FIND v(dout0_4) AT=330.025n

.meas tran vdout0_5ck650 FIND v(dout0_5) AT=330.025n

.meas tran vdout0_6ck650 FIND v(dout0_6) AT=330.025n

.meas tran vdout0_7ck650 FIND v(dout0_7) AT=330.025n

.meas tran vdout0_8ck650 FIND v(dout0_8) AT=330.025n

.meas tran vdout0_9ck650 FIND v(dout0_9) AT=330.025n

.meas tran vdout0_10ck650 FIND v(dout0_10) AT=330.025n

.meas tran vdout0_11ck650 FIND v(dout0_11) AT=330.025n

.meas tran vdout0_12ck650 FIND v(dout0_12) AT=330.025n

.meas tran vdout0_13ck650 FIND v(dout0_13) AT=330.025n

.meas tran vdout0_14ck650 FIND v(dout0_14) AT=330.025n

.meas tran vdout0_15ck650 FIND v(dout0_15) AT=330.025n

.meas tran vdout0_16ck650 FIND v(dout0_16) AT=330.025n

.meas tran vdout0_17ck650 FIND v(dout0_17) AT=330.025n

.meas tran vdout0_18ck650 FIND v(dout0_18) AT=330.025n

.meas tran vdout0_19ck650 FIND v(dout0_19) AT=330.025n

.meas tran vdout0_20ck650 FIND v(dout0_20) AT=330.025n

.meas tran vdout0_21ck650 FIND v(dout0_21) AT=330.025n

.meas tran vdout0_22ck650 FIND v(dout0_22) AT=330.025n

.meas tran vdout0_23ck650 FIND v(dout0_23) AT=330.025n

.meas tran vdout0_24ck650 FIND v(dout0_24) AT=330.025n

.meas tran vdout0_25ck650 FIND v(dout0_25) AT=330.025n

.meas tran vdout0_26ck650 FIND v(dout0_26) AT=330.025n

.meas tran vdout0_27ck650 FIND v(dout0_27) AT=330.025n

.meas tran vdout0_28ck650 FIND v(dout0_28) AT=330.025n

.meas tran vdout0_29ck650 FIND v(dout0_29) AT=330.025n

.meas tran vdout0_30ck650 FIND v(dout0_30) AT=330.025n

.meas tran vdout0_31ck650 FIND v(dout0_31) AT=330.025n

.meas tran vdout0_32ck650 FIND v(dout0_32) AT=330.025n

.meas tran vdout0_33ck650 FIND v(dout0_33) AT=330.025n

.meas tran vdout0_34ck650 FIND v(dout0_34) AT=330.025n

.meas tran vdout0_35ck650 FIND v(dout0_35) AT=330.025n

.meas tran vdout0_36ck650 FIND v(dout0_36) AT=330.025n

.meas tran vdout0_37ck650 FIND v(dout0_37) AT=330.025n

.meas tran vdout0_38ck650 FIND v(dout0_38) AT=330.025n

.meas tran vdout0_39ck650 FIND v(dout0_39) AT=330.025n

.meas tran vdout0_40ck650 FIND v(dout0_40) AT=330.025n

.meas tran vdout0_41ck650 FIND v(dout0_41) AT=330.025n

.meas tran vdout0_42ck650 FIND v(dout0_42) AT=330.025n

.meas tran vdout0_43ck650 FIND v(dout0_43) AT=330.025n

.meas tran vdout0_44ck650 FIND v(dout0_44) AT=330.025n

.meas tran vdout0_45ck650 FIND v(dout0_45) AT=330.025n

.meas tran vdout0_46ck650 FIND v(dout0_46) AT=330.025n

.meas tran vdout0_47ck650 FIND v(dout0_47) AT=330.025n

.meas tran vdout0_48ck650 FIND v(dout0_48) AT=330.025n

.meas tran vdout0_49ck650 FIND v(dout0_49) AT=330.025n

.meas tran vdout0_50ck650 FIND v(dout0_50) AT=330.025n

.meas tran vdout0_51ck650 FIND v(dout0_51) AT=330.025n

.meas tran vdout0_52ck650 FIND v(dout0_52) AT=330.025n

.meas tran vdout0_53ck650 FIND v(dout0_53) AT=330.025n

.meas tran vdout0_54ck650 FIND v(dout0_54) AT=330.025n

.meas tran vdout0_55ck650 FIND v(dout0_55) AT=330.025n

.meas tran vdout0_56ck650 FIND v(dout0_56) AT=330.025n

.meas tran vdout0_57ck650 FIND v(dout0_57) AT=330.025n

.meas tran vdout0_58ck650 FIND v(dout0_58) AT=330.025n

.meas tran vdout0_59ck650 FIND v(dout0_59) AT=330.025n

.meas tran vdout0_60ck650 FIND v(dout0_60) AT=330.025n

.meas tran vdout0_61ck650 FIND v(dout0_61) AT=330.025n

.meas tran vdout0_62ck650 FIND v(dout0_62) AT=330.025n

.meas tran vdout0_63ck650 FIND v(dout0_63) AT=330.025n

.meas tran vdout0_64ck650 FIND v(dout0_64) AT=330.025n

.meas tran vdout0_65ck650 FIND v(dout0_65) AT=330.025n

.meas tran vdout0_66ck650 FIND v(dout0_66) AT=330.025n

.meas tran vdout0_67ck650 FIND v(dout0_67) AT=330.025n

.meas tran vdout0_68ck650 FIND v(dout0_68) AT=330.025n

.meas tran vdout0_69ck650 FIND v(dout0_69) AT=330.025n

.meas tran vdout0_70ck650 FIND v(dout0_70) AT=330.025n

.meas tran vdout0_71ck650 FIND v(dout0_71) AT=330.025n

.meas tran vdout0_72ck650 FIND v(dout0_72) AT=330.025n

.meas tran vdout0_73ck650 FIND v(dout0_73) AT=330.025n

.meas tran vdout0_74ck650 FIND v(dout0_74) AT=330.025n

.meas tran vdout0_75ck650 FIND v(dout0_75) AT=330.025n

.meas tran vdout0_76ck650 FIND v(dout0_76) AT=330.025n

.meas tran vdout0_77ck650 FIND v(dout0_77) AT=330.025n

.meas tran vdout0_78ck650 FIND v(dout0_78) AT=330.025n

.meas tran vdout0_79ck650 FIND v(dout0_79) AT=330.025n

.meas tran vdout0_80ck650 FIND v(dout0_80) AT=330.025n

.meas tran vdout0_81ck650 FIND v(dout0_81) AT=330.025n

.meas tran vdout0_82ck650 FIND v(dout0_82) AT=330.025n

.meas tran vdout0_83ck650 FIND v(dout0_83) AT=330.025n

.meas tran vdout0_84ck650 FIND v(dout0_84) AT=330.025n

.meas tran vdout0_85ck650 FIND v(dout0_85) AT=330.025n

.meas tran vdout0_86ck650 FIND v(dout0_86) AT=330.025n

.meas tran vdout0_87ck650 FIND v(dout0_87) AT=330.025n

.meas tran vdout0_88ck650 FIND v(dout0_88) AT=330.025n

.meas tran vdout0_89ck650 FIND v(dout0_89) AT=330.025n

.meas tran vdout0_90ck650 FIND v(dout0_90) AT=330.025n

.meas tran vdout0_91ck650 FIND v(dout0_91) AT=330.025n

.meas tran vdout0_92ck650 FIND v(dout0_92) AT=330.025n

.meas tran vdout0_93ck650 FIND v(dout0_93) AT=330.025n

.meas tran vdout0_94ck650 FIND v(dout0_94) AT=330.025n

.meas tran vdout0_95ck650 FIND v(dout0_95) AT=330.025n

.meas tran vdout0_96ck650 FIND v(dout0_96) AT=330.025n

.meas tran vdout0_97ck650 FIND v(dout0_97) AT=330.025n

.meas tran vdout0_98ck650 FIND v(dout0_98) AT=330.025n

.meas tran vdout0_99ck650 FIND v(dout0_99) AT=330.025n

.meas tran vdout0_100ck650 FIND v(dout0_100) AT=330.025n

.meas tran vdout0_101ck650 FIND v(dout0_101) AT=330.025n

.meas tran vdout0_102ck650 FIND v(dout0_102) AT=330.025n

.meas tran vdout0_103ck650 FIND v(dout0_103) AT=330.025n

.meas tran vdout0_104ck650 FIND v(dout0_104) AT=330.025n

.meas tran vdout0_105ck650 FIND v(dout0_105) AT=330.025n

.meas tran vdout0_106ck650 FIND v(dout0_106) AT=330.025n

.meas tran vdout0_107ck650 FIND v(dout0_107) AT=330.025n

.meas tran vdout0_108ck650 FIND v(dout0_108) AT=330.025n

.meas tran vdout0_109ck650 FIND v(dout0_109) AT=330.025n

.meas tran vdout0_110ck650 FIND v(dout0_110) AT=330.025n

.meas tran vdout0_111ck650 FIND v(dout0_111) AT=330.025n

.meas tran vdout0_112ck650 FIND v(dout0_112) AT=330.025n

.meas tran vdout0_113ck650 FIND v(dout0_113) AT=330.025n

.meas tran vdout0_114ck650 FIND v(dout0_114) AT=330.025n

.meas tran vdout0_115ck650 FIND v(dout0_115) AT=330.025n

.meas tran vdout0_116ck650 FIND v(dout0_116) AT=330.025n

.meas tran vdout0_117ck650 FIND v(dout0_117) AT=330.025n

.meas tran vdout0_118ck650 FIND v(dout0_118) AT=330.025n

.meas tran vdout0_119ck650 FIND v(dout0_119) AT=330.025n

.meas tran vdout0_120ck650 FIND v(dout0_120) AT=330.025n

.meas tran vdout0_121ck650 FIND v(dout0_121) AT=330.025n

.meas tran vdout0_122ck650 FIND v(dout0_122) AT=330.025n

.meas tran vdout0_123ck650 FIND v(dout0_123) AT=330.025n

.meas tran vdout0_124ck650 FIND v(dout0_124) AT=330.025n

.meas tran vdout0_125ck650 FIND v(dout0_125) AT=330.025n

.meas tran vdout0_126ck650 FIND v(dout0_126) AT=330.025n

.meas tran vdout0_127ck650 FIND v(dout0_127) AT=330.025n

.meas tran vdout0_128ck650 FIND v(dout0_128) AT=330.025n

.meas tran vdout0_129ck650 FIND v(dout0_129) AT=330.025n

.meas tran vdout0_130ck650 FIND v(dout0_130) AT=330.025n

.meas tran vdout0_131ck650 FIND v(dout0_131) AT=330.025n

.meas tran vdout0_132ck650 FIND v(dout0_132) AT=330.025n

.meas tran vdout0_133ck650 FIND v(dout0_133) AT=330.025n

.meas tran vdout0_134ck650 FIND v(dout0_134) AT=330.025n

.meas tran vdout0_135ck650 FIND v(dout0_135) AT=330.025n

.meas tran vdout0_136ck650 FIND v(dout0_136) AT=330.025n

.meas tran vdout0_137ck650 FIND v(dout0_137) AT=330.025n

.meas tran vdout0_138ck650 FIND v(dout0_138) AT=330.025n

.meas tran vdout0_139ck650 FIND v(dout0_139) AT=330.025n

.meas tran vdout0_140ck650 FIND v(dout0_140) AT=330.025n

.meas tran vdout0_141ck650 FIND v(dout0_141) AT=330.025n

.meas tran vdout0_142ck650 FIND v(dout0_142) AT=330.025n

.meas tran vdout0_143ck650 FIND v(dout0_143) AT=330.025n

.meas tran vdout0_144ck650 FIND v(dout0_144) AT=330.025n

.meas tran vdout0_145ck650 FIND v(dout0_145) AT=330.025n

.meas tran vdout0_146ck650 FIND v(dout0_146) AT=330.025n

.meas tran vdout0_147ck650 FIND v(dout0_147) AT=330.025n

.meas tran vdout0_148ck650 FIND v(dout0_148) AT=330.025n

.meas tran vdout0_149ck650 FIND v(dout0_149) AT=330.025n

.meas tran vdout0_150ck650 FIND v(dout0_150) AT=330.025n

.meas tran vdout0_151ck650 FIND v(dout0_151) AT=330.025n

.meas tran vdout0_152ck650 FIND v(dout0_152) AT=330.025n

.meas tran vdout0_153ck650 FIND v(dout0_153) AT=330.025n

.meas tran vdout0_154ck650 FIND v(dout0_154) AT=330.025n

.meas tran vdout0_155ck650 FIND v(dout0_155) AT=330.025n

.meas tran vdout0_156ck650 FIND v(dout0_156) AT=330.025n

.meas tran vdout0_157ck650 FIND v(dout0_157) AT=330.025n

.meas tran vdout0_158ck650 FIND v(dout0_158) AT=330.025n

.meas tran vdout0_159ck650 FIND v(dout0_159) AT=330.025n

.meas tran vdout0_160ck650 FIND v(dout0_160) AT=330.025n

.meas tran vdout0_161ck650 FIND v(dout0_161) AT=330.025n

.meas tran vdout0_162ck650 FIND v(dout0_162) AT=330.025n

.meas tran vdout0_163ck650 FIND v(dout0_163) AT=330.025n

.meas tran vdout0_164ck650 FIND v(dout0_164) AT=330.025n

.meas tran vdout0_165ck650 FIND v(dout0_165) AT=330.025n

.meas tran vdout0_166ck650 FIND v(dout0_166) AT=330.025n

.meas tran vdout0_167ck650 FIND v(dout0_167) AT=330.025n

.meas tran vdout0_168ck650 FIND v(dout0_168) AT=330.025n

.meas tran vdout0_169ck650 FIND v(dout0_169) AT=330.025n

.meas tran vdout0_170ck650 FIND v(dout0_170) AT=330.025n

.meas tran vdout0_171ck650 FIND v(dout0_171) AT=330.025n

.meas tran vdout0_172ck650 FIND v(dout0_172) AT=330.025n

.meas tran vdout0_173ck650 FIND v(dout0_173) AT=330.025n

.meas tran vdout0_174ck650 FIND v(dout0_174) AT=330.025n

.meas tran vdout0_175ck650 FIND v(dout0_175) AT=330.025n

.meas tran vdout0_176ck650 FIND v(dout0_176) AT=330.025n

.meas tran vdout0_177ck650 FIND v(dout0_177) AT=330.025n

.meas tran vdout0_178ck650 FIND v(dout0_178) AT=330.025n

.meas tran vdout0_179ck650 FIND v(dout0_179) AT=330.025n

.meas tran vdout0_180ck650 FIND v(dout0_180) AT=330.025n

.meas tran vdout0_181ck650 FIND v(dout0_181) AT=330.025n

.meas tran vdout0_182ck650 FIND v(dout0_182) AT=330.025n

.meas tran vdout0_183ck650 FIND v(dout0_183) AT=330.025n

.meas tran vdout0_184ck650 FIND v(dout0_184) AT=330.025n

.meas tran vdout0_185ck650 FIND v(dout0_185) AT=330.025n

.meas tran vdout0_186ck650 FIND v(dout0_186) AT=330.025n

.meas tran vdout0_187ck650 FIND v(dout0_187) AT=330.025n

.meas tran vdout0_188ck650 FIND v(dout0_188) AT=330.025n

.meas tran vdout0_189ck650 FIND v(dout0_189) AT=330.025n

.meas tran vdout0_190ck650 FIND v(dout0_190) AT=330.025n

.meas tran vdout0_191ck650 FIND v(dout0_191) AT=330.025n

.meas tran vdout0_192ck650 FIND v(dout0_192) AT=330.025n

.meas tran vdout0_193ck650 FIND v(dout0_193) AT=330.025n

.meas tran vdout0_194ck650 FIND v(dout0_194) AT=330.025n

.meas tran vdout0_195ck650 FIND v(dout0_195) AT=330.025n

.meas tran vdout0_196ck650 FIND v(dout0_196) AT=330.025n

.meas tran vdout0_197ck650 FIND v(dout0_197) AT=330.025n

.meas tran vdout0_198ck650 FIND v(dout0_198) AT=330.025n

.meas tran vdout0_199ck650 FIND v(dout0_199) AT=330.025n

.meas tran vdout0_200ck650 FIND v(dout0_200) AT=330.025n

.meas tran vdout0_201ck650 FIND v(dout0_201) AT=330.025n

.meas tran vdout0_202ck650 FIND v(dout0_202) AT=330.025n

.meas tran vdout0_203ck650 FIND v(dout0_203) AT=330.025n

.meas tran vdout0_204ck650 FIND v(dout0_204) AT=330.025n

.meas tran vdout0_205ck650 FIND v(dout0_205) AT=330.025n

.meas tran vdout0_206ck650 FIND v(dout0_206) AT=330.025n

.meas tran vdout0_207ck650 FIND v(dout0_207) AT=330.025n

.meas tran vdout0_208ck650 FIND v(dout0_208) AT=330.025n

.meas tran vdout0_209ck650 FIND v(dout0_209) AT=330.025n

.meas tran vdout0_210ck650 FIND v(dout0_210) AT=330.025n

.meas tran vdout0_211ck650 FIND v(dout0_211) AT=330.025n

.meas tran vdout0_212ck650 FIND v(dout0_212) AT=330.025n

.meas tran vdout0_213ck650 FIND v(dout0_213) AT=330.025n

.meas tran vdout0_214ck650 FIND v(dout0_214) AT=330.025n

.meas tran vdout0_215ck650 FIND v(dout0_215) AT=330.025n

.meas tran vdout0_216ck650 FIND v(dout0_216) AT=330.025n

.meas tran vdout0_217ck650 FIND v(dout0_217) AT=330.025n

.meas tran vdout0_218ck650 FIND v(dout0_218) AT=330.025n

.meas tran vdout0_219ck650 FIND v(dout0_219) AT=330.025n

.meas tran vdout0_220ck650 FIND v(dout0_220) AT=330.025n

.meas tran vdout0_221ck650 FIND v(dout0_221) AT=330.025n

.meas tran vdout0_222ck650 FIND v(dout0_222) AT=330.025n

.meas tran vdout0_223ck650 FIND v(dout0_223) AT=330.025n

.meas tran vdout0_224ck650 FIND v(dout0_224) AT=330.025n

.meas tran vdout0_225ck650 FIND v(dout0_225) AT=330.025n

.meas tran vdout0_226ck650 FIND v(dout0_226) AT=330.025n

.meas tran vdout0_227ck650 FIND v(dout0_227) AT=330.025n

.meas tran vdout0_228ck650 FIND v(dout0_228) AT=330.025n

.meas tran vdout0_229ck650 FIND v(dout0_229) AT=330.025n

.meas tran vdout0_230ck650 FIND v(dout0_230) AT=330.025n

.meas tran vdout0_231ck650 FIND v(dout0_231) AT=330.025n

.meas tran vdout0_232ck650 FIND v(dout0_232) AT=330.025n

.meas tran vdout0_233ck650 FIND v(dout0_233) AT=330.025n

.meas tran vdout0_234ck650 FIND v(dout0_234) AT=330.025n

.meas tran vdout0_235ck650 FIND v(dout0_235) AT=330.025n

.meas tran vdout0_236ck650 FIND v(dout0_236) AT=330.025n

.meas tran vdout0_237ck650 FIND v(dout0_237) AT=330.025n

.meas tran vdout0_238ck650 FIND v(dout0_238) AT=330.025n

.meas tran vdout0_239ck650 FIND v(dout0_239) AT=330.025n

.meas tran vdout0_240ck650 FIND v(dout0_240) AT=330.025n

.meas tran vdout0_241ck650 FIND v(dout0_241) AT=330.025n

.meas tran vdout0_242ck650 FIND v(dout0_242) AT=330.025n

.meas tran vdout0_243ck650 FIND v(dout0_243) AT=330.025n

.meas tran vdout0_244ck650 FIND v(dout0_244) AT=330.025n

.meas tran vdout0_245ck650 FIND v(dout0_245) AT=330.025n

.meas tran vdout0_246ck650 FIND v(dout0_246) AT=330.025n

.meas tran vdout0_247ck650 FIND v(dout0_247) AT=330.025n

.meas tran vdout0_248ck650 FIND v(dout0_248) AT=330.025n

.meas tran vdout0_249ck650 FIND v(dout0_249) AT=330.025n

.meas tran vdout0_250ck650 FIND v(dout0_250) AT=330.025n

.meas tran vdout0_251ck650 FIND v(dout0_251) AT=330.025n

.meas tran vdout0_252ck650 FIND v(dout0_252) AT=330.025n

.meas tran vdout0_253ck650 FIND v(dout0_253) AT=330.025n

.meas tran vdout0_254ck650 FIND v(dout0_254) AT=330.025n

.meas tran vdout0_255ck650 FIND v(dout0_255) AT=330.025n

.meas tran vdout0_0ck680 FIND v(dout0_0) AT=345.025n

.meas tran vdout0_1ck680 FIND v(dout0_1) AT=345.025n

.meas tran vdout0_2ck680 FIND v(dout0_2) AT=345.025n

.meas tran vdout0_3ck680 FIND v(dout0_3) AT=345.025n

.meas tran vdout0_4ck680 FIND v(dout0_4) AT=345.025n

.meas tran vdout0_5ck680 FIND v(dout0_5) AT=345.025n

.meas tran vdout0_6ck680 FIND v(dout0_6) AT=345.025n

.meas tran vdout0_7ck680 FIND v(dout0_7) AT=345.025n

.meas tran vdout0_8ck680 FIND v(dout0_8) AT=345.025n

.meas tran vdout0_9ck680 FIND v(dout0_9) AT=345.025n

.meas tran vdout0_10ck680 FIND v(dout0_10) AT=345.025n

.meas tran vdout0_11ck680 FIND v(dout0_11) AT=345.025n

.meas tran vdout0_12ck680 FIND v(dout0_12) AT=345.025n

.meas tran vdout0_13ck680 FIND v(dout0_13) AT=345.025n

.meas tran vdout0_14ck680 FIND v(dout0_14) AT=345.025n

.meas tran vdout0_15ck680 FIND v(dout0_15) AT=345.025n

.meas tran vdout0_16ck680 FIND v(dout0_16) AT=345.025n

.meas tran vdout0_17ck680 FIND v(dout0_17) AT=345.025n

.meas tran vdout0_18ck680 FIND v(dout0_18) AT=345.025n

.meas tran vdout0_19ck680 FIND v(dout0_19) AT=345.025n

.meas tran vdout0_20ck680 FIND v(dout0_20) AT=345.025n

.meas tran vdout0_21ck680 FIND v(dout0_21) AT=345.025n

.meas tran vdout0_22ck680 FIND v(dout0_22) AT=345.025n

.meas tran vdout0_23ck680 FIND v(dout0_23) AT=345.025n

.meas tran vdout0_24ck680 FIND v(dout0_24) AT=345.025n

.meas tran vdout0_25ck680 FIND v(dout0_25) AT=345.025n

.meas tran vdout0_26ck680 FIND v(dout0_26) AT=345.025n

.meas tran vdout0_27ck680 FIND v(dout0_27) AT=345.025n

.meas tran vdout0_28ck680 FIND v(dout0_28) AT=345.025n

.meas tran vdout0_29ck680 FIND v(dout0_29) AT=345.025n

.meas tran vdout0_30ck680 FIND v(dout0_30) AT=345.025n

.meas tran vdout0_31ck680 FIND v(dout0_31) AT=345.025n

.meas tran vdout0_32ck680 FIND v(dout0_32) AT=345.025n

.meas tran vdout0_33ck680 FIND v(dout0_33) AT=345.025n

.meas tran vdout0_34ck680 FIND v(dout0_34) AT=345.025n

.meas tran vdout0_35ck680 FIND v(dout0_35) AT=345.025n

.meas tran vdout0_36ck680 FIND v(dout0_36) AT=345.025n

.meas tran vdout0_37ck680 FIND v(dout0_37) AT=345.025n

.meas tran vdout0_38ck680 FIND v(dout0_38) AT=345.025n

.meas tran vdout0_39ck680 FIND v(dout0_39) AT=345.025n

.meas tran vdout0_40ck680 FIND v(dout0_40) AT=345.025n

.meas tran vdout0_41ck680 FIND v(dout0_41) AT=345.025n

.meas tran vdout0_42ck680 FIND v(dout0_42) AT=345.025n

.meas tran vdout0_43ck680 FIND v(dout0_43) AT=345.025n

.meas tran vdout0_44ck680 FIND v(dout0_44) AT=345.025n

.meas tran vdout0_45ck680 FIND v(dout0_45) AT=345.025n

.meas tran vdout0_46ck680 FIND v(dout0_46) AT=345.025n

.meas tran vdout0_47ck680 FIND v(dout0_47) AT=345.025n

.meas tran vdout0_48ck680 FIND v(dout0_48) AT=345.025n

.meas tran vdout0_49ck680 FIND v(dout0_49) AT=345.025n

.meas tran vdout0_50ck680 FIND v(dout0_50) AT=345.025n

.meas tran vdout0_51ck680 FIND v(dout0_51) AT=345.025n

.meas tran vdout0_52ck680 FIND v(dout0_52) AT=345.025n

.meas tran vdout0_53ck680 FIND v(dout0_53) AT=345.025n

.meas tran vdout0_54ck680 FIND v(dout0_54) AT=345.025n

.meas tran vdout0_55ck680 FIND v(dout0_55) AT=345.025n

.meas tran vdout0_56ck680 FIND v(dout0_56) AT=345.025n

.meas tran vdout0_57ck680 FIND v(dout0_57) AT=345.025n

.meas tran vdout0_58ck680 FIND v(dout0_58) AT=345.025n

.meas tran vdout0_59ck680 FIND v(dout0_59) AT=345.025n

.meas tran vdout0_60ck680 FIND v(dout0_60) AT=345.025n

.meas tran vdout0_61ck680 FIND v(dout0_61) AT=345.025n

.meas tran vdout0_62ck680 FIND v(dout0_62) AT=345.025n

.meas tran vdout0_63ck680 FIND v(dout0_63) AT=345.025n

.meas tran vdout0_64ck680 FIND v(dout0_64) AT=345.025n

.meas tran vdout0_65ck680 FIND v(dout0_65) AT=345.025n

.meas tran vdout0_66ck680 FIND v(dout0_66) AT=345.025n

.meas tran vdout0_67ck680 FIND v(dout0_67) AT=345.025n

.meas tran vdout0_68ck680 FIND v(dout0_68) AT=345.025n

.meas tran vdout0_69ck680 FIND v(dout0_69) AT=345.025n

.meas tran vdout0_70ck680 FIND v(dout0_70) AT=345.025n

.meas tran vdout0_71ck680 FIND v(dout0_71) AT=345.025n

.meas tran vdout0_72ck680 FIND v(dout0_72) AT=345.025n

.meas tran vdout0_73ck680 FIND v(dout0_73) AT=345.025n

.meas tran vdout0_74ck680 FIND v(dout0_74) AT=345.025n

.meas tran vdout0_75ck680 FIND v(dout0_75) AT=345.025n

.meas tran vdout0_76ck680 FIND v(dout0_76) AT=345.025n

.meas tran vdout0_77ck680 FIND v(dout0_77) AT=345.025n

.meas tran vdout0_78ck680 FIND v(dout0_78) AT=345.025n

.meas tran vdout0_79ck680 FIND v(dout0_79) AT=345.025n

.meas tran vdout0_80ck680 FIND v(dout0_80) AT=345.025n

.meas tran vdout0_81ck680 FIND v(dout0_81) AT=345.025n

.meas tran vdout0_82ck680 FIND v(dout0_82) AT=345.025n

.meas tran vdout0_83ck680 FIND v(dout0_83) AT=345.025n

.meas tran vdout0_84ck680 FIND v(dout0_84) AT=345.025n

.meas tran vdout0_85ck680 FIND v(dout0_85) AT=345.025n

.meas tran vdout0_86ck680 FIND v(dout0_86) AT=345.025n

.meas tran vdout0_87ck680 FIND v(dout0_87) AT=345.025n

.meas tran vdout0_88ck680 FIND v(dout0_88) AT=345.025n

.meas tran vdout0_89ck680 FIND v(dout0_89) AT=345.025n

.meas tran vdout0_90ck680 FIND v(dout0_90) AT=345.025n

.meas tran vdout0_91ck680 FIND v(dout0_91) AT=345.025n

.meas tran vdout0_92ck680 FIND v(dout0_92) AT=345.025n

.meas tran vdout0_93ck680 FIND v(dout0_93) AT=345.025n

.meas tran vdout0_94ck680 FIND v(dout0_94) AT=345.025n

.meas tran vdout0_95ck680 FIND v(dout0_95) AT=345.025n

.meas tran vdout0_96ck680 FIND v(dout0_96) AT=345.025n

.meas tran vdout0_97ck680 FIND v(dout0_97) AT=345.025n

.meas tran vdout0_98ck680 FIND v(dout0_98) AT=345.025n

.meas tran vdout0_99ck680 FIND v(dout0_99) AT=345.025n

.meas tran vdout0_100ck680 FIND v(dout0_100) AT=345.025n

.meas tran vdout0_101ck680 FIND v(dout0_101) AT=345.025n

.meas tran vdout0_102ck680 FIND v(dout0_102) AT=345.025n

.meas tran vdout0_103ck680 FIND v(dout0_103) AT=345.025n

.meas tran vdout0_104ck680 FIND v(dout0_104) AT=345.025n

.meas tran vdout0_105ck680 FIND v(dout0_105) AT=345.025n

.meas tran vdout0_106ck680 FIND v(dout0_106) AT=345.025n

.meas tran vdout0_107ck680 FIND v(dout0_107) AT=345.025n

.meas tran vdout0_108ck680 FIND v(dout0_108) AT=345.025n

.meas tran vdout0_109ck680 FIND v(dout0_109) AT=345.025n

.meas tran vdout0_110ck680 FIND v(dout0_110) AT=345.025n

.meas tran vdout0_111ck680 FIND v(dout0_111) AT=345.025n

.meas tran vdout0_112ck680 FIND v(dout0_112) AT=345.025n

.meas tran vdout0_113ck680 FIND v(dout0_113) AT=345.025n

.meas tran vdout0_114ck680 FIND v(dout0_114) AT=345.025n

.meas tran vdout0_115ck680 FIND v(dout0_115) AT=345.025n

.meas tran vdout0_116ck680 FIND v(dout0_116) AT=345.025n

.meas tran vdout0_117ck680 FIND v(dout0_117) AT=345.025n

.meas tran vdout0_118ck680 FIND v(dout0_118) AT=345.025n

.meas tran vdout0_119ck680 FIND v(dout0_119) AT=345.025n

.meas tran vdout0_120ck680 FIND v(dout0_120) AT=345.025n

.meas tran vdout0_121ck680 FIND v(dout0_121) AT=345.025n

.meas tran vdout0_122ck680 FIND v(dout0_122) AT=345.025n

.meas tran vdout0_123ck680 FIND v(dout0_123) AT=345.025n

.meas tran vdout0_124ck680 FIND v(dout0_124) AT=345.025n

.meas tran vdout0_125ck680 FIND v(dout0_125) AT=345.025n

.meas tran vdout0_126ck680 FIND v(dout0_126) AT=345.025n

.meas tran vdout0_127ck680 FIND v(dout0_127) AT=345.025n

.meas tran vdout0_128ck680 FIND v(dout0_128) AT=345.025n

.meas tran vdout0_129ck680 FIND v(dout0_129) AT=345.025n

.meas tran vdout0_130ck680 FIND v(dout0_130) AT=345.025n

.meas tran vdout0_131ck680 FIND v(dout0_131) AT=345.025n

.meas tran vdout0_132ck680 FIND v(dout0_132) AT=345.025n

.meas tran vdout0_133ck680 FIND v(dout0_133) AT=345.025n

.meas tran vdout0_134ck680 FIND v(dout0_134) AT=345.025n

.meas tran vdout0_135ck680 FIND v(dout0_135) AT=345.025n

.meas tran vdout0_136ck680 FIND v(dout0_136) AT=345.025n

.meas tran vdout0_137ck680 FIND v(dout0_137) AT=345.025n

.meas tran vdout0_138ck680 FIND v(dout0_138) AT=345.025n

.meas tran vdout0_139ck680 FIND v(dout0_139) AT=345.025n

.meas tran vdout0_140ck680 FIND v(dout0_140) AT=345.025n

.meas tran vdout0_141ck680 FIND v(dout0_141) AT=345.025n

.meas tran vdout0_142ck680 FIND v(dout0_142) AT=345.025n

.meas tran vdout0_143ck680 FIND v(dout0_143) AT=345.025n

.meas tran vdout0_144ck680 FIND v(dout0_144) AT=345.025n

.meas tran vdout0_145ck680 FIND v(dout0_145) AT=345.025n

.meas tran vdout0_146ck680 FIND v(dout0_146) AT=345.025n

.meas tran vdout0_147ck680 FIND v(dout0_147) AT=345.025n

.meas tran vdout0_148ck680 FIND v(dout0_148) AT=345.025n

.meas tran vdout0_149ck680 FIND v(dout0_149) AT=345.025n

.meas tran vdout0_150ck680 FIND v(dout0_150) AT=345.025n

.meas tran vdout0_151ck680 FIND v(dout0_151) AT=345.025n

.meas tran vdout0_152ck680 FIND v(dout0_152) AT=345.025n

.meas tran vdout0_153ck680 FIND v(dout0_153) AT=345.025n

.meas tran vdout0_154ck680 FIND v(dout0_154) AT=345.025n

.meas tran vdout0_155ck680 FIND v(dout0_155) AT=345.025n

.meas tran vdout0_156ck680 FIND v(dout0_156) AT=345.025n

.meas tran vdout0_157ck680 FIND v(dout0_157) AT=345.025n

.meas tran vdout0_158ck680 FIND v(dout0_158) AT=345.025n

.meas tran vdout0_159ck680 FIND v(dout0_159) AT=345.025n

.meas tran vdout0_160ck680 FIND v(dout0_160) AT=345.025n

.meas tran vdout0_161ck680 FIND v(dout0_161) AT=345.025n

.meas tran vdout0_162ck680 FIND v(dout0_162) AT=345.025n

.meas tran vdout0_163ck680 FIND v(dout0_163) AT=345.025n

.meas tran vdout0_164ck680 FIND v(dout0_164) AT=345.025n

.meas tran vdout0_165ck680 FIND v(dout0_165) AT=345.025n

.meas tran vdout0_166ck680 FIND v(dout0_166) AT=345.025n

.meas tran vdout0_167ck680 FIND v(dout0_167) AT=345.025n

.meas tran vdout0_168ck680 FIND v(dout0_168) AT=345.025n

.meas tran vdout0_169ck680 FIND v(dout0_169) AT=345.025n

.meas tran vdout0_170ck680 FIND v(dout0_170) AT=345.025n

.meas tran vdout0_171ck680 FIND v(dout0_171) AT=345.025n

.meas tran vdout0_172ck680 FIND v(dout0_172) AT=345.025n

.meas tran vdout0_173ck680 FIND v(dout0_173) AT=345.025n

.meas tran vdout0_174ck680 FIND v(dout0_174) AT=345.025n

.meas tran vdout0_175ck680 FIND v(dout0_175) AT=345.025n

.meas tran vdout0_176ck680 FIND v(dout0_176) AT=345.025n

.meas tran vdout0_177ck680 FIND v(dout0_177) AT=345.025n

.meas tran vdout0_178ck680 FIND v(dout0_178) AT=345.025n

.meas tran vdout0_179ck680 FIND v(dout0_179) AT=345.025n

.meas tran vdout0_180ck680 FIND v(dout0_180) AT=345.025n

.meas tran vdout0_181ck680 FIND v(dout0_181) AT=345.025n

.meas tran vdout0_182ck680 FIND v(dout0_182) AT=345.025n

.meas tran vdout0_183ck680 FIND v(dout0_183) AT=345.025n

.meas tran vdout0_184ck680 FIND v(dout0_184) AT=345.025n

.meas tran vdout0_185ck680 FIND v(dout0_185) AT=345.025n

.meas tran vdout0_186ck680 FIND v(dout0_186) AT=345.025n

.meas tran vdout0_187ck680 FIND v(dout0_187) AT=345.025n

.meas tran vdout0_188ck680 FIND v(dout0_188) AT=345.025n

.meas tran vdout0_189ck680 FIND v(dout0_189) AT=345.025n

.meas tran vdout0_190ck680 FIND v(dout0_190) AT=345.025n

.meas tran vdout0_191ck680 FIND v(dout0_191) AT=345.025n

.meas tran vdout0_192ck680 FIND v(dout0_192) AT=345.025n

.meas tran vdout0_193ck680 FIND v(dout0_193) AT=345.025n

.meas tran vdout0_194ck680 FIND v(dout0_194) AT=345.025n

.meas tran vdout0_195ck680 FIND v(dout0_195) AT=345.025n

.meas tran vdout0_196ck680 FIND v(dout0_196) AT=345.025n

.meas tran vdout0_197ck680 FIND v(dout0_197) AT=345.025n

.meas tran vdout0_198ck680 FIND v(dout0_198) AT=345.025n

.meas tran vdout0_199ck680 FIND v(dout0_199) AT=345.025n

.meas tran vdout0_200ck680 FIND v(dout0_200) AT=345.025n

.meas tran vdout0_201ck680 FIND v(dout0_201) AT=345.025n

.meas tran vdout0_202ck680 FIND v(dout0_202) AT=345.025n

.meas tran vdout0_203ck680 FIND v(dout0_203) AT=345.025n

.meas tran vdout0_204ck680 FIND v(dout0_204) AT=345.025n

.meas tran vdout0_205ck680 FIND v(dout0_205) AT=345.025n

.meas tran vdout0_206ck680 FIND v(dout0_206) AT=345.025n

.meas tran vdout0_207ck680 FIND v(dout0_207) AT=345.025n

.meas tran vdout0_208ck680 FIND v(dout0_208) AT=345.025n

.meas tran vdout0_209ck680 FIND v(dout0_209) AT=345.025n

.meas tran vdout0_210ck680 FIND v(dout0_210) AT=345.025n

.meas tran vdout0_211ck680 FIND v(dout0_211) AT=345.025n

.meas tran vdout0_212ck680 FIND v(dout0_212) AT=345.025n

.meas tran vdout0_213ck680 FIND v(dout0_213) AT=345.025n

.meas tran vdout0_214ck680 FIND v(dout0_214) AT=345.025n

.meas tran vdout0_215ck680 FIND v(dout0_215) AT=345.025n

.meas tran vdout0_216ck680 FIND v(dout0_216) AT=345.025n

.meas tran vdout0_217ck680 FIND v(dout0_217) AT=345.025n

.meas tran vdout0_218ck680 FIND v(dout0_218) AT=345.025n

.meas tran vdout0_219ck680 FIND v(dout0_219) AT=345.025n

.meas tran vdout0_220ck680 FIND v(dout0_220) AT=345.025n

.meas tran vdout0_221ck680 FIND v(dout0_221) AT=345.025n

.meas tran vdout0_222ck680 FIND v(dout0_222) AT=345.025n

.meas tran vdout0_223ck680 FIND v(dout0_223) AT=345.025n

.meas tran vdout0_224ck680 FIND v(dout0_224) AT=345.025n

.meas tran vdout0_225ck680 FIND v(dout0_225) AT=345.025n

.meas tran vdout0_226ck680 FIND v(dout0_226) AT=345.025n

.meas tran vdout0_227ck680 FIND v(dout0_227) AT=345.025n

.meas tran vdout0_228ck680 FIND v(dout0_228) AT=345.025n

.meas tran vdout0_229ck680 FIND v(dout0_229) AT=345.025n

.meas tran vdout0_230ck680 FIND v(dout0_230) AT=345.025n

.meas tran vdout0_231ck680 FIND v(dout0_231) AT=345.025n

.meas tran vdout0_232ck680 FIND v(dout0_232) AT=345.025n

.meas tran vdout0_233ck680 FIND v(dout0_233) AT=345.025n

.meas tran vdout0_234ck680 FIND v(dout0_234) AT=345.025n

.meas tran vdout0_235ck680 FIND v(dout0_235) AT=345.025n

.meas tran vdout0_236ck680 FIND v(dout0_236) AT=345.025n

.meas tran vdout0_237ck680 FIND v(dout0_237) AT=345.025n

.meas tran vdout0_238ck680 FIND v(dout0_238) AT=345.025n

.meas tran vdout0_239ck680 FIND v(dout0_239) AT=345.025n

.meas tran vdout0_240ck680 FIND v(dout0_240) AT=345.025n

.meas tran vdout0_241ck680 FIND v(dout0_241) AT=345.025n

.meas tran vdout0_242ck680 FIND v(dout0_242) AT=345.025n

.meas tran vdout0_243ck680 FIND v(dout0_243) AT=345.025n

.meas tran vdout0_244ck680 FIND v(dout0_244) AT=345.025n

.meas tran vdout0_245ck680 FIND v(dout0_245) AT=345.025n

.meas tran vdout0_246ck680 FIND v(dout0_246) AT=345.025n

.meas tran vdout0_247ck680 FIND v(dout0_247) AT=345.025n

.meas tran vdout0_248ck680 FIND v(dout0_248) AT=345.025n

.meas tran vdout0_249ck680 FIND v(dout0_249) AT=345.025n

.meas tran vdout0_250ck680 FIND v(dout0_250) AT=345.025n

.meas tran vdout0_251ck680 FIND v(dout0_251) AT=345.025n

.meas tran vdout0_252ck680 FIND v(dout0_252) AT=345.025n

.meas tran vdout0_253ck680 FIND v(dout0_253) AT=345.025n

.meas tran vdout0_254ck680 FIND v(dout0_254) AT=345.025n

.meas tran vdout0_255ck680 FIND v(dout0_255) AT=345.025n

.meas tran vdout0_0ck690 FIND v(dout0_0) AT=350.025n

.meas tran vdout0_1ck690 FIND v(dout0_1) AT=350.025n

.meas tran vdout0_2ck690 FIND v(dout0_2) AT=350.025n

.meas tran vdout0_3ck690 FIND v(dout0_3) AT=350.025n

.meas tran vdout0_4ck690 FIND v(dout0_4) AT=350.025n

.meas tran vdout0_5ck690 FIND v(dout0_5) AT=350.025n

.meas tran vdout0_6ck690 FIND v(dout0_6) AT=350.025n

.meas tran vdout0_7ck690 FIND v(dout0_7) AT=350.025n

.meas tran vdout0_8ck690 FIND v(dout0_8) AT=350.025n

.meas tran vdout0_9ck690 FIND v(dout0_9) AT=350.025n

.meas tran vdout0_10ck690 FIND v(dout0_10) AT=350.025n

.meas tran vdout0_11ck690 FIND v(dout0_11) AT=350.025n

.meas tran vdout0_12ck690 FIND v(dout0_12) AT=350.025n

.meas tran vdout0_13ck690 FIND v(dout0_13) AT=350.025n

.meas tran vdout0_14ck690 FIND v(dout0_14) AT=350.025n

.meas tran vdout0_15ck690 FIND v(dout0_15) AT=350.025n

.meas tran vdout0_16ck690 FIND v(dout0_16) AT=350.025n

.meas tran vdout0_17ck690 FIND v(dout0_17) AT=350.025n

.meas tran vdout0_18ck690 FIND v(dout0_18) AT=350.025n

.meas tran vdout0_19ck690 FIND v(dout0_19) AT=350.025n

.meas tran vdout0_20ck690 FIND v(dout0_20) AT=350.025n

.meas tran vdout0_21ck690 FIND v(dout0_21) AT=350.025n

.meas tran vdout0_22ck690 FIND v(dout0_22) AT=350.025n

.meas tran vdout0_23ck690 FIND v(dout0_23) AT=350.025n

.meas tran vdout0_24ck690 FIND v(dout0_24) AT=350.025n

.meas tran vdout0_25ck690 FIND v(dout0_25) AT=350.025n

.meas tran vdout0_26ck690 FIND v(dout0_26) AT=350.025n

.meas tran vdout0_27ck690 FIND v(dout0_27) AT=350.025n

.meas tran vdout0_28ck690 FIND v(dout0_28) AT=350.025n

.meas tran vdout0_29ck690 FIND v(dout0_29) AT=350.025n

.meas tran vdout0_30ck690 FIND v(dout0_30) AT=350.025n

.meas tran vdout0_31ck690 FIND v(dout0_31) AT=350.025n

.meas tran vdout0_32ck690 FIND v(dout0_32) AT=350.025n

.meas tran vdout0_33ck690 FIND v(dout0_33) AT=350.025n

.meas tran vdout0_34ck690 FIND v(dout0_34) AT=350.025n

.meas tran vdout0_35ck690 FIND v(dout0_35) AT=350.025n

.meas tran vdout0_36ck690 FIND v(dout0_36) AT=350.025n

.meas tran vdout0_37ck690 FIND v(dout0_37) AT=350.025n

.meas tran vdout0_38ck690 FIND v(dout0_38) AT=350.025n

.meas tran vdout0_39ck690 FIND v(dout0_39) AT=350.025n

.meas tran vdout0_40ck690 FIND v(dout0_40) AT=350.025n

.meas tran vdout0_41ck690 FIND v(dout0_41) AT=350.025n

.meas tran vdout0_42ck690 FIND v(dout0_42) AT=350.025n

.meas tran vdout0_43ck690 FIND v(dout0_43) AT=350.025n

.meas tran vdout0_44ck690 FIND v(dout0_44) AT=350.025n

.meas tran vdout0_45ck690 FIND v(dout0_45) AT=350.025n

.meas tran vdout0_46ck690 FIND v(dout0_46) AT=350.025n

.meas tran vdout0_47ck690 FIND v(dout0_47) AT=350.025n

.meas tran vdout0_48ck690 FIND v(dout0_48) AT=350.025n

.meas tran vdout0_49ck690 FIND v(dout0_49) AT=350.025n

.meas tran vdout0_50ck690 FIND v(dout0_50) AT=350.025n

.meas tran vdout0_51ck690 FIND v(dout0_51) AT=350.025n

.meas tran vdout0_52ck690 FIND v(dout0_52) AT=350.025n

.meas tran vdout0_53ck690 FIND v(dout0_53) AT=350.025n

.meas tran vdout0_54ck690 FIND v(dout0_54) AT=350.025n

.meas tran vdout0_55ck690 FIND v(dout0_55) AT=350.025n

.meas tran vdout0_56ck690 FIND v(dout0_56) AT=350.025n

.meas tran vdout0_57ck690 FIND v(dout0_57) AT=350.025n

.meas tran vdout0_58ck690 FIND v(dout0_58) AT=350.025n

.meas tran vdout0_59ck690 FIND v(dout0_59) AT=350.025n

.meas tran vdout0_60ck690 FIND v(dout0_60) AT=350.025n

.meas tran vdout0_61ck690 FIND v(dout0_61) AT=350.025n

.meas tran vdout0_62ck690 FIND v(dout0_62) AT=350.025n

.meas tran vdout0_63ck690 FIND v(dout0_63) AT=350.025n

.meas tran vdout0_64ck690 FIND v(dout0_64) AT=350.025n

.meas tran vdout0_65ck690 FIND v(dout0_65) AT=350.025n

.meas tran vdout0_66ck690 FIND v(dout0_66) AT=350.025n

.meas tran vdout0_67ck690 FIND v(dout0_67) AT=350.025n

.meas tran vdout0_68ck690 FIND v(dout0_68) AT=350.025n

.meas tran vdout0_69ck690 FIND v(dout0_69) AT=350.025n

.meas tran vdout0_70ck690 FIND v(dout0_70) AT=350.025n

.meas tran vdout0_71ck690 FIND v(dout0_71) AT=350.025n

.meas tran vdout0_72ck690 FIND v(dout0_72) AT=350.025n

.meas tran vdout0_73ck690 FIND v(dout0_73) AT=350.025n

.meas tran vdout0_74ck690 FIND v(dout0_74) AT=350.025n

.meas tran vdout0_75ck690 FIND v(dout0_75) AT=350.025n

.meas tran vdout0_76ck690 FIND v(dout0_76) AT=350.025n

.meas tran vdout0_77ck690 FIND v(dout0_77) AT=350.025n

.meas tran vdout0_78ck690 FIND v(dout0_78) AT=350.025n

.meas tran vdout0_79ck690 FIND v(dout0_79) AT=350.025n

.meas tran vdout0_80ck690 FIND v(dout0_80) AT=350.025n

.meas tran vdout0_81ck690 FIND v(dout0_81) AT=350.025n

.meas tran vdout0_82ck690 FIND v(dout0_82) AT=350.025n

.meas tran vdout0_83ck690 FIND v(dout0_83) AT=350.025n

.meas tran vdout0_84ck690 FIND v(dout0_84) AT=350.025n

.meas tran vdout0_85ck690 FIND v(dout0_85) AT=350.025n

.meas tran vdout0_86ck690 FIND v(dout0_86) AT=350.025n

.meas tran vdout0_87ck690 FIND v(dout0_87) AT=350.025n

.meas tran vdout0_88ck690 FIND v(dout0_88) AT=350.025n

.meas tran vdout0_89ck690 FIND v(dout0_89) AT=350.025n

.meas tran vdout0_90ck690 FIND v(dout0_90) AT=350.025n

.meas tran vdout0_91ck690 FIND v(dout0_91) AT=350.025n

.meas tran vdout0_92ck690 FIND v(dout0_92) AT=350.025n

.meas tran vdout0_93ck690 FIND v(dout0_93) AT=350.025n

.meas tran vdout0_94ck690 FIND v(dout0_94) AT=350.025n

.meas tran vdout0_95ck690 FIND v(dout0_95) AT=350.025n

.meas tran vdout0_96ck690 FIND v(dout0_96) AT=350.025n

.meas tran vdout0_97ck690 FIND v(dout0_97) AT=350.025n

.meas tran vdout0_98ck690 FIND v(dout0_98) AT=350.025n

.meas tran vdout0_99ck690 FIND v(dout0_99) AT=350.025n

.meas tran vdout0_100ck690 FIND v(dout0_100) AT=350.025n

.meas tran vdout0_101ck690 FIND v(dout0_101) AT=350.025n

.meas tran vdout0_102ck690 FIND v(dout0_102) AT=350.025n

.meas tran vdout0_103ck690 FIND v(dout0_103) AT=350.025n

.meas tran vdout0_104ck690 FIND v(dout0_104) AT=350.025n

.meas tran vdout0_105ck690 FIND v(dout0_105) AT=350.025n

.meas tran vdout0_106ck690 FIND v(dout0_106) AT=350.025n

.meas tran vdout0_107ck690 FIND v(dout0_107) AT=350.025n

.meas tran vdout0_108ck690 FIND v(dout0_108) AT=350.025n

.meas tran vdout0_109ck690 FIND v(dout0_109) AT=350.025n

.meas tran vdout0_110ck690 FIND v(dout0_110) AT=350.025n

.meas tran vdout0_111ck690 FIND v(dout0_111) AT=350.025n

.meas tran vdout0_112ck690 FIND v(dout0_112) AT=350.025n

.meas tran vdout0_113ck690 FIND v(dout0_113) AT=350.025n

.meas tran vdout0_114ck690 FIND v(dout0_114) AT=350.025n

.meas tran vdout0_115ck690 FIND v(dout0_115) AT=350.025n

.meas tran vdout0_116ck690 FIND v(dout0_116) AT=350.025n

.meas tran vdout0_117ck690 FIND v(dout0_117) AT=350.025n

.meas tran vdout0_118ck690 FIND v(dout0_118) AT=350.025n

.meas tran vdout0_119ck690 FIND v(dout0_119) AT=350.025n

.meas tran vdout0_120ck690 FIND v(dout0_120) AT=350.025n

.meas tran vdout0_121ck690 FIND v(dout0_121) AT=350.025n

.meas tran vdout0_122ck690 FIND v(dout0_122) AT=350.025n

.meas tran vdout0_123ck690 FIND v(dout0_123) AT=350.025n

.meas tran vdout0_124ck690 FIND v(dout0_124) AT=350.025n

.meas tran vdout0_125ck690 FIND v(dout0_125) AT=350.025n

.meas tran vdout0_126ck690 FIND v(dout0_126) AT=350.025n

.meas tran vdout0_127ck690 FIND v(dout0_127) AT=350.025n

.meas tran vdout0_128ck690 FIND v(dout0_128) AT=350.025n

.meas tran vdout0_129ck690 FIND v(dout0_129) AT=350.025n

.meas tran vdout0_130ck690 FIND v(dout0_130) AT=350.025n

.meas tran vdout0_131ck690 FIND v(dout0_131) AT=350.025n

.meas tran vdout0_132ck690 FIND v(dout0_132) AT=350.025n

.meas tran vdout0_133ck690 FIND v(dout0_133) AT=350.025n

.meas tran vdout0_134ck690 FIND v(dout0_134) AT=350.025n

.meas tran vdout0_135ck690 FIND v(dout0_135) AT=350.025n

.meas tran vdout0_136ck690 FIND v(dout0_136) AT=350.025n

.meas tran vdout0_137ck690 FIND v(dout0_137) AT=350.025n

.meas tran vdout0_138ck690 FIND v(dout0_138) AT=350.025n

.meas tran vdout0_139ck690 FIND v(dout0_139) AT=350.025n

.meas tran vdout0_140ck690 FIND v(dout0_140) AT=350.025n

.meas tran vdout0_141ck690 FIND v(dout0_141) AT=350.025n

.meas tran vdout0_142ck690 FIND v(dout0_142) AT=350.025n

.meas tran vdout0_143ck690 FIND v(dout0_143) AT=350.025n

.meas tran vdout0_144ck690 FIND v(dout0_144) AT=350.025n

.meas tran vdout0_145ck690 FIND v(dout0_145) AT=350.025n

.meas tran vdout0_146ck690 FIND v(dout0_146) AT=350.025n

.meas tran vdout0_147ck690 FIND v(dout0_147) AT=350.025n

.meas tran vdout0_148ck690 FIND v(dout0_148) AT=350.025n

.meas tran vdout0_149ck690 FIND v(dout0_149) AT=350.025n

.meas tran vdout0_150ck690 FIND v(dout0_150) AT=350.025n

.meas tran vdout0_151ck690 FIND v(dout0_151) AT=350.025n

.meas tran vdout0_152ck690 FIND v(dout0_152) AT=350.025n

.meas tran vdout0_153ck690 FIND v(dout0_153) AT=350.025n

.meas tran vdout0_154ck690 FIND v(dout0_154) AT=350.025n

.meas tran vdout0_155ck690 FIND v(dout0_155) AT=350.025n

.meas tran vdout0_156ck690 FIND v(dout0_156) AT=350.025n

.meas tran vdout0_157ck690 FIND v(dout0_157) AT=350.025n

.meas tran vdout0_158ck690 FIND v(dout0_158) AT=350.025n

.meas tran vdout0_159ck690 FIND v(dout0_159) AT=350.025n

.meas tran vdout0_160ck690 FIND v(dout0_160) AT=350.025n

.meas tran vdout0_161ck690 FIND v(dout0_161) AT=350.025n

.meas tran vdout0_162ck690 FIND v(dout0_162) AT=350.025n

.meas tran vdout0_163ck690 FIND v(dout0_163) AT=350.025n

.meas tran vdout0_164ck690 FIND v(dout0_164) AT=350.025n

.meas tran vdout0_165ck690 FIND v(dout0_165) AT=350.025n

.meas tran vdout0_166ck690 FIND v(dout0_166) AT=350.025n

.meas tran vdout0_167ck690 FIND v(dout0_167) AT=350.025n

.meas tran vdout0_168ck690 FIND v(dout0_168) AT=350.025n

.meas tran vdout0_169ck690 FIND v(dout0_169) AT=350.025n

.meas tran vdout0_170ck690 FIND v(dout0_170) AT=350.025n

.meas tran vdout0_171ck690 FIND v(dout0_171) AT=350.025n

.meas tran vdout0_172ck690 FIND v(dout0_172) AT=350.025n

.meas tran vdout0_173ck690 FIND v(dout0_173) AT=350.025n

.meas tran vdout0_174ck690 FIND v(dout0_174) AT=350.025n

.meas tran vdout0_175ck690 FIND v(dout0_175) AT=350.025n

.meas tran vdout0_176ck690 FIND v(dout0_176) AT=350.025n

.meas tran vdout0_177ck690 FIND v(dout0_177) AT=350.025n

.meas tran vdout0_178ck690 FIND v(dout0_178) AT=350.025n

.meas tran vdout0_179ck690 FIND v(dout0_179) AT=350.025n

.meas tran vdout0_180ck690 FIND v(dout0_180) AT=350.025n

.meas tran vdout0_181ck690 FIND v(dout0_181) AT=350.025n

.meas tran vdout0_182ck690 FIND v(dout0_182) AT=350.025n

.meas tran vdout0_183ck690 FIND v(dout0_183) AT=350.025n

.meas tran vdout0_184ck690 FIND v(dout0_184) AT=350.025n

.meas tran vdout0_185ck690 FIND v(dout0_185) AT=350.025n

.meas tran vdout0_186ck690 FIND v(dout0_186) AT=350.025n

.meas tran vdout0_187ck690 FIND v(dout0_187) AT=350.025n

.meas tran vdout0_188ck690 FIND v(dout0_188) AT=350.025n

.meas tran vdout0_189ck690 FIND v(dout0_189) AT=350.025n

.meas tran vdout0_190ck690 FIND v(dout0_190) AT=350.025n

.meas tran vdout0_191ck690 FIND v(dout0_191) AT=350.025n

.meas tran vdout0_192ck690 FIND v(dout0_192) AT=350.025n

.meas tran vdout0_193ck690 FIND v(dout0_193) AT=350.025n

.meas tran vdout0_194ck690 FIND v(dout0_194) AT=350.025n

.meas tran vdout0_195ck690 FIND v(dout0_195) AT=350.025n

.meas tran vdout0_196ck690 FIND v(dout0_196) AT=350.025n

.meas tran vdout0_197ck690 FIND v(dout0_197) AT=350.025n

.meas tran vdout0_198ck690 FIND v(dout0_198) AT=350.025n

.meas tran vdout0_199ck690 FIND v(dout0_199) AT=350.025n

.meas tran vdout0_200ck690 FIND v(dout0_200) AT=350.025n

.meas tran vdout0_201ck690 FIND v(dout0_201) AT=350.025n

.meas tran vdout0_202ck690 FIND v(dout0_202) AT=350.025n

.meas tran vdout0_203ck690 FIND v(dout0_203) AT=350.025n

.meas tran vdout0_204ck690 FIND v(dout0_204) AT=350.025n

.meas tran vdout0_205ck690 FIND v(dout0_205) AT=350.025n

.meas tran vdout0_206ck690 FIND v(dout0_206) AT=350.025n

.meas tran vdout0_207ck690 FIND v(dout0_207) AT=350.025n

.meas tran vdout0_208ck690 FIND v(dout0_208) AT=350.025n

.meas tran vdout0_209ck690 FIND v(dout0_209) AT=350.025n

.meas tran vdout0_210ck690 FIND v(dout0_210) AT=350.025n

.meas tran vdout0_211ck690 FIND v(dout0_211) AT=350.025n

.meas tran vdout0_212ck690 FIND v(dout0_212) AT=350.025n

.meas tran vdout0_213ck690 FIND v(dout0_213) AT=350.025n

.meas tran vdout0_214ck690 FIND v(dout0_214) AT=350.025n

.meas tran vdout0_215ck690 FIND v(dout0_215) AT=350.025n

.meas tran vdout0_216ck690 FIND v(dout0_216) AT=350.025n

.meas tran vdout0_217ck690 FIND v(dout0_217) AT=350.025n

.meas tran vdout0_218ck690 FIND v(dout0_218) AT=350.025n

.meas tran vdout0_219ck690 FIND v(dout0_219) AT=350.025n

.meas tran vdout0_220ck690 FIND v(dout0_220) AT=350.025n

.meas tran vdout0_221ck690 FIND v(dout0_221) AT=350.025n

.meas tran vdout0_222ck690 FIND v(dout0_222) AT=350.025n

.meas tran vdout0_223ck690 FIND v(dout0_223) AT=350.025n

.meas tran vdout0_224ck690 FIND v(dout0_224) AT=350.025n

.meas tran vdout0_225ck690 FIND v(dout0_225) AT=350.025n

.meas tran vdout0_226ck690 FIND v(dout0_226) AT=350.025n

.meas tran vdout0_227ck690 FIND v(dout0_227) AT=350.025n

.meas tran vdout0_228ck690 FIND v(dout0_228) AT=350.025n

.meas tran vdout0_229ck690 FIND v(dout0_229) AT=350.025n

.meas tran vdout0_230ck690 FIND v(dout0_230) AT=350.025n

.meas tran vdout0_231ck690 FIND v(dout0_231) AT=350.025n

.meas tran vdout0_232ck690 FIND v(dout0_232) AT=350.025n

.meas tran vdout0_233ck690 FIND v(dout0_233) AT=350.025n

.meas tran vdout0_234ck690 FIND v(dout0_234) AT=350.025n

.meas tran vdout0_235ck690 FIND v(dout0_235) AT=350.025n

.meas tran vdout0_236ck690 FIND v(dout0_236) AT=350.025n

.meas tran vdout0_237ck690 FIND v(dout0_237) AT=350.025n

.meas tran vdout0_238ck690 FIND v(dout0_238) AT=350.025n

.meas tran vdout0_239ck690 FIND v(dout0_239) AT=350.025n

.meas tran vdout0_240ck690 FIND v(dout0_240) AT=350.025n

.meas tran vdout0_241ck690 FIND v(dout0_241) AT=350.025n

.meas tran vdout0_242ck690 FIND v(dout0_242) AT=350.025n

.meas tran vdout0_243ck690 FIND v(dout0_243) AT=350.025n

.meas tran vdout0_244ck690 FIND v(dout0_244) AT=350.025n

.meas tran vdout0_245ck690 FIND v(dout0_245) AT=350.025n

.meas tran vdout0_246ck690 FIND v(dout0_246) AT=350.025n

.meas tran vdout0_247ck690 FIND v(dout0_247) AT=350.025n

.meas tran vdout0_248ck690 FIND v(dout0_248) AT=350.025n

.meas tran vdout0_249ck690 FIND v(dout0_249) AT=350.025n

.meas tran vdout0_250ck690 FIND v(dout0_250) AT=350.025n

.meas tran vdout0_251ck690 FIND v(dout0_251) AT=350.025n

.meas tran vdout0_252ck690 FIND v(dout0_252) AT=350.025n

.meas tran vdout0_253ck690 FIND v(dout0_253) AT=350.025n

.meas tran vdout0_254ck690 FIND v(dout0_254) AT=350.025n

.meas tran vdout0_255ck690 FIND v(dout0_255) AT=350.025n

.meas tran vdout0_0ck730 FIND v(dout0_0) AT=370.025n

.meas tran vdout0_1ck730 FIND v(dout0_1) AT=370.025n

.meas tran vdout0_2ck730 FIND v(dout0_2) AT=370.025n

.meas tran vdout0_3ck730 FIND v(dout0_3) AT=370.025n

.meas tran vdout0_4ck730 FIND v(dout0_4) AT=370.025n

.meas tran vdout0_5ck730 FIND v(dout0_5) AT=370.025n

.meas tran vdout0_6ck730 FIND v(dout0_6) AT=370.025n

.meas tran vdout0_7ck730 FIND v(dout0_7) AT=370.025n

.meas tran vdout0_8ck730 FIND v(dout0_8) AT=370.025n

.meas tran vdout0_9ck730 FIND v(dout0_9) AT=370.025n

.meas tran vdout0_10ck730 FIND v(dout0_10) AT=370.025n

.meas tran vdout0_11ck730 FIND v(dout0_11) AT=370.025n

.meas tran vdout0_12ck730 FIND v(dout0_12) AT=370.025n

.meas tran vdout0_13ck730 FIND v(dout0_13) AT=370.025n

.meas tran vdout0_14ck730 FIND v(dout0_14) AT=370.025n

.meas tran vdout0_15ck730 FIND v(dout0_15) AT=370.025n

.meas tran vdout0_16ck730 FIND v(dout0_16) AT=370.025n

.meas tran vdout0_17ck730 FIND v(dout0_17) AT=370.025n

.meas tran vdout0_18ck730 FIND v(dout0_18) AT=370.025n

.meas tran vdout0_19ck730 FIND v(dout0_19) AT=370.025n

.meas tran vdout0_20ck730 FIND v(dout0_20) AT=370.025n

.meas tran vdout0_21ck730 FIND v(dout0_21) AT=370.025n

.meas tran vdout0_22ck730 FIND v(dout0_22) AT=370.025n

.meas tran vdout0_23ck730 FIND v(dout0_23) AT=370.025n

.meas tran vdout0_24ck730 FIND v(dout0_24) AT=370.025n

.meas tran vdout0_25ck730 FIND v(dout0_25) AT=370.025n

.meas tran vdout0_26ck730 FIND v(dout0_26) AT=370.025n

.meas tran vdout0_27ck730 FIND v(dout0_27) AT=370.025n

.meas tran vdout0_28ck730 FIND v(dout0_28) AT=370.025n

.meas tran vdout0_29ck730 FIND v(dout0_29) AT=370.025n

.meas tran vdout0_30ck730 FIND v(dout0_30) AT=370.025n

.meas tran vdout0_31ck730 FIND v(dout0_31) AT=370.025n

.meas tran vdout0_32ck730 FIND v(dout0_32) AT=370.025n

.meas tran vdout0_33ck730 FIND v(dout0_33) AT=370.025n

.meas tran vdout0_34ck730 FIND v(dout0_34) AT=370.025n

.meas tran vdout0_35ck730 FIND v(dout0_35) AT=370.025n

.meas tran vdout0_36ck730 FIND v(dout0_36) AT=370.025n

.meas tran vdout0_37ck730 FIND v(dout0_37) AT=370.025n

.meas tran vdout0_38ck730 FIND v(dout0_38) AT=370.025n

.meas tran vdout0_39ck730 FIND v(dout0_39) AT=370.025n

.meas tran vdout0_40ck730 FIND v(dout0_40) AT=370.025n

.meas tran vdout0_41ck730 FIND v(dout0_41) AT=370.025n

.meas tran vdout0_42ck730 FIND v(dout0_42) AT=370.025n

.meas tran vdout0_43ck730 FIND v(dout0_43) AT=370.025n

.meas tran vdout0_44ck730 FIND v(dout0_44) AT=370.025n

.meas tran vdout0_45ck730 FIND v(dout0_45) AT=370.025n

.meas tran vdout0_46ck730 FIND v(dout0_46) AT=370.025n

.meas tran vdout0_47ck730 FIND v(dout0_47) AT=370.025n

.meas tran vdout0_48ck730 FIND v(dout0_48) AT=370.025n

.meas tran vdout0_49ck730 FIND v(dout0_49) AT=370.025n

.meas tran vdout0_50ck730 FIND v(dout0_50) AT=370.025n

.meas tran vdout0_51ck730 FIND v(dout0_51) AT=370.025n

.meas tran vdout0_52ck730 FIND v(dout0_52) AT=370.025n

.meas tran vdout0_53ck730 FIND v(dout0_53) AT=370.025n

.meas tran vdout0_54ck730 FIND v(dout0_54) AT=370.025n

.meas tran vdout0_55ck730 FIND v(dout0_55) AT=370.025n

.meas tran vdout0_56ck730 FIND v(dout0_56) AT=370.025n

.meas tran vdout0_57ck730 FIND v(dout0_57) AT=370.025n

.meas tran vdout0_58ck730 FIND v(dout0_58) AT=370.025n

.meas tran vdout0_59ck730 FIND v(dout0_59) AT=370.025n

.meas tran vdout0_60ck730 FIND v(dout0_60) AT=370.025n

.meas tran vdout0_61ck730 FIND v(dout0_61) AT=370.025n

.meas tran vdout0_62ck730 FIND v(dout0_62) AT=370.025n

.meas tran vdout0_63ck730 FIND v(dout0_63) AT=370.025n

.meas tran vdout0_64ck730 FIND v(dout0_64) AT=370.025n

.meas tran vdout0_65ck730 FIND v(dout0_65) AT=370.025n

.meas tran vdout0_66ck730 FIND v(dout0_66) AT=370.025n

.meas tran vdout0_67ck730 FIND v(dout0_67) AT=370.025n

.meas tran vdout0_68ck730 FIND v(dout0_68) AT=370.025n

.meas tran vdout0_69ck730 FIND v(dout0_69) AT=370.025n

.meas tran vdout0_70ck730 FIND v(dout0_70) AT=370.025n

.meas tran vdout0_71ck730 FIND v(dout0_71) AT=370.025n

.meas tran vdout0_72ck730 FIND v(dout0_72) AT=370.025n

.meas tran vdout0_73ck730 FIND v(dout0_73) AT=370.025n

.meas tran vdout0_74ck730 FIND v(dout0_74) AT=370.025n

.meas tran vdout0_75ck730 FIND v(dout0_75) AT=370.025n

.meas tran vdout0_76ck730 FIND v(dout0_76) AT=370.025n

.meas tran vdout0_77ck730 FIND v(dout0_77) AT=370.025n

.meas tran vdout0_78ck730 FIND v(dout0_78) AT=370.025n

.meas tran vdout0_79ck730 FIND v(dout0_79) AT=370.025n

.meas tran vdout0_80ck730 FIND v(dout0_80) AT=370.025n

.meas tran vdout0_81ck730 FIND v(dout0_81) AT=370.025n

.meas tran vdout0_82ck730 FIND v(dout0_82) AT=370.025n

.meas tran vdout0_83ck730 FIND v(dout0_83) AT=370.025n

.meas tran vdout0_84ck730 FIND v(dout0_84) AT=370.025n

.meas tran vdout0_85ck730 FIND v(dout0_85) AT=370.025n

.meas tran vdout0_86ck730 FIND v(dout0_86) AT=370.025n

.meas tran vdout0_87ck730 FIND v(dout0_87) AT=370.025n

.meas tran vdout0_88ck730 FIND v(dout0_88) AT=370.025n

.meas tran vdout0_89ck730 FIND v(dout0_89) AT=370.025n

.meas tran vdout0_90ck730 FIND v(dout0_90) AT=370.025n

.meas tran vdout0_91ck730 FIND v(dout0_91) AT=370.025n

.meas tran vdout0_92ck730 FIND v(dout0_92) AT=370.025n

.meas tran vdout0_93ck730 FIND v(dout0_93) AT=370.025n

.meas tran vdout0_94ck730 FIND v(dout0_94) AT=370.025n

.meas tran vdout0_95ck730 FIND v(dout0_95) AT=370.025n

.meas tran vdout0_96ck730 FIND v(dout0_96) AT=370.025n

.meas tran vdout0_97ck730 FIND v(dout0_97) AT=370.025n

.meas tran vdout0_98ck730 FIND v(dout0_98) AT=370.025n

.meas tran vdout0_99ck730 FIND v(dout0_99) AT=370.025n

.meas tran vdout0_100ck730 FIND v(dout0_100) AT=370.025n

.meas tran vdout0_101ck730 FIND v(dout0_101) AT=370.025n

.meas tran vdout0_102ck730 FIND v(dout0_102) AT=370.025n

.meas tran vdout0_103ck730 FIND v(dout0_103) AT=370.025n

.meas tran vdout0_104ck730 FIND v(dout0_104) AT=370.025n

.meas tran vdout0_105ck730 FIND v(dout0_105) AT=370.025n

.meas tran vdout0_106ck730 FIND v(dout0_106) AT=370.025n

.meas tran vdout0_107ck730 FIND v(dout0_107) AT=370.025n

.meas tran vdout0_108ck730 FIND v(dout0_108) AT=370.025n

.meas tran vdout0_109ck730 FIND v(dout0_109) AT=370.025n

.meas tran vdout0_110ck730 FIND v(dout0_110) AT=370.025n

.meas tran vdout0_111ck730 FIND v(dout0_111) AT=370.025n

.meas tran vdout0_112ck730 FIND v(dout0_112) AT=370.025n

.meas tran vdout0_113ck730 FIND v(dout0_113) AT=370.025n

.meas tran vdout0_114ck730 FIND v(dout0_114) AT=370.025n

.meas tran vdout0_115ck730 FIND v(dout0_115) AT=370.025n

.meas tran vdout0_116ck730 FIND v(dout0_116) AT=370.025n

.meas tran vdout0_117ck730 FIND v(dout0_117) AT=370.025n

.meas tran vdout0_118ck730 FIND v(dout0_118) AT=370.025n

.meas tran vdout0_119ck730 FIND v(dout0_119) AT=370.025n

.meas tran vdout0_120ck730 FIND v(dout0_120) AT=370.025n

.meas tran vdout0_121ck730 FIND v(dout0_121) AT=370.025n

.meas tran vdout0_122ck730 FIND v(dout0_122) AT=370.025n

.meas tran vdout0_123ck730 FIND v(dout0_123) AT=370.025n

.meas tran vdout0_124ck730 FIND v(dout0_124) AT=370.025n

.meas tran vdout0_125ck730 FIND v(dout0_125) AT=370.025n

.meas tran vdout0_126ck730 FIND v(dout0_126) AT=370.025n

.meas tran vdout0_127ck730 FIND v(dout0_127) AT=370.025n

.meas tran vdout0_128ck730 FIND v(dout0_128) AT=370.025n

.meas tran vdout0_129ck730 FIND v(dout0_129) AT=370.025n

.meas tran vdout0_130ck730 FIND v(dout0_130) AT=370.025n

.meas tran vdout0_131ck730 FIND v(dout0_131) AT=370.025n

.meas tran vdout0_132ck730 FIND v(dout0_132) AT=370.025n

.meas tran vdout0_133ck730 FIND v(dout0_133) AT=370.025n

.meas tran vdout0_134ck730 FIND v(dout0_134) AT=370.025n

.meas tran vdout0_135ck730 FIND v(dout0_135) AT=370.025n

.meas tran vdout0_136ck730 FIND v(dout0_136) AT=370.025n

.meas tran vdout0_137ck730 FIND v(dout0_137) AT=370.025n

.meas tran vdout0_138ck730 FIND v(dout0_138) AT=370.025n

.meas tran vdout0_139ck730 FIND v(dout0_139) AT=370.025n

.meas tran vdout0_140ck730 FIND v(dout0_140) AT=370.025n

.meas tran vdout0_141ck730 FIND v(dout0_141) AT=370.025n

.meas tran vdout0_142ck730 FIND v(dout0_142) AT=370.025n

.meas tran vdout0_143ck730 FIND v(dout0_143) AT=370.025n

.meas tran vdout0_144ck730 FIND v(dout0_144) AT=370.025n

.meas tran vdout0_145ck730 FIND v(dout0_145) AT=370.025n

.meas tran vdout0_146ck730 FIND v(dout0_146) AT=370.025n

.meas tran vdout0_147ck730 FIND v(dout0_147) AT=370.025n

.meas tran vdout0_148ck730 FIND v(dout0_148) AT=370.025n

.meas tran vdout0_149ck730 FIND v(dout0_149) AT=370.025n

.meas tran vdout0_150ck730 FIND v(dout0_150) AT=370.025n

.meas tran vdout0_151ck730 FIND v(dout0_151) AT=370.025n

.meas tran vdout0_152ck730 FIND v(dout0_152) AT=370.025n

.meas tran vdout0_153ck730 FIND v(dout0_153) AT=370.025n

.meas tran vdout0_154ck730 FIND v(dout0_154) AT=370.025n

.meas tran vdout0_155ck730 FIND v(dout0_155) AT=370.025n

.meas tran vdout0_156ck730 FIND v(dout0_156) AT=370.025n

.meas tran vdout0_157ck730 FIND v(dout0_157) AT=370.025n

.meas tran vdout0_158ck730 FIND v(dout0_158) AT=370.025n

.meas tran vdout0_159ck730 FIND v(dout0_159) AT=370.025n

.meas tran vdout0_160ck730 FIND v(dout0_160) AT=370.025n

.meas tran vdout0_161ck730 FIND v(dout0_161) AT=370.025n

.meas tran vdout0_162ck730 FIND v(dout0_162) AT=370.025n

.meas tran vdout0_163ck730 FIND v(dout0_163) AT=370.025n

.meas tran vdout0_164ck730 FIND v(dout0_164) AT=370.025n

.meas tran vdout0_165ck730 FIND v(dout0_165) AT=370.025n

.meas tran vdout0_166ck730 FIND v(dout0_166) AT=370.025n

.meas tran vdout0_167ck730 FIND v(dout0_167) AT=370.025n

.meas tran vdout0_168ck730 FIND v(dout0_168) AT=370.025n

.meas tran vdout0_169ck730 FIND v(dout0_169) AT=370.025n

.meas tran vdout0_170ck730 FIND v(dout0_170) AT=370.025n

.meas tran vdout0_171ck730 FIND v(dout0_171) AT=370.025n

.meas tran vdout0_172ck730 FIND v(dout0_172) AT=370.025n

.meas tran vdout0_173ck730 FIND v(dout0_173) AT=370.025n

.meas tran vdout0_174ck730 FIND v(dout0_174) AT=370.025n

.meas tran vdout0_175ck730 FIND v(dout0_175) AT=370.025n

.meas tran vdout0_176ck730 FIND v(dout0_176) AT=370.025n

.meas tran vdout0_177ck730 FIND v(dout0_177) AT=370.025n

.meas tran vdout0_178ck730 FIND v(dout0_178) AT=370.025n

.meas tran vdout0_179ck730 FIND v(dout0_179) AT=370.025n

.meas tran vdout0_180ck730 FIND v(dout0_180) AT=370.025n

.meas tran vdout0_181ck730 FIND v(dout0_181) AT=370.025n

.meas tran vdout0_182ck730 FIND v(dout0_182) AT=370.025n

.meas tran vdout0_183ck730 FIND v(dout0_183) AT=370.025n

.meas tran vdout0_184ck730 FIND v(dout0_184) AT=370.025n

.meas tran vdout0_185ck730 FIND v(dout0_185) AT=370.025n

.meas tran vdout0_186ck730 FIND v(dout0_186) AT=370.025n

.meas tran vdout0_187ck730 FIND v(dout0_187) AT=370.025n

.meas tran vdout0_188ck730 FIND v(dout0_188) AT=370.025n

.meas tran vdout0_189ck730 FIND v(dout0_189) AT=370.025n

.meas tran vdout0_190ck730 FIND v(dout0_190) AT=370.025n

.meas tran vdout0_191ck730 FIND v(dout0_191) AT=370.025n

.meas tran vdout0_192ck730 FIND v(dout0_192) AT=370.025n

.meas tran vdout0_193ck730 FIND v(dout0_193) AT=370.025n

.meas tran vdout0_194ck730 FIND v(dout0_194) AT=370.025n

.meas tran vdout0_195ck730 FIND v(dout0_195) AT=370.025n

.meas tran vdout0_196ck730 FIND v(dout0_196) AT=370.025n

.meas tran vdout0_197ck730 FIND v(dout0_197) AT=370.025n

.meas tran vdout0_198ck730 FIND v(dout0_198) AT=370.025n

.meas tran vdout0_199ck730 FIND v(dout0_199) AT=370.025n

.meas tran vdout0_200ck730 FIND v(dout0_200) AT=370.025n

.meas tran vdout0_201ck730 FIND v(dout0_201) AT=370.025n

.meas tran vdout0_202ck730 FIND v(dout0_202) AT=370.025n

.meas tran vdout0_203ck730 FIND v(dout0_203) AT=370.025n

.meas tran vdout0_204ck730 FIND v(dout0_204) AT=370.025n

.meas tran vdout0_205ck730 FIND v(dout0_205) AT=370.025n

.meas tran vdout0_206ck730 FIND v(dout0_206) AT=370.025n

.meas tran vdout0_207ck730 FIND v(dout0_207) AT=370.025n

.meas tran vdout0_208ck730 FIND v(dout0_208) AT=370.025n

.meas tran vdout0_209ck730 FIND v(dout0_209) AT=370.025n

.meas tran vdout0_210ck730 FIND v(dout0_210) AT=370.025n

.meas tran vdout0_211ck730 FIND v(dout0_211) AT=370.025n

.meas tran vdout0_212ck730 FIND v(dout0_212) AT=370.025n

.meas tran vdout0_213ck730 FIND v(dout0_213) AT=370.025n

.meas tran vdout0_214ck730 FIND v(dout0_214) AT=370.025n

.meas tran vdout0_215ck730 FIND v(dout0_215) AT=370.025n

.meas tran vdout0_216ck730 FIND v(dout0_216) AT=370.025n

.meas tran vdout0_217ck730 FIND v(dout0_217) AT=370.025n

.meas tran vdout0_218ck730 FIND v(dout0_218) AT=370.025n

.meas tran vdout0_219ck730 FIND v(dout0_219) AT=370.025n

.meas tran vdout0_220ck730 FIND v(dout0_220) AT=370.025n

.meas tran vdout0_221ck730 FIND v(dout0_221) AT=370.025n

.meas tran vdout0_222ck730 FIND v(dout0_222) AT=370.025n

.meas tran vdout0_223ck730 FIND v(dout0_223) AT=370.025n

.meas tran vdout0_224ck730 FIND v(dout0_224) AT=370.025n

.meas tran vdout0_225ck730 FIND v(dout0_225) AT=370.025n

.meas tran vdout0_226ck730 FIND v(dout0_226) AT=370.025n

.meas tran vdout0_227ck730 FIND v(dout0_227) AT=370.025n

.meas tran vdout0_228ck730 FIND v(dout0_228) AT=370.025n

.meas tran vdout0_229ck730 FIND v(dout0_229) AT=370.025n

.meas tran vdout0_230ck730 FIND v(dout0_230) AT=370.025n

.meas tran vdout0_231ck730 FIND v(dout0_231) AT=370.025n

.meas tran vdout0_232ck730 FIND v(dout0_232) AT=370.025n

.meas tran vdout0_233ck730 FIND v(dout0_233) AT=370.025n

.meas tran vdout0_234ck730 FIND v(dout0_234) AT=370.025n

.meas tran vdout0_235ck730 FIND v(dout0_235) AT=370.025n

.meas tran vdout0_236ck730 FIND v(dout0_236) AT=370.025n

.meas tran vdout0_237ck730 FIND v(dout0_237) AT=370.025n

.meas tran vdout0_238ck730 FIND v(dout0_238) AT=370.025n

.meas tran vdout0_239ck730 FIND v(dout0_239) AT=370.025n

.meas tran vdout0_240ck730 FIND v(dout0_240) AT=370.025n

.meas tran vdout0_241ck730 FIND v(dout0_241) AT=370.025n

.meas tran vdout0_242ck730 FIND v(dout0_242) AT=370.025n

.meas tran vdout0_243ck730 FIND v(dout0_243) AT=370.025n

.meas tran vdout0_244ck730 FIND v(dout0_244) AT=370.025n

.meas tran vdout0_245ck730 FIND v(dout0_245) AT=370.025n

.meas tran vdout0_246ck730 FIND v(dout0_246) AT=370.025n

.meas tran vdout0_247ck730 FIND v(dout0_247) AT=370.025n

.meas tran vdout0_248ck730 FIND v(dout0_248) AT=370.025n

.meas tran vdout0_249ck730 FIND v(dout0_249) AT=370.025n

.meas tran vdout0_250ck730 FIND v(dout0_250) AT=370.025n

.meas tran vdout0_251ck730 FIND v(dout0_251) AT=370.025n

.meas tran vdout0_252ck730 FIND v(dout0_252) AT=370.025n

.meas tran vdout0_253ck730 FIND v(dout0_253) AT=370.025n

.meas tran vdout0_254ck730 FIND v(dout0_254) AT=370.025n

.meas tran vdout0_255ck730 FIND v(dout0_255) AT=370.025n

.meas tran vdout0_0ck770 FIND v(dout0_0) AT=390.025n

.meas tran vdout0_1ck770 FIND v(dout0_1) AT=390.025n

.meas tran vdout0_2ck770 FIND v(dout0_2) AT=390.025n

.meas tran vdout0_3ck770 FIND v(dout0_3) AT=390.025n

.meas tran vdout0_4ck770 FIND v(dout0_4) AT=390.025n

.meas tran vdout0_5ck770 FIND v(dout0_5) AT=390.025n

.meas tran vdout0_6ck770 FIND v(dout0_6) AT=390.025n

.meas tran vdout0_7ck770 FIND v(dout0_7) AT=390.025n

.meas tran vdout0_8ck770 FIND v(dout0_8) AT=390.025n

.meas tran vdout0_9ck770 FIND v(dout0_9) AT=390.025n

.meas tran vdout0_10ck770 FIND v(dout0_10) AT=390.025n

.meas tran vdout0_11ck770 FIND v(dout0_11) AT=390.025n

.meas tran vdout0_12ck770 FIND v(dout0_12) AT=390.025n

.meas tran vdout0_13ck770 FIND v(dout0_13) AT=390.025n

.meas tran vdout0_14ck770 FIND v(dout0_14) AT=390.025n

.meas tran vdout0_15ck770 FIND v(dout0_15) AT=390.025n

.meas tran vdout0_16ck770 FIND v(dout0_16) AT=390.025n

.meas tran vdout0_17ck770 FIND v(dout0_17) AT=390.025n

.meas tran vdout0_18ck770 FIND v(dout0_18) AT=390.025n

.meas tran vdout0_19ck770 FIND v(dout0_19) AT=390.025n

.meas tran vdout0_20ck770 FIND v(dout0_20) AT=390.025n

.meas tran vdout0_21ck770 FIND v(dout0_21) AT=390.025n

.meas tran vdout0_22ck770 FIND v(dout0_22) AT=390.025n

.meas tran vdout0_23ck770 FIND v(dout0_23) AT=390.025n

.meas tran vdout0_24ck770 FIND v(dout0_24) AT=390.025n

.meas tran vdout0_25ck770 FIND v(dout0_25) AT=390.025n

.meas tran vdout0_26ck770 FIND v(dout0_26) AT=390.025n

.meas tran vdout0_27ck770 FIND v(dout0_27) AT=390.025n

.meas tran vdout0_28ck770 FIND v(dout0_28) AT=390.025n

.meas tran vdout0_29ck770 FIND v(dout0_29) AT=390.025n

.meas tran vdout0_30ck770 FIND v(dout0_30) AT=390.025n

.meas tran vdout0_31ck770 FIND v(dout0_31) AT=390.025n

.meas tran vdout0_32ck770 FIND v(dout0_32) AT=390.025n

.meas tran vdout0_33ck770 FIND v(dout0_33) AT=390.025n

.meas tran vdout0_34ck770 FIND v(dout0_34) AT=390.025n

.meas tran vdout0_35ck770 FIND v(dout0_35) AT=390.025n

.meas tran vdout0_36ck770 FIND v(dout0_36) AT=390.025n

.meas tran vdout0_37ck770 FIND v(dout0_37) AT=390.025n

.meas tran vdout0_38ck770 FIND v(dout0_38) AT=390.025n

.meas tran vdout0_39ck770 FIND v(dout0_39) AT=390.025n

.meas tran vdout0_40ck770 FIND v(dout0_40) AT=390.025n

.meas tran vdout0_41ck770 FIND v(dout0_41) AT=390.025n

.meas tran vdout0_42ck770 FIND v(dout0_42) AT=390.025n

.meas tran vdout0_43ck770 FIND v(dout0_43) AT=390.025n

.meas tran vdout0_44ck770 FIND v(dout0_44) AT=390.025n

.meas tran vdout0_45ck770 FIND v(dout0_45) AT=390.025n

.meas tran vdout0_46ck770 FIND v(dout0_46) AT=390.025n

.meas tran vdout0_47ck770 FIND v(dout0_47) AT=390.025n

.meas tran vdout0_48ck770 FIND v(dout0_48) AT=390.025n

.meas tran vdout0_49ck770 FIND v(dout0_49) AT=390.025n

.meas tran vdout0_50ck770 FIND v(dout0_50) AT=390.025n

.meas tran vdout0_51ck770 FIND v(dout0_51) AT=390.025n

.meas tran vdout0_52ck770 FIND v(dout0_52) AT=390.025n

.meas tran vdout0_53ck770 FIND v(dout0_53) AT=390.025n

.meas tran vdout0_54ck770 FIND v(dout0_54) AT=390.025n

.meas tran vdout0_55ck770 FIND v(dout0_55) AT=390.025n

.meas tran vdout0_56ck770 FIND v(dout0_56) AT=390.025n

.meas tran vdout0_57ck770 FIND v(dout0_57) AT=390.025n

.meas tran vdout0_58ck770 FIND v(dout0_58) AT=390.025n

.meas tran vdout0_59ck770 FIND v(dout0_59) AT=390.025n

.meas tran vdout0_60ck770 FIND v(dout0_60) AT=390.025n

.meas tran vdout0_61ck770 FIND v(dout0_61) AT=390.025n

.meas tran vdout0_62ck770 FIND v(dout0_62) AT=390.025n

.meas tran vdout0_63ck770 FIND v(dout0_63) AT=390.025n

.meas tran vdout0_64ck770 FIND v(dout0_64) AT=390.025n

.meas tran vdout0_65ck770 FIND v(dout0_65) AT=390.025n

.meas tran vdout0_66ck770 FIND v(dout0_66) AT=390.025n

.meas tran vdout0_67ck770 FIND v(dout0_67) AT=390.025n

.meas tran vdout0_68ck770 FIND v(dout0_68) AT=390.025n

.meas tran vdout0_69ck770 FIND v(dout0_69) AT=390.025n

.meas tran vdout0_70ck770 FIND v(dout0_70) AT=390.025n

.meas tran vdout0_71ck770 FIND v(dout0_71) AT=390.025n

.meas tran vdout0_72ck770 FIND v(dout0_72) AT=390.025n

.meas tran vdout0_73ck770 FIND v(dout0_73) AT=390.025n

.meas tran vdout0_74ck770 FIND v(dout0_74) AT=390.025n

.meas tran vdout0_75ck770 FIND v(dout0_75) AT=390.025n

.meas tran vdout0_76ck770 FIND v(dout0_76) AT=390.025n

.meas tran vdout0_77ck770 FIND v(dout0_77) AT=390.025n

.meas tran vdout0_78ck770 FIND v(dout0_78) AT=390.025n

.meas tran vdout0_79ck770 FIND v(dout0_79) AT=390.025n

.meas tran vdout0_80ck770 FIND v(dout0_80) AT=390.025n

.meas tran vdout0_81ck770 FIND v(dout0_81) AT=390.025n

.meas tran vdout0_82ck770 FIND v(dout0_82) AT=390.025n

.meas tran vdout0_83ck770 FIND v(dout0_83) AT=390.025n

.meas tran vdout0_84ck770 FIND v(dout0_84) AT=390.025n

.meas tran vdout0_85ck770 FIND v(dout0_85) AT=390.025n

.meas tran vdout0_86ck770 FIND v(dout0_86) AT=390.025n

.meas tran vdout0_87ck770 FIND v(dout0_87) AT=390.025n

.meas tran vdout0_88ck770 FIND v(dout0_88) AT=390.025n

.meas tran vdout0_89ck770 FIND v(dout0_89) AT=390.025n

.meas tran vdout0_90ck770 FIND v(dout0_90) AT=390.025n

.meas tran vdout0_91ck770 FIND v(dout0_91) AT=390.025n

.meas tran vdout0_92ck770 FIND v(dout0_92) AT=390.025n

.meas tran vdout0_93ck770 FIND v(dout0_93) AT=390.025n

.meas tran vdout0_94ck770 FIND v(dout0_94) AT=390.025n

.meas tran vdout0_95ck770 FIND v(dout0_95) AT=390.025n

.meas tran vdout0_96ck770 FIND v(dout0_96) AT=390.025n

.meas tran vdout0_97ck770 FIND v(dout0_97) AT=390.025n

.meas tran vdout0_98ck770 FIND v(dout0_98) AT=390.025n

.meas tran vdout0_99ck770 FIND v(dout0_99) AT=390.025n

.meas tran vdout0_100ck770 FIND v(dout0_100) AT=390.025n

.meas tran vdout0_101ck770 FIND v(dout0_101) AT=390.025n

.meas tran vdout0_102ck770 FIND v(dout0_102) AT=390.025n

.meas tran vdout0_103ck770 FIND v(dout0_103) AT=390.025n

.meas tran vdout0_104ck770 FIND v(dout0_104) AT=390.025n

.meas tran vdout0_105ck770 FIND v(dout0_105) AT=390.025n

.meas tran vdout0_106ck770 FIND v(dout0_106) AT=390.025n

.meas tran vdout0_107ck770 FIND v(dout0_107) AT=390.025n

.meas tran vdout0_108ck770 FIND v(dout0_108) AT=390.025n

.meas tran vdout0_109ck770 FIND v(dout0_109) AT=390.025n

.meas tran vdout0_110ck770 FIND v(dout0_110) AT=390.025n

.meas tran vdout0_111ck770 FIND v(dout0_111) AT=390.025n

.meas tran vdout0_112ck770 FIND v(dout0_112) AT=390.025n

.meas tran vdout0_113ck770 FIND v(dout0_113) AT=390.025n

.meas tran vdout0_114ck770 FIND v(dout0_114) AT=390.025n

.meas tran vdout0_115ck770 FIND v(dout0_115) AT=390.025n

.meas tran vdout0_116ck770 FIND v(dout0_116) AT=390.025n

.meas tran vdout0_117ck770 FIND v(dout0_117) AT=390.025n

.meas tran vdout0_118ck770 FIND v(dout0_118) AT=390.025n

.meas tran vdout0_119ck770 FIND v(dout0_119) AT=390.025n

.meas tran vdout0_120ck770 FIND v(dout0_120) AT=390.025n

.meas tran vdout0_121ck770 FIND v(dout0_121) AT=390.025n

.meas tran vdout0_122ck770 FIND v(dout0_122) AT=390.025n

.meas tran vdout0_123ck770 FIND v(dout0_123) AT=390.025n

.meas tran vdout0_124ck770 FIND v(dout0_124) AT=390.025n

.meas tran vdout0_125ck770 FIND v(dout0_125) AT=390.025n

.meas tran vdout0_126ck770 FIND v(dout0_126) AT=390.025n

.meas tran vdout0_127ck770 FIND v(dout0_127) AT=390.025n

.meas tran vdout0_128ck770 FIND v(dout0_128) AT=390.025n

.meas tran vdout0_129ck770 FIND v(dout0_129) AT=390.025n

.meas tran vdout0_130ck770 FIND v(dout0_130) AT=390.025n

.meas tran vdout0_131ck770 FIND v(dout0_131) AT=390.025n

.meas tran vdout0_132ck770 FIND v(dout0_132) AT=390.025n

.meas tran vdout0_133ck770 FIND v(dout0_133) AT=390.025n

.meas tran vdout0_134ck770 FIND v(dout0_134) AT=390.025n

.meas tran vdout0_135ck770 FIND v(dout0_135) AT=390.025n

.meas tran vdout0_136ck770 FIND v(dout0_136) AT=390.025n

.meas tran vdout0_137ck770 FIND v(dout0_137) AT=390.025n

.meas tran vdout0_138ck770 FIND v(dout0_138) AT=390.025n

.meas tran vdout0_139ck770 FIND v(dout0_139) AT=390.025n

.meas tran vdout0_140ck770 FIND v(dout0_140) AT=390.025n

.meas tran vdout0_141ck770 FIND v(dout0_141) AT=390.025n

.meas tran vdout0_142ck770 FIND v(dout0_142) AT=390.025n

.meas tran vdout0_143ck770 FIND v(dout0_143) AT=390.025n

.meas tran vdout0_144ck770 FIND v(dout0_144) AT=390.025n

.meas tran vdout0_145ck770 FIND v(dout0_145) AT=390.025n

.meas tran vdout0_146ck770 FIND v(dout0_146) AT=390.025n

.meas tran vdout0_147ck770 FIND v(dout0_147) AT=390.025n

.meas tran vdout0_148ck770 FIND v(dout0_148) AT=390.025n

.meas tran vdout0_149ck770 FIND v(dout0_149) AT=390.025n

.meas tran vdout0_150ck770 FIND v(dout0_150) AT=390.025n

.meas tran vdout0_151ck770 FIND v(dout0_151) AT=390.025n

.meas tran vdout0_152ck770 FIND v(dout0_152) AT=390.025n

.meas tran vdout0_153ck770 FIND v(dout0_153) AT=390.025n

.meas tran vdout0_154ck770 FIND v(dout0_154) AT=390.025n

.meas tran vdout0_155ck770 FIND v(dout0_155) AT=390.025n

.meas tran vdout0_156ck770 FIND v(dout0_156) AT=390.025n

.meas tran vdout0_157ck770 FIND v(dout0_157) AT=390.025n

.meas tran vdout0_158ck770 FIND v(dout0_158) AT=390.025n

.meas tran vdout0_159ck770 FIND v(dout0_159) AT=390.025n

.meas tran vdout0_160ck770 FIND v(dout0_160) AT=390.025n

.meas tran vdout0_161ck770 FIND v(dout0_161) AT=390.025n

.meas tran vdout0_162ck770 FIND v(dout0_162) AT=390.025n

.meas tran vdout0_163ck770 FIND v(dout0_163) AT=390.025n

.meas tran vdout0_164ck770 FIND v(dout0_164) AT=390.025n

.meas tran vdout0_165ck770 FIND v(dout0_165) AT=390.025n

.meas tran vdout0_166ck770 FIND v(dout0_166) AT=390.025n

.meas tran vdout0_167ck770 FIND v(dout0_167) AT=390.025n

.meas tran vdout0_168ck770 FIND v(dout0_168) AT=390.025n

.meas tran vdout0_169ck770 FIND v(dout0_169) AT=390.025n

.meas tran vdout0_170ck770 FIND v(dout0_170) AT=390.025n

.meas tran vdout0_171ck770 FIND v(dout0_171) AT=390.025n

.meas tran vdout0_172ck770 FIND v(dout0_172) AT=390.025n

.meas tran vdout0_173ck770 FIND v(dout0_173) AT=390.025n

.meas tran vdout0_174ck770 FIND v(dout0_174) AT=390.025n

.meas tran vdout0_175ck770 FIND v(dout0_175) AT=390.025n

.meas tran vdout0_176ck770 FIND v(dout0_176) AT=390.025n

.meas tran vdout0_177ck770 FIND v(dout0_177) AT=390.025n

.meas tran vdout0_178ck770 FIND v(dout0_178) AT=390.025n

.meas tran vdout0_179ck770 FIND v(dout0_179) AT=390.025n

.meas tran vdout0_180ck770 FIND v(dout0_180) AT=390.025n

.meas tran vdout0_181ck770 FIND v(dout0_181) AT=390.025n

.meas tran vdout0_182ck770 FIND v(dout0_182) AT=390.025n

.meas tran vdout0_183ck770 FIND v(dout0_183) AT=390.025n

.meas tran vdout0_184ck770 FIND v(dout0_184) AT=390.025n

.meas tran vdout0_185ck770 FIND v(dout0_185) AT=390.025n

.meas tran vdout0_186ck770 FIND v(dout0_186) AT=390.025n

.meas tran vdout0_187ck770 FIND v(dout0_187) AT=390.025n

.meas tran vdout0_188ck770 FIND v(dout0_188) AT=390.025n

.meas tran vdout0_189ck770 FIND v(dout0_189) AT=390.025n

.meas tran vdout0_190ck770 FIND v(dout0_190) AT=390.025n

.meas tran vdout0_191ck770 FIND v(dout0_191) AT=390.025n

.meas tran vdout0_192ck770 FIND v(dout0_192) AT=390.025n

.meas tran vdout0_193ck770 FIND v(dout0_193) AT=390.025n

.meas tran vdout0_194ck770 FIND v(dout0_194) AT=390.025n

.meas tran vdout0_195ck770 FIND v(dout0_195) AT=390.025n

.meas tran vdout0_196ck770 FIND v(dout0_196) AT=390.025n

.meas tran vdout0_197ck770 FIND v(dout0_197) AT=390.025n

.meas tran vdout0_198ck770 FIND v(dout0_198) AT=390.025n

.meas tran vdout0_199ck770 FIND v(dout0_199) AT=390.025n

.meas tran vdout0_200ck770 FIND v(dout0_200) AT=390.025n

.meas tran vdout0_201ck770 FIND v(dout0_201) AT=390.025n

.meas tran vdout0_202ck770 FIND v(dout0_202) AT=390.025n

.meas tran vdout0_203ck770 FIND v(dout0_203) AT=390.025n

.meas tran vdout0_204ck770 FIND v(dout0_204) AT=390.025n

.meas tran vdout0_205ck770 FIND v(dout0_205) AT=390.025n

.meas tran vdout0_206ck770 FIND v(dout0_206) AT=390.025n

.meas tran vdout0_207ck770 FIND v(dout0_207) AT=390.025n

.meas tran vdout0_208ck770 FIND v(dout0_208) AT=390.025n

.meas tran vdout0_209ck770 FIND v(dout0_209) AT=390.025n

.meas tran vdout0_210ck770 FIND v(dout0_210) AT=390.025n

.meas tran vdout0_211ck770 FIND v(dout0_211) AT=390.025n

.meas tran vdout0_212ck770 FIND v(dout0_212) AT=390.025n

.meas tran vdout0_213ck770 FIND v(dout0_213) AT=390.025n

.meas tran vdout0_214ck770 FIND v(dout0_214) AT=390.025n

.meas tran vdout0_215ck770 FIND v(dout0_215) AT=390.025n

.meas tran vdout0_216ck770 FIND v(dout0_216) AT=390.025n

.meas tran vdout0_217ck770 FIND v(dout0_217) AT=390.025n

.meas tran vdout0_218ck770 FIND v(dout0_218) AT=390.025n

.meas tran vdout0_219ck770 FIND v(dout0_219) AT=390.025n

.meas tran vdout0_220ck770 FIND v(dout0_220) AT=390.025n

.meas tran vdout0_221ck770 FIND v(dout0_221) AT=390.025n

.meas tran vdout0_222ck770 FIND v(dout0_222) AT=390.025n

.meas tran vdout0_223ck770 FIND v(dout0_223) AT=390.025n

.meas tran vdout0_224ck770 FIND v(dout0_224) AT=390.025n

.meas tran vdout0_225ck770 FIND v(dout0_225) AT=390.025n

.meas tran vdout0_226ck770 FIND v(dout0_226) AT=390.025n

.meas tran vdout0_227ck770 FIND v(dout0_227) AT=390.025n

.meas tran vdout0_228ck770 FIND v(dout0_228) AT=390.025n

.meas tran vdout0_229ck770 FIND v(dout0_229) AT=390.025n

.meas tran vdout0_230ck770 FIND v(dout0_230) AT=390.025n

.meas tran vdout0_231ck770 FIND v(dout0_231) AT=390.025n

.meas tran vdout0_232ck770 FIND v(dout0_232) AT=390.025n

.meas tran vdout0_233ck770 FIND v(dout0_233) AT=390.025n

.meas tran vdout0_234ck770 FIND v(dout0_234) AT=390.025n

.meas tran vdout0_235ck770 FIND v(dout0_235) AT=390.025n

.meas tran vdout0_236ck770 FIND v(dout0_236) AT=390.025n

.meas tran vdout0_237ck770 FIND v(dout0_237) AT=390.025n

.meas tran vdout0_238ck770 FIND v(dout0_238) AT=390.025n

.meas tran vdout0_239ck770 FIND v(dout0_239) AT=390.025n

.meas tran vdout0_240ck770 FIND v(dout0_240) AT=390.025n

.meas tran vdout0_241ck770 FIND v(dout0_241) AT=390.025n

.meas tran vdout0_242ck770 FIND v(dout0_242) AT=390.025n

.meas tran vdout0_243ck770 FIND v(dout0_243) AT=390.025n

.meas tran vdout0_244ck770 FIND v(dout0_244) AT=390.025n

.meas tran vdout0_245ck770 FIND v(dout0_245) AT=390.025n

.meas tran vdout0_246ck770 FIND v(dout0_246) AT=390.025n

.meas tran vdout0_247ck770 FIND v(dout0_247) AT=390.025n

.meas tran vdout0_248ck770 FIND v(dout0_248) AT=390.025n

.meas tran vdout0_249ck770 FIND v(dout0_249) AT=390.025n

.meas tran vdout0_250ck770 FIND v(dout0_250) AT=390.025n

.meas tran vdout0_251ck770 FIND v(dout0_251) AT=390.025n

.meas tran vdout0_252ck770 FIND v(dout0_252) AT=390.025n

.meas tran vdout0_253ck770 FIND v(dout0_253) AT=390.025n

.meas tran vdout0_254ck770 FIND v(dout0_254) AT=390.025n

.meas tran vdout0_255ck770 FIND v(dout0_255) AT=390.025n

.meas tran vdout0_0ck780 FIND v(dout0_0) AT=395.025n

.meas tran vdout0_1ck780 FIND v(dout0_1) AT=395.025n

.meas tran vdout0_2ck780 FIND v(dout0_2) AT=395.025n

.meas tran vdout0_3ck780 FIND v(dout0_3) AT=395.025n

.meas tran vdout0_4ck780 FIND v(dout0_4) AT=395.025n

.meas tran vdout0_5ck780 FIND v(dout0_5) AT=395.025n

.meas tran vdout0_6ck780 FIND v(dout0_6) AT=395.025n

.meas tran vdout0_7ck780 FIND v(dout0_7) AT=395.025n

.meas tran vdout0_8ck780 FIND v(dout0_8) AT=395.025n

.meas tran vdout0_9ck780 FIND v(dout0_9) AT=395.025n

.meas tran vdout0_10ck780 FIND v(dout0_10) AT=395.025n

.meas tran vdout0_11ck780 FIND v(dout0_11) AT=395.025n

.meas tran vdout0_12ck780 FIND v(dout0_12) AT=395.025n

.meas tran vdout0_13ck780 FIND v(dout0_13) AT=395.025n

.meas tran vdout0_14ck780 FIND v(dout0_14) AT=395.025n

.meas tran vdout0_15ck780 FIND v(dout0_15) AT=395.025n

.meas tran vdout0_16ck780 FIND v(dout0_16) AT=395.025n

.meas tran vdout0_17ck780 FIND v(dout0_17) AT=395.025n

.meas tran vdout0_18ck780 FIND v(dout0_18) AT=395.025n

.meas tran vdout0_19ck780 FIND v(dout0_19) AT=395.025n

.meas tran vdout0_20ck780 FIND v(dout0_20) AT=395.025n

.meas tran vdout0_21ck780 FIND v(dout0_21) AT=395.025n

.meas tran vdout0_22ck780 FIND v(dout0_22) AT=395.025n

.meas tran vdout0_23ck780 FIND v(dout0_23) AT=395.025n

.meas tran vdout0_24ck780 FIND v(dout0_24) AT=395.025n

.meas tran vdout0_25ck780 FIND v(dout0_25) AT=395.025n

.meas tran vdout0_26ck780 FIND v(dout0_26) AT=395.025n

.meas tran vdout0_27ck780 FIND v(dout0_27) AT=395.025n

.meas tran vdout0_28ck780 FIND v(dout0_28) AT=395.025n

.meas tran vdout0_29ck780 FIND v(dout0_29) AT=395.025n

.meas tran vdout0_30ck780 FIND v(dout0_30) AT=395.025n

.meas tran vdout0_31ck780 FIND v(dout0_31) AT=395.025n

.meas tran vdout0_32ck780 FIND v(dout0_32) AT=395.025n

.meas tran vdout0_33ck780 FIND v(dout0_33) AT=395.025n

.meas tran vdout0_34ck780 FIND v(dout0_34) AT=395.025n

.meas tran vdout0_35ck780 FIND v(dout0_35) AT=395.025n

.meas tran vdout0_36ck780 FIND v(dout0_36) AT=395.025n

.meas tran vdout0_37ck780 FIND v(dout0_37) AT=395.025n

.meas tran vdout0_38ck780 FIND v(dout0_38) AT=395.025n

.meas tran vdout0_39ck780 FIND v(dout0_39) AT=395.025n

.meas tran vdout0_40ck780 FIND v(dout0_40) AT=395.025n

.meas tran vdout0_41ck780 FIND v(dout0_41) AT=395.025n

.meas tran vdout0_42ck780 FIND v(dout0_42) AT=395.025n

.meas tran vdout0_43ck780 FIND v(dout0_43) AT=395.025n

.meas tran vdout0_44ck780 FIND v(dout0_44) AT=395.025n

.meas tran vdout0_45ck780 FIND v(dout0_45) AT=395.025n

.meas tran vdout0_46ck780 FIND v(dout0_46) AT=395.025n

.meas tran vdout0_47ck780 FIND v(dout0_47) AT=395.025n

.meas tran vdout0_48ck780 FIND v(dout0_48) AT=395.025n

.meas tran vdout0_49ck780 FIND v(dout0_49) AT=395.025n

.meas tran vdout0_50ck780 FIND v(dout0_50) AT=395.025n

.meas tran vdout0_51ck780 FIND v(dout0_51) AT=395.025n

.meas tran vdout0_52ck780 FIND v(dout0_52) AT=395.025n

.meas tran vdout0_53ck780 FIND v(dout0_53) AT=395.025n

.meas tran vdout0_54ck780 FIND v(dout0_54) AT=395.025n

.meas tran vdout0_55ck780 FIND v(dout0_55) AT=395.025n

.meas tran vdout0_56ck780 FIND v(dout0_56) AT=395.025n

.meas tran vdout0_57ck780 FIND v(dout0_57) AT=395.025n

.meas tran vdout0_58ck780 FIND v(dout0_58) AT=395.025n

.meas tran vdout0_59ck780 FIND v(dout0_59) AT=395.025n

.meas tran vdout0_60ck780 FIND v(dout0_60) AT=395.025n

.meas tran vdout0_61ck780 FIND v(dout0_61) AT=395.025n

.meas tran vdout0_62ck780 FIND v(dout0_62) AT=395.025n

.meas tran vdout0_63ck780 FIND v(dout0_63) AT=395.025n

.meas tran vdout0_64ck780 FIND v(dout0_64) AT=395.025n

.meas tran vdout0_65ck780 FIND v(dout0_65) AT=395.025n

.meas tran vdout0_66ck780 FIND v(dout0_66) AT=395.025n

.meas tran vdout0_67ck780 FIND v(dout0_67) AT=395.025n

.meas tran vdout0_68ck780 FIND v(dout0_68) AT=395.025n

.meas tran vdout0_69ck780 FIND v(dout0_69) AT=395.025n

.meas tran vdout0_70ck780 FIND v(dout0_70) AT=395.025n

.meas tran vdout0_71ck780 FIND v(dout0_71) AT=395.025n

.meas tran vdout0_72ck780 FIND v(dout0_72) AT=395.025n

.meas tran vdout0_73ck780 FIND v(dout0_73) AT=395.025n

.meas tran vdout0_74ck780 FIND v(dout0_74) AT=395.025n

.meas tran vdout0_75ck780 FIND v(dout0_75) AT=395.025n

.meas tran vdout0_76ck780 FIND v(dout0_76) AT=395.025n

.meas tran vdout0_77ck780 FIND v(dout0_77) AT=395.025n

.meas tran vdout0_78ck780 FIND v(dout0_78) AT=395.025n

.meas tran vdout0_79ck780 FIND v(dout0_79) AT=395.025n

.meas tran vdout0_80ck780 FIND v(dout0_80) AT=395.025n

.meas tran vdout0_81ck780 FIND v(dout0_81) AT=395.025n

.meas tran vdout0_82ck780 FIND v(dout0_82) AT=395.025n

.meas tran vdout0_83ck780 FIND v(dout0_83) AT=395.025n

.meas tran vdout0_84ck780 FIND v(dout0_84) AT=395.025n

.meas tran vdout0_85ck780 FIND v(dout0_85) AT=395.025n

.meas tran vdout0_86ck780 FIND v(dout0_86) AT=395.025n

.meas tran vdout0_87ck780 FIND v(dout0_87) AT=395.025n

.meas tran vdout0_88ck780 FIND v(dout0_88) AT=395.025n

.meas tran vdout0_89ck780 FIND v(dout0_89) AT=395.025n

.meas tran vdout0_90ck780 FIND v(dout0_90) AT=395.025n

.meas tran vdout0_91ck780 FIND v(dout0_91) AT=395.025n

.meas tran vdout0_92ck780 FIND v(dout0_92) AT=395.025n

.meas tran vdout0_93ck780 FIND v(dout0_93) AT=395.025n

.meas tran vdout0_94ck780 FIND v(dout0_94) AT=395.025n

.meas tran vdout0_95ck780 FIND v(dout0_95) AT=395.025n

.meas tran vdout0_96ck780 FIND v(dout0_96) AT=395.025n

.meas tran vdout0_97ck780 FIND v(dout0_97) AT=395.025n

.meas tran vdout0_98ck780 FIND v(dout0_98) AT=395.025n

.meas tran vdout0_99ck780 FIND v(dout0_99) AT=395.025n

.meas tran vdout0_100ck780 FIND v(dout0_100) AT=395.025n

.meas tran vdout0_101ck780 FIND v(dout0_101) AT=395.025n

.meas tran vdout0_102ck780 FIND v(dout0_102) AT=395.025n

.meas tran vdout0_103ck780 FIND v(dout0_103) AT=395.025n

.meas tran vdout0_104ck780 FIND v(dout0_104) AT=395.025n

.meas tran vdout0_105ck780 FIND v(dout0_105) AT=395.025n

.meas tran vdout0_106ck780 FIND v(dout0_106) AT=395.025n

.meas tran vdout0_107ck780 FIND v(dout0_107) AT=395.025n

.meas tran vdout0_108ck780 FIND v(dout0_108) AT=395.025n

.meas tran vdout0_109ck780 FIND v(dout0_109) AT=395.025n

.meas tran vdout0_110ck780 FIND v(dout0_110) AT=395.025n

.meas tran vdout0_111ck780 FIND v(dout0_111) AT=395.025n

.meas tran vdout0_112ck780 FIND v(dout0_112) AT=395.025n

.meas tran vdout0_113ck780 FIND v(dout0_113) AT=395.025n

.meas tran vdout0_114ck780 FIND v(dout0_114) AT=395.025n

.meas tran vdout0_115ck780 FIND v(dout0_115) AT=395.025n

.meas tran vdout0_116ck780 FIND v(dout0_116) AT=395.025n

.meas tran vdout0_117ck780 FIND v(dout0_117) AT=395.025n

.meas tran vdout0_118ck780 FIND v(dout0_118) AT=395.025n

.meas tran vdout0_119ck780 FIND v(dout0_119) AT=395.025n

.meas tran vdout0_120ck780 FIND v(dout0_120) AT=395.025n

.meas tran vdout0_121ck780 FIND v(dout0_121) AT=395.025n

.meas tran vdout0_122ck780 FIND v(dout0_122) AT=395.025n

.meas tran vdout0_123ck780 FIND v(dout0_123) AT=395.025n

.meas tran vdout0_124ck780 FIND v(dout0_124) AT=395.025n

.meas tran vdout0_125ck780 FIND v(dout0_125) AT=395.025n

.meas tran vdout0_126ck780 FIND v(dout0_126) AT=395.025n

.meas tran vdout0_127ck780 FIND v(dout0_127) AT=395.025n

.meas tran vdout0_128ck780 FIND v(dout0_128) AT=395.025n

.meas tran vdout0_129ck780 FIND v(dout0_129) AT=395.025n

.meas tran vdout0_130ck780 FIND v(dout0_130) AT=395.025n

.meas tran vdout0_131ck780 FIND v(dout0_131) AT=395.025n

.meas tran vdout0_132ck780 FIND v(dout0_132) AT=395.025n

.meas tran vdout0_133ck780 FIND v(dout0_133) AT=395.025n

.meas tran vdout0_134ck780 FIND v(dout0_134) AT=395.025n

.meas tran vdout0_135ck780 FIND v(dout0_135) AT=395.025n

.meas tran vdout0_136ck780 FIND v(dout0_136) AT=395.025n

.meas tran vdout0_137ck780 FIND v(dout0_137) AT=395.025n

.meas tran vdout0_138ck780 FIND v(dout0_138) AT=395.025n

.meas tran vdout0_139ck780 FIND v(dout0_139) AT=395.025n

.meas tran vdout0_140ck780 FIND v(dout0_140) AT=395.025n

.meas tran vdout0_141ck780 FIND v(dout0_141) AT=395.025n

.meas tran vdout0_142ck780 FIND v(dout0_142) AT=395.025n

.meas tran vdout0_143ck780 FIND v(dout0_143) AT=395.025n

.meas tran vdout0_144ck780 FIND v(dout0_144) AT=395.025n

.meas tran vdout0_145ck780 FIND v(dout0_145) AT=395.025n

.meas tran vdout0_146ck780 FIND v(dout0_146) AT=395.025n

.meas tran vdout0_147ck780 FIND v(dout0_147) AT=395.025n

.meas tran vdout0_148ck780 FIND v(dout0_148) AT=395.025n

.meas tran vdout0_149ck780 FIND v(dout0_149) AT=395.025n

.meas tran vdout0_150ck780 FIND v(dout0_150) AT=395.025n

.meas tran vdout0_151ck780 FIND v(dout0_151) AT=395.025n

.meas tran vdout0_152ck780 FIND v(dout0_152) AT=395.025n

.meas tran vdout0_153ck780 FIND v(dout0_153) AT=395.025n

.meas tran vdout0_154ck780 FIND v(dout0_154) AT=395.025n

.meas tran vdout0_155ck780 FIND v(dout0_155) AT=395.025n

.meas tran vdout0_156ck780 FIND v(dout0_156) AT=395.025n

.meas tran vdout0_157ck780 FIND v(dout0_157) AT=395.025n

.meas tran vdout0_158ck780 FIND v(dout0_158) AT=395.025n

.meas tran vdout0_159ck780 FIND v(dout0_159) AT=395.025n

.meas tran vdout0_160ck780 FIND v(dout0_160) AT=395.025n

.meas tran vdout0_161ck780 FIND v(dout0_161) AT=395.025n

.meas tran vdout0_162ck780 FIND v(dout0_162) AT=395.025n

.meas tran vdout0_163ck780 FIND v(dout0_163) AT=395.025n

.meas tran vdout0_164ck780 FIND v(dout0_164) AT=395.025n

.meas tran vdout0_165ck780 FIND v(dout0_165) AT=395.025n

.meas tran vdout0_166ck780 FIND v(dout0_166) AT=395.025n

.meas tran vdout0_167ck780 FIND v(dout0_167) AT=395.025n

.meas tran vdout0_168ck780 FIND v(dout0_168) AT=395.025n

.meas tran vdout0_169ck780 FIND v(dout0_169) AT=395.025n

.meas tran vdout0_170ck780 FIND v(dout0_170) AT=395.025n

.meas tran vdout0_171ck780 FIND v(dout0_171) AT=395.025n

.meas tran vdout0_172ck780 FIND v(dout0_172) AT=395.025n

.meas tran vdout0_173ck780 FIND v(dout0_173) AT=395.025n

.meas tran vdout0_174ck780 FIND v(dout0_174) AT=395.025n

.meas tran vdout0_175ck780 FIND v(dout0_175) AT=395.025n

.meas tran vdout0_176ck780 FIND v(dout0_176) AT=395.025n

.meas tran vdout0_177ck780 FIND v(dout0_177) AT=395.025n

.meas tran vdout0_178ck780 FIND v(dout0_178) AT=395.025n

.meas tran vdout0_179ck780 FIND v(dout0_179) AT=395.025n

.meas tran vdout0_180ck780 FIND v(dout0_180) AT=395.025n

.meas tran vdout0_181ck780 FIND v(dout0_181) AT=395.025n

.meas tran vdout0_182ck780 FIND v(dout0_182) AT=395.025n

.meas tran vdout0_183ck780 FIND v(dout0_183) AT=395.025n

.meas tran vdout0_184ck780 FIND v(dout0_184) AT=395.025n

.meas tran vdout0_185ck780 FIND v(dout0_185) AT=395.025n

.meas tran vdout0_186ck780 FIND v(dout0_186) AT=395.025n

.meas tran vdout0_187ck780 FIND v(dout0_187) AT=395.025n

.meas tran vdout0_188ck780 FIND v(dout0_188) AT=395.025n

.meas tran vdout0_189ck780 FIND v(dout0_189) AT=395.025n

.meas tran vdout0_190ck780 FIND v(dout0_190) AT=395.025n

.meas tran vdout0_191ck780 FIND v(dout0_191) AT=395.025n

.meas tran vdout0_192ck780 FIND v(dout0_192) AT=395.025n

.meas tran vdout0_193ck780 FIND v(dout0_193) AT=395.025n

.meas tran vdout0_194ck780 FIND v(dout0_194) AT=395.025n

.meas tran vdout0_195ck780 FIND v(dout0_195) AT=395.025n

.meas tran vdout0_196ck780 FIND v(dout0_196) AT=395.025n

.meas tran vdout0_197ck780 FIND v(dout0_197) AT=395.025n

.meas tran vdout0_198ck780 FIND v(dout0_198) AT=395.025n

.meas tran vdout0_199ck780 FIND v(dout0_199) AT=395.025n

.meas tran vdout0_200ck780 FIND v(dout0_200) AT=395.025n

.meas tran vdout0_201ck780 FIND v(dout0_201) AT=395.025n

.meas tran vdout0_202ck780 FIND v(dout0_202) AT=395.025n

.meas tran vdout0_203ck780 FIND v(dout0_203) AT=395.025n

.meas tran vdout0_204ck780 FIND v(dout0_204) AT=395.025n

.meas tran vdout0_205ck780 FIND v(dout0_205) AT=395.025n

.meas tran vdout0_206ck780 FIND v(dout0_206) AT=395.025n

.meas tran vdout0_207ck780 FIND v(dout0_207) AT=395.025n

.meas tran vdout0_208ck780 FIND v(dout0_208) AT=395.025n

.meas tran vdout0_209ck780 FIND v(dout0_209) AT=395.025n

.meas tran vdout0_210ck780 FIND v(dout0_210) AT=395.025n

.meas tran vdout0_211ck780 FIND v(dout0_211) AT=395.025n

.meas tran vdout0_212ck780 FIND v(dout0_212) AT=395.025n

.meas tran vdout0_213ck780 FIND v(dout0_213) AT=395.025n

.meas tran vdout0_214ck780 FIND v(dout0_214) AT=395.025n

.meas tran vdout0_215ck780 FIND v(dout0_215) AT=395.025n

.meas tran vdout0_216ck780 FIND v(dout0_216) AT=395.025n

.meas tran vdout0_217ck780 FIND v(dout0_217) AT=395.025n

.meas tran vdout0_218ck780 FIND v(dout0_218) AT=395.025n

.meas tran vdout0_219ck780 FIND v(dout0_219) AT=395.025n

.meas tran vdout0_220ck780 FIND v(dout0_220) AT=395.025n

.meas tran vdout0_221ck780 FIND v(dout0_221) AT=395.025n

.meas tran vdout0_222ck780 FIND v(dout0_222) AT=395.025n

.meas tran vdout0_223ck780 FIND v(dout0_223) AT=395.025n

.meas tran vdout0_224ck780 FIND v(dout0_224) AT=395.025n

.meas tran vdout0_225ck780 FIND v(dout0_225) AT=395.025n

.meas tran vdout0_226ck780 FIND v(dout0_226) AT=395.025n

.meas tran vdout0_227ck780 FIND v(dout0_227) AT=395.025n

.meas tran vdout0_228ck780 FIND v(dout0_228) AT=395.025n

.meas tran vdout0_229ck780 FIND v(dout0_229) AT=395.025n

.meas tran vdout0_230ck780 FIND v(dout0_230) AT=395.025n

.meas tran vdout0_231ck780 FIND v(dout0_231) AT=395.025n

.meas tran vdout0_232ck780 FIND v(dout0_232) AT=395.025n

.meas tran vdout0_233ck780 FIND v(dout0_233) AT=395.025n

.meas tran vdout0_234ck780 FIND v(dout0_234) AT=395.025n

.meas tran vdout0_235ck780 FIND v(dout0_235) AT=395.025n

.meas tran vdout0_236ck780 FIND v(dout0_236) AT=395.025n

.meas tran vdout0_237ck780 FIND v(dout0_237) AT=395.025n

.meas tran vdout0_238ck780 FIND v(dout0_238) AT=395.025n

.meas tran vdout0_239ck780 FIND v(dout0_239) AT=395.025n

.meas tran vdout0_240ck780 FIND v(dout0_240) AT=395.025n

.meas tran vdout0_241ck780 FIND v(dout0_241) AT=395.025n

.meas tran vdout0_242ck780 FIND v(dout0_242) AT=395.025n

.meas tran vdout0_243ck780 FIND v(dout0_243) AT=395.025n

.meas tran vdout0_244ck780 FIND v(dout0_244) AT=395.025n

.meas tran vdout0_245ck780 FIND v(dout0_245) AT=395.025n

.meas tran vdout0_246ck780 FIND v(dout0_246) AT=395.025n

.meas tran vdout0_247ck780 FIND v(dout0_247) AT=395.025n

.meas tran vdout0_248ck780 FIND v(dout0_248) AT=395.025n

.meas tran vdout0_249ck780 FIND v(dout0_249) AT=395.025n

.meas tran vdout0_250ck780 FIND v(dout0_250) AT=395.025n

.meas tran vdout0_251ck780 FIND v(dout0_251) AT=395.025n

.meas tran vdout0_252ck780 FIND v(dout0_252) AT=395.025n

.meas tran vdout0_253ck780 FIND v(dout0_253) AT=395.025n

.meas tran vdout0_254ck780 FIND v(dout0_254) AT=395.025n

.meas tran vdout0_255ck780 FIND v(dout0_255) AT=395.025n

.meas tran vdout0_0ck790 FIND v(dout0_0) AT=400.025n

.meas tran vdout0_1ck790 FIND v(dout0_1) AT=400.025n

.meas tran vdout0_2ck790 FIND v(dout0_2) AT=400.025n

.meas tran vdout0_3ck790 FIND v(dout0_3) AT=400.025n

.meas tran vdout0_4ck790 FIND v(dout0_4) AT=400.025n

.meas tran vdout0_5ck790 FIND v(dout0_5) AT=400.025n

.meas tran vdout0_6ck790 FIND v(dout0_6) AT=400.025n

.meas tran vdout0_7ck790 FIND v(dout0_7) AT=400.025n

.meas tran vdout0_8ck790 FIND v(dout0_8) AT=400.025n

.meas tran vdout0_9ck790 FIND v(dout0_9) AT=400.025n

.meas tran vdout0_10ck790 FIND v(dout0_10) AT=400.025n

.meas tran vdout0_11ck790 FIND v(dout0_11) AT=400.025n

.meas tran vdout0_12ck790 FIND v(dout0_12) AT=400.025n

.meas tran vdout0_13ck790 FIND v(dout0_13) AT=400.025n

.meas tran vdout0_14ck790 FIND v(dout0_14) AT=400.025n

.meas tran vdout0_15ck790 FIND v(dout0_15) AT=400.025n

.meas tran vdout0_16ck790 FIND v(dout0_16) AT=400.025n

.meas tran vdout0_17ck790 FIND v(dout0_17) AT=400.025n

.meas tran vdout0_18ck790 FIND v(dout0_18) AT=400.025n

.meas tran vdout0_19ck790 FIND v(dout0_19) AT=400.025n

.meas tran vdout0_20ck790 FIND v(dout0_20) AT=400.025n

.meas tran vdout0_21ck790 FIND v(dout0_21) AT=400.025n

.meas tran vdout0_22ck790 FIND v(dout0_22) AT=400.025n

.meas tran vdout0_23ck790 FIND v(dout0_23) AT=400.025n

.meas tran vdout0_24ck790 FIND v(dout0_24) AT=400.025n

.meas tran vdout0_25ck790 FIND v(dout0_25) AT=400.025n

.meas tran vdout0_26ck790 FIND v(dout0_26) AT=400.025n

.meas tran vdout0_27ck790 FIND v(dout0_27) AT=400.025n

.meas tran vdout0_28ck790 FIND v(dout0_28) AT=400.025n

.meas tran vdout0_29ck790 FIND v(dout0_29) AT=400.025n

.meas tran vdout0_30ck790 FIND v(dout0_30) AT=400.025n

.meas tran vdout0_31ck790 FIND v(dout0_31) AT=400.025n

.meas tran vdout0_32ck790 FIND v(dout0_32) AT=400.025n

.meas tran vdout0_33ck790 FIND v(dout0_33) AT=400.025n

.meas tran vdout0_34ck790 FIND v(dout0_34) AT=400.025n

.meas tran vdout0_35ck790 FIND v(dout0_35) AT=400.025n

.meas tran vdout0_36ck790 FIND v(dout0_36) AT=400.025n

.meas tran vdout0_37ck790 FIND v(dout0_37) AT=400.025n

.meas tran vdout0_38ck790 FIND v(dout0_38) AT=400.025n

.meas tran vdout0_39ck790 FIND v(dout0_39) AT=400.025n

.meas tran vdout0_40ck790 FIND v(dout0_40) AT=400.025n

.meas tran vdout0_41ck790 FIND v(dout0_41) AT=400.025n

.meas tran vdout0_42ck790 FIND v(dout0_42) AT=400.025n

.meas tran vdout0_43ck790 FIND v(dout0_43) AT=400.025n

.meas tran vdout0_44ck790 FIND v(dout0_44) AT=400.025n

.meas tran vdout0_45ck790 FIND v(dout0_45) AT=400.025n

.meas tran vdout0_46ck790 FIND v(dout0_46) AT=400.025n

.meas tran vdout0_47ck790 FIND v(dout0_47) AT=400.025n

.meas tran vdout0_48ck790 FIND v(dout0_48) AT=400.025n

.meas tran vdout0_49ck790 FIND v(dout0_49) AT=400.025n

.meas tran vdout0_50ck790 FIND v(dout0_50) AT=400.025n

.meas tran vdout0_51ck790 FIND v(dout0_51) AT=400.025n

.meas tran vdout0_52ck790 FIND v(dout0_52) AT=400.025n

.meas tran vdout0_53ck790 FIND v(dout0_53) AT=400.025n

.meas tran vdout0_54ck790 FIND v(dout0_54) AT=400.025n

.meas tran vdout0_55ck790 FIND v(dout0_55) AT=400.025n

.meas tran vdout0_56ck790 FIND v(dout0_56) AT=400.025n

.meas tran vdout0_57ck790 FIND v(dout0_57) AT=400.025n

.meas tran vdout0_58ck790 FIND v(dout0_58) AT=400.025n

.meas tran vdout0_59ck790 FIND v(dout0_59) AT=400.025n

.meas tran vdout0_60ck790 FIND v(dout0_60) AT=400.025n

.meas tran vdout0_61ck790 FIND v(dout0_61) AT=400.025n

.meas tran vdout0_62ck790 FIND v(dout0_62) AT=400.025n

.meas tran vdout0_63ck790 FIND v(dout0_63) AT=400.025n

.meas tran vdout0_64ck790 FIND v(dout0_64) AT=400.025n

.meas tran vdout0_65ck790 FIND v(dout0_65) AT=400.025n

.meas tran vdout0_66ck790 FIND v(dout0_66) AT=400.025n

.meas tran vdout0_67ck790 FIND v(dout0_67) AT=400.025n

.meas tran vdout0_68ck790 FIND v(dout0_68) AT=400.025n

.meas tran vdout0_69ck790 FIND v(dout0_69) AT=400.025n

.meas tran vdout0_70ck790 FIND v(dout0_70) AT=400.025n

.meas tran vdout0_71ck790 FIND v(dout0_71) AT=400.025n

.meas tran vdout0_72ck790 FIND v(dout0_72) AT=400.025n

.meas tran vdout0_73ck790 FIND v(dout0_73) AT=400.025n

.meas tran vdout0_74ck790 FIND v(dout0_74) AT=400.025n

.meas tran vdout0_75ck790 FIND v(dout0_75) AT=400.025n

.meas tran vdout0_76ck790 FIND v(dout0_76) AT=400.025n

.meas tran vdout0_77ck790 FIND v(dout0_77) AT=400.025n

.meas tran vdout0_78ck790 FIND v(dout0_78) AT=400.025n

.meas tran vdout0_79ck790 FIND v(dout0_79) AT=400.025n

.meas tran vdout0_80ck790 FIND v(dout0_80) AT=400.025n

.meas tran vdout0_81ck790 FIND v(dout0_81) AT=400.025n

.meas tran vdout0_82ck790 FIND v(dout0_82) AT=400.025n

.meas tran vdout0_83ck790 FIND v(dout0_83) AT=400.025n

.meas tran vdout0_84ck790 FIND v(dout0_84) AT=400.025n

.meas tran vdout0_85ck790 FIND v(dout0_85) AT=400.025n

.meas tran vdout0_86ck790 FIND v(dout0_86) AT=400.025n

.meas tran vdout0_87ck790 FIND v(dout0_87) AT=400.025n

.meas tran vdout0_88ck790 FIND v(dout0_88) AT=400.025n

.meas tran vdout0_89ck790 FIND v(dout0_89) AT=400.025n

.meas tran vdout0_90ck790 FIND v(dout0_90) AT=400.025n

.meas tran vdout0_91ck790 FIND v(dout0_91) AT=400.025n

.meas tran vdout0_92ck790 FIND v(dout0_92) AT=400.025n

.meas tran vdout0_93ck790 FIND v(dout0_93) AT=400.025n

.meas tran vdout0_94ck790 FIND v(dout0_94) AT=400.025n

.meas tran vdout0_95ck790 FIND v(dout0_95) AT=400.025n

.meas tran vdout0_96ck790 FIND v(dout0_96) AT=400.025n

.meas tran vdout0_97ck790 FIND v(dout0_97) AT=400.025n

.meas tran vdout0_98ck790 FIND v(dout0_98) AT=400.025n

.meas tran vdout0_99ck790 FIND v(dout0_99) AT=400.025n

.meas tran vdout0_100ck790 FIND v(dout0_100) AT=400.025n

.meas tran vdout0_101ck790 FIND v(dout0_101) AT=400.025n

.meas tran vdout0_102ck790 FIND v(dout0_102) AT=400.025n

.meas tran vdout0_103ck790 FIND v(dout0_103) AT=400.025n

.meas tran vdout0_104ck790 FIND v(dout0_104) AT=400.025n

.meas tran vdout0_105ck790 FIND v(dout0_105) AT=400.025n

.meas tran vdout0_106ck790 FIND v(dout0_106) AT=400.025n

.meas tran vdout0_107ck790 FIND v(dout0_107) AT=400.025n

.meas tran vdout0_108ck790 FIND v(dout0_108) AT=400.025n

.meas tran vdout0_109ck790 FIND v(dout0_109) AT=400.025n

.meas tran vdout0_110ck790 FIND v(dout0_110) AT=400.025n

.meas tran vdout0_111ck790 FIND v(dout0_111) AT=400.025n

.meas tran vdout0_112ck790 FIND v(dout0_112) AT=400.025n

.meas tran vdout0_113ck790 FIND v(dout0_113) AT=400.025n

.meas tran vdout0_114ck790 FIND v(dout0_114) AT=400.025n

.meas tran vdout0_115ck790 FIND v(dout0_115) AT=400.025n

.meas tran vdout0_116ck790 FIND v(dout0_116) AT=400.025n

.meas tran vdout0_117ck790 FIND v(dout0_117) AT=400.025n

.meas tran vdout0_118ck790 FIND v(dout0_118) AT=400.025n

.meas tran vdout0_119ck790 FIND v(dout0_119) AT=400.025n

.meas tran vdout0_120ck790 FIND v(dout0_120) AT=400.025n

.meas tran vdout0_121ck790 FIND v(dout0_121) AT=400.025n

.meas tran vdout0_122ck790 FIND v(dout0_122) AT=400.025n

.meas tran vdout0_123ck790 FIND v(dout0_123) AT=400.025n

.meas tran vdout0_124ck790 FIND v(dout0_124) AT=400.025n

.meas tran vdout0_125ck790 FIND v(dout0_125) AT=400.025n

.meas tran vdout0_126ck790 FIND v(dout0_126) AT=400.025n

.meas tran vdout0_127ck790 FIND v(dout0_127) AT=400.025n

.meas tran vdout0_128ck790 FIND v(dout0_128) AT=400.025n

.meas tran vdout0_129ck790 FIND v(dout0_129) AT=400.025n

.meas tran vdout0_130ck790 FIND v(dout0_130) AT=400.025n

.meas tran vdout0_131ck790 FIND v(dout0_131) AT=400.025n

.meas tran vdout0_132ck790 FIND v(dout0_132) AT=400.025n

.meas tran vdout0_133ck790 FIND v(dout0_133) AT=400.025n

.meas tran vdout0_134ck790 FIND v(dout0_134) AT=400.025n

.meas tran vdout0_135ck790 FIND v(dout0_135) AT=400.025n

.meas tran vdout0_136ck790 FIND v(dout0_136) AT=400.025n

.meas tran vdout0_137ck790 FIND v(dout0_137) AT=400.025n

.meas tran vdout0_138ck790 FIND v(dout0_138) AT=400.025n

.meas tran vdout0_139ck790 FIND v(dout0_139) AT=400.025n

.meas tran vdout0_140ck790 FIND v(dout0_140) AT=400.025n

.meas tran vdout0_141ck790 FIND v(dout0_141) AT=400.025n

.meas tran vdout0_142ck790 FIND v(dout0_142) AT=400.025n

.meas tran vdout0_143ck790 FIND v(dout0_143) AT=400.025n

.meas tran vdout0_144ck790 FIND v(dout0_144) AT=400.025n

.meas tran vdout0_145ck790 FIND v(dout0_145) AT=400.025n

.meas tran vdout0_146ck790 FIND v(dout0_146) AT=400.025n

.meas tran vdout0_147ck790 FIND v(dout0_147) AT=400.025n

.meas tran vdout0_148ck790 FIND v(dout0_148) AT=400.025n

.meas tran vdout0_149ck790 FIND v(dout0_149) AT=400.025n

.meas tran vdout0_150ck790 FIND v(dout0_150) AT=400.025n

.meas tran vdout0_151ck790 FIND v(dout0_151) AT=400.025n

.meas tran vdout0_152ck790 FIND v(dout0_152) AT=400.025n

.meas tran vdout0_153ck790 FIND v(dout0_153) AT=400.025n

.meas tran vdout0_154ck790 FIND v(dout0_154) AT=400.025n

.meas tran vdout0_155ck790 FIND v(dout0_155) AT=400.025n

.meas tran vdout0_156ck790 FIND v(dout0_156) AT=400.025n

.meas tran vdout0_157ck790 FIND v(dout0_157) AT=400.025n

.meas tran vdout0_158ck790 FIND v(dout0_158) AT=400.025n

.meas tran vdout0_159ck790 FIND v(dout0_159) AT=400.025n

.meas tran vdout0_160ck790 FIND v(dout0_160) AT=400.025n

.meas tran vdout0_161ck790 FIND v(dout0_161) AT=400.025n

.meas tran vdout0_162ck790 FIND v(dout0_162) AT=400.025n

.meas tran vdout0_163ck790 FIND v(dout0_163) AT=400.025n

.meas tran vdout0_164ck790 FIND v(dout0_164) AT=400.025n

.meas tran vdout0_165ck790 FIND v(dout0_165) AT=400.025n

.meas tran vdout0_166ck790 FIND v(dout0_166) AT=400.025n

.meas tran vdout0_167ck790 FIND v(dout0_167) AT=400.025n

.meas tran vdout0_168ck790 FIND v(dout0_168) AT=400.025n

.meas tran vdout0_169ck790 FIND v(dout0_169) AT=400.025n

.meas tran vdout0_170ck790 FIND v(dout0_170) AT=400.025n

.meas tran vdout0_171ck790 FIND v(dout0_171) AT=400.025n

.meas tran vdout0_172ck790 FIND v(dout0_172) AT=400.025n

.meas tran vdout0_173ck790 FIND v(dout0_173) AT=400.025n

.meas tran vdout0_174ck790 FIND v(dout0_174) AT=400.025n

.meas tran vdout0_175ck790 FIND v(dout0_175) AT=400.025n

.meas tran vdout0_176ck790 FIND v(dout0_176) AT=400.025n

.meas tran vdout0_177ck790 FIND v(dout0_177) AT=400.025n

.meas tran vdout0_178ck790 FIND v(dout0_178) AT=400.025n

.meas tran vdout0_179ck790 FIND v(dout0_179) AT=400.025n

.meas tran vdout0_180ck790 FIND v(dout0_180) AT=400.025n

.meas tran vdout0_181ck790 FIND v(dout0_181) AT=400.025n

.meas tran vdout0_182ck790 FIND v(dout0_182) AT=400.025n

.meas tran vdout0_183ck790 FIND v(dout0_183) AT=400.025n

.meas tran vdout0_184ck790 FIND v(dout0_184) AT=400.025n

.meas tran vdout0_185ck790 FIND v(dout0_185) AT=400.025n

.meas tran vdout0_186ck790 FIND v(dout0_186) AT=400.025n

.meas tran vdout0_187ck790 FIND v(dout0_187) AT=400.025n

.meas tran vdout0_188ck790 FIND v(dout0_188) AT=400.025n

.meas tran vdout0_189ck790 FIND v(dout0_189) AT=400.025n

.meas tran vdout0_190ck790 FIND v(dout0_190) AT=400.025n

.meas tran vdout0_191ck790 FIND v(dout0_191) AT=400.025n

.meas tran vdout0_192ck790 FIND v(dout0_192) AT=400.025n

.meas tran vdout0_193ck790 FIND v(dout0_193) AT=400.025n

.meas tran vdout0_194ck790 FIND v(dout0_194) AT=400.025n

.meas tran vdout0_195ck790 FIND v(dout0_195) AT=400.025n

.meas tran vdout0_196ck790 FIND v(dout0_196) AT=400.025n

.meas tran vdout0_197ck790 FIND v(dout0_197) AT=400.025n

.meas tran vdout0_198ck790 FIND v(dout0_198) AT=400.025n

.meas tran vdout0_199ck790 FIND v(dout0_199) AT=400.025n

.meas tran vdout0_200ck790 FIND v(dout0_200) AT=400.025n

.meas tran vdout0_201ck790 FIND v(dout0_201) AT=400.025n

.meas tran vdout0_202ck790 FIND v(dout0_202) AT=400.025n

.meas tran vdout0_203ck790 FIND v(dout0_203) AT=400.025n

.meas tran vdout0_204ck790 FIND v(dout0_204) AT=400.025n

.meas tran vdout0_205ck790 FIND v(dout0_205) AT=400.025n

.meas tran vdout0_206ck790 FIND v(dout0_206) AT=400.025n

.meas tran vdout0_207ck790 FIND v(dout0_207) AT=400.025n

.meas tran vdout0_208ck790 FIND v(dout0_208) AT=400.025n

.meas tran vdout0_209ck790 FIND v(dout0_209) AT=400.025n

.meas tran vdout0_210ck790 FIND v(dout0_210) AT=400.025n

.meas tran vdout0_211ck790 FIND v(dout0_211) AT=400.025n

.meas tran vdout0_212ck790 FIND v(dout0_212) AT=400.025n

.meas tran vdout0_213ck790 FIND v(dout0_213) AT=400.025n

.meas tran vdout0_214ck790 FIND v(dout0_214) AT=400.025n

.meas tran vdout0_215ck790 FIND v(dout0_215) AT=400.025n

.meas tran vdout0_216ck790 FIND v(dout0_216) AT=400.025n

.meas tran vdout0_217ck790 FIND v(dout0_217) AT=400.025n

.meas tran vdout0_218ck790 FIND v(dout0_218) AT=400.025n

.meas tran vdout0_219ck790 FIND v(dout0_219) AT=400.025n

.meas tran vdout0_220ck790 FIND v(dout0_220) AT=400.025n

.meas tran vdout0_221ck790 FIND v(dout0_221) AT=400.025n

.meas tran vdout0_222ck790 FIND v(dout0_222) AT=400.025n

.meas tran vdout0_223ck790 FIND v(dout0_223) AT=400.025n

.meas tran vdout0_224ck790 FIND v(dout0_224) AT=400.025n

.meas tran vdout0_225ck790 FIND v(dout0_225) AT=400.025n

.meas tran vdout0_226ck790 FIND v(dout0_226) AT=400.025n

.meas tran vdout0_227ck790 FIND v(dout0_227) AT=400.025n

.meas tran vdout0_228ck790 FIND v(dout0_228) AT=400.025n

.meas tran vdout0_229ck790 FIND v(dout0_229) AT=400.025n

.meas tran vdout0_230ck790 FIND v(dout0_230) AT=400.025n

.meas tran vdout0_231ck790 FIND v(dout0_231) AT=400.025n

.meas tran vdout0_232ck790 FIND v(dout0_232) AT=400.025n

.meas tran vdout0_233ck790 FIND v(dout0_233) AT=400.025n

.meas tran vdout0_234ck790 FIND v(dout0_234) AT=400.025n

.meas tran vdout0_235ck790 FIND v(dout0_235) AT=400.025n

.meas tran vdout0_236ck790 FIND v(dout0_236) AT=400.025n

.meas tran vdout0_237ck790 FIND v(dout0_237) AT=400.025n

.meas tran vdout0_238ck790 FIND v(dout0_238) AT=400.025n

.meas tran vdout0_239ck790 FIND v(dout0_239) AT=400.025n

.meas tran vdout0_240ck790 FIND v(dout0_240) AT=400.025n

.meas tran vdout0_241ck790 FIND v(dout0_241) AT=400.025n

.meas tran vdout0_242ck790 FIND v(dout0_242) AT=400.025n

.meas tran vdout0_243ck790 FIND v(dout0_243) AT=400.025n

.meas tran vdout0_244ck790 FIND v(dout0_244) AT=400.025n

.meas tran vdout0_245ck790 FIND v(dout0_245) AT=400.025n

.meas tran vdout0_246ck790 FIND v(dout0_246) AT=400.025n

.meas tran vdout0_247ck790 FIND v(dout0_247) AT=400.025n

.meas tran vdout0_248ck790 FIND v(dout0_248) AT=400.025n

.meas tran vdout0_249ck790 FIND v(dout0_249) AT=400.025n

.meas tran vdout0_250ck790 FIND v(dout0_250) AT=400.025n

.meas tran vdout0_251ck790 FIND v(dout0_251) AT=400.025n

.meas tran vdout0_252ck790 FIND v(dout0_252) AT=400.025n

.meas tran vdout0_253ck790 FIND v(dout0_253) AT=400.025n

.meas tran vdout0_254ck790 FIND v(dout0_254) AT=400.025n

.meas tran vdout0_255ck790 FIND v(dout0_255) AT=400.025n

.meas tran vdout0_0ck810 FIND v(dout0_0) AT=410.025n

.meas tran vdout0_1ck810 FIND v(dout0_1) AT=410.025n

.meas tran vdout0_2ck810 FIND v(dout0_2) AT=410.025n

.meas tran vdout0_3ck810 FIND v(dout0_3) AT=410.025n

.meas tran vdout0_4ck810 FIND v(dout0_4) AT=410.025n

.meas tran vdout0_5ck810 FIND v(dout0_5) AT=410.025n

.meas tran vdout0_6ck810 FIND v(dout0_6) AT=410.025n

.meas tran vdout0_7ck810 FIND v(dout0_7) AT=410.025n

.meas tran vdout0_8ck810 FIND v(dout0_8) AT=410.025n

.meas tran vdout0_9ck810 FIND v(dout0_9) AT=410.025n

.meas tran vdout0_10ck810 FIND v(dout0_10) AT=410.025n

.meas tran vdout0_11ck810 FIND v(dout0_11) AT=410.025n

.meas tran vdout0_12ck810 FIND v(dout0_12) AT=410.025n

.meas tran vdout0_13ck810 FIND v(dout0_13) AT=410.025n

.meas tran vdout0_14ck810 FIND v(dout0_14) AT=410.025n

.meas tran vdout0_15ck810 FIND v(dout0_15) AT=410.025n

.meas tran vdout0_16ck810 FIND v(dout0_16) AT=410.025n

.meas tran vdout0_17ck810 FIND v(dout0_17) AT=410.025n

.meas tran vdout0_18ck810 FIND v(dout0_18) AT=410.025n

.meas tran vdout0_19ck810 FIND v(dout0_19) AT=410.025n

.meas tran vdout0_20ck810 FIND v(dout0_20) AT=410.025n

.meas tran vdout0_21ck810 FIND v(dout0_21) AT=410.025n

.meas tran vdout0_22ck810 FIND v(dout0_22) AT=410.025n

.meas tran vdout0_23ck810 FIND v(dout0_23) AT=410.025n

.meas tran vdout0_24ck810 FIND v(dout0_24) AT=410.025n

.meas tran vdout0_25ck810 FIND v(dout0_25) AT=410.025n

.meas tran vdout0_26ck810 FIND v(dout0_26) AT=410.025n

.meas tran vdout0_27ck810 FIND v(dout0_27) AT=410.025n

.meas tran vdout0_28ck810 FIND v(dout0_28) AT=410.025n

.meas tran vdout0_29ck810 FIND v(dout0_29) AT=410.025n

.meas tran vdout0_30ck810 FIND v(dout0_30) AT=410.025n

.meas tran vdout0_31ck810 FIND v(dout0_31) AT=410.025n

.meas tran vdout0_32ck810 FIND v(dout0_32) AT=410.025n

.meas tran vdout0_33ck810 FIND v(dout0_33) AT=410.025n

.meas tran vdout0_34ck810 FIND v(dout0_34) AT=410.025n

.meas tran vdout0_35ck810 FIND v(dout0_35) AT=410.025n

.meas tran vdout0_36ck810 FIND v(dout0_36) AT=410.025n

.meas tran vdout0_37ck810 FIND v(dout0_37) AT=410.025n

.meas tran vdout0_38ck810 FIND v(dout0_38) AT=410.025n

.meas tran vdout0_39ck810 FIND v(dout0_39) AT=410.025n

.meas tran vdout0_40ck810 FIND v(dout0_40) AT=410.025n

.meas tran vdout0_41ck810 FIND v(dout0_41) AT=410.025n

.meas tran vdout0_42ck810 FIND v(dout0_42) AT=410.025n

.meas tran vdout0_43ck810 FIND v(dout0_43) AT=410.025n

.meas tran vdout0_44ck810 FIND v(dout0_44) AT=410.025n

.meas tran vdout0_45ck810 FIND v(dout0_45) AT=410.025n

.meas tran vdout0_46ck810 FIND v(dout0_46) AT=410.025n

.meas tran vdout0_47ck810 FIND v(dout0_47) AT=410.025n

.meas tran vdout0_48ck810 FIND v(dout0_48) AT=410.025n

.meas tran vdout0_49ck810 FIND v(dout0_49) AT=410.025n

.meas tran vdout0_50ck810 FIND v(dout0_50) AT=410.025n

.meas tran vdout0_51ck810 FIND v(dout0_51) AT=410.025n

.meas tran vdout0_52ck810 FIND v(dout0_52) AT=410.025n

.meas tran vdout0_53ck810 FIND v(dout0_53) AT=410.025n

.meas tran vdout0_54ck810 FIND v(dout0_54) AT=410.025n

.meas tran vdout0_55ck810 FIND v(dout0_55) AT=410.025n

.meas tran vdout0_56ck810 FIND v(dout0_56) AT=410.025n

.meas tran vdout0_57ck810 FIND v(dout0_57) AT=410.025n

.meas tran vdout0_58ck810 FIND v(dout0_58) AT=410.025n

.meas tran vdout0_59ck810 FIND v(dout0_59) AT=410.025n

.meas tran vdout0_60ck810 FIND v(dout0_60) AT=410.025n

.meas tran vdout0_61ck810 FIND v(dout0_61) AT=410.025n

.meas tran vdout0_62ck810 FIND v(dout0_62) AT=410.025n

.meas tran vdout0_63ck810 FIND v(dout0_63) AT=410.025n

.meas tran vdout0_64ck810 FIND v(dout0_64) AT=410.025n

.meas tran vdout0_65ck810 FIND v(dout0_65) AT=410.025n

.meas tran vdout0_66ck810 FIND v(dout0_66) AT=410.025n

.meas tran vdout0_67ck810 FIND v(dout0_67) AT=410.025n

.meas tran vdout0_68ck810 FIND v(dout0_68) AT=410.025n

.meas tran vdout0_69ck810 FIND v(dout0_69) AT=410.025n

.meas tran vdout0_70ck810 FIND v(dout0_70) AT=410.025n

.meas tran vdout0_71ck810 FIND v(dout0_71) AT=410.025n

.meas tran vdout0_72ck810 FIND v(dout0_72) AT=410.025n

.meas tran vdout0_73ck810 FIND v(dout0_73) AT=410.025n

.meas tran vdout0_74ck810 FIND v(dout0_74) AT=410.025n

.meas tran vdout0_75ck810 FIND v(dout0_75) AT=410.025n

.meas tran vdout0_76ck810 FIND v(dout0_76) AT=410.025n

.meas tran vdout0_77ck810 FIND v(dout0_77) AT=410.025n

.meas tran vdout0_78ck810 FIND v(dout0_78) AT=410.025n

.meas tran vdout0_79ck810 FIND v(dout0_79) AT=410.025n

.meas tran vdout0_80ck810 FIND v(dout0_80) AT=410.025n

.meas tran vdout0_81ck810 FIND v(dout0_81) AT=410.025n

.meas tran vdout0_82ck810 FIND v(dout0_82) AT=410.025n

.meas tran vdout0_83ck810 FIND v(dout0_83) AT=410.025n

.meas tran vdout0_84ck810 FIND v(dout0_84) AT=410.025n

.meas tran vdout0_85ck810 FIND v(dout0_85) AT=410.025n

.meas tran vdout0_86ck810 FIND v(dout0_86) AT=410.025n

.meas tran vdout0_87ck810 FIND v(dout0_87) AT=410.025n

.meas tran vdout0_88ck810 FIND v(dout0_88) AT=410.025n

.meas tran vdout0_89ck810 FIND v(dout0_89) AT=410.025n

.meas tran vdout0_90ck810 FIND v(dout0_90) AT=410.025n

.meas tran vdout0_91ck810 FIND v(dout0_91) AT=410.025n

.meas tran vdout0_92ck810 FIND v(dout0_92) AT=410.025n

.meas tran vdout0_93ck810 FIND v(dout0_93) AT=410.025n

.meas tran vdout0_94ck810 FIND v(dout0_94) AT=410.025n

.meas tran vdout0_95ck810 FIND v(dout0_95) AT=410.025n

.meas tran vdout0_96ck810 FIND v(dout0_96) AT=410.025n

.meas tran vdout0_97ck810 FIND v(dout0_97) AT=410.025n

.meas tran vdout0_98ck810 FIND v(dout0_98) AT=410.025n

.meas tran vdout0_99ck810 FIND v(dout0_99) AT=410.025n

.meas tran vdout0_100ck810 FIND v(dout0_100) AT=410.025n

.meas tran vdout0_101ck810 FIND v(dout0_101) AT=410.025n

.meas tran vdout0_102ck810 FIND v(dout0_102) AT=410.025n

.meas tran vdout0_103ck810 FIND v(dout0_103) AT=410.025n

.meas tran vdout0_104ck810 FIND v(dout0_104) AT=410.025n

.meas tran vdout0_105ck810 FIND v(dout0_105) AT=410.025n

.meas tran vdout0_106ck810 FIND v(dout0_106) AT=410.025n

.meas tran vdout0_107ck810 FIND v(dout0_107) AT=410.025n

.meas tran vdout0_108ck810 FIND v(dout0_108) AT=410.025n

.meas tran vdout0_109ck810 FIND v(dout0_109) AT=410.025n

.meas tran vdout0_110ck810 FIND v(dout0_110) AT=410.025n

.meas tran vdout0_111ck810 FIND v(dout0_111) AT=410.025n

.meas tran vdout0_112ck810 FIND v(dout0_112) AT=410.025n

.meas tran vdout0_113ck810 FIND v(dout0_113) AT=410.025n

.meas tran vdout0_114ck810 FIND v(dout0_114) AT=410.025n

.meas tran vdout0_115ck810 FIND v(dout0_115) AT=410.025n

.meas tran vdout0_116ck810 FIND v(dout0_116) AT=410.025n

.meas tran vdout0_117ck810 FIND v(dout0_117) AT=410.025n

.meas tran vdout0_118ck810 FIND v(dout0_118) AT=410.025n

.meas tran vdout0_119ck810 FIND v(dout0_119) AT=410.025n

.meas tran vdout0_120ck810 FIND v(dout0_120) AT=410.025n

.meas tran vdout0_121ck810 FIND v(dout0_121) AT=410.025n

.meas tran vdout0_122ck810 FIND v(dout0_122) AT=410.025n

.meas tran vdout0_123ck810 FIND v(dout0_123) AT=410.025n

.meas tran vdout0_124ck810 FIND v(dout0_124) AT=410.025n

.meas tran vdout0_125ck810 FIND v(dout0_125) AT=410.025n

.meas tran vdout0_126ck810 FIND v(dout0_126) AT=410.025n

.meas tran vdout0_127ck810 FIND v(dout0_127) AT=410.025n

.meas tran vdout0_128ck810 FIND v(dout0_128) AT=410.025n

.meas tran vdout0_129ck810 FIND v(dout0_129) AT=410.025n

.meas tran vdout0_130ck810 FIND v(dout0_130) AT=410.025n

.meas tran vdout0_131ck810 FIND v(dout0_131) AT=410.025n

.meas tran vdout0_132ck810 FIND v(dout0_132) AT=410.025n

.meas tran vdout0_133ck810 FIND v(dout0_133) AT=410.025n

.meas tran vdout0_134ck810 FIND v(dout0_134) AT=410.025n

.meas tran vdout0_135ck810 FIND v(dout0_135) AT=410.025n

.meas tran vdout0_136ck810 FIND v(dout0_136) AT=410.025n

.meas tran vdout0_137ck810 FIND v(dout0_137) AT=410.025n

.meas tran vdout0_138ck810 FIND v(dout0_138) AT=410.025n

.meas tran vdout0_139ck810 FIND v(dout0_139) AT=410.025n

.meas tran vdout0_140ck810 FIND v(dout0_140) AT=410.025n

.meas tran vdout0_141ck810 FIND v(dout0_141) AT=410.025n

.meas tran vdout0_142ck810 FIND v(dout0_142) AT=410.025n

.meas tran vdout0_143ck810 FIND v(dout0_143) AT=410.025n

.meas tran vdout0_144ck810 FIND v(dout0_144) AT=410.025n

.meas tran vdout0_145ck810 FIND v(dout0_145) AT=410.025n

.meas tran vdout0_146ck810 FIND v(dout0_146) AT=410.025n

.meas tran vdout0_147ck810 FIND v(dout0_147) AT=410.025n

.meas tran vdout0_148ck810 FIND v(dout0_148) AT=410.025n

.meas tran vdout0_149ck810 FIND v(dout0_149) AT=410.025n

.meas tran vdout0_150ck810 FIND v(dout0_150) AT=410.025n

.meas tran vdout0_151ck810 FIND v(dout0_151) AT=410.025n

.meas tran vdout0_152ck810 FIND v(dout0_152) AT=410.025n

.meas tran vdout0_153ck810 FIND v(dout0_153) AT=410.025n

.meas tran vdout0_154ck810 FIND v(dout0_154) AT=410.025n

.meas tran vdout0_155ck810 FIND v(dout0_155) AT=410.025n

.meas tran vdout0_156ck810 FIND v(dout0_156) AT=410.025n

.meas tran vdout0_157ck810 FIND v(dout0_157) AT=410.025n

.meas tran vdout0_158ck810 FIND v(dout0_158) AT=410.025n

.meas tran vdout0_159ck810 FIND v(dout0_159) AT=410.025n

.meas tran vdout0_160ck810 FIND v(dout0_160) AT=410.025n

.meas tran vdout0_161ck810 FIND v(dout0_161) AT=410.025n

.meas tran vdout0_162ck810 FIND v(dout0_162) AT=410.025n

.meas tran vdout0_163ck810 FIND v(dout0_163) AT=410.025n

.meas tran vdout0_164ck810 FIND v(dout0_164) AT=410.025n

.meas tran vdout0_165ck810 FIND v(dout0_165) AT=410.025n

.meas tran vdout0_166ck810 FIND v(dout0_166) AT=410.025n

.meas tran vdout0_167ck810 FIND v(dout0_167) AT=410.025n

.meas tran vdout0_168ck810 FIND v(dout0_168) AT=410.025n

.meas tran vdout0_169ck810 FIND v(dout0_169) AT=410.025n

.meas tran vdout0_170ck810 FIND v(dout0_170) AT=410.025n

.meas tran vdout0_171ck810 FIND v(dout0_171) AT=410.025n

.meas tran vdout0_172ck810 FIND v(dout0_172) AT=410.025n

.meas tran vdout0_173ck810 FIND v(dout0_173) AT=410.025n

.meas tran vdout0_174ck810 FIND v(dout0_174) AT=410.025n

.meas tran vdout0_175ck810 FIND v(dout0_175) AT=410.025n

.meas tran vdout0_176ck810 FIND v(dout0_176) AT=410.025n

.meas tran vdout0_177ck810 FIND v(dout0_177) AT=410.025n

.meas tran vdout0_178ck810 FIND v(dout0_178) AT=410.025n

.meas tran vdout0_179ck810 FIND v(dout0_179) AT=410.025n

.meas tran vdout0_180ck810 FIND v(dout0_180) AT=410.025n

.meas tran vdout0_181ck810 FIND v(dout0_181) AT=410.025n

.meas tran vdout0_182ck810 FIND v(dout0_182) AT=410.025n

.meas tran vdout0_183ck810 FIND v(dout0_183) AT=410.025n

.meas tran vdout0_184ck810 FIND v(dout0_184) AT=410.025n

.meas tran vdout0_185ck810 FIND v(dout0_185) AT=410.025n

.meas tran vdout0_186ck810 FIND v(dout0_186) AT=410.025n

.meas tran vdout0_187ck810 FIND v(dout0_187) AT=410.025n

.meas tran vdout0_188ck810 FIND v(dout0_188) AT=410.025n

.meas tran vdout0_189ck810 FIND v(dout0_189) AT=410.025n

.meas tran vdout0_190ck810 FIND v(dout0_190) AT=410.025n

.meas tran vdout0_191ck810 FIND v(dout0_191) AT=410.025n

.meas tran vdout0_192ck810 FIND v(dout0_192) AT=410.025n

.meas tran vdout0_193ck810 FIND v(dout0_193) AT=410.025n

.meas tran vdout0_194ck810 FIND v(dout0_194) AT=410.025n

.meas tran vdout0_195ck810 FIND v(dout0_195) AT=410.025n

.meas tran vdout0_196ck810 FIND v(dout0_196) AT=410.025n

.meas tran vdout0_197ck810 FIND v(dout0_197) AT=410.025n

.meas tran vdout0_198ck810 FIND v(dout0_198) AT=410.025n

.meas tran vdout0_199ck810 FIND v(dout0_199) AT=410.025n

.meas tran vdout0_200ck810 FIND v(dout0_200) AT=410.025n

.meas tran vdout0_201ck810 FIND v(dout0_201) AT=410.025n

.meas tran vdout0_202ck810 FIND v(dout0_202) AT=410.025n

.meas tran vdout0_203ck810 FIND v(dout0_203) AT=410.025n

.meas tran vdout0_204ck810 FIND v(dout0_204) AT=410.025n

.meas tran vdout0_205ck810 FIND v(dout0_205) AT=410.025n

.meas tran vdout0_206ck810 FIND v(dout0_206) AT=410.025n

.meas tran vdout0_207ck810 FIND v(dout0_207) AT=410.025n

.meas tran vdout0_208ck810 FIND v(dout0_208) AT=410.025n

.meas tran vdout0_209ck810 FIND v(dout0_209) AT=410.025n

.meas tran vdout0_210ck810 FIND v(dout0_210) AT=410.025n

.meas tran vdout0_211ck810 FIND v(dout0_211) AT=410.025n

.meas tran vdout0_212ck810 FIND v(dout0_212) AT=410.025n

.meas tran vdout0_213ck810 FIND v(dout0_213) AT=410.025n

.meas tran vdout0_214ck810 FIND v(dout0_214) AT=410.025n

.meas tran vdout0_215ck810 FIND v(dout0_215) AT=410.025n

.meas tran vdout0_216ck810 FIND v(dout0_216) AT=410.025n

.meas tran vdout0_217ck810 FIND v(dout0_217) AT=410.025n

.meas tran vdout0_218ck810 FIND v(dout0_218) AT=410.025n

.meas tran vdout0_219ck810 FIND v(dout0_219) AT=410.025n

.meas tran vdout0_220ck810 FIND v(dout0_220) AT=410.025n

.meas tran vdout0_221ck810 FIND v(dout0_221) AT=410.025n

.meas tran vdout0_222ck810 FIND v(dout0_222) AT=410.025n

.meas tran vdout0_223ck810 FIND v(dout0_223) AT=410.025n

.meas tran vdout0_224ck810 FIND v(dout0_224) AT=410.025n

.meas tran vdout0_225ck810 FIND v(dout0_225) AT=410.025n

.meas tran vdout0_226ck810 FIND v(dout0_226) AT=410.025n

.meas tran vdout0_227ck810 FIND v(dout0_227) AT=410.025n

.meas tran vdout0_228ck810 FIND v(dout0_228) AT=410.025n

.meas tran vdout0_229ck810 FIND v(dout0_229) AT=410.025n

.meas tran vdout0_230ck810 FIND v(dout0_230) AT=410.025n

.meas tran vdout0_231ck810 FIND v(dout0_231) AT=410.025n

.meas tran vdout0_232ck810 FIND v(dout0_232) AT=410.025n

.meas tran vdout0_233ck810 FIND v(dout0_233) AT=410.025n

.meas tran vdout0_234ck810 FIND v(dout0_234) AT=410.025n

.meas tran vdout0_235ck810 FIND v(dout0_235) AT=410.025n

.meas tran vdout0_236ck810 FIND v(dout0_236) AT=410.025n

.meas tran vdout0_237ck810 FIND v(dout0_237) AT=410.025n

.meas tran vdout0_238ck810 FIND v(dout0_238) AT=410.025n

.meas tran vdout0_239ck810 FIND v(dout0_239) AT=410.025n

.meas tran vdout0_240ck810 FIND v(dout0_240) AT=410.025n

.meas tran vdout0_241ck810 FIND v(dout0_241) AT=410.025n

.meas tran vdout0_242ck810 FIND v(dout0_242) AT=410.025n

.meas tran vdout0_243ck810 FIND v(dout0_243) AT=410.025n

.meas tran vdout0_244ck810 FIND v(dout0_244) AT=410.025n

.meas tran vdout0_245ck810 FIND v(dout0_245) AT=410.025n

.meas tran vdout0_246ck810 FIND v(dout0_246) AT=410.025n

.meas tran vdout0_247ck810 FIND v(dout0_247) AT=410.025n

.meas tran vdout0_248ck810 FIND v(dout0_248) AT=410.025n

.meas tran vdout0_249ck810 FIND v(dout0_249) AT=410.025n

.meas tran vdout0_250ck810 FIND v(dout0_250) AT=410.025n

.meas tran vdout0_251ck810 FIND v(dout0_251) AT=410.025n

.meas tran vdout0_252ck810 FIND v(dout0_252) AT=410.025n

.meas tran vdout0_253ck810 FIND v(dout0_253) AT=410.025n

.meas tran vdout0_254ck810 FIND v(dout0_254) AT=410.025n

.meas tran vdout0_255ck810 FIND v(dout0_255) AT=410.025n

.meas tran vdout0_0ck840 FIND v(dout0_0) AT=425.025n

.meas tran vdout0_1ck840 FIND v(dout0_1) AT=425.025n

.meas tran vdout0_2ck840 FIND v(dout0_2) AT=425.025n

.meas tran vdout0_3ck840 FIND v(dout0_3) AT=425.025n

.meas tran vdout0_4ck840 FIND v(dout0_4) AT=425.025n

.meas tran vdout0_5ck840 FIND v(dout0_5) AT=425.025n

.meas tran vdout0_6ck840 FIND v(dout0_6) AT=425.025n

.meas tran vdout0_7ck840 FIND v(dout0_7) AT=425.025n

.meas tran vdout0_8ck840 FIND v(dout0_8) AT=425.025n

.meas tran vdout0_9ck840 FIND v(dout0_9) AT=425.025n

.meas tran vdout0_10ck840 FIND v(dout0_10) AT=425.025n

.meas tran vdout0_11ck840 FIND v(dout0_11) AT=425.025n

.meas tran vdout0_12ck840 FIND v(dout0_12) AT=425.025n

.meas tran vdout0_13ck840 FIND v(dout0_13) AT=425.025n

.meas tran vdout0_14ck840 FIND v(dout0_14) AT=425.025n

.meas tran vdout0_15ck840 FIND v(dout0_15) AT=425.025n

.meas tran vdout0_16ck840 FIND v(dout0_16) AT=425.025n

.meas tran vdout0_17ck840 FIND v(dout0_17) AT=425.025n

.meas tran vdout0_18ck840 FIND v(dout0_18) AT=425.025n

.meas tran vdout0_19ck840 FIND v(dout0_19) AT=425.025n

.meas tran vdout0_20ck840 FIND v(dout0_20) AT=425.025n

.meas tran vdout0_21ck840 FIND v(dout0_21) AT=425.025n

.meas tran vdout0_22ck840 FIND v(dout0_22) AT=425.025n

.meas tran vdout0_23ck840 FIND v(dout0_23) AT=425.025n

.meas tran vdout0_24ck840 FIND v(dout0_24) AT=425.025n

.meas tran vdout0_25ck840 FIND v(dout0_25) AT=425.025n

.meas tran vdout0_26ck840 FIND v(dout0_26) AT=425.025n

.meas tran vdout0_27ck840 FIND v(dout0_27) AT=425.025n

.meas tran vdout0_28ck840 FIND v(dout0_28) AT=425.025n

.meas tran vdout0_29ck840 FIND v(dout0_29) AT=425.025n

.meas tran vdout0_30ck840 FIND v(dout0_30) AT=425.025n

.meas tran vdout0_31ck840 FIND v(dout0_31) AT=425.025n

.meas tran vdout0_32ck840 FIND v(dout0_32) AT=425.025n

.meas tran vdout0_33ck840 FIND v(dout0_33) AT=425.025n

.meas tran vdout0_34ck840 FIND v(dout0_34) AT=425.025n

.meas tran vdout0_35ck840 FIND v(dout0_35) AT=425.025n

.meas tran vdout0_36ck840 FIND v(dout0_36) AT=425.025n

.meas tran vdout0_37ck840 FIND v(dout0_37) AT=425.025n

.meas tran vdout0_38ck840 FIND v(dout0_38) AT=425.025n

.meas tran vdout0_39ck840 FIND v(dout0_39) AT=425.025n

.meas tran vdout0_40ck840 FIND v(dout0_40) AT=425.025n

.meas tran vdout0_41ck840 FIND v(dout0_41) AT=425.025n

.meas tran vdout0_42ck840 FIND v(dout0_42) AT=425.025n

.meas tran vdout0_43ck840 FIND v(dout0_43) AT=425.025n

.meas tran vdout0_44ck840 FIND v(dout0_44) AT=425.025n

.meas tran vdout0_45ck840 FIND v(dout0_45) AT=425.025n

.meas tran vdout0_46ck840 FIND v(dout0_46) AT=425.025n

.meas tran vdout0_47ck840 FIND v(dout0_47) AT=425.025n

.meas tran vdout0_48ck840 FIND v(dout0_48) AT=425.025n

.meas tran vdout0_49ck840 FIND v(dout0_49) AT=425.025n

.meas tran vdout0_50ck840 FIND v(dout0_50) AT=425.025n

.meas tran vdout0_51ck840 FIND v(dout0_51) AT=425.025n

.meas tran vdout0_52ck840 FIND v(dout0_52) AT=425.025n

.meas tran vdout0_53ck840 FIND v(dout0_53) AT=425.025n

.meas tran vdout0_54ck840 FIND v(dout0_54) AT=425.025n

.meas tran vdout0_55ck840 FIND v(dout0_55) AT=425.025n

.meas tran vdout0_56ck840 FIND v(dout0_56) AT=425.025n

.meas tran vdout0_57ck840 FIND v(dout0_57) AT=425.025n

.meas tran vdout0_58ck840 FIND v(dout0_58) AT=425.025n

.meas tran vdout0_59ck840 FIND v(dout0_59) AT=425.025n

.meas tran vdout0_60ck840 FIND v(dout0_60) AT=425.025n

.meas tran vdout0_61ck840 FIND v(dout0_61) AT=425.025n

.meas tran vdout0_62ck840 FIND v(dout0_62) AT=425.025n

.meas tran vdout0_63ck840 FIND v(dout0_63) AT=425.025n

.meas tran vdout0_64ck840 FIND v(dout0_64) AT=425.025n

.meas tran vdout0_65ck840 FIND v(dout0_65) AT=425.025n

.meas tran vdout0_66ck840 FIND v(dout0_66) AT=425.025n

.meas tran vdout0_67ck840 FIND v(dout0_67) AT=425.025n

.meas tran vdout0_68ck840 FIND v(dout0_68) AT=425.025n

.meas tran vdout0_69ck840 FIND v(dout0_69) AT=425.025n

.meas tran vdout0_70ck840 FIND v(dout0_70) AT=425.025n

.meas tran vdout0_71ck840 FIND v(dout0_71) AT=425.025n

.meas tran vdout0_72ck840 FIND v(dout0_72) AT=425.025n

.meas tran vdout0_73ck840 FIND v(dout0_73) AT=425.025n

.meas tran vdout0_74ck840 FIND v(dout0_74) AT=425.025n

.meas tran vdout0_75ck840 FIND v(dout0_75) AT=425.025n

.meas tran vdout0_76ck840 FIND v(dout0_76) AT=425.025n

.meas tran vdout0_77ck840 FIND v(dout0_77) AT=425.025n

.meas tran vdout0_78ck840 FIND v(dout0_78) AT=425.025n

.meas tran vdout0_79ck840 FIND v(dout0_79) AT=425.025n

.meas tran vdout0_80ck840 FIND v(dout0_80) AT=425.025n

.meas tran vdout0_81ck840 FIND v(dout0_81) AT=425.025n

.meas tran vdout0_82ck840 FIND v(dout0_82) AT=425.025n

.meas tran vdout0_83ck840 FIND v(dout0_83) AT=425.025n

.meas tran vdout0_84ck840 FIND v(dout0_84) AT=425.025n

.meas tran vdout0_85ck840 FIND v(dout0_85) AT=425.025n

.meas tran vdout0_86ck840 FIND v(dout0_86) AT=425.025n

.meas tran vdout0_87ck840 FIND v(dout0_87) AT=425.025n

.meas tran vdout0_88ck840 FIND v(dout0_88) AT=425.025n

.meas tran vdout0_89ck840 FIND v(dout0_89) AT=425.025n

.meas tran vdout0_90ck840 FIND v(dout0_90) AT=425.025n

.meas tran vdout0_91ck840 FIND v(dout0_91) AT=425.025n

.meas tran vdout0_92ck840 FIND v(dout0_92) AT=425.025n

.meas tran vdout0_93ck840 FIND v(dout0_93) AT=425.025n

.meas tran vdout0_94ck840 FIND v(dout0_94) AT=425.025n

.meas tran vdout0_95ck840 FIND v(dout0_95) AT=425.025n

.meas tran vdout0_96ck840 FIND v(dout0_96) AT=425.025n

.meas tran vdout0_97ck840 FIND v(dout0_97) AT=425.025n

.meas tran vdout0_98ck840 FIND v(dout0_98) AT=425.025n

.meas tran vdout0_99ck840 FIND v(dout0_99) AT=425.025n

.meas tran vdout0_100ck840 FIND v(dout0_100) AT=425.025n

.meas tran vdout0_101ck840 FIND v(dout0_101) AT=425.025n

.meas tran vdout0_102ck840 FIND v(dout0_102) AT=425.025n

.meas tran vdout0_103ck840 FIND v(dout0_103) AT=425.025n

.meas tran vdout0_104ck840 FIND v(dout0_104) AT=425.025n

.meas tran vdout0_105ck840 FIND v(dout0_105) AT=425.025n

.meas tran vdout0_106ck840 FIND v(dout0_106) AT=425.025n

.meas tran vdout0_107ck840 FIND v(dout0_107) AT=425.025n

.meas tran vdout0_108ck840 FIND v(dout0_108) AT=425.025n

.meas tran vdout0_109ck840 FIND v(dout0_109) AT=425.025n

.meas tran vdout0_110ck840 FIND v(dout0_110) AT=425.025n

.meas tran vdout0_111ck840 FIND v(dout0_111) AT=425.025n

.meas tran vdout0_112ck840 FIND v(dout0_112) AT=425.025n

.meas tran vdout0_113ck840 FIND v(dout0_113) AT=425.025n

.meas tran vdout0_114ck840 FIND v(dout0_114) AT=425.025n

.meas tran vdout0_115ck840 FIND v(dout0_115) AT=425.025n

.meas tran vdout0_116ck840 FIND v(dout0_116) AT=425.025n

.meas tran vdout0_117ck840 FIND v(dout0_117) AT=425.025n

.meas tran vdout0_118ck840 FIND v(dout0_118) AT=425.025n

.meas tran vdout0_119ck840 FIND v(dout0_119) AT=425.025n

.meas tran vdout0_120ck840 FIND v(dout0_120) AT=425.025n

.meas tran vdout0_121ck840 FIND v(dout0_121) AT=425.025n

.meas tran vdout0_122ck840 FIND v(dout0_122) AT=425.025n

.meas tran vdout0_123ck840 FIND v(dout0_123) AT=425.025n

.meas tran vdout0_124ck840 FIND v(dout0_124) AT=425.025n

.meas tran vdout0_125ck840 FIND v(dout0_125) AT=425.025n

.meas tran vdout0_126ck840 FIND v(dout0_126) AT=425.025n

.meas tran vdout0_127ck840 FIND v(dout0_127) AT=425.025n

.meas tran vdout0_128ck840 FIND v(dout0_128) AT=425.025n

.meas tran vdout0_129ck840 FIND v(dout0_129) AT=425.025n

.meas tran vdout0_130ck840 FIND v(dout0_130) AT=425.025n

.meas tran vdout0_131ck840 FIND v(dout0_131) AT=425.025n

.meas tran vdout0_132ck840 FIND v(dout0_132) AT=425.025n

.meas tran vdout0_133ck840 FIND v(dout0_133) AT=425.025n

.meas tran vdout0_134ck840 FIND v(dout0_134) AT=425.025n

.meas tran vdout0_135ck840 FIND v(dout0_135) AT=425.025n

.meas tran vdout0_136ck840 FIND v(dout0_136) AT=425.025n

.meas tran vdout0_137ck840 FIND v(dout0_137) AT=425.025n

.meas tran vdout0_138ck840 FIND v(dout0_138) AT=425.025n

.meas tran vdout0_139ck840 FIND v(dout0_139) AT=425.025n

.meas tran vdout0_140ck840 FIND v(dout0_140) AT=425.025n

.meas tran vdout0_141ck840 FIND v(dout0_141) AT=425.025n

.meas tran vdout0_142ck840 FIND v(dout0_142) AT=425.025n

.meas tran vdout0_143ck840 FIND v(dout0_143) AT=425.025n

.meas tran vdout0_144ck840 FIND v(dout0_144) AT=425.025n

.meas tran vdout0_145ck840 FIND v(dout0_145) AT=425.025n

.meas tran vdout0_146ck840 FIND v(dout0_146) AT=425.025n

.meas tran vdout0_147ck840 FIND v(dout0_147) AT=425.025n

.meas tran vdout0_148ck840 FIND v(dout0_148) AT=425.025n

.meas tran vdout0_149ck840 FIND v(dout0_149) AT=425.025n

.meas tran vdout0_150ck840 FIND v(dout0_150) AT=425.025n

.meas tran vdout0_151ck840 FIND v(dout0_151) AT=425.025n

.meas tran vdout0_152ck840 FIND v(dout0_152) AT=425.025n

.meas tran vdout0_153ck840 FIND v(dout0_153) AT=425.025n

.meas tran vdout0_154ck840 FIND v(dout0_154) AT=425.025n

.meas tran vdout0_155ck840 FIND v(dout0_155) AT=425.025n

.meas tran vdout0_156ck840 FIND v(dout0_156) AT=425.025n

.meas tran vdout0_157ck840 FIND v(dout0_157) AT=425.025n

.meas tran vdout0_158ck840 FIND v(dout0_158) AT=425.025n

.meas tran vdout0_159ck840 FIND v(dout0_159) AT=425.025n

.meas tran vdout0_160ck840 FIND v(dout0_160) AT=425.025n

.meas tran vdout0_161ck840 FIND v(dout0_161) AT=425.025n

.meas tran vdout0_162ck840 FIND v(dout0_162) AT=425.025n

.meas tran vdout0_163ck840 FIND v(dout0_163) AT=425.025n

.meas tran vdout0_164ck840 FIND v(dout0_164) AT=425.025n

.meas tran vdout0_165ck840 FIND v(dout0_165) AT=425.025n

.meas tran vdout0_166ck840 FIND v(dout0_166) AT=425.025n

.meas tran vdout0_167ck840 FIND v(dout0_167) AT=425.025n

.meas tran vdout0_168ck840 FIND v(dout0_168) AT=425.025n

.meas tran vdout0_169ck840 FIND v(dout0_169) AT=425.025n

.meas tran vdout0_170ck840 FIND v(dout0_170) AT=425.025n

.meas tran vdout0_171ck840 FIND v(dout0_171) AT=425.025n

.meas tran vdout0_172ck840 FIND v(dout0_172) AT=425.025n

.meas tran vdout0_173ck840 FIND v(dout0_173) AT=425.025n

.meas tran vdout0_174ck840 FIND v(dout0_174) AT=425.025n

.meas tran vdout0_175ck840 FIND v(dout0_175) AT=425.025n

.meas tran vdout0_176ck840 FIND v(dout0_176) AT=425.025n

.meas tran vdout0_177ck840 FIND v(dout0_177) AT=425.025n

.meas tran vdout0_178ck840 FIND v(dout0_178) AT=425.025n

.meas tran vdout0_179ck840 FIND v(dout0_179) AT=425.025n

.meas tran vdout0_180ck840 FIND v(dout0_180) AT=425.025n

.meas tran vdout0_181ck840 FIND v(dout0_181) AT=425.025n

.meas tran vdout0_182ck840 FIND v(dout0_182) AT=425.025n

.meas tran vdout0_183ck840 FIND v(dout0_183) AT=425.025n

.meas tran vdout0_184ck840 FIND v(dout0_184) AT=425.025n

.meas tran vdout0_185ck840 FIND v(dout0_185) AT=425.025n

.meas tran vdout0_186ck840 FIND v(dout0_186) AT=425.025n

.meas tran vdout0_187ck840 FIND v(dout0_187) AT=425.025n

.meas tran vdout0_188ck840 FIND v(dout0_188) AT=425.025n

.meas tran vdout0_189ck840 FIND v(dout0_189) AT=425.025n

.meas tran vdout0_190ck840 FIND v(dout0_190) AT=425.025n

.meas tran vdout0_191ck840 FIND v(dout0_191) AT=425.025n

.meas tran vdout0_192ck840 FIND v(dout0_192) AT=425.025n

.meas tran vdout0_193ck840 FIND v(dout0_193) AT=425.025n

.meas tran vdout0_194ck840 FIND v(dout0_194) AT=425.025n

.meas tran vdout0_195ck840 FIND v(dout0_195) AT=425.025n

.meas tran vdout0_196ck840 FIND v(dout0_196) AT=425.025n

.meas tran vdout0_197ck840 FIND v(dout0_197) AT=425.025n

.meas tran vdout0_198ck840 FIND v(dout0_198) AT=425.025n

.meas tran vdout0_199ck840 FIND v(dout0_199) AT=425.025n

.meas tran vdout0_200ck840 FIND v(dout0_200) AT=425.025n

.meas tran vdout0_201ck840 FIND v(dout0_201) AT=425.025n

.meas tran vdout0_202ck840 FIND v(dout0_202) AT=425.025n

.meas tran vdout0_203ck840 FIND v(dout0_203) AT=425.025n

.meas tran vdout0_204ck840 FIND v(dout0_204) AT=425.025n

.meas tran vdout0_205ck840 FIND v(dout0_205) AT=425.025n

.meas tran vdout0_206ck840 FIND v(dout0_206) AT=425.025n

.meas tran vdout0_207ck840 FIND v(dout0_207) AT=425.025n

.meas tran vdout0_208ck840 FIND v(dout0_208) AT=425.025n

.meas tran vdout0_209ck840 FIND v(dout0_209) AT=425.025n

.meas tran vdout0_210ck840 FIND v(dout0_210) AT=425.025n

.meas tran vdout0_211ck840 FIND v(dout0_211) AT=425.025n

.meas tran vdout0_212ck840 FIND v(dout0_212) AT=425.025n

.meas tran vdout0_213ck840 FIND v(dout0_213) AT=425.025n

.meas tran vdout0_214ck840 FIND v(dout0_214) AT=425.025n

.meas tran vdout0_215ck840 FIND v(dout0_215) AT=425.025n

.meas tran vdout0_216ck840 FIND v(dout0_216) AT=425.025n

.meas tran vdout0_217ck840 FIND v(dout0_217) AT=425.025n

.meas tran vdout0_218ck840 FIND v(dout0_218) AT=425.025n

.meas tran vdout0_219ck840 FIND v(dout0_219) AT=425.025n

.meas tran vdout0_220ck840 FIND v(dout0_220) AT=425.025n

.meas tran vdout0_221ck840 FIND v(dout0_221) AT=425.025n

.meas tran vdout0_222ck840 FIND v(dout0_222) AT=425.025n

.meas tran vdout0_223ck840 FIND v(dout0_223) AT=425.025n

.meas tran vdout0_224ck840 FIND v(dout0_224) AT=425.025n

.meas tran vdout0_225ck840 FIND v(dout0_225) AT=425.025n

.meas tran vdout0_226ck840 FIND v(dout0_226) AT=425.025n

.meas tran vdout0_227ck840 FIND v(dout0_227) AT=425.025n

.meas tran vdout0_228ck840 FIND v(dout0_228) AT=425.025n

.meas tran vdout0_229ck840 FIND v(dout0_229) AT=425.025n

.meas tran vdout0_230ck840 FIND v(dout0_230) AT=425.025n

.meas tran vdout0_231ck840 FIND v(dout0_231) AT=425.025n

.meas tran vdout0_232ck840 FIND v(dout0_232) AT=425.025n

.meas tran vdout0_233ck840 FIND v(dout0_233) AT=425.025n

.meas tran vdout0_234ck840 FIND v(dout0_234) AT=425.025n

.meas tran vdout0_235ck840 FIND v(dout0_235) AT=425.025n

.meas tran vdout0_236ck840 FIND v(dout0_236) AT=425.025n

.meas tran vdout0_237ck840 FIND v(dout0_237) AT=425.025n

.meas tran vdout0_238ck840 FIND v(dout0_238) AT=425.025n

.meas tran vdout0_239ck840 FIND v(dout0_239) AT=425.025n

.meas tran vdout0_240ck840 FIND v(dout0_240) AT=425.025n

.meas tran vdout0_241ck840 FIND v(dout0_241) AT=425.025n

.meas tran vdout0_242ck840 FIND v(dout0_242) AT=425.025n

.meas tran vdout0_243ck840 FIND v(dout0_243) AT=425.025n

.meas tran vdout0_244ck840 FIND v(dout0_244) AT=425.025n

.meas tran vdout0_245ck840 FIND v(dout0_245) AT=425.025n

.meas tran vdout0_246ck840 FIND v(dout0_246) AT=425.025n

.meas tran vdout0_247ck840 FIND v(dout0_247) AT=425.025n

.meas tran vdout0_248ck840 FIND v(dout0_248) AT=425.025n

.meas tran vdout0_249ck840 FIND v(dout0_249) AT=425.025n

.meas tran vdout0_250ck840 FIND v(dout0_250) AT=425.025n

.meas tran vdout0_251ck840 FIND v(dout0_251) AT=425.025n

.meas tran vdout0_252ck840 FIND v(dout0_252) AT=425.025n

.meas tran vdout0_253ck840 FIND v(dout0_253) AT=425.025n

.meas tran vdout0_254ck840 FIND v(dout0_254) AT=425.025n

.meas tran vdout0_255ck840 FIND v(dout0_255) AT=425.025n

.meas tran vdout0_0ck860 FIND v(dout0_0) AT=435.025n

.meas tran vdout0_1ck860 FIND v(dout0_1) AT=435.025n

.meas tran vdout0_2ck860 FIND v(dout0_2) AT=435.025n

.meas tran vdout0_3ck860 FIND v(dout0_3) AT=435.025n

.meas tran vdout0_4ck860 FIND v(dout0_4) AT=435.025n

.meas tran vdout0_5ck860 FIND v(dout0_5) AT=435.025n

.meas tran vdout0_6ck860 FIND v(dout0_6) AT=435.025n

.meas tran vdout0_7ck860 FIND v(dout0_7) AT=435.025n

.meas tran vdout0_8ck860 FIND v(dout0_8) AT=435.025n

.meas tran vdout0_9ck860 FIND v(dout0_9) AT=435.025n

.meas tran vdout0_10ck860 FIND v(dout0_10) AT=435.025n

.meas tran vdout0_11ck860 FIND v(dout0_11) AT=435.025n

.meas tran vdout0_12ck860 FIND v(dout0_12) AT=435.025n

.meas tran vdout0_13ck860 FIND v(dout0_13) AT=435.025n

.meas tran vdout0_14ck860 FIND v(dout0_14) AT=435.025n

.meas tran vdout0_15ck860 FIND v(dout0_15) AT=435.025n

.meas tran vdout0_16ck860 FIND v(dout0_16) AT=435.025n

.meas tran vdout0_17ck860 FIND v(dout0_17) AT=435.025n

.meas tran vdout0_18ck860 FIND v(dout0_18) AT=435.025n

.meas tran vdout0_19ck860 FIND v(dout0_19) AT=435.025n

.meas tran vdout0_20ck860 FIND v(dout0_20) AT=435.025n

.meas tran vdout0_21ck860 FIND v(dout0_21) AT=435.025n

.meas tran vdout0_22ck860 FIND v(dout0_22) AT=435.025n

.meas tran vdout0_23ck860 FIND v(dout0_23) AT=435.025n

.meas tran vdout0_24ck860 FIND v(dout0_24) AT=435.025n

.meas tran vdout0_25ck860 FIND v(dout0_25) AT=435.025n

.meas tran vdout0_26ck860 FIND v(dout0_26) AT=435.025n

.meas tran vdout0_27ck860 FIND v(dout0_27) AT=435.025n

.meas tran vdout0_28ck860 FIND v(dout0_28) AT=435.025n

.meas tran vdout0_29ck860 FIND v(dout0_29) AT=435.025n

.meas tran vdout0_30ck860 FIND v(dout0_30) AT=435.025n

.meas tran vdout0_31ck860 FIND v(dout0_31) AT=435.025n

.meas tran vdout0_32ck860 FIND v(dout0_32) AT=435.025n

.meas tran vdout0_33ck860 FIND v(dout0_33) AT=435.025n

.meas tran vdout0_34ck860 FIND v(dout0_34) AT=435.025n

.meas tran vdout0_35ck860 FIND v(dout0_35) AT=435.025n

.meas tran vdout0_36ck860 FIND v(dout0_36) AT=435.025n

.meas tran vdout0_37ck860 FIND v(dout0_37) AT=435.025n

.meas tran vdout0_38ck860 FIND v(dout0_38) AT=435.025n

.meas tran vdout0_39ck860 FIND v(dout0_39) AT=435.025n

.meas tran vdout0_40ck860 FIND v(dout0_40) AT=435.025n

.meas tran vdout0_41ck860 FIND v(dout0_41) AT=435.025n

.meas tran vdout0_42ck860 FIND v(dout0_42) AT=435.025n

.meas tran vdout0_43ck860 FIND v(dout0_43) AT=435.025n

.meas tran vdout0_44ck860 FIND v(dout0_44) AT=435.025n

.meas tran vdout0_45ck860 FIND v(dout0_45) AT=435.025n

.meas tran vdout0_46ck860 FIND v(dout0_46) AT=435.025n

.meas tran vdout0_47ck860 FIND v(dout0_47) AT=435.025n

.meas tran vdout0_48ck860 FIND v(dout0_48) AT=435.025n

.meas tran vdout0_49ck860 FIND v(dout0_49) AT=435.025n

.meas tran vdout0_50ck860 FIND v(dout0_50) AT=435.025n

.meas tran vdout0_51ck860 FIND v(dout0_51) AT=435.025n

.meas tran vdout0_52ck860 FIND v(dout0_52) AT=435.025n

.meas tran vdout0_53ck860 FIND v(dout0_53) AT=435.025n

.meas tran vdout0_54ck860 FIND v(dout0_54) AT=435.025n

.meas tran vdout0_55ck860 FIND v(dout0_55) AT=435.025n

.meas tran vdout0_56ck860 FIND v(dout0_56) AT=435.025n

.meas tran vdout0_57ck860 FIND v(dout0_57) AT=435.025n

.meas tran vdout0_58ck860 FIND v(dout0_58) AT=435.025n

.meas tran vdout0_59ck860 FIND v(dout0_59) AT=435.025n

.meas tran vdout0_60ck860 FIND v(dout0_60) AT=435.025n

.meas tran vdout0_61ck860 FIND v(dout0_61) AT=435.025n

.meas tran vdout0_62ck860 FIND v(dout0_62) AT=435.025n

.meas tran vdout0_63ck860 FIND v(dout0_63) AT=435.025n

.meas tran vdout0_64ck860 FIND v(dout0_64) AT=435.025n

.meas tran vdout0_65ck860 FIND v(dout0_65) AT=435.025n

.meas tran vdout0_66ck860 FIND v(dout0_66) AT=435.025n

.meas tran vdout0_67ck860 FIND v(dout0_67) AT=435.025n

.meas tran vdout0_68ck860 FIND v(dout0_68) AT=435.025n

.meas tran vdout0_69ck860 FIND v(dout0_69) AT=435.025n

.meas tran vdout0_70ck860 FIND v(dout0_70) AT=435.025n

.meas tran vdout0_71ck860 FIND v(dout0_71) AT=435.025n

.meas tran vdout0_72ck860 FIND v(dout0_72) AT=435.025n

.meas tran vdout0_73ck860 FIND v(dout0_73) AT=435.025n

.meas tran vdout0_74ck860 FIND v(dout0_74) AT=435.025n

.meas tran vdout0_75ck860 FIND v(dout0_75) AT=435.025n

.meas tran vdout0_76ck860 FIND v(dout0_76) AT=435.025n

.meas tran vdout0_77ck860 FIND v(dout0_77) AT=435.025n

.meas tran vdout0_78ck860 FIND v(dout0_78) AT=435.025n

.meas tran vdout0_79ck860 FIND v(dout0_79) AT=435.025n

.meas tran vdout0_80ck860 FIND v(dout0_80) AT=435.025n

.meas tran vdout0_81ck860 FIND v(dout0_81) AT=435.025n

.meas tran vdout0_82ck860 FIND v(dout0_82) AT=435.025n

.meas tran vdout0_83ck860 FIND v(dout0_83) AT=435.025n

.meas tran vdout0_84ck860 FIND v(dout0_84) AT=435.025n

.meas tran vdout0_85ck860 FIND v(dout0_85) AT=435.025n

.meas tran vdout0_86ck860 FIND v(dout0_86) AT=435.025n

.meas tran vdout0_87ck860 FIND v(dout0_87) AT=435.025n

.meas tran vdout0_88ck860 FIND v(dout0_88) AT=435.025n

.meas tran vdout0_89ck860 FIND v(dout0_89) AT=435.025n

.meas tran vdout0_90ck860 FIND v(dout0_90) AT=435.025n

.meas tran vdout0_91ck860 FIND v(dout0_91) AT=435.025n

.meas tran vdout0_92ck860 FIND v(dout0_92) AT=435.025n

.meas tran vdout0_93ck860 FIND v(dout0_93) AT=435.025n

.meas tran vdout0_94ck860 FIND v(dout0_94) AT=435.025n

.meas tran vdout0_95ck860 FIND v(dout0_95) AT=435.025n

.meas tran vdout0_96ck860 FIND v(dout0_96) AT=435.025n

.meas tran vdout0_97ck860 FIND v(dout0_97) AT=435.025n

.meas tran vdout0_98ck860 FIND v(dout0_98) AT=435.025n

.meas tran vdout0_99ck860 FIND v(dout0_99) AT=435.025n

.meas tran vdout0_100ck860 FIND v(dout0_100) AT=435.025n

.meas tran vdout0_101ck860 FIND v(dout0_101) AT=435.025n

.meas tran vdout0_102ck860 FIND v(dout0_102) AT=435.025n

.meas tran vdout0_103ck860 FIND v(dout0_103) AT=435.025n

.meas tran vdout0_104ck860 FIND v(dout0_104) AT=435.025n

.meas tran vdout0_105ck860 FIND v(dout0_105) AT=435.025n

.meas tran vdout0_106ck860 FIND v(dout0_106) AT=435.025n

.meas tran vdout0_107ck860 FIND v(dout0_107) AT=435.025n

.meas tran vdout0_108ck860 FIND v(dout0_108) AT=435.025n

.meas tran vdout0_109ck860 FIND v(dout0_109) AT=435.025n

.meas tran vdout0_110ck860 FIND v(dout0_110) AT=435.025n

.meas tran vdout0_111ck860 FIND v(dout0_111) AT=435.025n

.meas tran vdout0_112ck860 FIND v(dout0_112) AT=435.025n

.meas tran vdout0_113ck860 FIND v(dout0_113) AT=435.025n

.meas tran vdout0_114ck860 FIND v(dout0_114) AT=435.025n

.meas tran vdout0_115ck860 FIND v(dout0_115) AT=435.025n

.meas tran vdout0_116ck860 FIND v(dout0_116) AT=435.025n

.meas tran vdout0_117ck860 FIND v(dout0_117) AT=435.025n

.meas tran vdout0_118ck860 FIND v(dout0_118) AT=435.025n

.meas tran vdout0_119ck860 FIND v(dout0_119) AT=435.025n

.meas tran vdout0_120ck860 FIND v(dout0_120) AT=435.025n

.meas tran vdout0_121ck860 FIND v(dout0_121) AT=435.025n

.meas tran vdout0_122ck860 FIND v(dout0_122) AT=435.025n

.meas tran vdout0_123ck860 FIND v(dout0_123) AT=435.025n

.meas tran vdout0_124ck860 FIND v(dout0_124) AT=435.025n

.meas tran vdout0_125ck860 FIND v(dout0_125) AT=435.025n

.meas tran vdout0_126ck860 FIND v(dout0_126) AT=435.025n

.meas tran vdout0_127ck860 FIND v(dout0_127) AT=435.025n

.meas tran vdout0_128ck860 FIND v(dout0_128) AT=435.025n

.meas tran vdout0_129ck860 FIND v(dout0_129) AT=435.025n

.meas tran vdout0_130ck860 FIND v(dout0_130) AT=435.025n

.meas tran vdout0_131ck860 FIND v(dout0_131) AT=435.025n

.meas tran vdout0_132ck860 FIND v(dout0_132) AT=435.025n

.meas tran vdout0_133ck860 FIND v(dout0_133) AT=435.025n

.meas tran vdout0_134ck860 FIND v(dout0_134) AT=435.025n

.meas tran vdout0_135ck860 FIND v(dout0_135) AT=435.025n

.meas tran vdout0_136ck860 FIND v(dout0_136) AT=435.025n

.meas tran vdout0_137ck860 FIND v(dout0_137) AT=435.025n

.meas tran vdout0_138ck860 FIND v(dout0_138) AT=435.025n

.meas tran vdout0_139ck860 FIND v(dout0_139) AT=435.025n

.meas tran vdout0_140ck860 FIND v(dout0_140) AT=435.025n

.meas tran vdout0_141ck860 FIND v(dout0_141) AT=435.025n

.meas tran vdout0_142ck860 FIND v(dout0_142) AT=435.025n

.meas tran vdout0_143ck860 FIND v(dout0_143) AT=435.025n

.meas tran vdout0_144ck860 FIND v(dout0_144) AT=435.025n

.meas tran vdout0_145ck860 FIND v(dout0_145) AT=435.025n

.meas tran vdout0_146ck860 FIND v(dout0_146) AT=435.025n

.meas tran vdout0_147ck860 FIND v(dout0_147) AT=435.025n

.meas tran vdout0_148ck860 FIND v(dout0_148) AT=435.025n

.meas tran vdout0_149ck860 FIND v(dout0_149) AT=435.025n

.meas tran vdout0_150ck860 FIND v(dout0_150) AT=435.025n

.meas tran vdout0_151ck860 FIND v(dout0_151) AT=435.025n

.meas tran vdout0_152ck860 FIND v(dout0_152) AT=435.025n

.meas tran vdout0_153ck860 FIND v(dout0_153) AT=435.025n

.meas tran vdout0_154ck860 FIND v(dout0_154) AT=435.025n

.meas tran vdout0_155ck860 FIND v(dout0_155) AT=435.025n

.meas tran vdout0_156ck860 FIND v(dout0_156) AT=435.025n

.meas tran vdout0_157ck860 FIND v(dout0_157) AT=435.025n

.meas tran vdout0_158ck860 FIND v(dout0_158) AT=435.025n

.meas tran vdout0_159ck860 FIND v(dout0_159) AT=435.025n

.meas tran vdout0_160ck860 FIND v(dout0_160) AT=435.025n

.meas tran vdout0_161ck860 FIND v(dout0_161) AT=435.025n

.meas tran vdout0_162ck860 FIND v(dout0_162) AT=435.025n

.meas tran vdout0_163ck860 FIND v(dout0_163) AT=435.025n

.meas tran vdout0_164ck860 FIND v(dout0_164) AT=435.025n

.meas tran vdout0_165ck860 FIND v(dout0_165) AT=435.025n

.meas tran vdout0_166ck860 FIND v(dout0_166) AT=435.025n

.meas tran vdout0_167ck860 FIND v(dout0_167) AT=435.025n

.meas tran vdout0_168ck860 FIND v(dout0_168) AT=435.025n

.meas tran vdout0_169ck860 FIND v(dout0_169) AT=435.025n

.meas tran vdout0_170ck860 FIND v(dout0_170) AT=435.025n

.meas tran vdout0_171ck860 FIND v(dout0_171) AT=435.025n

.meas tran vdout0_172ck860 FIND v(dout0_172) AT=435.025n

.meas tran vdout0_173ck860 FIND v(dout0_173) AT=435.025n

.meas tran vdout0_174ck860 FIND v(dout0_174) AT=435.025n

.meas tran vdout0_175ck860 FIND v(dout0_175) AT=435.025n

.meas tran vdout0_176ck860 FIND v(dout0_176) AT=435.025n

.meas tran vdout0_177ck860 FIND v(dout0_177) AT=435.025n

.meas tran vdout0_178ck860 FIND v(dout0_178) AT=435.025n

.meas tran vdout0_179ck860 FIND v(dout0_179) AT=435.025n

.meas tran vdout0_180ck860 FIND v(dout0_180) AT=435.025n

.meas tran vdout0_181ck860 FIND v(dout0_181) AT=435.025n

.meas tran vdout0_182ck860 FIND v(dout0_182) AT=435.025n

.meas tran vdout0_183ck860 FIND v(dout0_183) AT=435.025n

.meas tran vdout0_184ck860 FIND v(dout0_184) AT=435.025n

.meas tran vdout0_185ck860 FIND v(dout0_185) AT=435.025n

.meas tran vdout0_186ck860 FIND v(dout0_186) AT=435.025n

.meas tran vdout0_187ck860 FIND v(dout0_187) AT=435.025n

.meas tran vdout0_188ck860 FIND v(dout0_188) AT=435.025n

.meas tran vdout0_189ck860 FIND v(dout0_189) AT=435.025n

.meas tran vdout0_190ck860 FIND v(dout0_190) AT=435.025n

.meas tran vdout0_191ck860 FIND v(dout0_191) AT=435.025n

.meas tran vdout0_192ck860 FIND v(dout0_192) AT=435.025n

.meas tran vdout0_193ck860 FIND v(dout0_193) AT=435.025n

.meas tran vdout0_194ck860 FIND v(dout0_194) AT=435.025n

.meas tran vdout0_195ck860 FIND v(dout0_195) AT=435.025n

.meas tran vdout0_196ck860 FIND v(dout0_196) AT=435.025n

.meas tran vdout0_197ck860 FIND v(dout0_197) AT=435.025n

.meas tran vdout0_198ck860 FIND v(dout0_198) AT=435.025n

.meas tran vdout0_199ck860 FIND v(dout0_199) AT=435.025n

.meas tran vdout0_200ck860 FIND v(dout0_200) AT=435.025n

.meas tran vdout0_201ck860 FIND v(dout0_201) AT=435.025n

.meas tran vdout0_202ck860 FIND v(dout0_202) AT=435.025n

.meas tran vdout0_203ck860 FIND v(dout0_203) AT=435.025n

.meas tran vdout0_204ck860 FIND v(dout0_204) AT=435.025n

.meas tran vdout0_205ck860 FIND v(dout0_205) AT=435.025n

.meas tran vdout0_206ck860 FIND v(dout0_206) AT=435.025n

.meas tran vdout0_207ck860 FIND v(dout0_207) AT=435.025n

.meas tran vdout0_208ck860 FIND v(dout0_208) AT=435.025n

.meas tran vdout0_209ck860 FIND v(dout0_209) AT=435.025n

.meas tran vdout0_210ck860 FIND v(dout0_210) AT=435.025n

.meas tran vdout0_211ck860 FIND v(dout0_211) AT=435.025n

.meas tran vdout0_212ck860 FIND v(dout0_212) AT=435.025n

.meas tran vdout0_213ck860 FIND v(dout0_213) AT=435.025n

.meas tran vdout0_214ck860 FIND v(dout0_214) AT=435.025n

.meas tran vdout0_215ck860 FIND v(dout0_215) AT=435.025n

.meas tran vdout0_216ck860 FIND v(dout0_216) AT=435.025n

.meas tran vdout0_217ck860 FIND v(dout0_217) AT=435.025n

.meas tran vdout0_218ck860 FIND v(dout0_218) AT=435.025n

.meas tran vdout0_219ck860 FIND v(dout0_219) AT=435.025n

.meas tran vdout0_220ck860 FIND v(dout0_220) AT=435.025n

.meas tran vdout0_221ck860 FIND v(dout0_221) AT=435.025n

.meas tran vdout0_222ck860 FIND v(dout0_222) AT=435.025n

.meas tran vdout0_223ck860 FIND v(dout0_223) AT=435.025n

.meas tran vdout0_224ck860 FIND v(dout0_224) AT=435.025n

.meas tran vdout0_225ck860 FIND v(dout0_225) AT=435.025n

.meas tran vdout0_226ck860 FIND v(dout0_226) AT=435.025n

.meas tran vdout0_227ck860 FIND v(dout0_227) AT=435.025n

.meas tran vdout0_228ck860 FIND v(dout0_228) AT=435.025n

.meas tran vdout0_229ck860 FIND v(dout0_229) AT=435.025n

.meas tran vdout0_230ck860 FIND v(dout0_230) AT=435.025n

.meas tran vdout0_231ck860 FIND v(dout0_231) AT=435.025n

.meas tran vdout0_232ck860 FIND v(dout0_232) AT=435.025n

.meas tran vdout0_233ck860 FIND v(dout0_233) AT=435.025n

.meas tran vdout0_234ck860 FIND v(dout0_234) AT=435.025n

.meas tran vdout0_235ck860 FIND v(dout0_235) AT=435.025n

.meas tran vdout0_236ck860 FIND v(dout0_236) AT=435.025n

.meas tran vdout0_237ck860 FIND v(dout0_237) AT=435.025n

.meas tran vdout0_238ck860 FIND v(dout0_238) AT=435.025n

.meas tran vdout0_239ck860 FIND v(dout0_239) AT=435.025n

.meas tran vdout0_240ck860 FIND v(dout0_240) AT=435.025n

.meas tran vdout0_241ck860 FIND v(dout0_241) AT=435.025n

.meas tran vdout0_242ck860 FIND v(dout0_242) AT=435.025n

.meas tran vdout0_243ck860 FIND v(dout0_243) AT=435.025n

.meas tran vdout0_244ck860 FIND v(dout0_244) AT=435.025n

.meas tran vdout0_245ck860 FIND v(dout0_245) AT=435.025n

.meas tran vdout0_246ck860 FIND v(dout0_246) AT=435.025n

.meas tran vdout0_247ck860 FIND v(dout0_247) AT=435.025n

.meas tran vdout0_248ck860 FIND v(dout0_248) AT=435.025n

.meas tran vdout0_249ck860 FIND v(dout0_249) AT=435.025n

.meas tran vdout0_250ck860 FIND v(dout0_250) AT=435.025n

.meas tran vdout0_251ck860 FIND v(dout0_251) AT=435.025n

.meas tran vdout0_252ck860 FIND v(dout0_252) AT=435.025n

.meas tran vdout0_253ck860 FIND v(dout0_253) AT=435.025n

.meas tran vdout0_254ck860 FIND v(dout0_254) AT=435.025n

.meas tran vdout0_255ck860 FIND v(dout0_255) AT=435.025n

.meas tran vdout0_0ck870 FIND v(dout0_0) AT=440.025n

.meas tran vdout0_1ck870 FIND v(dout0_1) AT=440.025n

.meas tran vdout0_2ck870 FIND v(dout0_2) AT=440.025n

.meas tran vdout0_3ck870 FIND v(dout0_3) AT=440.025n

.meas tran vdout0_4ck870 FIND v(dout0_4) AT=440.025n

.meas tran vdout0_5ck870 FIND v(dout0_5) AT=440.025n

.meas tran vdout0_6ck870 FIND v(dout0_6) AT=440.025n

.meas tran vdout0_7ck870 FIND v(dout0_7) AT=440.025n

.meas tran vdout0_8ck870 FIND v(dout0_8) AT=440.025n

.meas tran vdout0_9ck870 FIND v(dout0_9) AT=440.025n

.meas tran vdout0_10ck870 FIND v(dout0_10) AT=440.025n

.meas tran vdout0_11ck870 FIND v(dout0_11) AT=440.025n

.meas tran vdout0_12ck870 FIND v(dout0_12) AT=440.025n

.meas tran vdout0_13ck870 FIND v(dout0_13) AT=440.025n

.meas tran vdout0_14ck870 FIND v(dout0_14) AT=440.025n

.meas tran vdout0_15ck870 FIND v(dout0_15) AT=440.025n

.meas tran vdout0_16ck870 FIND v(dout0_16) AT=440.025n

.meas tran vdout0_17ck870 FIND v(dout0_17) AT=440.025n

.meas tran vdout0_18ck870 FIND v(dout0_18) AT=440.025n

.meas tran vdout0_19ck870 FIND v(dout0_19) AT=440.025n

.meas tran vdout0_20ck870 FIND v(dout0_20) AT=440.025n

.meas tran vdout0_21ck870 FIND v(dout0_21) AT=440.025n

.meas tran vdout0_22ck870 FIND v(dout0_22) AT=440.025n

.meas tran vdout0_23ck870 FIND v(dout0_23) AT=440.025n

.meas tran vdout0_24ck870 FIND v(dout0_24) AT=440.025n

.meas tran vdout0_25ck870 FIND v(dout0_25) AT=440.025n

.meas tran vdout0_26ck870 FIND v(dout0_26) AT=440.025n

.meas tran vdout0_27ck870 FIND v(dout0_27) AT=440.025n

.meas tran vdout0_28ck870 FIND v(dout0_28) AT=440.025n

.meas tran vdout0_29ck870 FIND v(dout0_29) AT=440.025n

.meas tran vdout0_30ck870 FIND v(dout0_30) AT=440.025n

.meas tran vdout0_31ck870 FIND v(dout0_31) AT=440.025n

.meas tran vdout0_32ck870 FIND v(dout0_32) AT=440.025n

.meas tran vdout0_33ck870 FIND v(dout0_33) AT=440.025n

.meas tran vdout0_34ck870 FIND v(dout0_34) AT=440.025n

.meas tran vdout0_35ck870 FIND v(dout0_35) AT=440.025n

.meas tran vdout0_36ck870 FIND v(dout0_36) AT=440.025n

.meas tran vdout0_37ck870 FIND v(dout0_37) AT=440.025n

.meas tran vdout0_38ck870 FIND v(dout0_38) AT=440.025n

.meas tran vdout0_39ck870 FIND v(dout0_39) AT=440.025n

.meas tran vdout0_40ck870 FIND v(dout0_40) AT=440.025n

.meas tran vdout0_41ck870 FIND v(dout0_41) AT=440.025n

.meas tran vdout0_42ck870 FIND v(dout0_42) AT=440.025n

.meas tran vdout0_43ck870 FIND v(dout0_43) AT=440.025n

.meas tran vdout0_44ck870 FIND v(dout0_44) AT=440.025n

.meas tran vdout0_45ck870 FIND v(dout0_45) AT=440.025n

.meas tran vdout0_46ck870 FIND v(dout0_46) AT=440.025n

.meas tran vdout0_47ck870 FIND v(dout0_47) AT=440.025n

.meas tran vdout0_48ck870 FIND v(dout0_48) AT=440.025n

.meas tran vdout0_49ck870 FIND v(dout0_49) AT=440.025n

.meas tran vdout0_50ck870 FIND v(dout0_50) AT=440.025n

.meas tran vdout0_51ck870 FIND v(dout0_51) AT=440.025n

.meas tran vdout0_52ck870 FIND v(dout0_52) AT=440.025n

.meas tran vdout0_53ck870 FIND v(dout0_53) AT=440.025n

.meas tran vdout0_54ck870 FIND v(dout0_54) AT=440.025n

.meas tran vdout0_55ck870 FIND v(dout0_55) AT=440.025n

.meas tran vdout0_56ck870 FIND v(dout0_56) AT=440.025n

.meas tran vdout0_57ck870 FIND v(dout0_57) AT=440.025n

.meas tran vdout0_58ck870 FIND v(dout0_58) AT=440.025n

.meas tran vdout0_59ck870 FIND v(dout0_59) AT=440.025n

.meas tran vdout0_60ck870 FIND v(dout0_60) AT=440.025n

.meas tran vdout0_61ck870 FIND v(dout0_61) AT=440.025n

.meas tran vdout0_62ck870 FIND v(dout0_62) AT=440.025n

.meas tran vdout0_63ck870 FIND v(dout0_63) AT=440.025n

.meas tran vdout0_64ck870 FIND v(dout0_64) AT=440.025n

.meas tran vdout0_65ck870 FIND v(dout0_65) AT=440.025n

.meas tran vdout0_66ck870 FIND v(dout0_66) AT=440.025n

.meas tran vdout0_67ck870 FIND v(dout0_67) AT=440.025n

.meas tran vdout0_68ck870 FIND v(dout0_68) AT=440.025n

.meas tran vdout0_69ck870 FIND v(dout0_69) AT=440.025n

.meas tran vdout0_70ck870 FIND v(dout0_70) AT=440.025n

.meas tran vdout0_71ck870 FIND v(dout0_71) AT=440.025n

.meas tran vdout0_72ck870 FIND v(dout0_72) AT=440.025n

.meas tran vdout0_73ck870 FIND v(dout0_73) AT=440.025n

.meas tran vdout0_74ck870 FIND v(dout0_74) AT=440.025n

.meas tran vdout0_75ck870 FIND v(dout0_75) AT=440.025n

.meas tran vdout0_76ck870 FIND v(dout0_76) AT=440.025n

.meas tran vdout0_77ck870 FIND v(dout0_77) AT=440.025n

.meas tran vdout0_78ck870 FIND v(dout0_78) AT=440.025n

.meas tran vdout0_79ck870 FIND v(dout0_79) AT=440.025n

.meas tran vdout0_80ck870 FIND v(dout0_80) AT=440.025n

.meas tran vdout0_81ck870 FIND v(dout0_81) AT=440.025n

.meas tran vdout0_82ck870 FIND v(dout0_82) AT=440.025n

.meas tran vdout0_83ck870 FIND v(dout0_83) AT=440.025n

.meas tran vdout0_84ck870 FIND v(dout0_84) AT=440.025n

.meas tran vdout0_85ck870 FIND v(dout0_85) AT=440.025n

.meas tran vdout0_86ck870 FIND v(dout0_86) AT=440.025n

.meas tran vdout0_87ck870 FIND v(dout0_87) AT=440.025n

.meas tran vdout0_88ck870 FIND v(dout0_88) AT=440.025n

.meas tran vdout0_89ck870 FIND v(dout0_89) AT=440.025n

.meas tran vdout0_90ck870 FIND v(dout0_90) AT=440.025n

.meas tran vdout0_91ck870 FIND v(dout0_91) AT=440.025n

.meas tran vdout0_92ck870 FIND v(dout0_92) AT=440.025n

.meas tran vdout0_93ck870 FIND v(dout0_93) AT=440.025n

.meas tran vdout0_94ck870 FIND v(dout0_94) AT=440.025n

.meas tran vdout0_95ck870 FIND v(dout0_95) AT=440.025n

.meas tran vdout0_96ck870 FIND v(dout0_96) AT=440.025n

.meas tran vdout0_97ck870 FIND v(dout0_97) AT=440.025n

.meas tran vdout0_98ck870 FIND v(dout0_98) AT=440.025n

.meas tran vdout0_99ck870 FIND v(dout0_99) AT=440.025n

.meas tran vdout0_100ck870 FIND v(dout0_100) AT=440.025n

.meas tran vdout0_101ck870 FIND v(dout0_101) AT=440.025n

.meas tran vdout0_102ck870 FIND v(dout0_102) AT=440.025n

.meas tran vdout0_103ck870 FIND v(dout0_103) AT=440.025n

.meas tran vdout0_104ck870 FIND v(dout0_104) AT=440.025n

.meas tran vdout0_105ck870 FIND v(dout0_105) AT=440.025n

.meas tran vdout0_106ck870 FIND v(dout0_106) AT=440.025n

.meas tran vdout0_107ck870 FIND v(dout0_107) AT=440.025n

.meas tran vdout0_108ck870 FIND v(dout0_108) AT=440.025n

.meas tran vdout0_109ck870 FIND v(dout0_109) AT=440.025n

.meas tran vdout0_110ck870 FIND v(dout0_110) AT=440.025n

.meas tran vdout0_111ck870 FIND v(dout0_111) AT=440.025n

.meas tran vdout0_112ck870 FIND v(dout0_112) AT=440.025n

.meas tran vdout0_113ck870 FIND v(dout0_113) AT=440.025n

.meas tran vdout0_114ck870 FIND v(dout0_114) AT=440.025n

.meas tran vdout0_115ck870 FIND v(dout0_115) AT=440.025n

.meas tran vdout0_116ck870 FIND v(dout0_116) AT=440.025n

.meas tran vdout0_117ck870 FIND v(dout0_117) AT=440.025n

.meas tran vdout0_118ck870 FIND v(dout0_118) AT=440.025n

.meas tran vdout0_119ck870 FIND v(dout0_119) AT=440.025n

.meas tran vdout0_120ck870 FIND v(dout0_120) AT=440.025n

.meas tran vdout0_121ck870 FIND v(dout0_121) AT=440.025n

.meas tran vdout0_122ck870 FIND v(dout0_122) AT=440.025n

.meas tran vdout0_123ck870 FIND v(dout0_123) AT=440.025n

.meas tran vdout0_124ck870 FIND v(dout0_124) AT=440.025n

.meas tran vdout0_125ck870 FIND v(dout0_125) AT=440.025n

.meas tran vdout0_126ck870 FIND v(dout0_126) AT=440.025n

.meas tran vdout0_127ck870 FIND v(dout0_127) AT=440.025n

.meas tran vdout0_128ck870 FIND v(dout0_128) AT=440.025n

.meas tran vdout0_129ck870 FIND v(dout0_129) AT=440.025n

.meas tran vdout0_130ck870 FIND v(dout0_130) AT=440.025n

.meas tran vdout0_131ck870 FIND v(dout0_131) AT=440.025n

.meas tran vdout0_132ck870 FIND v(dout0_132) AT=440.025n

.meas tran vdout0_133ck870 FIND v(dout0_133) AT=440.025n

.meas tran vdout0_134ck870 FIND v(dout0_134) AT=440.025n

.meas tran vdout0_135ck870 FIND v(dout0_135) AT=440.025n

.meas tran vdout0_136ck870 FIND v(dout0_136) AT=440.025n

.meas tran vdout0_137ck870 FIND v(dout0_137) AT=440.025n

.meas tran vdout0_138ck870 FIND v(dout0_138) AT=440.025n

.meas tran vdout0_139ck870 FIND v(dout0_139) AT=440.025n

.meas tran vdout0_140ck870 FIND v(dout0_140) AT=440.025n

.meas tran vdout0_141ck870 FIND v(dout0_141) AT=440.025n

.meas tran vdout0_142ck870 FIND v(dout0_142) AT=440.025n

.meas tran vdout0_143ck870 FIND v(dout0_143) AT=440.025n

.meas tran vdout0_144ck870 FIND v(dout0_144) AT=440.025n

.meas tran vdout0_145ck870 FIND v(dout0_145) AT=440.025n

.meas tran vdout0_146ck870 FIND v(dout0_146) AT=440.025n

.meas tran vdout0_147ck870 FIND v(dout0_147) AT=440.025n

.meas tran vdout0_148ck870 FIND v(dout0_148) AT=440.025n

.meas tran vdout0_149ck870 FIND v(dout0_149) AT=440.025n

.meas tran vdout0_150ck870 FIND v(dout0_150) AT=440.025n

.meas tran vdout0_151ck870 FIND v(dout0_151) AT=440.025n

.meas tran vdout0_152ck870 FIND v(dout0_152) AT=440.025n

.meas tran vdout0_153ck870 FIND v(dout0_153) AT=440.025n

.meas tran vdout0_154ck870 FIND v(dout0_154) AT=440.025n

.meas tran vdout0_155ck870 FIND v(dout0_155) AT=440.025n

.meas tran vdout0_156ck870 FIND v(dout0_156) AT=440.025n

.meas tran vdout0_157ck870 FIND v(dout0_157) AT=440.025n

.meas tran vdout0_158ck870 FIND v(dout0_158) AT=440.025n

.meas tran vdout0_159ck870 FIND v(dout0_159) AT=440.025n

.meas tran vdout0_160ck870 FIND v(dout0_160) AT=440.025n

.meas tran vdout0_161ck870 FIND v(dout0_161) AT=440.025n

.meas tran vdout0_162ck870 FIND v(dout0_162) AT=440.025n

.meas tran vdout0_163ck870 FIND v(dout0_163) AT=440.025n

.meas tran vdout0_164ck870 FIND v(dout0_164) AT=440.025n

.meas tran vdout0_165ck870 FIND v(dout0_165) AT=440.025n

.meas tran vdout0_166ck870 FIND v(dout0_166) AT=440.025n

.meas tran vdout0_167ck870 FIND v(dout0_167) AT=440.025n

.meas tran vdout0_168ck870 FIND v(dout0_168) AT=440.025n

.meas tran vdout0_169ck870 FIND v(dout0_169) AT=440.025n

.meas tran vdout0_170ck870 FIND v(dout0_170) AT=440.025n

.meas tran vdout0_171ck870 FIND v(dout0_171) AT=440.025n

.meas tran vdout0_172ck870 FIND v(dout0_172) AT=440.025n

.meas tran vdout0_173ck870 FIND v(dout0_173) AT=440.025n

.meas tran vdout0_174ck870 FIND v(dout0_174) AT=440.025n

.meas tran vdout0_175ck870 FIND v(dout0_175) AT=440.025n

.meas tran vdout0_176ck870 FIND v(dout0_176) AT=440.025n

.meas tran vdout0_177ck870 FIND v(dout0_177) AT=440.025n

.meas tran vdout0_178ck870 FIND v(dout0_178) AT=440.025n

.meas tran vdout0_179ck870 FIND v(dout0_179) AT=440.025n

.meas tran vdout0_180ck870 FIND v(dout0_180) AT=440.025n

.meas tran vdout0_181ck870 FIND v(dout0_181) AT=440.025n

.meas tran vdout0_182ck870 FIND v(dout0_182) AT=440.025n

.meas tran vdout0_183ck870 FIND v(dout0_183) AT=440.025n

.meas tran vdout0_184ck870 FIND v(dout0_184) AT=440.025n

.meas tran vdout0_185ck870 FIND v(dout0_185) AT=440.025n

.meas tran vdout0_186ck870 FIND v(dout0_186) AT=440.025n

.meas tran vdout0_187ck870 FIND v(dout0_187) AT=440.025n

.meas tran vdout0_188ck870 FIND v(dout0_188) AT=440.025n

.meas tran vdout0_189ck870 FIND v(dout0_189) AT=440.025n

.meas tran vdout0_190ck870 FIND v(dout0_190) AT=440.025n

.meas tran vdout0_191ck870 FIND v(dout0_191) AT=440.025n

.meas tran vdout0_192ck870 FIND v(dout0_192) AT=440.025n

.meas tran vdout0_193ck870 FIND v(dout0_193) AT=440.025n

.meas tran vdout0_194ck870 FIND v(dout0_194) AT=440.025n

.meas tran vdout0_195ck870 FIND v(dout0_195) AT=440.025n

.meas tran vdout0_196ck870 FIND v(dout0_196) AT=440.025n

.meas tran vdout0_197ck870 FIND v(dout0_197) AT=440.025n

.meas tran vdout0_198ck870 FIND v(dout0_198) AT=440.025n

.meas tran vdout0_199ck870 FIND v(dout0_199) AT=440.025n

.meas tran vdout0_200ck870 FIND v(dout0_200) AT=440.025n

.meas tran vdout0_201ck870 FIND v(dout0_201) AT=440.025n

.meas tran vdout0_202ck870 FIND v(dout0_202) AT=440.025n

.meas tran vdout0_203ck870 FIND v(dout0_203) AT=440.025n

.meas tran vdout0_204ck870 FIND v(dout0_204) AT=440.025n

.meas tran vdout0_205ck870 FIND v(dout0_205) AT=440.025n

.meas tran vdout0_206ck870 FIND v(dout0_206) AT=440.025n

.meas tran vdout0_207ck870 FIND v(dout0_207) AT=440.025n

.meas tran vdout0_208ck870 FIND v(dout0_208) AT=440.025n

.meas tran vdout0_209ck870 FIND v(dout0_209) AT=440.025n

.meas tran vdout0_210ck870 FIND v(dout0_210) AT=440.025n

.meas tran vdout0_211ck870 FIND v(dout0_211) AT=440.025n

.meas tran vdout0_212ck870 FIND v(dout0_212) AT=440.025n

.meas tran vdout0_213ck870 FIND v(dout0_213) AT=440.025n

.meas tran vdout0_214ck870 FIND v(dout0_214) AT=440.025n

.meas tran vdout0_215ck870 FIND v(dout0_215) AT=440.025n

.meas tran vdout0_216ck870 FIND v(dout0_216) AT=440.025n

.meas tran vdout0_217ck870 FIND v(dout0_217) AT=440.025n

.meas tran vdout0_218ck870 FIND v(dout0_218) AT=440.025n

.meas tran vdout0_219ck870 FIND v(dout0_219) AT=440.025n

.meas tran vdout0_220ck870 FIND v(dout0_220) AT=440.025n

.meas tran vdout0_221ck870 FIND v(dout0_221) AT=440.025n

.meas tran vdout0_222ck870 FIND v(dout0_222) AT=440.025n

.meas tran vdout0_223ck870 FIND v(dout0_223) AT=440.025n

.meas tran vdout0_224ck870 FIND v(dout0_224) AT=440.025n

.meas tran vdout0_225ck870 FIND v(dout0_225) AT=440.025n

.meas tran vdout0_226ck870 FIND v(dout0_226) AT=440.025n

.meas tran vdout0_227ck870 FIND v(dout0_227) AT=440.025n

.meas tran vdout0_228ck870 FIND v(dout0_228) AT=440.025n

.meas tran vdout0_229ck870 FIND v(dout0_229) AT=440.025n

.meas tran vdout0_230ck870 FIND v(dout0_230) AT=440.025n

.meas tran vdout0_231ck870 FIND v(dout0_231) AT=440.025n

.meas tran vdout0_232ck870 FIND v(dout0_232) AT=440.025n

.meas tran vdout0_233ck870 FIND v(dout0_233) AT=440.025n

.meas tran vdout0_234ck870 FIND v(dout0_234) AT=440.025n

.meas tran vdout0_235ck870 FIND v(dout0_235) AT=440.025n

.meas tran vdout0_236ck870 FIND v(dout0_236) AT=440.025n

.meas tran vdout0_237ck870 FIND v(dout0_237) AT=440.025n

.meas tran vdout0_238ck870 FIND v(dout0_238) AT=440.025n

.meas tran vdout0_239ck870 FIND v(dout0_239) AT=440.025n

.meas tran vdout0_240ck870 FIND v(dout0_240) AT=440.025n

.meas tran vdout0_241ck870 FIND v(dout0_241) AT=440.025n

.meas tran vdout0_242ck870 FIND v(dout0_242) AT=440.025n

.meas tran vdout0_243ck870 FIND v(dout0_243) AT=440.025n

.meas tran vdout0_244ck870 FIND v(dout0_244) AT=440.025n

.meas tran vdout0_245ck870 FIND v(dout0_245) AT=440.025n

.meas tran vdout0_246ck870 FIND v(dout0_246) AT=440.025n

.meas tran vdout0_247ck870 FIND v(dout0_247) AT=440.025n

.meas tran vdout0_248ck870 FIND v(dout0_248) AT=440.025n

.meas tran vdout0_249ck870 FIND v(dout0_249) AT=440.025n

.meas tran vdout0_250ck870 FIND v(dout0_250) AT=440.025n

.meas tran vdout0_251ck870 FIND v(dout0_251) AT=440.025n

.meas tran vdout0_252ck870 FIND v(dout0_252) AT=440.025n

.meas tran vdout0_253ck870 FIND v(dout0_253) AT=440.025n

.meas tran vdout0_254ck870 FIND v(dout0_254) AT=440.025n

.meas tran vdout0_255ck870 FIND v(dout0_255) AT=440.025n

.meas tran vdout0_0ck880 FIND v(dout0_0) AT=445.025n

.meas tran vdout0_1ck880 FIND v(dout0_1) AT=445.025n

.meas tran vdout0_2ck880 FIND v(dout0_2) AT=445.025n

.meas tran vdout0_3ck880 FIND v(dout0_3) AT=445.025n

.meas tran vdout0_4ck880 FIND v(dout0_4) AT=445.025n

.meas tran vdout0_5ck880 FIND v(dout0_5) AT=445.025n

.meas tran vdout0_6ck880 FIND v(dout0_6) AT=445.025n

.meas tran vdout0_7ck880 FIND v(dout0_7) AT=445.025n

.meas tran vdout0_8ck880 FIND v(dout0_8) AT=445.025n

.meas tran vdout0_9ck880 FIND v(dout0_9) AT=445.025n

.meas tran vdout0_10ck880 FIND v(dout0_10) AT=445.025n

.meas tran vdout0_11ck880 FIND v(dout0_11) AT=445.025n

.meas tran vdout0_12ck880 FIND v(dout0_12) AT=445.025n

.meas tran vdout0_13ck880 FIND v(dout0_13) AT=445.025n

.meas tran vdout0_14ck880 FIND v(dout0_14) AT=445.025n

.meas tran vdout0_15ck880 FIND v(dout0_15) AT=445.025n

.meas tran vdout0_16ck880 FIND v(dout0_16) AT=445.025n

.meas tran vdout0_17ck880 FIND v(dout0_17) AT=445.025n

.meas tran vdout0_18ck880 FIND v(dout0_18) AT=445.025n

.meas tran vdout0_19ck880 FIND v(dout0_19) AT=445.025n

.meas tran vdout0_20ck880 FIND v(dout0_20) AT=445.025n

.meas tran vdout0_21ck880 FIND v(dout0_21) AT=445.025n

.meas tran vdout0_22ck880 FIND v(dout0_22) AT=445.025n

.meas tran vdout0_23ck880 FIND v(dout0_23) AT=445.025n

.meas tran vdout0_24ck880 FIND v(dout0_24) AT=445.025n

.meas tran vdout0_25ck880 FIND v(dout0_25) AT=445.025n

.meas tran vdout0_26ck880 FIND v(dout0_26) AT=445.025n

.meas tran vdout0_27ck880 FIND v(dout0_27) AT=445.025n

.meas tran vdout0_28ck880 FIND v(dout0_28) AT=445.025n

.meas tran vdout0_29ck880 FIND v(dout0_29) AT=445.025n

.meas tran vdout0_30ck880 FIND v(dout0_30) AT=445.025n

.meas tran vdout0_31ck880 FIND v(dout0_31) AT=445.025n

.meas tran vdout0_32ck880 FIND v(dout0_32) AT=445.025n

.meas tran vdout0_33ck880 FIND v(dout0_33) AT=445.025n

.meas tran vdout0_34ck880 FIND v(dout0_34) AT=445.025n

.meas tran vdout0_35ck880 FIND v(dout0_35) AT=445.025n

.meas tran vdout0_36ck880 FIND v(dout0_36) AT=445.025n

.meas tran vdout0_37ck880 FIND v(dout0_37) AT=445.025n

.meas tran vdout0_38ck880 FIND v(dout0_38) AT=445.025n

.meas tran vdout0_39ck880 FIND v(dout0_39) AT=445.025n

.meas tran vdout0_40ck880 FIND v(dout0_40) AT=445.025n

.meas tran vdout0_41ck880 FIND v(dout0_41) AT=445.025n

.meas tran vdout0_42ck880 FIND v(dout0_42) AT=445.025n

.meas tran vdout0_43ck880 FIND v(dout0_43) AT=445.025n

.meas tran vdout0_44ck880 FIND v(dout0_44) AT=445.025n

.meas tran vdout0_45ck880 FIND v(dout0_45) AT=445.025n

.meas tran vdout0_46ck880 FIND v(dout0_46) AT=445.025n

.meas tran vdout0_47ck880 FIND v(dout0_47) AT=445.025n

.meas tran vdout0_48ck880 FIND v(dout0_48) AT=445.025n

.meas tran vdout0_49ck880 FIND v(dout0_49) AT=445.025n

.meas tran vdout0_50ck880 FIND v(dout0_50) AT=445.025n

.meas tran vdout0_51ck880 FIND v(dout0_51) AT=445.025n

.meas tran vdout0_52ck880 FIND v(dout0_52) AT=445.025n

.meas tran vdout0_53ck880 FIND v(dout0_53) AT=445.025n

.meas tran vdout0_54ck880 FIND v(dout0_54) AT=445.025n

.meas tran vdout0_55ck880 FIND v(dout0_55) AT=445.025n

.meas tran vdout0_56ck880 FIND v(dout0_56) AT=445.025n

.meas tran vdout0_57ck880 FIND v(dout0_57) AT=445.025n

.meas tran vdout0_58ck880 FIND v(dout0_58) AT=445.025n

.meas tran vdout0_59ck880 FIND v(dout0_59) AT=445.025n

.meas tran vdout0_60ck880 FIND v(dout0_60) AT=445.025n

.meas tran vdout0_61ck880 FIND v(dout0_61) AT=445.025n

.meas tran vdout0_62ck880 FIND v(dout0_62) AT=445.025n

.meas tran vdout0_63ck880 FIND v(dout0_63) AT=445.025n

.meas tran vdout0_64ck880 FIND v(dout0_64) AT=445.025n

.meas tran vdout0_65ck880 FIND v(dout0_65) AT=445.025n

.meas tran vdout0_66ck880 FIND v(dout0_66) AT=445.025n

.meas tran vdout0_67ck880 FIND v(dout0_67) AT=445.025n

.meas tran vdout0_68ck880 FIND v(dout0_68) AT=445.025n

.meas tran vdout0_69ck880 FIND v(dout0_69) AT=445.025n

.meas tran vdout0_70ck880 FIND v(dout0_70) AT=445.025n

.meas tran vdout0_71ck880 FIND v(dout0_71) AT=445.025n

.meas tran vdout0_72ck880 FIND v(dout0_72) AT=445.025n

.meas tran vdout0_73ck880 FIND v(dout0_73) AT=445.025n

.meas tran vdout0_74ck880 FIND v(dout0_74) AT=445.025n

.meas tran vdout0_75ck880 FIND v(dout0_75) AT=445.025n

.meas tran vdout0_76ck880 FIND v(dout0_76) AT=445.025n

.meas tran vdout0_77ck880 FIND v(dout0_77) AT=445.025n

.meas tran vdout0_78ck880 FIND v(dout0_78) AT=445.025n

.meas tran vdout0_79ck880 FIND v(dout0_79) AT=445.025n

.meas tran vdout0_80ck880 FIND v(dout0_80) AT=445.025n

.meas tran vdout0_81ck880 FIND v(dout0_81) AT=445.025n

.meas tran vdout0_82ck880 FIND v(dout0_82) AT=445.025n

.meas tran vdout0_83ck880 FIND v(dout0_83) AT=445.025n

.meas tran vdout0_84ck880 FIND v(dout0_84) AT=445.025n

.meas tran vdout0_85ck880 FIND v(dout0_85) AT=445.025n

.meas tran vdout0_86ck880 FIND v(dout0_86) AT=445.025n

.meas tran vdout0_87ck880 FIND v(dout0_87) AT=445.025n

.meas tran vdout0_88ck880 FIND v(dout0_88) AT=445.025n

.meas tran vdout0_89ck880 FIND v(dout0_89) AT=445.025n

.meas tran vdout0_90ck880 FIND v(dout0_90) AT=445.025n

.meas tran vdout0_91ck880 FIND v(dout0_91) AT=445.025n

.meas tran vdout0_92ck880 FIND v(dout0_92) AT=445.025n

.meas tran vdout0_93ck880 FIND v(dout0_93) AT=445.025n

.meas tran vdout0_94ck880 FIND v(dout0_94) AT=445.025n

.meas tran vdout0_95ck880 FIND v(dout0_95) AT=445.025n

.meas tran vdout0_96ck880 FIND v(dout0_96) AT=445.025n

.meas tran vdout0_97ck880 FIND v(dout0_97) AT=445.025n

.meas tran vdout0_98ck880 FIND v(dout0_98) AT=445.025n

.meas tran vdout0_99ck880 FIND v(dout0_99) AT=445.025n

.meas tran vdout0_100ck880 FIND v(dout0_100) AT=445.025n

.meas tran vdout0_101ck880 FIND v(dout0_101) AT=445.025n

.meas tran vdout0_102ck880 FIND v(dout0_102) AT=445.025n

.meas tran vdout0_103ck880 FIND v(dout0_103) AT=445.025n

.meas tran vdout0_104ck880 FIND v(dout0_104) AT=445.025n

.meas tran vdout0_105ck880 FIND v(dout0_105) AT=445.025n

.meas tran vdout0_106ck880 FIND v(dout0_106) AT=445.025n

.meas tran vdout0_107ck880 FIND v(dout0_107) AT=445.025n

.meas tran vdout0_108ck880 FIND v(dout0_108) AT=445.025n

.meas tran vdout0_109ck880 FIND v(dout0_109) AT=445.025n

.meas tran vdout0_110ck880 FIND v(dout0_110) AT=445.025n

.meas tran vdout0_111ck880 FIND v(dout0_111) AT=445.025n

.meas tran vdout0_112ck880 FIND v(dout0_112) AT=445.025n

.meas tran vdout0_113ck880 FIND v(dout0_113) AT=445.025n

.meas tran vdout0_114ck880 FIND v(dout0_114) AT=445.025n

.meas tran vdout0_115ck880 FIND v(dout0_115) AT=445.025n

.meas tran vdout0_116ck880 FIND v(dout0_116) AT=445.025n

.meas tran vdout0_117ck880 FIND v(dout0_117) AT=445.025n

.meas tran vdout0_118ck880 FIND v(dout0_118) AT=445.025n

.meas tran vdout0_119ck880 FIND v(dout0_119) AT=445.025n

.meas tran vdout0_120ck880 FIND v(dout0_120) AT=445.025n

.meas tran vdout0_121ck880 FIND v(dout0_121) AT=445.025n

.meas tran vdout0_122ck880 FIND v(dout0_122) AT=445.025n

.meas tran vdout0_123ck880 FIND v(dout0_123) AT=445.025n

.meas tran vdout0_124ck880 FIND v(dout0_124) AT=445.025n

.meas tran vdout0_125ck880 FIND v(dout0_125) AT=445.025n

.meas tran vdout0_126ck880 FIND v(dout0_126) AT=445.025n

.meas tran vdout0_127ck880 FIND v(dout0_127) AT=445.025n

.meas tran vdout0_128ck880 FIND v(dout0_128) AT=445.025n

.meas tran vdout0_129ck880 FIND v(dout0_129) AT=445.025n

.meas tran vdout0_130ck880 FIND v(dout0_130) AT=445.025n

.meas tran vdout0_131ck880 FIND v(dout0_131) AT=445.025n

.meas tran vdout0_132ck880 FIND v(dout0_132) AT=445.025n

.meas tran vdout0_133ck880 FIND v(dout0_133) AT=445.025n

.meas tran vdout0_134ck880 FIND v(dout0_134) AT=445.025n

.meas tran vdout0_135ck880 FIND v(dout0_135) AT=445.025n

.meas tran vdout0_136ck880 FIND v(dout0_136) AT=445.025n

.meas tran vdout0_137ck880 FIND v(dout0_137) AT=445.025n

.meas tran vdout0_138ck880 FIND v(dout0_138) AT=445.025n

.meas tran vdout0_139ck880 FIND v(dout0_139) AT=445.025n

.meas tran vdout0_140ck880 FIND v(dout0_140) AT=445.025n

.meas tran vdout0_141ck880 FIND v(dout0_141) AT=445.025n

.meas tran vdout0_142ck880 FIND v(dout0_142) AT=445.025n

.meas tran vdout0_143ck880 FIND v(dout0_143) AT=445.025n

.meas tran vdout0_144ck880 FIND v(dout0_144) AT=445.025n

.meas tran vdout0_145ck880 FIND v(dout0_145) AT=445.025n

.meas tran vdout0_146ck880 FIND v(dout0_146) AT=445.025n

.meas tran vdout0_147ck880 FIND v(dout0_147) AT=445.025n

.meas tran vdout0_148ck880 FIND v(dout0_148) AT=445.025n

.meas tran vdout0_149ck880 FIND v(dout0_149) AT=445.025n

.meas tran vdout0_150ck880 FIND v(dout0_150) AT=445.025n

.meas tran vdout0_151ck880 FIND v(dout0_151) AT=445.025n

.meas tran vdout0_152ck880 FIND v(dout0_152) AT=445.025n

.meas tran vdout0_153ck880 FIND v(dout0_153) AT=445.025n

.meas tran vdout0_154ck880 FIND v(dout0_154) AT=445.025n

.meas tran vdout0_155ck880 FIND v(dout0_155) AT=445.025n

.meas tran vdout0_156ck880 FIND v(dout0_156) AT=445.025n

.meas tran vdout0_157ck880 FIND v(dout0_157) AT=445.025n

.meas tran vdout0_158ck880 FIND v(dout0_158) AT=445.025n

.meas tran vdout0_159ck880 FIND v(dout0_159) AT=445.025n

.meas tran vdout0_160ck880 FIND v(dout0_160) AT=445.025n

.meas tran vdout0_161ck880 FIND v(dout0_161) AT=445.025n

.meas tran vdout0_162ck880 FIND v(dout0_162) AT=445.025n

.meas tran vdout0_163ck880 FIND v(dout0_163) AT=445.025n

.meas tran vdout0_164ck880 FIND v(dout0_164) AT=445.025n

.meas tran vdout0_165ck880 FIND v(dout0_165) AT=445.025n

.meas tran vdout0_166ck880 FIND v(dout0_166) AT=445.025n

.meas tran vdout0_167ck880 FIND v(dout0_167) AT=445.025n

.meas tran vdout0_168ck880 FIND v(dout0_168) AT=445.025n

.meas tran vdout0_169ck880 FIND v(dout0_169) AT=445.025n

.meas tran vdout0_170ck880 FIND v(dout0_170) AT=445.025n

.meas tran vdout0_171ck880 FIND v(dout0_171) AT=445.025n

.meas tran vdout0_172ck880 FIND v(dout0_172) AT=445.025n

.meas tran vdout0_173ck880 FIND v(dout0_173) AT=445.025n

.meas tran vdout0_174ck880 FIND v(dout0_174) AT=445.025n

.meas tran vdout0_175ck880 FIND v(dout0_175) AT=445.025n

.meas tran vdout0_176ck880 FIND v(dout0_176) AT=445.025n

.meas tran vdout0_177ck880 FIND v(dout0_177) AT=445.025n

.meas tran vdout0_178ck880 FIND v(dout0_178) AT=445.025n

.meas tran vdout0_179ck880 FIND v(dout0_179) AT=445.025n

.meas tran vdout0_180ck880 FIND v(dout0_180) AT=445.025n

.meas tran vdout0_181ck880 FIND v(dout0_181) AT=445.025n

.meas tran vdout0_182ck880 FIND v(dout0_182) AT=445.025n

.meas tran vdout0_183ck880 FIND v(dout0_183) AT=445.025n

.meas tran vdout0_184ck880 FIND v(dout0_184) AT=445.025n

.meas tran vdout0_185ck880 FIND v(dout0_185) AT=445.025n

.meas tran vdout0_186ck880 FIND v(dout0_186) AT=445.025n

.meas tran vdout0_187ck880 FIND v(dout0_187) AT=445.025n

.meas tran vdout0_188ck880 FIND v(dout0_188) AT=445.025n

.meas tran vdout0_189ck880 FIND v(dout0_189) AT=445.025n

.meas tran vdout0_190ck880 FIND v(dout0_190) AT=445.025n

.meas tran vdout0_191ck880 FIND v(dout0_191) AT=445.025n

.meas tran vdout0_192ck880 FIND v(dout0_192) AT=445.025n

.meas tran vdout0_193ck880 FIND v(dout0_193) AT=445.025n

.meas tran vdout0_194ck880 FIND v(dout0_194) AT=445.025n

.meas tran vdout0_195ck880 FIND v(dout0_195) AT=445.025n

.meas tran vdout0_196ck880 FIND v(dout0_196) AT=445.025n

.meas tran vdout0_197ck880 FIND v(dout0_197) AT=445.025n

.meas tran vdout0_198ck880 FIND v(dout0_198) AT=445.025n

.meas tran vdout0_199ck880 FIND v(dout0_199) AT=445.025n

.meas tran vdout0_200ck880 FIND v(dout0_200) AT=445.025n

.meas tran vdout0_201ck880 FIND v(dout0_201) AT=445.025n

.meas tran vdout0_202ck880 FIND v(dout0_202) AT=445.025n

.meas tran vdout0_203ck880 FIND v(dout0_203) AT=445.025n

.meas tran vdout0_204ck880 FIND v(dout0_204) AT=445.025n

.meas tran vdout0_205ck880 FIND v(dout0_205) AT=445.025n

.meas tran vdout0_206ck880 FIND v(dout0_206) AT=445.025n

.meas tran vdout0_207ck880 FIND v(dout0_207) AT=445.025n

.meas tran vdout0_208ck880 FIND v(dout0_208) AT=445.025n

.meas tran vdout0_209ck880 FIND v(dout0_209) AT=445.025n

.meas tran vdout0_210ck880 FIND v(dout0_210) AT=445.025n

.meas tran vdout0_211ck880 FIND v(dout0_211) AT=445.025n

.meas tran vdout0_212ck880 FIND v(dout0_212) AT=445.025n

.meas tran vdout0_213ck880 FIND v(dout0_213) AT=445.025n

.meas tran vdout0_214ck880 FIND v(dout0_214) AT=445.025n

.meas tran vdout0_215ck880 FIND v(dout0_215) AT=445.025n

.meas tran vdout0_216ck880 FIND v(dout0_216) AT=445.025n

.meas tran vdout0_217ck880 FIND v(dout0_217) AT=445.025n

.meas tran vdout0_218ck880 FIND v(dout0_218) AT=445.025n

.meas tran vdout0_219ck880 FIND v(dout0_219) AT=445.025n

.meas tran vdout0_220ck880 FIND v(dout0_220) AT=445.025n

.meas tran vdout0_221ck880 FIND v(dout0_221) AT=445.025n

.meas tran vdout0_222ck880 FIND v(dout0_222) AT=445.025n

.meas tran vdout0_223ck880 FIND v(dout0_223) AT=445.025n

.meas tran vdout0_224ck880 FIND v(dout0_224) AT=445.025n

.meas tran vdout0_225ck880 FIND v(dout0_225) AT=445.025n

.meas tran vdout0_226ck880 FIND v(dout0_226) AT=445.025n

.meas tran vdout0_227ck880 FIND v(dout0_227) AT=445.025n

.meas tran vdout0_228ck880 FIND v(dout0_228) AT=445.025n

.meas tran vdout0_229ck880 FIND v(dout0_229) AT=445.025n

.meas tran vdout0_230ck880 FIND v(dout0_230) AT=445.025n

.meas tran vdout0_231ck880 FIND v(dout0_231) AT=445.025n

.meas tran vdout0_232ck880 FIND v(dout0_232) AT=445.025n

.meas tran vdout0_233ck880 FIND v(dout0_233) AT=445.025n

.meas tran vdout0_234ck880 FIND v(dout0_234) AT=445.025n

.meas tran vdout0_235ck880 FIND v(dout0_235) AT=445.025n

.meas tran vdout0_236ck880 FIND v(dout0_236) AT=445.025n

.meas tran vdout0_237ck880 FIND v(dout0_237) AT=445.025n

.meas tran vdout0_238ck880 FIND v(dout0_238) AT=445.025n

.meas tran vdout0_239ck880 FIND v(dout0_239) AT=445.025n

.meas tran vdout0_240ck880 FIND v(dout0_240) AT=445.025n

.meas tran vdout0_241ck880 FIND v(dout0_241) AT=445.025n

.meas tran vdout0_242ck880 FIND v(dout0_242) AT=445.025n

.meas tran vdout0_243ck880 FIND v(dout0_243) AT=445.025n

.meas tran vdout0_244ck880 FIND v(dout0_244) AT=445.025n

.meas tran vdout0_245ck880 FIND v(dout0_245) AT=445.025n

.meas tran vdout0_246ck880 FIND v(dout0_246) AT=445.025n

.meas tran vdout0_247ck880 FIND v(dout0_247) AT=445.025n

.meas tran vdout0_248ck880 FIND v(dout0_248) AT=445.025n

.meas tran vdout0_249ck880 FIND v(dout0_249) AT=445.025n

.meas tran vdout0_250ck880 FIND v(dout0_250) AT=445.025n

.meas tran vdout0_251ck880 FIND v(dout0_251) AT=445.025n

.meas tran vdout0_252ck880 FIND v(dout0_252) AT=445.025n

.meas tran vdout0_253ck880 FIND v(dout0_253) AT=445.025n

.meas tran vdout0_254ck880 FIND v(dout0_254) AT=445.025n

.meas tran vdout0_255ck880 FIND v(dout0_255) AT=445.025n

.meas tran vdout0_0ck910 FIND v(dout0_0) AT=460.025n

.meas tran vdout0_1ck910 FIND v(dout0_1) AT=460.025n

.meas tran vdout0_2ck910 FIND v(dout0_2) AT=460.025n

.meas tran vdout0_3ck910 FIND v(dout0_3) AT=460.025n

.meas tran vdout0_4ck910 FIND v(dout0_4) AT=460.025n

.meas tran vdout0_5ck910 FIND v(dout0_5) AT=460.025n

.meas tran vdout0_6ck910 FIND v(dout0_6) AT=460.025n

.meas tran vdout0_7ck910 FIND v(dout0_7) AT=460.025n

.meas tran vdout0_8ck910 FIND v(dout0_8) AT=460.025n

.meas tran vdout0_9ck910 FIND v(dout0_9) AT=460.025n

.meas tran vdout0_10ck910 FIND v(dout0_10) AT=460.025n

.meas tran vdout0_11ck910 FIND v(dout0_11) AT=460.025n

.meas tran vdout0_12ck910 FIND v(dout0_12) AT=460.025n

.meas tran vdout0_13ck910 FIND v(dout0_13) AT=460.025n

.meas tran vdout0_14ck910 FIND v(dout0_14) AT=460.025n

.meas tran vdout0_15ck910 FIND v(dout0_15) AT=460.025n

.meas tran vdout0_16ck910 FIND v(dout0_16) AT=460.025n

.meas tran vdout0_17ck910 FIND v(dout0_17) AT=460.025n

.meas tran vdout0_18ck910 FIND v(dout0_18) AT=460.025n

.meas tran vdout0_19ck910 FIND v(dout0_19) AT=460.025n

.meas tran vdout0_20ck910 FIND v(dout0_20) AT=460.025n

.meas tran vdout0_21ck910 FIND v(dout0_21) AT=460.025n

.meas tran vdout0_22ck910 FIND v(dout0_22) AT=460.025n

.meas tran vdout0_23ck910 FIND v(dout0_23) AT=460.025n

.meas tran vdout0_24ck910 FIND v(dout0_24) AT=460.025n

.meas tran vdout0_25ck910 FIND v(dout0_25) AT=460.025n

.meas tran vdout0_26ck910 FIND v(dout0_26) AT=460.025n

.meas tran vdout0_27ck910 FIND v(dout0_27) AT=460.025n

.meas tran vdout0_28ck910 FIND v(dout0_28) AT=460.025n

.meas tran vdout0_29ck910 FIND v(dout0_29) AT=460.025n

.meas tran vdout0_30ck910 FIND v(dout0_30) AT=460.025n

.meas tran vdout0_31ck910 FIND v(dout0_31) AT=460.025n

.meas tran vdout0_32ck910 FIND v(dout0_32) AT=460.025n

.meas tran vdout0_33ck910 FIND v(dout0_33) AT=460.025n

.meas tran vdout0_34ck910 FIND v(dout0_34) AT=460.025n

.meas tran vdout0_35ck910 FIND v(dout0_35) AT=460.025n

.meas tran vdout0_36ck910 FIND v(dout0_36) AT=460.025n

.meas tran vdout0_37ck910 FIND v(dout0_37) AT=460.025n

.meas tran vdout0_38ck910 FIND v(dout0_38) AT=460.025n

.meas tran vdout0_39ck910 FIND v(dout0_39) AT=460.025n

.meas tran vdout0_40ck910 FIND v(dout0_40) AT=460.025n

.meas tran vdout0_41ck910 FIND v(dout0_41) AT=460.025n

.meas tran vdout0_42ck910 FIND v(dout0_42) AT=460.025n

.meas tran vdout0_43ck910 FIND v(dout0_43) AT=460.025n

.meas tran vdout0_44ck910 FIND v(dout0_44) AT=460.025n

.meas tran vdout0_45ck910 FIND v(dout0_45) AT=460.025n

.meas tran vdout0_46ck910 FIND v(dout0_46) AT=460.025n

.meas tran vdout0_47ck910 FIND v(dout0_47) AT=460.025n

.meas tran vdout0_48ck910 FIND v(dout0_48) AT=460.025n

.meas tran vdout0_49ck910 FIND v(dout0_49) AT=460.025n

.meas tran vdout0_50ck910 FIND v(dout0_50) AT=460.025n

.meas tran vdout0_51ck910 FIND v(dout0_51) AT=460.025n

.meas tran vdout0_52ck910 FIND v(dout0_52) AT=460.025n

.meas tran vdout0_53ck910 FIND v(dout0_53) AT=460.025n

.meas tran vdout0_54ck910 FIND v(dout0_54) AT=460.025n

.meas tran vdout0_55ck910 FIND v(dout0_55) AT=460.025n

.meas tran vdout0_56ck910 FIND v(dout0_56) AT=460.025n

.meas tran vdout0_57ck910 FIND v(dout0_57) AT=460.025n

.meas tran vdout0_58ck910 FIND v(dout0_58) AT=460.025n

.meas tran vdout0_59ck910 FIND v(dout0_59) AT=460.025n

.meas tran vdout0_60ck910 FIND v(dout0_60) AT=460.025n

.meas tran vdout0_61ck910 FIND v(dout0_61) AT=460.025n

.meas tran vdout0_62ck910 FIND v(dout0_62) AT=460.025n

.meas tran vdout0_63ck910 FIND v(dout0_63) AT=460.025n

.meas tran vdout0_64ck910 FIND v(dout0_64) AT=460.025n

.meas tran vdout0_65ck910 FIND v(dout0_65) AT=460.025n

.meas tran vdout0_66ck910 FIND v(dout0_66) AT=460.025n

.meas tran vdout0_67ck910 FIND v(dout0_67) AT=460.025n

.meas tran vdout0_68ck910 FIND v(dout0_68) AT=460.025n

.meas tran vdout0_69ck910 FIND v(dout0_69) AT=460.025n

.meas tran vdout0_70ck910 FIND v(dout0_70) AT=460.025n

.meas tran vdout0_71ck910 FIND v(dout0_71) AT=460.025n

.meas tran vdout0_72ck910 FIND v(dout0_72) AT=460.025n

.meas tran vdout0_73ck910 FIND v(dout0_73) AT=460.025n

.meas tran vdout0_74ck910 FIND v(dout0_74) AT=460.025n

.meas tran vdout0_75ck910 FIND v(dout0_75) AT=460.025n

.meas tran vdout0_76ck910 FIND v(dout0_76) AT=460.025n

.meas tran vdout0_77ck910 FIND v(dout0_77) AT=460.025n

.meas tran vdout0_78ck910 FIND v(dout0_78) AT=460.025n

.meas tran vdout0_79ck910 FIND v(dout0_79) AT=460.025n

.meas tran vdout0_80ck910 FIND v(dout0_80) AT=460.025n

.meas tran vdout0_81ck910 FIND v(dout0_81) AT=460.025n

.meas tran vdout0_82ck910 FIND v(dout0_82) AT=460.025n

.meas tran vdout0_83ck910 FIND v(dout0_83) AT=460.025n

.meas tran vdout0_84ck910 FIND v(dout0_84) AT=460.025n

.meas tran vdout0_85ck910 FIND v(dout0_85) AT=460.025n

.meas tran vdout0_86ck910 FIND v(dout0_86) AT=460.025n

.meas tran vdout0_87ck910 FIND v(dout0_87) AT=460.025n

.meas tran vdout0_88ck910 FIND v(dout0_88) AT=460.025n

.meas tran vdout0_89ck910 FIND v(dout0_89) AT=460.025n

.meas tran vdout0_90ck910 FIND v(dout0_90) AT=460.025n

.meas tran vdout0_91ck910 FIND v(dout0_91) AT=460.025n

.meas tran vdout0_92ck910 FIND v(dout0_92) AT=460.025n

.meas tran vdout0_93ck910 FIND v(dout0_93) AT=460.025n

.meas tran vdout0_94ck910 FIND v(dout0_94) AT=460.025n

.meas tran vdout0_95ck910 FIND v(dout0_95) AT=460.025n

.meas tran vdout0_96ck910 FIND v(dout0_96) AT=460.025n

.meas tran vdout0_97ck910 FIND v(dout0_97) AT=460.025n

.meas tran vdout0_98ck910 FIND v(dout0_98) AT=460.025n

.meas tran vdout0_99ck910 FIND v(dout0_99) AT=460.025n

.meas tran vdout0_100ck910 FIND v(dout0_100) AT=460.025n

.meas tran vdout0_101ck910 FIND v(dout0_101) AT=460.025n

.meas tran vdout0_102ck910 FIND v(dout0_102) AT=460.025n

.meas tran vdout0_103ck910 FIND v(dout0_103) AT=460.025n

.meas tran vdout0_104ck910 FIND v(dout0_104) AT=460.025n

.meas tran vdout0_105ck910 FIND v(dout0_105) AT=460.025n

.meas tran vdout0_106ck910 FIND v(dout0_106) AT=460.025n

.meas tran vdout0_107ck910 FIND v(dout0_107) AT=460.025n

.meas tran vdout0_108ck910 FIND v(dout0_108) AT=460.025n

.meas tran vdout0_109ck910 FIND v(dout0_109) AT=460.025n

.meas tran vdout0_110ck910 FIND v(dout0_110) AT=460.025n

.meas tran vdout0_111ck910 FIND v(dout0_111) AT=460.025n

.meas tran vdout0_112ck910 FIND v(dout0_112) AT=460.025n

.meas tran vdout0_113ck910 FIND v(dout0_113) AT=460.025n

.meas tran vdout0_114ck910 FIND v(dout0_114) AT=460.025n

.meas tran vdout0_115ck910 FIND v(dout0_115) AT=460.025n

.meas tran vdout0_116ck910 FIND v(dout0_116) AT=460.025n

.meas tran vdout0_117ck910 FIND v(dout0_117) AT=460.025n

.meas tran vdout0_118ck910 FIND v(dout0_118) AT=460.025n

.meas tran vdout0_119ck910 FIND v(dout0_119) AT=460.025n

.meas tran vdout0_120ck910 FIND v(dout0_120) AT=460.025n

.meas tran vdout0_121ck910 FIND v(dout0_121) AT=460.025n

.meas tran vdout0_122ck910 FIND v(dout0_122) AT=460.025n

.meas tran vdout0_123ck910 FIND v(dout0_123) AT=460.025n

.meas tran vdout0_124ck910 FIND v(dout0_124) AT=460.025n

.meas tran vdout0_125ck910 FIND v(dout0_125) AT=460.025n

.meas tran vdout0_126ck910 FIND v(dout0_126) AT=460.025n

.meas tran vdout0_127ck910 FIND v(dout0_127) AT=460.025n

.meas tran vdout0_128ck910 FIND v(dout0_128) AT=460.025n

.meas tran vdout0_129ck910 FIND v(dout0_129) AT=460.025n

.meas tran vdout0_130ck910 FIND v(dout0_130) AT=460.025n

.meas tran vdout0_131ck910 FIND v(dout0_131) AT=460.025n

.meas tran vdout0_132ck910 FIND v(dout0_132) AT=460.025n

.meas tran vdout0_133ck910 FIND v(dout0_133) AT=460.025n

.meas tran vdout0_134ck910 FIND v(dout0_134) AT=460.025n

.meas tran vdout0_135ck910 FIND v(dout0_135) AT=460.025n

.meas tran vdout0_136ck910 FIND v(dout0_136) AT=460.025n

.meas tran vdout0_137ck910 FIND v(dout0_137) AT=460.025n

.meas tran vdout0_138ck910 FIND v(dout0_138) AT=460.025n

.meas tran vdout0_139ck910 FIND v(dout0_139) AT=460.025n

.meas tran vdout0_140ck910 FIND v(dout0_140) AT=460.025n

.meas tran vdout0_141ck910 FIND v(dout0_141) AT=460.025n

.meas tran vdout0_142ck910 FIND v(dout0_142) AT=460.025n

.meas tran vdout0_143ck910 FIND v(dout0_143) AT=460.025n

.meas tran vdout0_144ck910 FIND v(dout0_144) AT=460.025n

.meas tran vdout0_145ck910 FIND v(dout0_145) AT=460.025n

.meas tran vdout0_146ck910 FIND v(dout0_146) AT=460.025n

.meas tran vdout0_147ck910 FIND v(dout0_147) AT=460.025n

.meas tran vdout0_148ck910 FIND v(dout0_148) AT=460.025n

.meas tran vdout0_149ck910 FIND v(dout0_149) AT=460.025n

.meas tran vdout0_150ck910 FIND v(dout0_150) AT=460.025n

.meas tran vdout0_151ck910 FIND v(dout0_151) AT=460.025n

.meas tran vdout0_152ck910 FIND v(dout0_152) AT=460.025n

.meas tran vdout0_153ck910 FIND v(dout0_153) AT=460.025n

.meas tran vdout0_154ck910 FIND v(dout0_154) AT=460.025n

.meas tran vdout0_155ck910 FIND v(dout0_155) AT=460.025n

.meas tran vdout0_156ck910 FIND v(dout0_156) AT=460.025n

.meas tran vdout0_157ck910 FIND v(dout0_157) AT=460.025n

.meas tran vdout0_158ck910 FIND v(dout0_158) AT=460.025n

.meas tran vdout0_159ck910 FIND v(dout0_159) AT=460.025n

.meas tran vdout0_160ck910 FIND v(dout0_160) AT=460.025n

.meas tran vdout0_161ck910 FIND v(dout0_161) AT=460.025n

.meas tran vdout0_162ck910 FIND v(dout0_162) AT=460.025n

.meas tran vdout0_163ck910 FIND v(dout0_163) AT=460.025n

.meas tran vdout0_164ck910 FIND v(dout0_164) AT=460.025n

.meas tran vdout0_165ck910 FIND v(dout0_165) AT=460.025n

.meas tran vdout0_166ck910 FIND v(dout0_166) AT=460.025n

.meas tran vdout0_167ck910 FIND v(dout0_167) AT=460.025n

.meas tran vdout0_168ck910 FIND v(dout0_168) AT=460.025n

.meas tran vdout0_169ck910 FIND v(dout0_169) AT=460.025n

.meas tran vdout0_170ck910 FIND v(dout0_170) AT=460.025n

.meas tran vdout0_171ck910 FIND v(dout0_171) AT=460.025n

.meas tran vdout0_172ck910 FIND v(dout0_172) AT=460.025n

.meas tran vdout0_173ck910 FIND v(dout0_173) AT=460.025n

.meas tran vdout0_174ck910 FIND v(dout0_174) AT=460.025n

.meas tran vdout0_175ck910 FIND v(dout0_175) AT=460.025n

.meas tran vdout0_176ck910 FIND v(dout0_176) AT=460.025n

.meas tran vdout0_177ck910 FIND v(dout0_177) AT=460.025n

.meas tran vdout0_178ck910 FIND v(dout0_178) AT=460.025n

.meas tran vdout0_179ck910 FIND v(dout0_179) AT=460.025n

.meas tran vdout0_180ck910 FIND v(dout0_180) AT=460.025n

.meas tran vdout0_181ck910 FIND v(dout0_181) AT=460.025n

.meas tran vdout0_182ck910 FIND v(dout0_182) AT=460.025n

.meas tran vdout0_183ck910 FIND v(dout0_183) AT=460.025n

.meas tran vdout0_184ck910 FIND v(dout0_184) AT=460.025n

.meas tran vdout0_185ck910 FIND v(dout0_185) AT=460.025n

.meas tran vdout0_186ck910 FIND v(dout0_186) AT=460.025n

.meas tran vdout0_187ck910 FIND v(dout0_187) AT=460.025n

.meas tran vdout0_188ck910 FIND v(dout0_188) AT=460.025n

.meas tran vdout0_189ck910 FIND v(dout0_189) AT=460.025n

.meas tran vdout0_190ck910 FIND v(dout0_190) AT=460.025n

.meas tran vdout0_191ck910 FIND v(dout0_191) AT=460.025n

.meas tran vdout0_192ck910 FIND v(dout0_192) AT=460.025n

.meas tran vdout0_193ck910 FIND v(dout0_193) AT=460.025n

.meas tran vdout0_194ck910 FIND v(dout0_194) AT=460.025n

.meas tran vdout0_195ck910 FIND v(dout0_195) AT=460.025n

.meas tran vdout0_196ck910 FIND v(dout0_196) AT=460.025n

.meas tran vdout0_197ck910 FIND v(dout0_197) AT=460.025n

.meas tran vdout0_198ck910 FIND v(dout0_198) AT=460.025n

.meas tran vdout0_199ck910 FIND v(dout0_199) AT=460.025n

.meas tran vdout0_200ck910 FIND v(dout0_200) AT=460.025n

.meas tran vdout0_201ck910 FIND v(dout0_201) AT=460.025n

.meas tran vdout0_202ck910 FIND v(dout0_202) AT=460.025n

.meas tran vdout0_203ck910 FIND v(dout0_203) AT=460.025n

.meas tran vdout0_204ck910 FIND v(dout0_204) AT=460.025n

.meas tran vdout0_205ck910 FIND v(dout0_205) AT=460.025n

.meas tran vdout0_206ck910 FIND v(dout0_206) AT=460.025n

.meas tran vdout0_207ck910 FIND v(dout0_207) AT=460.025n

.meas tran vdout0_208ck910 FIND v(dout0_208) AT=460.025n

.meas tran vdout0_209ck910 FIND v(dout0_209) AT=460.025n

.meas tran vdout0_210ck910 FIND v(dout0_210) AT=460.025n

.meas tran vdout0_211ck910 FIND v(dout0_211) AT=460.025n

.meas tran vdout0_212ck910 FIND v(dout0_212) AT=460.025n

.meas tran vdout0_213ck910 FIND v(dout0_213) AT=460.025n

.meas tran vdout0_214ck910 FIND v(dout0_214) AT=460.025n

.meas tran vdout0_215ck910 FIND v(dout0_215) AT=460.025n

.meas tran vdout0_216ck910 FIND v(dout0_216) AT=460.025n

.meas tran vdout0_217ck910 FIND v(dout0_217) AT=460.025n

.meas tran vdout0_218ck910 FIND v(dout0_218) AT=460.025n

.meas tran vdout0_219ck910 FIND v(dout0_219) AT=460.025n

.meas tran vdout0_220ck910 FIND v(dout0_220) AT=460.025n

.meas tran vdout0_221ck910 FIND v(dout0_221) AT=460.025n

.meas tran vdout0_222ck910 FIND v(dout0_222) AT=460.025n

.meas tran vdout0_223ck910 FIND v(dout0_223) AT=460.025n

.meas tran vdout0_224ck910 FIND v(dout0_224) AT=460.025n

.meas tran vdout0_225ck910 FIND v(dout0_225) AT=460.025n

.meas tran vdout0_226ck910 FIND v(dout0_226) AT=460.025n

.meas tran vdout0_227ck910 FIND v(dout0_227) AT=460.025n

.meas tran vdout0_228ck910 FIND v(dout0_228) AT=460.025n

.meas tran vdout0_229ck910 FIND v(dout0_229) AT=460.025n

.meas tran vdout0_230ck910 FIND v(dout0_230) AT=460.025n

.meas tran vdout0_231ck910 FIND v(dout0_231) AT=460.025n

.meas tran vdout0_232ck910 FIND v(dout0_232) AT=460.025n

.meas tran vdout0_233ck910 FIND v(dout0_233) AT=460.025n

.meas tran vdout0_234ck910 FIND v(dout0_234) AT=460.025n

.meas tran vdout0_235ck910 FIND v(dout0_235) AT=460.025n

.meas tran vdout0_236ck910 FIND v(dout0_236) AT=460.025n

.meas tran vdout0_237ck910 FIND v(dout0_237) AT=460.025n

.meas tran vdout0_238ck910 FIND v(dout0_238) AT=460.025n

.meas tran vdout0_239ck910 FIND v(dout0_239) AT=460.025n

.meas tran vdout0_240ck910 FIND v(dout0_240) AT=460.025n

.meas tran vdout0_241ck910 FIND v(dout0_241) AT=460.025n

.meas tran vdout0_242ck910 FIND v(dout0_242) AT=460.025n

.meas tran vdout0_243ck910 FIND v(dout0_243) AT=460.025n

.meas tran vdout0_244ck910 FIND v(dout0_244) AT=460.025n

.meas tran vdout0_245ck910 FIND v(dout0_245) AT=460.025n

.meas tran vdout0_246ck910 FIND v(dout0_246) AT=460.025n

.meas tran vdout0_247ck910 FIND v(dout0_247) AT=460.025n

.meas tran vdout0_248ck910 FIND v(dout0_248) AT=460.025n

.meas tran vdout0_249ck910 FIND v(dout0_249) AT=460.025n

.meas tran vdout0_250ck910 FIND v(dout0_250) AT=460.025n

.meas tran vdout0_251ck910 FIND v(dout0_251) AT=460.025n

.meas tran vdout0_252ck910 FIND v(dout0_252) AT=460.025n

.meas tran vdout0_253ck910 FIND v(dout0_253) AT=460.025n

.meas tran vdout0_254ck910 FIND v(dout0_254) AT=460.025n

.meas tran vdout0_255ck910 FIND v(dout0_255) AT=460.025n

.meas tran vdout0_0ck920 FIND v(dout0_0) AT=465.025n

.meas tran vdout0_1ck920 FIND v(dout0_1) AT=465.025n

.meas tran vdout0_2ck920 FIND v(dout0_2) AT=465.025n

.meas tran vdout0_3ck920 FIND v(dout0_3) AT=465.025n

.meas tran vdout0_4ck920 FIND v(dout0_4) AT=465.025n

.meas tran vdout0_5ck920 FIND v(dout0_5) AT=465.025n

.meas tran vdout0_6ck920 FIND v(dout0_6) AT=465.025n

.meas tran vdout0_7ck920 FIND v(dout0_7) AT=465.025n

.meas tran vdout0_8ck920 FIND v(dout0_8) AT=465.025n

.meas tran vdout0_9ck920 FIND v(dout0_9) AT=465.025n

.meas tran vdout0_10ck920 FIND v(dout0_10) AT=465.025n

.meas tran vdout0_11ck920 FIND v(dout0_11) AT=465.025n

.meas tran vdout0_12ck920 FIND v(dout0_12) AT=465.025n

.meas tran vdout0_13ck920 FIND v(dout0_13) AT=465.025n

.meas tran vdout0_14ck920 FIND v(dout0_14) AT=465.025n

.meas tran vdout0_15ck920 FIND v(dout0_15) AT=465.025n

.meas tran vdout0_16ck920 FIND v(dout0_16) AT=465.025n

.meas tran vdout0_17ck920 FIND v(dout0_17) AT=465.025n

.meas tran vdout0_18ck920 FIND v(dout0_18) AT=465.025n

.meas tran vdout0_19ck920 FIND v(dout0_19) AT=465.025n

.meas tran vdout0_20ck920 FIND v(dout0_20) AT=465.025n

.meas tran vdout0_21ck920 FIND v(dout0_21) AT=465.025n

.meas tran vdout0_22ck920 FIND v(dout0_22) AT=465.025n

.meas tran vdout0_23ck920 FIND v(dout0_23) AT=465.025n

.meas tran vdout0_24ck920 FIND v(dout0_24) AT=465.025n

.meas tran vdout0_25ck920 FIND v(dout0_25) AT=465.025n

.meas tran vdout0_26ck920 FIND v(dout0_26) AT=465.025n

.meas tran vdout0_27ck920 FIND v(dout0_27) AT=465.025n

.meas tran vdout0_28ck920 FIND v(dout0_28) AT=465.025n

.meas tran vdout0_29ck920 FIND v(dout0_29) AT=465.025n

.meas tran vdout0_30ck920 FIND v(dout0_30) AT=465.025n

.meas tran vdout0_31ck920 FIND v(dout0_31) AT=465.025n

.meas tran vdout0_32ck920 FIND v(dout0_32) AT=465.025n

.meas tran vdout0_33ck920 FIND v(dout0_33) AT=465.025n

.meas tran vdout0_34ck920 FIND v(dout0_34) AT=465.025n

.meas tran vdout0_35ck920 FIND v(dout0_35) AT=465.025n

.meas tran vdout0_36ck920 FIND v(dout0_36) AT=465.025n

.meas tran vdout0_37ck920 FIND v(dout0_37) AT=465.025n

.meas tran vdout0_38ck920 FIND v(dout0_38) AT=465.025n

.meas tran vdout0_39ck920 FIND v(dout0_39) AT=465.025n

.meas tran vdout0_40ck920 FIND v(dout0_40) AT=465.025n

.meas tran vdout0_41ck920 FIND v(dout0_41) AT=465.025n

.meas tran vdout0_42ck920 FIND v(dout0_42) AT=465.025n

.meas tran vdout0_43ck920 FIND v(dout0_43) AT=465.025n

.meas tran vdout0_44ck920 FIND v(dout0_44) AT=465.025n

.meas tran vdout0_45ck920 FIND v(dout0_45) AT=465.025n

.meas tran vdout0_46ck920 FIND v(dout0_46) AT=465.025n

.meas tran vdout0_47ck920 FIND v(dout0_47) AT=465.025n

.meas tran vdout0_48ck920 FIND v(dout0_48) AT=465.025n

.meas tran vdout0_49ck920 FIND v(dout0_49) AT=465.025n

.meas tran vdout0_50ck920 FIND v(dout0_50) AT=465.025n

.meas tran vdout0_51ck920 FIND v(dout0_51) AT=465.025n

.meas tran vdout0_52ck920 FIND v(dout0_52) AT=465.025n

.meas tran vdout0_53ck920 FIND v(dout0_53) AT=465.025n

.meas tran vdout0_54ck920 FIND v(dout0_54) AT=465.025n

.meas tran vdout0_55ck920 FIND v(dout0_55) AT=465.025n

.meas tran vdout0_56ck920 FIND v(dout0_56) AT=465.025n

.meas tran vdout0_57ck920 FIND v(dout0_57) AT=465.025n

.meas tran vdout0_58ck920 FIND v(dout0_58) AT=465.025n

.meas tran vdout0_59ck920 FIND v(dout0_59) AT=465.025n

.meas tran vdout0_60ck920 FIND v(dout0_60) AT=465.025n

.meas tran vdout0_61ck920 FIND v(dout0_61) AT=465.025n

.meas tran vdout0_62ck920 FIND v(dout0_62) AT=465.025n

.meas tran vdout0_63ck920 FIND v(dout0_63) AT=465.025n

.meas tran vdout0_64ck920 FIND v(dout0_64) AT=465.025n

.meas tran vdout0_65ck920 FIND v(dout0_65) AT=465.025n

.meas tran vdout0_66ck920 FIND v(dout0_66) AT=465.025n

.meas tran vdout0_67ck920 FIND v(dout0_67) AT=465.025n

.meas tran vdout0_68ck920 FIND v(dout0_68) AT=465.025n

.meas tran vdout0_69ck920 FIND v(dout0_69) AT=465.025n

.meas tran vdout0_70ck920 FIND v(dout0_70) AT=465.025n

.meas tran vdout0_71ck920 FIND v(dout0_71) AT=465.025n

.meas tran vdout0_72ck920 FIND v(dout0_72) AT=465.025n

.meas tran vdout0_73ck920 FIND v(dout0_73) AT=465.025n

.meas tran vdout0_74ck920 FIND v(dout0_74) AT=465.025n

.meas tran vdout0_75ck920 FIND v(dout0_75) AT=465.025n

.meas tran vdout0_76ck920 FIND v(dout0_76) AT=465.025n

.meas tran vdout0_77ck920 FIND v(dout0_77) AT=465.025n

.meas tran vdout0_78ck920 FIND v(dout0_78) AT=465.025n

.meas tran vdout0_79ck920 FIND v(dout0_79) AT=465.025n

.meas tran vdout0_80ck920 FIND v(dout0_80) AT=465.025n

.meas tran vdout0_81ck920 FIND v(dout0_81) AT=465.025n

.meas tran vdout0_82ck920 FIND v(dout0_82) AT=465.025n

.meas tran vdout0_83ck920 FIND v(dout0_83) AT=465.025n

.meas tran vdout0_84ck920 FIND v(dout0_84) AT=465.025n

.meas tran vdout0_85ck920 FIND v(dout0_85) AT=465.025n

.meas tran vdout0_86ck920 FIND v(dout0_86) AT=465.025n

.meas tran vdout0_87ck920 FIND v(dout0_87) AT=465.025n

.meas tran vdout0_88ck920 FIND v(dout0_88) AT=465.025n

.meas tran vdout0_89ck920 FIND v(dout0_89) AT=465.025n

.meas tran vdout0_90ck920 FIND v(dout0_90) AT=465.025n

.meas tran vdout0_91ck920 FIND v(dout0_91) AT=465.025n

.meas tran vdout0_92ck920 FIND v(dout0_92) AT=465.025n

.meas tran vdout0_93ck920 FIND v(dout0_93) AT=465.025n

.meas tran vdout0_94ck920 FIND v(dout0_94) AT=465.025n

.meas tran vdout0_95ck920 FIND v(dout0_95) AT=465.025n

.meas tran vdout0_96ck920 FIND v(dout0_96) AT=465.025n

.meas tran vdout0_97ck920 FIND v(dout0_97) AT=465.025n

.meas tran vdout0_98ck920 FIND v(dout0_98) AT=465.025n

.meas tran vdout0_99ck920 FIND v(dout0_99) AT=465.025n

.meas tran vdout0_100ck920 FIND v(dout0_100) AT=465.025n

.meas tran vdout0_101ck920 FIND v(dout0_101) AT=465.025n

.meas tran vdout0_102ck920 FIND v(dout0_102) AT=465.025n

.meas tran vdout0_103ck920 FIND v(dout0_103) AT=465.025n

.meas tran vdout0_104ck920 FIND v(dout0_104) AT=465.025n

.meas tran vdout0_105ck920 FIND v(dout0_105) AT=465.025n

.meas tran vdout0_106ck920 FIND v(dout0_106) AT=465.025n

.meas tran vdout0_107ck920 FIND v(dout0_107) AT=465.025n

.meas tran vdout0_108ck920 FIND v(dout0_108) AT=465.025n

.meas tran vdout0_109ck920 FIND v(dout0_109) AT=465.025n

.meas tran vdout0_110ck920 FIND v(dout0_110) AT=465.025n

.meas tran vdout0_111ck920 FIND v(dout0_111) AT=465.025n

.meas tran vdout0_112ck920 FIND v(dout0_112) AT=465.025n

.meas tran vdout0_113ck920 FIND v(dout0_113) AT=465.025n

.meas tran vdout0_114ck920 FIND v(dout0_114) AT=465.025n

.meas tran vdout0_115ck920 FIND v(dout0_115) AT=465.025n

.meas tran vdout0_116ck920 FIND v(dout0_116) AT=465.025n

.meas tran vdout0_117ck920 FIND v(dout0_117) AT=465.025n

.meas tran vdout0_118ck920 FIND v(dout0_118) AT=465.025n

.meas tran vdout0_119ck920 FIND v(dout0_119) AT=465.025n

.meas tran vdout0_120ck920 FIND v(dout0_120) AT=465.025n

.meas tran vdout0_121ck920 FIND v(dout0_121) AT=465.025n

.meas tran vdout0_122ck920 FIND v(dout0_122) AT=465.025n

.meas tran vdout0_123ck920 FIND v(dout0_123) AT=465.025n

.meas tran vdout0_124ck920 FIND v(dout0_124) AT=465.025n

.meas tran vdout0_125ck920 FIND v(dout0_125) AT=465.025n

.meas tran vdout0_126ck920 FIND v(dout0_126) AT=465.025n

.meas tran vdout0_127ck920 FIND v(dout0_127) AT=465.025n

.meas tran vdout0_128ck920 FIND v(dout0_128) AT=465.025n

.meas tran vdout0_129ck920 FIND v(dout0_129) AT=465.025n

.meas tran vdout0_130ck920 FIND v(dout0_130) AT=465.025n

.meas tran vdout0_131ck920 FIND v(dout0_131) AT=465.025n

.meas tran vdout0_132ck920 FIND v(dout0_132) AT=465.025n

.meas tran vdout0_133ck920 FIND v(dout0_133) AT=465.025n

.meas tran vdout0_134ck920 FIND v(dout0_134) AT=465.025n

.meas tran vdout0_135ck920 FIND v(dout0_135) AT=465.025n

.meas tran vdout0_136ck920 FIND v(dout0_136) AT=465.025n

.meas tran vdout0_137ck920 FIND v(dout0_137) AT=465.025n

.meas tran vdout0_138ck920 FIND v(dout0_138) AT=465.025n

.meas tran vdout0_139ck920 FIND v(dout0_139) AT=465.025n

.meas tran vdout0_140ck920 FIND v(dout0_140) AT=465.025n

.meas tran vdout0_141ck920 FIND v(dout0_141) AT=465.025n

.meas tran vdout0_142ck920 FIND v(dout0_142) AT=465.025n

.meas tran vdout0_143ck920 FIND v(dout0_143) AT=465.025n

.meas tran vdout0_144ck920 FIND v(dout0_144) AT=465.025n

.meas tran vdout0_145ck920 FIND v(dout0_145) AT=465.025n

.meas tran vdout0_146ck920 FIND v(dout0_146) AT=465.025n

.meas tran vdout0_147ck920 FIND v(dout0_147) AT=465.025n

.meas tran vdout0_148ck920 FIND v(dout0_148) AT=465.025n

.meas tran vdout0_149ck920 FIND v(dout0_149) AT=465.025n

.meas tran vdout0_150ck920 FIND v(dout0_150) AT=465.025n

.meas tran vdout0_151ck920 FIND v(dout0_151) AT=465.025n

.meas tran vdout0_152ck920 FIND v(dout0_152) AT=465.025n

.meas tran vdout0_153ck920 FIND v(dout0_153) AT=465.025n

.meas tran vdout0_154ck920 FIND v(dout0_154) AT=465.025n

.meas tran vdout0_155ck920 FIND v(dout0_155) AT=465.025n

.meas tran vdout0_156ck920 FIND v(dout0_156) AT=465.025n

.meas tran vdout0_157ck920 FIND v(dout0_157) AT=465.025n

.meas tran vdout0_158ck920 FIND v(dout0_158) AT=465.025n

.meas tran vdout0_159ck920 FIND v(dout0_159) AT=465.025n

.meas tran vdout0_160ck920 FIND v(dout0_160) AT=465.025n

.meas tran vdout0_161ck920 FIND v(dout0_161) AT=465.025n

.meas tran vdout0_162ck920 FIND v(dout0_162) AT=465.025n

.meas tran vdout0_163ck920 FIND v(dout0_163) AT=465.025n

.meas tran vdout0_164ck920 FIND v(dout0_164) AT=465.025n

.meas tran vdout0_165ck920 FIND v(dout0_165) AT=465.025n

.meas tran vdout0_166ck920 FIND v(dout0_166) AT=465.025n

.meas tran vdout0_167ck920 FIND v(dout0_167) AT=465.025n

.meas tran vdout0_168ck920 FIND v(dout0_168) AT=465.025n

.meas tran vdout0_169ck920 FIND v(dout0_169) AT=465.025n

.meas tran vdout0_170ck920 FIND v(dout0_170) AT=465.025n

.meas tran vdout0_171ck920 FIND v(dout0_171) AT=465.025n

.meas tran vdout0_172ck920 FIND v(dout0_172) AT=465.025n

.meas tran vdout0_173ck920 FIND v(dout0_173) AT=465.025n

.meas tran vdout0_174ck920 FIND v(dout0_174) AT=465.025n

.meas tran vdout0_175ck920 FIND v(dout0_175) AT=465.025n

.meas tran vdout0_176ck920 FIND v(dout0_176) AT=465.025n

.meas tran vdout0_177ck920 FIND v(dout0_177) AT=465.025n

.meas tran vdout0_178ck920 FIND v(dout0_178) AT=465.025n

.meas tran vdout0_179ck920 FIND v(dout0_179) AT=465.025n

.meas tran vdout0_180ck920 FIND v(dout0_180) AT=465.025n

.meas tran vdout0_181ck920 FIND v(dout0_181) AT=465.025n

.meas tran vdout0_182ck920 FIND v(dout0_182) AT=465.025n

.meas tran vdout0_183ck920 FIND v(dout0_183) AT=465.025n

.meas tran vdout0_184ck920 FIND v(dout0_184) AT=465.025n

.meas tran vdout0_185ck920 FIND v(dout0_185) AT=465.025n

.meas tran vdout0_186ck920 FIND v(dout0_186) AT=465.025n

.meas tran vdout0_187ck920 FIND v(dout0_187) AT=465.025n

.meas tran vdout0_188ck920 FIND v(dout0_188) AT=465.025n

.meas tran vdout0_189ck920 FIND v(dout0_189) AT=465.025n

.meas tran vdout0_190ck920 FIND v(dout0_190) AT=465.025n

.meas tran vdout0_191ck920 FIND v(dout0_191) AT=465.025n

.meas tran vdout0_192ck920 FIND v(dout0_192) AT=465.025n

.meas tran vdout0_193ck920 FIND v(dout0_193) AT=465.025n

.meas tran vdout0_194ck920 FIND v(dout0_194) AT=465.025n

.meas tran vdout0_195ck920 FIND v(dout0_195) AT=465.025n

.meas tran vdout0_196ck920 FIND v(dout0_196) AT=465.025n

.meas tran vdout0_197ck920 FIND v(dout0_197) AT=465.025n

.meas tran vdout0_198ck920 FIND v(dout0_198) AT=465.025n

.meas tran vdout0_199ck920 FIND v(dout0_199) AT=465.025n

.meas tran vdout0_200ck920 FIND v(dout0_200) AT=465.025n

.meas tran vdout0_201ck920 FIND v(dout0_201) AT=465.025n

.meas tran vdout0_202ck920 FIND v(dout0_202) AT=465.025n

.meas tran vdout0_203ck920 FIND v(dout0_203) AT=465.025n

.meas tran vdout0_204ck920 FIND v(dout0_204) AT=465.025n

.meas tran vdout0_205ck920 FIND v(dout0_205) AT=465.025n

.meas tran vdout0_206ck920 FIND v(dout0_206) AT=465.025n

.meas tran vdout0_207ck920 FIND v(dout0_207) AT=465.025n

.meas tran vdout0_208ck920 FIND v(dout0_208) AT=465.025n

.meas tran vdout0_209ck920 FIND v(dout0_209) AT=465.025n

.meas tran vdout0_210ck920 FIND v(dout0_210) AT=465.025n

.meas tran vdout0_211ck920 FIND v(dout0_211) AT=465.025n

.meas tran vdout0_212ck920 FIND v(dout0_212) AT=465.025n

.meas tran vdout0_213ck920 FIND v(dout0_213) AT=465.025n

.meas tran vdout0_214ck920 FIND v(dout0_214) AT=465.025n

.meas tran vdout0_215ck920 FIND v(dout0_215) AT=465.025n

.meas tran vdout0_216ck920 FIND v(dout0_216) AT=465.025n

.meas tran vdout0_217ck920 FIND v(dout0_217) AT=465.025n

.meas tran vdout0_218ck920 FIND v(dout0_218) AT=465.025n

.meas tran vdout0_219ck920 FIND v(dout0_219) AT=465.025n

.meas tran vdout0_220ck920 FIND v(dout0_220) AT=465.025n

.meas tran vdout0_221ck920 FIND v(dout0_221) AT=465.025n

.meas tran vdout0_222ck920 FIND v(dout0_222) AT=465.025n

.meas tran vdout0_223ck920 FIND v(dout0_223) AT=465.025n

.meas tran vdout0_224ck920 FIND v(dout0_224) AT=465.025n

.meas tran vdout0_225ck920 FIND v(dout0_225) AT=465.025n

.meas tran vdout0_226ck920 FIND v(dout0_226) AT=465.025n

.meas tran vdout0_227ck920 FIND v(dout0_227) AT=465.025n

.meas tran vdout0_228ck920 FIND v(dout0_228) AT=465.025n

.meas tran vdout0_229ck920 FIND v(dout0_229) AT=465.025n

.meas tran vdout0_230ck920 FIND v(dout0_230) AT=465.025n

.meas tran vdout0_231ck920 FIND v(dout0_231) AT=465.025n

.meas tran vdout0_232ck920 FIND v(dout0_232) AT=465.025n

.meas tran vdout0_233ck920 FIND v(dout0_233) AT=465.025n

.meas tran vdout0_234ck920 FIND v(dout0_234) AT=465.025n

.meas tran vdout0_235ck920 FIND v(dout0_235) AT=465.025n

.meas tran vdout0_236ck920 FIND v(dout0_236) AT=465.025n

.meas tran vdout0_237ck920 FIND v(dout0_237) AT=465.025n

.meas tran vdout0_238ck920 FIND v(dout0_238) AT=465.025n

.meas tran vdout0_239ck920 FIND v(dout0_239) AT=465.025n

.meas tran vdout0_240ck920 FIND v(dout0_240) AT=465.025n

.meas tran vdout0_241ck920 FIND v(dout0_241) AT=465.025n

.meas tran vdout0_242ck920 FIND v(dout0_242) AT=465.025n

.meas tran vdout0_243ck920 FIND v(dout0_243) AT=465.025n

.meas tran vdout0_244ck920 FIND v(dout0_244) AT=465.025n

.meas tran vdout0_245ck920 FIND v(dout0_245) AT=465.025n

.meas tran vdout0_246ck920 FIND v(dout0_246) AT=465.025n

.meas tran vdout0_247ck920 FIND v(dout0_247) AT=465.025n

.meas tran vdout0_248ck920 FIND v(dout0_248) AT=465.025n

.meas tran vdout0_249ck920 FIND v(dout0_249) AT=465.025n

.meas tran vdout0_250ck920 FIND v(dout0_250) AT=465.025n

.meas tran vdout0_251ck920 FIND v(dout0_251) AT=465.025n

.meas tran vdout0_252ck920 FIND v(dout0_252) AT=465.025n

.meas tran vdout0_253ck920 FIND v(dout0_253) AT=465.025n

.meas tran vdout0_254ck920 FIND v(dout0_254) AT=465.025n

.meas tran vdout0_255ck920 FIND v(dout0_255) AT=465.025n

.meas tran vdout0_0ck940 FIND v(dout0_0) AT=475.025n

.meas tran vdout0_1ck940 FIND v(dout0_1) AT=475.025n

.meas tran vdout0_2ck940 FIND v(dout0_2) AT=475.025n

.meas tran vdout0_3ck940 FIND v(dout0_3) AT=475.025n

.meas tran vdout0_4ck940 FIND v(dout0_4) AT=475.025n

.meas tran vdout0_5ck940 FIND v(dout0_5) AT=475.025n

.meas tran vdout0_6ck940 FIND v(dout0_6) AT=475.025n

.meas tran vdout0_7ck940 FIND v(dout0_7) AT=475.025n

.meas tran vdout0_8ck940 FIND v(dout0_8) AT=475.025n

.meas tran vdout0_9ck940 FIND v(dout0_9) AT=475.025n

.meas tran vdout0_10ck940 FIND v(dout0_10) AT=475.025n

.meas tran vdout0_11ck940 FIND v(dout0_11) AT=475.025n

.meas tran vdout0_12ck940 FIND v(dout0_12) AT=475.025n

.meas tran vdout0_13ck940 FIND v(dout0_13) AT=475.025n

.meas tran vdout0_14ck940 FIND v(dout0_14) AT=475.025n

.meas tran vdout0_15ck940 FIND v(dout0_15) AT=475.025n

.meas tran vdout0_16ck940 FIND v(dout0_16) AT=475.025n

.meas tran vdout0_17ck940 FIND v(dout0_17) AT=475.025n

.meas tran vdout0_18ck940 FIND v(dout0_18) AT=475.025n

.meas tran vdout0_19ck940 FIND v(dout0_19) AT=475.025n

.meas tran vdout0_20ck940 FIND v(dout0_20) AT=475.025n

.meas tran vdout0_21ck940 FIND v(dout0_21) AT=475.025n

.meas tran vdout0_22ck940 FIND v(dout0_22) AT=475.025n

.meas tran vdout0_23ck940 FIND v(dout0_23) AT=475.025n

.meas tran vdout0_24ck940 FIND v(dout0_24) AT=475.025n

.meas tran vdout0_25ck940 FIND v(dout0_25) AT=475.025n

.meas tran vdout0_26ck940 FIND v(dout0_26) AT=475.025n

.meas tran vdout0_27ck940 FIND v(dout0_27) AT=475.025n

.meas tran vdout0_28ck940 FIND v(dout0_28) AT=475.025n

.meas tran vdout0_29ck940 FIND v(dout0_29) AT=475.025n

.meas tran vdout0_30ck940 FIND v(dout0_30) AT=475.025n

.meas tran vdout0_31ck940 FIND v(dout0_31) AT=475.025n

.meas tran vdout0_32ck940 FIND v(dout0_32) AT=475.025n

.meas tran vdout0_33ck940 FIND v(dout0_33) AT=475.025n

.meas tran vdout0_34ck940 FIND v(dout0_34) AT=475.025n

.meas tran vdout0_35ck940 FIND v(dout0_35) AT=475.025n

.meas tran vdout0_36ck940 FIND v(dout0_36) AT=475.025n

.meas tran vdout0_37ck940 FIND v(dout0_37) AT=475.025n

.meas tran vdout0_38ck940 FIND v(dout0_38) AT=475.025n

.meas tran vdout0_39ck940 FIND v(dout0_39) AT=475.025n

.meas tran vdout0_40ck940 FIND v(dout0_40) AT=475.025n

.meas tran vdout0_41ck940 FIND v(dout0_41) AT=475.025n

.meas tran vdout0_42ck940 FIND v(dout0_42) AT=475.025n

.meas tran vdout0_43ck940 FIND v(dout0_43) AT=475.025n

.meas tran vdout0_44ck940 FIND v(dout0_44) AT=475.025n

.meas tran vdout0_45ck940 FIND v(dout0_45) AT=475.025n

.meas tran vdout0_46ck940 FIND v(dout0_46) AT=475.025n

.meas tran vdout0_47ck940 FIND v(dout0_47) AT=475.025n

.meas tran vdout0_48ck940 FIND v(dout0_48) AT=475.025n

.meas tran vdout0_49ck940 FIND v(dout0_49) AT=475.025n

.meas tran vdout0_50ck940 FIND v(dout0_50) AT=475.025n

.meas tran vdout0_51ck940 FIND v(dout0_51) AT=475.025n

.meas tran vdout0_52ck940 FIND v(dout0_52) AT=475.025n

.meas tran vdout0_53ck940 FIND v(dout0_53) AT=475.025n

.meas tran vdout0_54ck940 FIND v(dout0_54) AT=475.025n

.meas tran vdout0_55ck940 FIND v(dout0_55) AT=475.025n

.meas tran vdout0_56ck940 FIND v(dout0_56) AT=475.025n

.meas tran vdout0_57ck940 FIND v(dout0_57) AT=475.025n

.meas tran vdout0_58ck940 FIND v(dout0_58) AT=475.025n

.meas tran vdout0_59ck940 FIND v(dout0_59) AT=475.025n

.meas tran vdout0_60ck940 FIND v(dout0_60) AT=475.025n

.meas tran vdout0_61ck940 FIND v(dout0_61) AT=475.025n

.meas tran vdout0_62ck940 FIND v(dout0_62) AT=475.025n

.meas tran vdout0_63ck940 FIND v(dout0_63) AT=475.025n

.meas tran vdout0_64ck940 FIND v(dout0_64) AT=475.025n

.meas tran vdout0_65ck940 FIND v(dout0_65) AT=475.025n

.meas tran vdout0_66ck940 FIND v(dout0_66) AT=475.025n

.meas tran vdout0_67ck940 FIND v(dout0_67) AT=475.025n

.meas tran vdout0_68ck940 FIND v(dout0_68) AT=475.025n

.meas tran vdout0_69ck940 FIND v(dout0_69) AT=475.025n

.meas tran vdout0_70ck940 FIND v(dout0_70) AT=475.025n

.meas tran vdout0_71ck940 FIND v(dout0_71) AT=475.025n

.meas tran vdout0_72ck940 FIND v(dout0_72) AT=475.025n

.meas tran vdout0_73ck940 FIND v(dout0_73) AT=475.025n

.meas tran vdout0_74ck940 FIND v(dout0_74) AT=475.025n

.meas tran vdout0_75ck940 FIND v(dout0_75) AT=475.025n

.meas tran vdout0_76ck940 FIND v(dout0_76) AT=475.025n

.meas tran vdout0_77ck940 FIND v(dout0_77) AT=475.025n

.meas tran vdout0_78ck940 FIND v(dout0_78) AT=475.025n

.meas tran vdout0_79ck940 FIND v(dout0_79) AT=475.025n

.meas tran vdout0_80ck940 FIND v(dout0_80) AT=475.025n

.meas tran vdout0_81ck940 FIND v(dout0_81) AT=475.025n

.meas tran vdout0_82ck940 FIND v(dout0_82) AT=475.025n

.meas tran vdout0_83ck940 FIND v(dout0_83) AT=475.025n

.meas tran vdout0_84ck940 FIND v(dout0_84) AT=475.025n

.meas tran vdout0_85ck940 FIND v(dout0_85) AT=475.025n

.meas tran vdout0_86ck940 FIND v(dout0_86) AT=475.025n

.meas tran vdout0_87ck940 FIND v(dout0_87) AT=475.025n

.meas tran vdout0_88ck940 FIND v(dout0_88) AT=475.025n

.meas tran vdout0_89ck940 FIND v(dout0_89) AT=475.025n

.meas tran vdout0_90ck940 FIND v(dout0_90) AT=475.025n

.meas tran vdout0_91ck940 FIND v(dout0_91) AT=475.025n

.meas tran vdout0_92ck940 FIND v(dout0_92) AT=475.025n

.meas tran vdout0_93ck940 FIND v(dout0_93) AT=475.025n

.meas tran vdout0_94ck940 FIND v(dout0_94) AT=475.025n

.meas tran vdout0_95ck940 FIND v(dout0_95) AT=475.025n

.meas tran vdout0_96ck940 FIND v(dout0_96) AT=475.025n

.meas tran vdout0_97ck940 FIND v(dout0_97) AT=475.025n

.meas tran vdout0_98ck940 FIND v(dout0_98) AT=475.025n

.meas tran vdout0_99ck940 FIND v(dout0_99) AT=475.025n

.meas tran vdout0_100ck940 FIND v(dout0_100) AT=475.025n

.meas tran vdout0_101ck940 FIND v(dout0_101) AT=475.025n

.meas tran vdout0_102ck940 FIND v(dout0_102) AT=475.025n

.meas tran vdout0_103ck940 FIND v(dout0_103) AT=475.025n

.meas tran vdout0_104ck940 FIND v(dout0_104) AT=475.025n

.meas tran vdout0_105ck940 FIND v(dout0_105) AT=475.025n

.meas tran vdout0_106ck940 FIND v(dout0_106) AT=475.025n

.meas tran vdout0_107ck940 FIND v(dout0_107) AT=475.025n

.meas tran vdout0_108ck940 FIND v(dout0_108) AT=475.025n

.meas tran vdout0_109ck940 FIND v(dout0_109) AT=475.025n

.meas tran vdout0_110ck940 FIND v(dout0_110) AT=475.025n

.meas tran vdout0_111ck940 FIND v(dout0_111) AT=475.025n

.meas tran vdout0_112ck940 FIND v(dout0_112) AT=475.025n

.meas tran vdout0_113ck940 FIND v(dout0_113) AT=475.025n

.meas tran vdout0_114ck940 FIND v(dout0_114) AT=475.025n

.meas tran vdout0_115ck940 FIND v(dout0_115) AT=475.025n

.meas tran vdout0_116ck940 FIND v(dout0_116) AT=475.025n

.meas tran vdout0_117ck940 FIND v(dout0_117) AT=475.025n

.meas tran vdout0_118ck940 FIND v(dout0_118) AT=475.025n

.meas tran vdout0_119ck940 FIND v(dout0_119) AT=475.025n

.meas tran vdout0_120ck940 FIND v(dout0_120) AT=475.025n

.meas tran vdout0_121ck940 FIND v(dout0_121) AT=475.025n

.meas tran vdout0_122ck940 FIND v(dout0_122) AT=475.025n

.meas tran vdout0_123ck940 FIND v(dout0_123) AT=475.025n

.meas tran vdout0_124ck940 FIND v(dout0_124) AT=475.025n

.meas tran vdout0_125ck940 FIND v(dout0_125) AT=475.025n

.meas tran vdout0_126ck940 FIND v(dout0_126) AT=475.025n

.meas tran vdout0_127ck940 FIND v(dout0_127) AT=475.025n

.meas tran vdout0_128ck940 FIND v(dout0_128) AT=475.025n

.meas tran vdout0_129ck940 FIND v(dout0_129) AT=475.025n

.meas tran vdout0_130ck940 FIND v(dout0_130) AT=475.025n

.meas tran vdout0_131ck940 FIND v(dout0_131) AT=475.025n

.meas tran vdout0_132ck940 FIND v(dout0_132) AT=475.025n

.meas tran vdout0_133ck940 FIND v(dout0_133) AT=475.025n

.meas tran vdout0_134ck940 FIND v(dout0_134) AT=475.025n

.meas tran vdout0_135ck940 FIND v(dout0_135) AT=475.025n

.meas tran vdout0_136ck940 FIND v(dout0_136) AT=475.025n

.meas tran vdout0_137ck940 FIND v(dout0_137) AT=475.025n

.meas tran vdout0_138ck940 FIND v(dout0_138) AT=475.025n

.meas tran vdout0_139ck940 FIND v(dout0_139) AT=475.025n

.meas tran vdout0_140ck940 FIND v(dout0_140) AT=475.025n

.meas tran vdout0_141ck940 FIND v(dout0_141) AT=475.025n

.meas tran vdout0_142ck940 FIND v(dout0_142) AT=475.025n

.meas tran vdout0_143ck940 FIND v(dout0_143) AT=475.025n

.meas tran vdout0_144ck940 FIND v(dout0_144) AT=475.025n

.meas tran vdout0_145ck940 FIND v(dout0_145) AT=475.025n

.meas tran vdout0_146ck940 FIND v(dout0_146) AT=475.025n

.meas tran vdout0_147ck940 FIND v(dout0_147) AT=475.025n

.meas tran vdout0_148ck940 FIND v(dout0_148) AT=475.025n

.meas tran vdout0_149ck940 FIND v(dout0_149) AT=475.025n

.meas tran vdout0_150ck940 FIND v(dout0_150) AT=475.025n

.meas tran vdout0_151ck940 FIND v(dout0_151) AT=475.025n

.meas tran vdout0_152ck940 FIND v(dout0_152) AT=475.025n

.meas tran vdout0_153ck940 FIND v(dout0_153) AT=475.025n

.meas tran vdout0_154ck940 FIND v(dout0_154) AT=475.025n

.meas tran vdout0_155ck940 FIND v(dout0_155) AT=475.025n

.meas tran vdout0_156ck940 FIND v(dout0_156) AT=475.025n

.meas tran vdout0_157ck940 FIND v(dout0_157) AT=475.025n

.meas tran vdout0_158ck940 FIND v(dout0_158) AT=475.025n

.meas tran vdout0_159ck940 FIND v(dout0_159) AT=475.025n

.meas tran vdout0_160ck940 FIND v(dout0_160) AT=475.025n

.meas tran vdout0_161ck940 FIND v(dout0_161) AT=475.025n

.meas tran vdout0_162ck940 FIND v(dout0_162) AT=475.025n

.meas tran vdout0_163ck940 FIND v(dout0_163) AT=475.025n

.meas tran vdout0_164ck940 FIND v(dout0_164) AT=475.025n

.meas tran vdout0_165ck940 FIND v(dout0_165) AT=475.025n

.meas tran vdout0_166ck940 FIND v(dout0_166) AT=475.025n

.meas tran vdout0_167ck940 FIND v(dout0_167) AT=475.025n

.meas tran vdout0_168ck940 FIND v(dout0_168) AT=475.025n

.meas tran vdout0_169ck940 FIND v(dout0_169) AT=475.025n

.meas tran vdout0_170ck940 FIND v(dout0_170) AT=475.025n

.meas tran vdout0_171ck940 FIND v(dout0_171) AT=475.025n

.meas tran vdout0_172ck940 FIND v(dout0_172) AT=475.025n

.meas tran vdout0_173ck940 FIND v(dout0_173) AT=475.025n

.meas tran vdout0_174ck940 FIND v(dout0_174) AT=475.025n

.meas tran vdout0_175ck940 FIND v(dout0_175) AT=475.025n

.meas tran vdout0_176ck940 FIND v(dout0_176) AT=475.025n

.meas tran vdout0_177ck940 FIND v(dout0_177) AT=475.025n

.meas tran vdout0_178ck940 FIND v(dout0_178) AT=475.025n

.meas tran vdout0_179ck940 FIND v(dout0_179) AT=475.025n

.meas tran vdout0_180ck940 FIND v(dout0_180) AT=475.025n

.meas tran vdout0_181ck940 FIND v(dout0_181) AT=475.025n

.meas tran vdout0_182ck940 FIND v(dout0_182) AT=475.025n

.meas tran vdout0_183ck940 FIND v(dout0_183) AT=475.025n

.meas tran vdout0_184ck940 FIND v(dout0_184) AT=475.025n

.meas tran vdout0_185ck940 FIND v(dout0_185) AT=475.025n

.meas tran vdout0_186ck940 FIND v(dout0_186) AT=475.025n

.meas tran vdout0_187ck940 FIND v(dout0_187) AT=475.025n

.meas tran vdout0_188ck940 FIND v(dout0_188) AT=475.025n

.meas tran vdout0_189ck940 FIND v(dout0_189) AT=475.025n

.meas tran vdout0_190ck940 FIND v(dout0_190) AT=475.025n

.meas tran vdout0_191ck940 FIND v(dout0_191) AT=475.025n

.meas tran vdout0_192ck940 FIND v(dout0_192) AT=475.025n

.meas tran vdout0_193ck940 FIND v(dout0_193) AT=475.025n

.meas tran vdout0_194ck940 FIND v(dout0_194) AT=475.025n

.meas tran vdout0_195ck940 FIND v(dout0_195) AT=475.025n

.meas tran vdout0_196ck940 FIND v(dout0_196) AT=475.025n

.meas tran vdout0_197ck940 FIND v(dout0_197) AT=475.025n

.meas tran vdout0_198ck940 FIND v(dout0_198) AT=475.025n

.meas tran vdout0_199ck940 FIND v(dout0_199) AT=475.025n

.meas tran vdout0_200ck940 FIND v(dout0_200) AT=475.025n

.meas tran vdout0_201ck940 FIND v(dout0_201) AT=475.025n

.meas tran vdout0_202ck940 FIND v(dout0_202) AT=475.025n

.meas tran vdout0_203ck940 FIND v(dout0_203) AT=475.025n

.meas tran vdout0_204ck940 FIND v(dout0_204) AT=475.025n

.meas tran vdout0_205ck940 FIND v(dout0_205) AT=475.025n

.meas tran vdout0_206ck940 FIND v(dout0_206) AT=475.025n

.meas tran vdout0_207ck940 FIND v(dout0_207) AT=475.025n

.meas tran vdout0_208ck940 FIND v(dout0_208) AT=475.025n

.meas tran vdout0_209ck940 FIND v(dout0_209) AT=475.025n

.meas tran vdout0_210ck940 FIND v(dout0_210) AT=475.025n

.meas tran vdout0_211ck940 FIND v(dout0_211) AT=475.025n

.meas tran vdout0_212ck940 FIND v(dout0_212) AT=475.025n

.meas tran vdout0_213ck940 FIND v(dout0_213) AT=475.025n

.meas tran vdout0_214ck940 FIND v(dout0_214) AT=475.025n

.meas tran vdout0_215ck940 FIND v(dout0_215) AT=475.025n

.meas tran vdout0_216ck940 FIND v(dout0_216) AT=475.025n

.meas tran vdout0_217ck940 FIND v(dout0_217) AT=475.025n

.meas tran vdout0_218ck940 FIND v(dout0_218) AT=475.025n

.meas tran vdout0_219ck940 FIND v(dout0_219) AT=475.025n

.meas tran vdout0_220ck940 FIND v(dout0_220) AT=475.025n

.meas tran vdout0_221ck940 FIND v(dout0_221) AT=475.025n

.meas tran vdout0_222ck940 FIND v(dout0_222) AT=475.025n

.meas tran vdout0_223ck940 FIND v(dout0_223) AT=475.025n

.meas tran vdout0_224ck940 FIND v(dout0_224) AT=475.025n

.meas tran vdout0_225ck940 FIND v(dout0_225) AT=475.025n

.meas tran vdout0_226ck940 FIND v(dout0_226) AT=475.025n

.meas tran vdout0_227ck940 FIND v(dout0_227) AT=475.025n

.meas tran vdout0_228ck940 FIND v(dout0_228) AT=475.025n

.meas tran vdout0_229ck940 FIND v(dout0_229) AT=475.025n

.meas tran vdout0_230ck940 FIND v(dout0_230) AT=475.025n

.meas tran vdout0_231ck940 FIND v(dout0_231) AT=475.025n

.meas tran vdout0_232ck940 FIND v(dout0_232) AT=475.025n

.meas tran vdout0_233ck940 FIND v(dout0_233) AT=475.025n

.meas tran vdout0_234ck940 FIND v(dout0_234) AT=475.025n

.meas tran vdout0_235ck940 FIND v(dout0_235) AT=475.025n

.meas tran vdout0_236ck940 FIND v(dout0_236) AT=475.025n

.meas tran vdout0_237ck940 FIND v(dout0_237) AT=475.025n

.meas tran vdout0_238ck940 FIND v(dout0_238) AT=475.025n

.meas tran vdout0_239ck940 FIND v(dout0_239) AT=475.025n

.meas tran vdout0_240ck940 FIND v(dout0_240) AT=475.025n

.meas tran vdout0_241ck940 FIND v(dout0_241) AT=475.025n

.meas tran vdout0_242ck940 FIND v(dout0_242) AT=475.025n

.meas tran vdout0_243ck940 FIND v(dout0_243) AT=475.025n

.meas tran vdout0_244ck940 FIND v(dout0_244) AT=475.025n

.meas tran vdout0_245ck940 FIND v(dout0_245) AT=475.025n

.meas tran vdout0_246ck940 FIND v(dout0_246) AT=475.025n

.meas tran vdout0_247ck940 FIND v(dout0_247) AT=475.025n

.meas tran vdout0_248ck940 FIND v(dout0_248) AT=475.025n

.meas tran vdout0_249ck940 FIND v(dout0_249) AT=475.025n

.meas tran vdout0_250ck940 FIND v(dout0_250) AT=475.025n

.meas tran vdout0_251ck940 FIND v(dout0_251) AT=475.025n

.meas tran vdout0_252ck940 FIND v(dout0_252) AT=475.025n

.meas tran vdout0_253ck940 FIND v(dout0_253) AT=475.025n

.meas tran vdout0_254ck940 FIND v(dout0_254) AT=475.025n

.meas tran vdout0_255ck940 FIND v(dout0_255) AT=475.025n

.meas tran vdout0_0ck950 FIND v(dout0_0) AT=480.025n

.meas tran vdout0_1ck950 FIND v(dout0_1) AT=480.025n

.meas tran vdout0_2ck950 FIND v(dout0_2) AT=480.025n

.meas tran vdout0_3ck950 FIND v(dout0_3) AT=480.025n

.meas tran vdout0_4ck950 FIND v(dout0_4) AT=480.025n

.meas tran vdout0_5ck950 FIND v(dout0_5) AT=480.025n

.meas tran vdout0_6ck950 FIND v(dout0_6) AT=480.025n

.meas tran vdout0_7ck950 FIND v(dout0_7) AT=480.025n

.meas tran vdout0_8ck950 FIND v(dout0_8) AT=480.025n

.meas tran vdout0_9ck950 FIND v(dout0_9) AT=480.025n

.meas tran vdout0_10ck950 FIND v(dout0_10) AT=480.025n

.meas tran vdout0_11ck950 FIND v(dout0_11) AT=480.025n

.meas tran vdout0_12ck950 FIND v(dout0_12) AT=480.025n

.meas tran vdout0_13ck950 FIND v(dout0_13) AT=480.025n

.meas tran vdout0_14ck950 FIND v(dout0_14) AT=480.025n

.meas tran vdout0_15ck950 FIND v(dout0_15) AT=480.025n

.meas tran vdout0_16ck950 FIND v(dout0_16) AT=480.025n

.meas tran vdout0_17ck950 FIND v(dout0_17) AT=480.025n

.meas tran vdout0_18ck950 FIND v(dout0_18) AT=480.025n

.meas tran vdout0_19ck950 FIND v(dout0_19) AT=480.025n

.meas tran vdout0_20ck950 FIND v(dout0_20) AT=480.025n

.meas tran vdout0_21ck950 FIND v(dout0_21) AT=480.025n

.meas tran vdout0_22ck950 FIND v(dout0_22) AT=480.025n

.meas tran vdout0_23ck950 FIND v(dout0_23) AT=480.025n

.meas tran vdout0_24ck950 FIND v(dout0_24) AT=480.025n

.meas tran vdout0_25ck950 FIND v(dout0_25) AT=480.025n

.meas tran vdout0_26ck950 FIND v(dout0_26) AT=480.025n

.meas tran vdout0_27ck950 FIND v(dout0_27) AT=480.025n

.meas tran vdout0_28ck950 FIND v(dout0_28) AT=480.025n

.meas tran vdout0_29ck950 FIND v(dout0_29) AT=480.025n

.meas tran vdout0_30ck950 FIND v(dout0_30) AT=480.025n

.meas tran vdout0_31ck950 FIND v(dout0_31) AT=480.025n

.meas tran vdout0_32ck950 FIND v(dout0_32) AT=480.025n

.meas tran vdout0_33ck950 FIND v(dout0_33) AT=480.025n

.meas tran vdout0_34ck950 FIND v(dout0_34) AT=480.025n

.meas tran vdout0_35ck950 FIND v(dout0_35) AT=480.025n

.meas tran vdout0_36ck950 FIND v(dout0_36) AT=480.025n

.meas tran vdout0_37ck950 FIND v(dout0_37) AT=480.025n

.meas tran vdout0_38ck950 FIND v(dout0_38) AT=480.025n

.meas tran vdout0_39ck950 FIND v(dout0_39) AT=480.025n

.meas tran vdout0_40ck950 FIND v(dout0_40) AT=480.025n

.meas tran vdout0_41ck950 FIND v(dout0_41) AT=480.025n

.meas tran vdout0_42ck950 FIND v(dout0_42) AT=480.025n

.meas tran vdout0_43ck950 FIND v(dout0_43) AT=480.025n

.meas tran vdout0_44ck950 FIND v(dout0_44) AT=480.025n

.meas tran vdout0_45ck950 FIND v(dout0_45) AT=480.025n

.meas tran vdout0_46ck950 FIND v(dout0_46) AT=480.025n

.meas tran vdout0_47ck950 FIND v(dout0_47) AT=480.025n

.meas tran vdout0_48ck950 FIND v(dout0_48) AT=480.025n

.meas tran vdout0_49ck950 FIND v(dout0_49) AT=480.025n

.meas tran vdout0_50ck950 FIND v(dout0_50) AT=480.025n

.meas tran vdout0_51ck950 FIND v(dout0_51) AT=480.025n

.meas tran vdout0_52ck950 FIND v(dout0_52) AT=480.025n

.meas tran vdout0_53ck950 FIND v(dout0_53) AT=480.025n

.meas tran vdout0_54ck950 FIND v(dout0_54) AT=480.025n

.meas tran vdout0_55ck950 FIND v(dout0_55) AT=480.025n

.meas tran vdout0_56ck950 FIND v(dout0_56) AT=480.025n

.meas tran vdout0_57ck950 FIND v(dout0_57) AT=480.025n

.meas tran vdout0_58ck950 FIND v(dout0_58) AT=480.025n

.meas tran vdout0_59ck950 FIND v(dout0_59) AT=480.025n

.meas tran vdout0_60ck950 FIND v(dout0_60) AT=480.025n

.meas tran vdout0_61ck950 FIND v(dout0_61) AT=480.025n

.meas tran vdout0_62ck950 FIND v(dout0_62) AT=480.025n

.meas tran vdout0_63ck950 FIND v(dout0_63) AT=480.025n

.meas tran vdout0_64ck950 FIND v(dout0_64) AT=480.025n

.meas tran vdout0_65ck950 FIND v(dout0_65) AT=480.025n

.meas tran vdout0_66ck950 FIND v(dout0_66) AT=480.025n

.meas tran vdout0_67ck950 FIND v(dout0_67) AT=480.025n

.meas tran vdout0_68ck950 FIND v(dout0_68) AT=480.025n

.meas tran vdout0_69ck950 FIND v(dout0_69) AT=480.025n

.meas tran vdout0_70ck950 FIND v(dout0_70) AT=480.025n

.meas tran vdout0_71ck950 FIND v(dout0_71) AT=480.025n

.meas tran vdout0_72ck950 FIND v(dout0_72) AT=480.025n

.meas tran vdout0_73ck950 FIND v(dout0_73) AT=480.025n

.meas tran vdout0_74ck950 FIND v(dout0_74) AT=480.025n

.meas tran vdout0_75ck950 FIND v(dout0_75) AT=480.025n

.meas tran vdout0_76ck950 FIND v(dout0_76) AT=480.025n

.meas tran vdout0_77ck950 FIND v(dout0_77) AT=480.025n

.meas tran vdout0_78ck950 FIND v(dout0_78) AT=480.025n

.meas tran vdout0_79ck950 FIND v(dout0_79) AT=480.025n

.meas tran vdout0_80ck950 FIND v(dout0_80) AT=480.025n

.meas tran vdout0_81ck950 FIND v(dout0_81) AT=480.025n

.meas tran vdout0_82ck950 FIND v(dout0_82) AT=480.025n

.meas tran vdout0_83ck950 FIND v(dout0_83) AT=480.025n

.meas tran vdout0_84ck950 FIND v(dout0_84) AT=480.025n

.meas tran vdout0_85ck950 FIND v(dout0_85) AT=480.025n

.meas tran vdout0_86ck950 FIND v(dout0_86) AT=480.025n

.meas tran vdout0_87ck950 FIND v(dout0_87) AT=480.025n

.meas tran vdout0_88ck950 FIND v(dout0_88) AT=480.025n

.meas tran vdout0_89ck950 FIND v(dout0_89) AT=480.025n

.meas tran vdout0_90ck950 FIND v(dout0_90) AT=480.025n

.meas tran vdout0_91ck950 FIND v(dout0_91) AT=480.025n

.meas tran vdout0_92ck950 FIND v(dout0_92) AT=480.025n

.meas tran vdout0_93ck950 FIND v(dout0_93) AT=480.025n

.meas tran vdout0_94ck950 FIND v(dout0_94) AT=480.025n

.meas tran vdout0_95ck950 FIND v(dout0_95) AT=480.025n

.meas tran vdout0_96ck950 FIND v(dout0_96) AT=480.025n

.meas tran vdout0_97ck950 FIND v(dout0_97) AT=480.025n

.meas tran vdout0_98ck950 FIND v(dout0_98) AT=480.025n

.meas tran vdout0_99ck950 FIND v(dout0_99) AT=480.025n

.meas tran vdout0_100ck950 FIND v(dout0_100) AT=480.025n

.meas tran vdout0_101ck950 FIND v(dout0_101) AT=480.025n

.meas tran vdout0_102ck950 FIND v(dout0_102) AT=480.025n

.meas tran vdout0_103ck950 FIND v(dout0_103) AT=480.025n

.meas tran vdout0_104ck950 FIND v(dout0_104) AT=480.025n

.meas tran vdout0_105ck950 FIND v(dout0_105) AT=480.025n

.meas tran vdout0_106ck950 FIND v(dout0_106) AT=480.025n

.meas tran vdout0_107ck950 FIND v(dout0_107) AT=480.025n

.meas tran vdout0_108ck950 FIND v(dout0_108) AT=480.025n

.meas tran vdout0_109ck950 FIND v(dout0_109) AT=480.025n

.meas tran vdout0_110ck950 FIND v(dout0_110) AT=480.025n

.meas tran vdout0_111ck950 FIND v(dout0_111) AT=480.025n

.meas tran vdout0_112ck950 FIND v(dout0_112) AT=480.025n

.meas tran vdout0_113ck950 FIND v(dout0_113) AT=480.025n

.meas tran vdout0_114ck950 FIND v(dout0_114) AT=480.025n

.meas tran vdout0_115ck950 FIND v(dout0_115) AT=480.025n

.meas tran vdout0_116ck950 FIND v(dout0_116) AT=480.025n

.meas tran vdout0_117ck950 FIND v(dout0_117) AT=480.025n

.meas tran vdout0_118ck950 FIND v(dout0_118) AT=480.025n

.meas tran vdout0_119ck950 FIND v(dout0_119) AT=480.025n

.meas tran vdout0_120ck950 FIND v(dout0_120) AT=480.025n

.meas tran vdout0_121ck950 FIND v(dout0_121) AT=480.025n

.meas tran vdout0_122ck950 FIND v(dout0_122) AT=480.025n

.meas tran vdout0_123ck950 FIND v(dout0_123) AT=480.025n

.meas tran vdout0_124ck950 FIND v(dout0_124) AT=480.025n

.meas tran vdout0_125ck950 FIND v(dout0_125) AT=480.025n

.meas tran vdout0_126ck950 FIND v(dout0_126) AT=480.025n

.meas tran vdout0_127ck950 FIND v(dout0_127) AT=480.025n

.meas tran vdout0_128ck950 FIND v(dout0_128) AT=480.025n

.meas tran vdout0_129ck950 FIND v(dout0_129) AT=480.025n

.meas tran vdout0_130ck950 FIND v(dout0_130) AT=480.025n

.meas tran vdout0_131ck950 FIND v(dout0_131) AT=480.025n

.meas tran vdout0_132ck950 FIND v(dout0_132) AT=480.025n

.meas tran vdout0_133ck950 FIND v(dout0_133) AT=480.025n

.meas tran vdout0_134ck950 FIND v(dout0_134) AT=480.025n

.meas tran vdout0_135ck950 FIND v(dout0_135) AT=480.025n

.meas tran vdout0_136ck950 FIND v(dout0_136) AT=480.025n

.meas tran vdout0_137ck950 FIND v(dout0_137) AT=480.025n

.meas tran vdout0_138ck950 FIND v(dout0_138) AT=480.025n

.meas tran vdout0_139ck950 FIND v(dout0_139) AT=480.025n

.meas tran vdout0_140ck950 FIND v(dout0_140) AT=480.025n

.meas tran vdout0_141ck950 FIND v(dout0_141) AT=480.025n

.meas tran vdout0_142ck950 FIND v(dout0_142) AT=480.025n

.meas tran vdout0_143ck950 FIND v(dout0_143) AT=480.025n

.meas tran vdout0_144ck950 FIND v(dout0_144) AT=480.025n

.meas tran vdout0_145ck950 FIND v(dout0_145) AT=480.025n

.meas tran vdout0_146ck950 FIND v(dout0_146) AT=480.025n

.meas tran vdout0_147ck950 FIND v(dout0_147) AT=480.025n

.meas tran vdout0_148ck950 FIND v(dout0_148) AT=480.025n

.meas tran vdout0_149ck950 FIND v(dout0_149) AT=480.025n

.meas tran vdout0_150ck950 FIND v(dout0_150) AT=480.025n

.meas tran vdout0_151ck950 FIND v(dout0_151) AT=480.025n

.meas tran vdout0_152ck950 FIND v(dout0_152) AT=480.025n

.meas tran vdout0_153ck950 FIND v(dout0_153) AT=480.025n

.meas tran vdout0_154ck950 FIND v(dout0_154) AT=480.025n

.meas tran vdout0_155ck950 FIND v(dout0_155) AT=480.025n

.meas tran vdout0_156ck950 FIND v(dout0_156) AT=480.025n

.meas tran vdout0_157ck950 FIND v(dout0_157) AT=480.025n

.meas tran vdout0_158ck950 FIND v(dout0_158) AT=480.025n

.meas tran vdout0_159ck950 FIND v(dout0_159) AT=480.025n

.meas tran vdout0_160ck950 FIND v(dout0_160) AT=480.025n

.meas tran vdout0_161ck950 FIND v(dout0_161) AT=480.025n

.meas tran vdout0_162ck950 FIND v(dout0_162) AT=480.025n

.meas tran vdout0_163ck950 FIND v(dout0_163) AT=480.025n

.meas tran vdout0_164ck950 FIND v(dout0_164) AT=480.025n

.meas tran vdout0_165ck950 FIND v(dout0_165) AT=480.025n

.meas tran vdout0_166ck950 FIND v(dout0_166) AT=480.025n

.meas tran vdout0_167ck950 FIND v(dout0_167) AT=480.025n

.meas tran vdout0_168ck950 FIND v(dout0_168) AT=480.025n

.meas tran vdout0_169ck950 FIND v(dout0_169) AT=480.025n

.meas tran vdout0_170ck950 FIND v(dout0_170) AT=480.025n

.meas tran vdout0_171ck950 FIND v(dout0_171) AT=480.025n

.meas tran vdout0_172ck950 FIND v(dout0_172) AT=480.025n

.meas tran vdout0_173ck950 FIND v(dout0_173) AT=480.025n

.meas tran vdout0_174ck950 FIND v(dout0_174) AT=480.025n

.meas tran vdout0_175ck950 FIND v(dout0_175) AT=480.025n

.meas tran vdout0_176ck950 FIND v(dout0_176) AT=480.025n

.meas tran vdout0_177ck950 FIND v(dout0_177) AT=480.025n

.meas tran vdout0_178ck950 FIND v(dout0_178) AT=480.025n

.meas tran vdout0_179ck950 FIND v(dout0_179) AT=480.025n

.meas tran vdout0_180ck950 FIND v(dout0_180) AT=480.025n

.meas tran vdout0_181ck950 FIND v(dout0_181) AT=480.025n

.meas tran vdout0_182ck950 FIND v(dout0_182) AT=480.025n

.meas tran vdout0_183ck950 FIND v(dout0_183) AT=480.025n

.meas tran vdout0_184ck950 FIND v(dout0_184) AT=480.025n

.meas tran vdout0_185ck950 FIND v(dout0_185) AT=480.025n

.meas tran vdout0_186ck950 FIND v(dout0_186) AT=480.025n

.meas tran vdout0_187ck950 FIND v(dout0_187) AT=480.025n

.meas tran vdout0_188ck950 FIND v(dout0_188) AT=480.025n

.meas tran vdout0_189ck950 FIND v(dout0_189) AT=480.025n

.meas tran vdout0_190ck950 FIND v(dout0_190) AT=480.025n

.meas tran vdout0_191ck950 FIND v(dout0_191) AT=480.025n

.meas tran vdout0_192ck950 FIND v(dout0_192) AT=480.025n

.meas tran vdout0_193ck950 FIND v(dout0_193) AT=480.025n

.meas tran vdout0_194ck950 FIND v(dout0_194) AT=480.025n

.meas tran vdout0_195ck950 FIND v(dout0_195) AT=480.025n

.meas tran vdout0_196ck950 FIND v(dout0_196) AT=480.025n

.meas tran vdout0_197ck950 FIND v(dout0_197) AT=480.025n

.meas tran vdout0_198ck950 FIND v(dout0_198) AT=480.025n

.meas tran vdout0_199ck950 FIND v(dout0_199) AT=480.025n

.meas tran vdout0_200ck950 FIND v(dout0_200) AT=480.025n

.meas tran vdout0_201ck950 FIND v(dout0_201) AT=480.025n

.meas tran vdout0_202ck950 FIND v(dout0_202) AT=480.025n

.meas tran vdout0_203ck950 FIND v(dout0_203) AT=480.025n

.meas tran vdout0_204ck950 FIND v(dout0_204) AT=480.025n

.meas tran vdout0_205ck950 FIND v(dout0_205) AT=480.025n

.meas tran vdout0_206ck950 FIND v(dout0_206) AT=480.025n

.meas tran vdout0_207ck950 FIND v(dout0_207) AT=480.025n

.meas tran vdout0_208ck950 FIND v(dout0_208) AT=480.025n

.meas tran vdout0_209ck950 FIND v(dout0_209) AT=480.025n

.meas tran vdout0_210ck950 FIND v(dout0_210) AT=480.025n

.meas tran vdout0_211ck950 FIND v(dout0_211) AT=480.025n

.meas tran vdout0_212ck950 FIND v(dout0_212) AT=480.025n

.meas tran vdout0_213ck950 FIND v(dout0_213) AT=480.025n

.meas tran vdout0_214ck950 FIND v(dout0_214) AT=480.025n

.meas tran vdout0_215ck950 FIND v(dout0_215) AT=480.025n

.meas tran vdout0_216ck950 FIND v(dout0_216) AT=480.025n

.meas tran vdout0_217ck950 FIND v(dout0_217) AT=480.025n

.meas tran vdout0_218ck950 FIND v(dout0_218) AT=480.025n

.meas tran vdout0_219ck950 FIND v(dout0_219) AT=480.025n

.meas tran vdout0_220ck950 FIND v(dout0_220) AT=480.025n

.meas tran vdout0_221ck950 FIND v(dout0_221) AT=480.025n

.meas tran vdout0_222ck950 FIND v(dout0_222) AT=480.025n

.meas tran vdout0_223ck950 FIND v(dout0_223) AT=480.025n

.meas tran vdout0_224ck950 FIND v(dout0_224) AT=480.025n

.meas tran vdout0_225ck950 FIND v(dout0_225) AT=480.025n

.meas tran vdout0_226ck950 FIND v(dout0_226) AT=480.025n

.meas tran vdout0_227ck950 FIND v(dout0_227) AT=480.025n

.meas tran vdout0_228ck950 FIND v(dout0_228) AT=480.025n

.meas tran vdout0_229ck950 FIND v(dout0_229) AT=480.025n

.meas tran vdout0_230ck950 FIND v(dout0_230) AT=480.025n

.meas tran vdout0_231ck950 FIND v(dout0_231) AT=480.025n

.meas tran vdout0_232ck950 FIND v(dout0_232) AT=480.025n

.meas tran vdout0_233ck950 FIND v(dout0_233) AT=480.025n

.meas tran vdout0_234ck950 FIND v(dout0_234) AT=480.025n

.meas tran vdout0_235ck950 FIND v(dout0_235) AT=480.025n

.meas tran vdout0_236ck950 FIND v(dout0_236) AT=480.025n

.meas tran vdout0_237ck950 FIND v(dout0_237) AT=480.025n

.meas tran vdout0_238ck950 FIND v(dout0_238) AT=480.025n

.meas tran vdout0_239ck950 FIND v(dout0_239) AT=480.025n

.meas tran vdout0_240ck950 FIND v(dout0_240) AT=480.025n

.meas tran vdout0_241ck950 FIND v(dout0_241) AT=480.025n

.meas tran vdout0_242ck950 FIND v(dout0_242) AT=480.025n

.meas tran vdout0_243ck950 FIND v(dout0_243) AT=480.025n

.meas tran vdout0_244ck950 FIND v(dout0_244) AT=480.025n

.meas tran vdout0_245ck950 FIND v(dout0_245) AT=480.025n

.meas tran vdout0_246ck950 FIND v(dout0_246) AT=480.025n

.meas tran vdout0_247ck950 FIND v(dout0_247) AT=480.025n

.meas tran vdout0_248ck950 FIND v(dout0_248) AT=480.025n

.meas tran vdout0_249ck950 FIND v(dout0_249) AT=480.025n

.meas tran vdout0_250ck950 FIND v(dout0_250) AT=480.025n

.meas tran vdout0_251ck950 FIND v(dout0_251) AT=480.025n

.meas tran vdout0_252ck950 FIND v(dout0_252) AT=480.025n

.meas tran vdout0_253ck950 FIND v(dout0_253) AT=480.025n

.meas tran vdout0_254ck950 FIND v(dout0_254) AT=480.025n

.meas tran vdout0_255ck950 FIND v(dout0_255) AT=480.025n

.meas tran vdout0_0ck960 FIND v(dout0_0) AT=485.025n

.meas tran vdout0_1ck960 FIND v(dout0_1) AT=485.025n

.meas tran vdout0_2ck960 FIND v(dout0_2) AT=485.025n

.meas tran vdout0_3ck960 FIND v(dout0_3) AT=485.025n

.meas tran vdout0_4ck960 FIND v(dout0_4) AT=485.025n

.meas tran vdout0_5ck960 FIND v(dout0_5) AT=485.025n

.meas tran vdout0_6ck960 FIND v(dout0_6) AT=485.025n

.meas tran vdout0_7ck960 FIND v(dout0_7) AT=485.025n

.meas tran vdout0_8ck960 FIND v(dout0_8) AT=485.025n

.meas tran vdout0_9ck960 FIND v(dout0_9) AT=485.025n

.meas tran vdout0_10ck960 FIND v(dout0_10) AT=485.025n

.meas tran vdout0_11ck960 FIND v(dout0_11) AT=485.025n

.meas tran vdout0_12ck960 FIND v(dout0_12) AT=485.025n

.meas tran vdout0_13ck960 FIND v(dout0_13) AT=485.025n

.meas tran vdout0_14ck960 FIND v(dout0_14) AT=485.025n

.meas tran vdout0_15ck960 FIND v(dout0_15) AT=485.025n

.meas tran vdout0_16ck960 FIND v(dout0_16) AT=485.025n

.meas tran vdout0_17ck960 FIND v(dout0_17) AT=485.025n

.meas tran vdout0_18ck960 FIND v(dout0_18) AT=485.025n

.meas tran vdout0_19ck960 FIND v(dout0_19) AT=485.025n

.meas tran vdout0_20ck960 FIND v(dout0_20) AT=485.025n

.meas tran vdout0_21ck960 FIND v(dout0_21) AT=485.025n

.meas tran vdout0_22ck960 FIND v(dout0_22) AT=485.025n

.meas tran vdout0_23ck960 FIND v(dout0_23) AT=485.025n

.meas tran vdout0_24ck960 FIND v(dout0_24) AT=485.025n

.meas tran vdout0_25ck960 FIND v(dout0_25) AT=485.025n

.meas tran vdout0_26ck960 FIND v(dout0_26) AT=485.025n

.meas tran vdout0_27ck960 FIND v(dout0_27) AT=485.025n

.meas tran vdout0_28ck960 FIND v(dout0_28) AT=485.025n

.meas tran vdout0_29ck960 FIND v(dout0_29) AT=485.025n

.meas tran vdout0_30ck960 FIND v(dout0_30) AT=485.025n

.meas tran vdout0_31ck960 FIND v(dout0_31) AT=485.025n

.meas tran vdout0_32ck960 FIND v(dout0_32) AT=485.025n

.meas tran vdout0_33ck960 FIND v(dout0_33) AT=485.025n

.meas tran vdout0_34ck960 FIND v(dout0_34) AT=485.025n

.meas tran vdout0_35ck960 FIND v(dout0_35) AT=485.025n

.meas tran vdout0_36ck960 FIND v(dout0_36) AT=485.025n

.meas tran vdout0_37ck960 FIND v(dout0_37) AT=485.025n

.meas tran vdout0_38ck960 FIND v(dout0_38) AT=485.025n

.meas tran vdout0_39ck960 FIND v(dout0_39) AT=485.025n

.meas tran vdout0_40ck960 FIND v(dout0_40) AT=485.025n

.meas tran vdout0_41ck960 FIND v(dout0_41) AT=485.025n

.meas tran vdout0_42ck960 FIND v(dout0_42) AT=485.025n

.meas tran vdout0_43ck960 FIND v(dout0_43) AT=485.025n

.meas tran vdout0_44ck960 FIND v(dout0_44) AT=485.025n

.meas tran vdout0_45ck960 FIND v(dout0_45) AT=485.025n

.meas tran vdout0_46ck960 FIND v(dout0_46) AT=485.025n

.meas tran vdout0_47ck960 FIND v(dout0_47) AT=485.025n

.meas tran vdout0_48ck960 FIND v(dout0_48) AT=485.025n

.meas tran vdout0_49ck960 FIND v(dout0_49) AT=485.025n

.meas tran vdout0_50ck960 FIND v(dout0_50) AT=485.025n

.meas tran vdout0_51ck960 FIND v(dout0_51) AT=485.025n

.meas tran vdout0_52ck960 FIND v(dout0_52) AT=485.025n

.meas tran vdout0_53ck960 FIND v(dout0_53) AT=485.025n

.meas tran vdout0_54ck960 FIND v(dout0_54) AT=485.025n

.meas tran vdout0_55ck960 FIND v(dout0_55) AT=485.025n

.meas tran vdout0_56ck960 FIND v(dout0_56) AT=485.025n

.meas tran vdout0_57ck960 FIND v(dout0_57) AT=485.025n

.meas tran vdout0_58ck960 FIND v(dout0_58) AT=485.025n

.meas tran vdout0_59ck960 FIND v(dout0_59) AT=485.025n

.meas tran vdout0_60ck960 FIND v(dout0_60) AT=485.025n

.meas tran vdout0_61ck960 FIND v(dout0_61) AT=485.025n

.meas tran vdout0_62ck960 FIND v(dout0_62) AT=485.025n

.meas tran vdout0_63ck960 FIND v(dout0_63) AT=485.025n

.meas tran vdout0_64ck960 FIND v(dout0_64) AT=485.025n

.meas tran vdout0_65ck960 FIND v(dout0_65) AT=485.025n

.meas tran vdout0_66ck960 FIND v(dout0_66) AT=485.025n

.meas tran vdout0_67ck960 FIND v(dout0_67) AT=485.025n

.meas tran vdout0_68ck960 FIND v(dout0_68) AT=485.025n

.meas tran vdout0_69ck960 FIND v(dout0_69) AT=485.025n

.meas tran vdout0_70ck960 FIND v(dout0_70) AT=485.025n

.meas tran vdout0_71ck960 FIND v(dout0_71) AT=485.025n

.meas tran vdout0_72ck960 FIND v(dout0_72) AT=485.025n

.meas tran vdout0_73ck960 FIND v(dout0_73) AT=485.025n

.meas tran vdout0_74ck960 FIND v(dout0_74) AT=485.025n

.meas tran vdout0_75ck960 FIND v(dout0_75) AT=485.025n

.meas tran vdout0_76ck960 FIND v(dout0_76) AT=485.025n

.meas tran vdout0_77ck960 FIND v(dout0_77) AT=485.025n

.meas tran vdout0_78ck960 FIND v(dout0_78) AT=485.025n

.meas tran vdout0_79ck960 FIND v(dout0_79) AT=485.025n

.meas tran vdout0_80ck960 FIND v(dout0_80) AT=485.025n

.meas tran vdout0_81ck960 FIND v(dout0_81) AT=485.025n

.meas tran vdout0_82ck960 FIND v(dout0_82) AT=485.025n

.meas tran vdout0_83ck960 FIND v(dout0_83) AT=485.025n

.meas tran vdout0_84ck960 FIND v(dout0_84) AT=485.025n

.meas tran vdout0_85ck960 FIND v(dout0_85) AT=485.025n

.meas tran vdout0_86ck960 FIND v(dout0_86) AT=485.025n

.meas tran vdout0_87ck960 FIND v(dout0_87) AT=485.025n

.meas tran vdout0_88ck960 FIND v(dout0_88) AT=485.025n

.meas tran vdout0_89ck960 FIND v(dout0_89) AT=485.025n

.meas tran vdout0_90ck960 FIND v(dout0_90) AT=485.025n

.meas tran vdout0_91ck960 FIND v(dout0_91) AT=485.025n

.meas tran vdout0_92ck960 FIND v(dout0_92) AT=485.025n

.meas tran vdout0_93ck960 FIND v(dout0_93) AT=485.025n

.meas tran vdout0_94ck960 FIND v(dout0_94) AT=485.025n

.meas tran vdout0_95ck960 FIND v(dout0_95) AT=485.025n

.meas tran vdout0_96ck960 FIND v(dout0_96) AT=485.025n

.meas tran vdout0_97ck960 FIND v(dout0_97) AT=485.025n

.meas tran vdout0_98ck960 FIND v(dout0_98) AT=485.025n

.meas tran vdout0_99ck960 FIND v(dout0_99) AT=485.025n

.meas tran vdout0_100ck960 FIND v(dout0_100) AT=485.025n

.meas tran vdout0_101ck960 FIND v(dout0_101) AT=485.025n

.meas tran vdout0_102ck960 FIND v(dout0_102) AT=485.025n

.meas tran vdout0_103ck960 FIND v(dout0_103) AT=485.025n

.meas tran vdout0_104ck960 FIND v(dout0_104) AT=485.025n

.meas tran vdout0_105ck960 FIND v(dout0_105) AT=485.025n

.meas tran vdout0_106ck960 FIND v(dout0_106) AT=485.025n

.meas tran vdout0_107ck960 FIND v(dout0_107) AT=485.025n

.meas tran vdout0_108ck960 FIND v(dout0_108) AT=485.025n

.meas tran vdout0_109ck960 FIND v(dout0_109) AT=485.025n

.meas tran vdout0_110ck960 FIND v(dout0_110) AT=485.025n

.meas tran vdout0_111ck960 FIND v(dout0_111) AT=485.025n

.meas tran vdout0_112ck960 FIND v(dout0_112) AT=485.025n

.meas tran vdout0_113ck960 FIND v(dout0_113) AT=485.025n

.meas tran vdout0_114ck960 FIND v(dout0_114) AT=485.025n

.meas tran vdout0_115ck960 FIND v(dout0_115) AT=485.025n

.meas tran vdout0_116ck960 FIND v(dout0_116) AT=485.025n

.meas tran vdout0_117ck960 FIND v(dout0_117) AT=485.025n

.meas tran vdout0_118ck960 FIND v(dout0_118) AT=485.025n

.meas tran vdout0_119ck960 FIND v(dout0_119) AT=485.025n

.meas tran vdout0_120ck960 FIND v(dout0_120) AT=485.025n

.meas tran vdout0_121ck960 FIND v(dout0_121) AT=485.025n

.meas tran vdout0_122ck960 FIND v(dout0_122) AT=485.025n

.meas tran vdout0_123ck960 FIND v(dout0_123) AT=485.025n

.meas tran vdout0_124ck960 FIND v(dout0_124) AT=485.025n

.meas tran vdout0_125ck960 FIND v(dout0_125) AT=485.025n

.meas tran vdout0_126ck960 FIND v(dout0_126) AT=485.025n

.meas tran vdout0_127ck960 FIND v(dout0_127) AT=485.025n

.meas tran vdout0_128ck960 FIND v(dout0_128) AT=485.025n

.meas tran vdout0_129ck960 FIND v(dout0_129) AT=485.025n

.meas tran vdout0_130ck960 FIND v(dout0_130) AT=485.025n

.meas tran vdout0_131ck960 FIND v(dout0_131) AT=485.025n

.meas tran vdout0_132ck960 FIND v(dout0_132) AT=485.025n

.meas tran vdout0_133ck960 FIND v(dout0_133) AT=485.025n

.meas tran vdout0_134ck960 FIND v(dout0_134) AT=485.025n

.meas tran vdout0_135ck960 FIND v(dout0_135) AT=485.025n

.meas tran vdout0_136ck960 FIND v(dout0_136) AT=485.025n

.meas tran vdout0_137ck960 FIND v(dout0_137) AT=485.025n

.meas tran vdout0_138ck960 FIND v(dout0_138) AT=485.025n

.meas tran vdout0_139ck960 FIND v(dout0_139) AT=485.025n

.meas tran vdout0_140ck960 FIND v(dout0_140) AT=485.025n

.meas tran vdout0_141ck960 FIND v(dout0_141) AT=485.025n

.meas tran vdout0_142ck960 FIND v(dout0_142) AT=485.025n

.meas tran vdout0_143ck960 FIND v(dout0_143) AT=485.025n

.meas tran vdout0_144ck960 FIND v(dout0_144) AT=485.025n

.meas tran vdout0_145ck960 FIND v(dout0_145) AT=485.025n

.meas tran vdout0_146ck960 FIND v(dout0_146) AT=485.025n

.meas tran vdout0_147ck960 FIND v(dout0_147) AT=485.025n

.meas tran vdout0_148ck960 FIND v(dout0_148) AT=485.025n

.meas tran vdout0_149ck960 FIND v(dout0_149) AT=485.025n

.meas tran vdout0_150ck960 FIND v(dout0_150) AT=485.025n

.meas tran vdout0_151ck960 FIND v(dout0_151) AT=485.025n

.meas tran vdout0_152ck960 FIND v(dout0_152) AT=485.025n

.meas tran vdout0_153ck960 FIND v(dout0_153) AT=485.025n

.meas tran vdout0_154ck960 FIND v(dout0_154) AT=485.025n

.meas tran vdout0_155ck960 FIND v(dout0_155) AT=485.025n

.meas tran vdout0_156ck960 FIND v(dout0_156) AT=485.025n

.meas tran vdout0_157ck960 FIND v(dout0_157) AT=485.025n

.meas tran vdout0_158ck960 FIND v(dout0_158) AT=485.025n

.meas tran vdout0_159ck960 FIND v(dout0_159) AT=485.025n

.meas tran vdout0_160ck960 FIND v(dout0_160) AT=485.025n

.meas tran vdout0_161ck960 FIND v(dout0_161) AT=485.025n

.meas tran vdout0_162ck960 FIND v(dout0_162) AT=485.025n

.meas tran vdout0_163ck960 FIND v(dout0_163) AT=485.025n

.meas tran vdout0_164ck960 FIND v(dout0_164) AT=485.025n

.meas tran vdout0_165ck960 FIND v(dout0_165) AT=485.025n

.meas tran vdout0_166ck960 FIND v(dout0_166) AT=485.025n

.meas tran vdout0_167ck960 FIND v(dout0_167) AT=485.025n

.meas tran vdout0_168ck960 FIND v(dout0_168) AT=485.025n

.meas tran vdout0_169ck960 FIND v(dout0_169) AT=485.025n

.meas tran vdout0_170ck960 FIND v(dout0_170) AT=485.025n

.meas tran vdout0_171ck960 FIND v(dout0_171) AT=485.025n

.meas tran vdout0_172ck960 FIND v(dout0_172) AT=485.025n

.meas tran vdout0_173ck960 FIND v(dout0_173) AT=485.025n

.meas tran vdout0_174ck960 FIND v(dout0_174) AT=485.025n

.meas tran vdout0_175ck960 FIND v(dout0_175) AT=485.025n

.meas tran vdout0_176ck960 FIND v(dout0_176) AT=485.025n

.meas tran vdout0_177ck960 FIND v(dout0_177) AT=485.025n

.meas tran vdout0_178ck960 FIND v(dout0_178) AT=485.025n

.meas tran vdout0_179ck960 FIND v(dout0_179) AT=485.025n

.meas tran vdout0_180ck960 FIND v(dout0_180) AT=485.025n

.meas tran vdout0_181ck960 FIND v(dout0_181) AT=485.025n

.meas tran vdout0_182ck960 FIND v(dout0_182) AT=485.025n

.meas tran vdout0_183ck960 FIND v(dout0_183) AT=485.025n

.meas tran vdout0_184ck960 FIND v(dout0_184) AT=485.025n

.meas tran vdout0_185ck960 FIND v(dout0_185) AT=485.025n

.meas tran vdout0_186ck960 FIND v(dout0_186) AT=485.025n

.meas tran vdout0_187ck960 FIND v(dout0_187) AT=485.025n

.meas tran vdout0_188ck960 FIND v(dout0_188) AT=485.025n

.meas tran vdout0_189ck960 FIND v(dout0_189) AT=485.025n

.meas tran vdout0_190ck960 FIND v(dout0_190) AT=485.025n

.meas tran vdout0_191ck960 FIND v(dout0_191) AT=485.025n

.meas tran vdout0_192ck960 FIND v(dout0_192) AT=485.025n

.meas tran vdout0_193ck960 FIND v(dout0_193) AT=485.025n

.meas tran vdout0_194ck960 FIND v(dout0_194) AT=485.025n

.meas tran vdout0_195ck960 FIND v(dout0_195) AT=485.025n

.meas tran vdout0_196ck960 FIND v(dout0_196) AT=485.025n

.meas tran vdout0_197ck960 FIND v(dout0_197) AT=485.025n

.meas tran vdout0_198ck960 FIND v(dout0_198) AT=485.025n

.meas tran vdout0_199ck960 FIND v(dout0_199) AT=485.025n

.meas tran vdout0_200ck960 FIND v(dout0_200) AT=485.025n

.meas tran vdout0_201ck960 FIND v(dout0_201) AT=485.025n

.meas tran vdout0_202ck960 FIND v(dout0_202) AT=485.025n

.meas tran vdout0_203ck960 FIND v(dout0_203) AT=485.025n

.meas tran vdout0_204ck960 FIND v(dout0_204) AT=485.025n

.meas tran vdout0_205ck960 FIND v(dout0_205) AT=485.025n

.meas tran vdout0_206ck960 FIND v(dout0_206) AT=485.025n

.meas tran vdout0_207ck960 FIND v(dout0_207) AT=485.025n

.meas tran vdout0_208ck960 FIND v(dout0_208) AT=485.025n

.meas tran vdout0_209ck960 FIND v(dout0_209) AT=485.025n

.meas tran vdout0_210ck960 FIND v(dout0_210) AT=485.025n

.meas tran vdout0_211ck960 FIND v(dout0_211) AT=485.025n

.meas tran vdout0_212ck960 FIND v(dout0_212) AT=485.025n

.meas tran vdout0_213ck960 FIND v(dout0_213) AT=485.025n

.meas tran vdout0_214ck960 FIND v(dout0_214) AT=485.025n

.meas tran vdout0_215ck960 FIND v(dout0_215) AT=485.025n

.meas tran vdout0_216ck960 FIND v(dout0_216) AT=485.025n

.meas tran vdout0_217ck960 FIND v(dout0_217) AT=485.025n

.meas tran vdout0_218ck960 FIND v(dout0_218) AT=485.025n

.meas tran vdout0_219ck960 FIND v(dout0_219) AT=485.025n

.meas tran vdout0_220ck960 FIND v(dout0_220) AT=485.025n

.meas tran vdout0_221ck960 FIND v(dout0_221) AT=485.025n

.meas tran vdout0_222ck960 FIND v(dout0_222) AT=485.025n

.meas tran vdout0_223ck960 FIND v(dout0_223) AT=485.025n

.meas tran vdout0_224ck960 FIND v(dout0_224) AT=485.025n

.meas tran vdout0_225ck960 FIND v(dout0_225) AT=485.025n

.meas tran vdout0_226ck960 FIND v(dout0_226) AT=485.025n

.meas tran vdout0_227ck960 FIND v(dout0_227) AT=485.025n

.meas tran vdout0_228ck960 FIND v(dout0_228) AT=485.025n

.meas tran vdout0_229ck960 FIND v(dout0_229) AT=485.025n

.meas tran vdout0_230ck960 FIND v(dout0_230) AT=485.025n

.meas tran vdout0_231ck960 FIND v(dout0_231) AT=485.025n

.meas tran vdout0_232ck960 FIND v(dout0_232) AT=485.025n

.meas tran vdout0_233ck960 FIND v(dout0_233) AT=485.025n

.meas tran vdout0_234ck960 FIND v(dout0_234) AT=485.025n

.meas tran vdout0_235ck960 FIND v(dout0_235) AT=485.025n

.meas tran vdout0_236ck960 FIND v(dout0_236) AT=485.025n

.meas tran vdout0_237ck960 FIND v(dout0_237) AT=485.025n

.meas tran vdout0_238ck960 FIND v(dout0_238) AT=485.025n

.meas tran vdout0_239ck960 FIND v(dout0_239) AT=485.025n

.meas tran vdout0_240ck960 FIND v(dout0_240) AT=485.025n

.meas tran vdout0_241ck960 FIND v(dout0_241) AT=485.025n

.meas tran vdout0_242ck960 FIND v(dout0_242) AT=485.025n

.meas tran vdout0_243ck960 FIND v(dout0_243) AT=485.025n

.meas tran vdout0_244ck960 FIND v(dout0_244) AT=485.025n

.meas tran vdout0_245ck960 FIND v(dout0_245) AT=485.025n

.meas tran vdout0_246ck960 FIND v(dout0_246) AT=485.025n

.meas tran vdout0_247ck960 FIND v(dout0_247) AT=485.025n

.meas tran vdout0_248ck960 FIND v(dout0_248) AT=485.025n

.meas tran vdout0_249ck960 FIND v(dout0_249) AT=485.025n

.meas tran vdout0_250ck960 FIND v(dout0_250) AT=485.025n

.meas tran vdout0_251ck960 FIND v(dout0_251) AT=485.025n

.meas tran vdout0_252ck960 FIND v(dout0_252) AT=485.025n

.meas tran vdout0_253ck960 FIND v(dout0_253) AT=485.025n

.meas tran vdout0_254ck960 FIND v(dout0_254) AT=485.025n

.meas tran vdout0_255ck960 FIND v(dout0_255) AT=485.025n

.meas tran vdout0_0ck990 FIND v(dout0_0) AT=500.025n

.meas tran vdout0_1ck990 FIND v(dout0_1) AT=500.025n

.meas tran vdout0_2ck990 FIND v(dout0_2) AT=500.025n

.meas tran vdout0_3ck990 FIND v(dout0_3) AT=500.025n

.meas tran vdout0_4ck990 FIND v(dout0_4) AT=500.025n

.meas tran vdout0_5ck990 FIND v(dout0_5) AT=500.025n

.meas tran vdout0_6ck990 FIND v(dout0_6) AT=500.025n

.meas tran vdout0_7ck990 FIND v(dout0_7) AT=500.025n

.meas tran vdout0_8ck990 FIND v(dout0_8) AT=500.025n

.meas tran vdout0_9ck990 FIND v(dout0_9) AT=500.025n

.meas tran vdout0_10ck990 FIND v(dout0_10) AT=500.025n

.meas tran vdout0_11ck990 FIND v(dout0_11) AT=500.025n

.meas tran vdout0_12ck990 FIND v(dout0_12) AT=500.025n

.meas tran vdout0_13ck990 FIND v(dout0_13) AT=500.025n

.meas tran vdout0_14ck990 FIND v(dout0_14) AT=500.025n

.meas tran vdout0_15ck990 FIND v(dout0_15) AT=500.025n

.meas tran vdout0_16ck990 FIND v(dout0_16) AT=500.025n

.meas tran vdout0_17ck990 FIND v(dout0_17) AT=500.025n

.meas tran vdout0_18ck990 FIND v(dout0_18) AT=500.025n

.meas tran vdout0_19ck990 FIND v(dout0_19) AT=500.025n

.meas tran vdout0_20ck990 FIND v(dout0_20) AT=500.025n

.meas tran vdout0_21ck990 FIND v(dout0_21) AT=500.025n

.meas tran vdout0_22ck990 FIND v(dout0_22) AT=500.025n

.meas tran vdout0_23ck990 FIND v(dout0_23) AT=500.025n

.meas tran vdout0_24ck990 FIND v(dout0_24) AT=500.025n

.meas tran vdout0_25ck990 FIND v(dout0_25) AT=500.025n

.meas tran vdout0_26ck990 FIND v(dout0_26) AT=500.025n

.meas tran vdout0_27ck990 FIND v(dout0_27) AT=500.025n

.meas tran vdout0_28ck990 FIND v(dout0_28) AT=500.025n

.meas tran vdout0_29ck990 FIND v(dout0_29) AT=500.025n

.meas tran vdout0_30ck990 FIND v(dout0_30) AT=500.025n

.meas tran vdout0_31ck990 FIND v(dout0_31) AT=500.025n

.meas tran vdout0_32ck990 FIND v(dout0_32) AT=500.025n

.meas tran vdout0_33ck990 FIND v(dout0_33) AT=500.025n

.meas tran vdout0_34ck990 FIND v(dout0_34) AT=500.025n

.meas tran vdout0_35ck990 FIND v(dout0_35) AT=500.025n

.meas tran vdout0_36ck990 FIND v(dout0_36) AT=500.025n

.meas tran vdout0_37ck990 FIND v(dout0_37) AT=500.025n

.meas tran vdout0_38ck990 FIND v(dout0_38) AT=500.025n

.meas tran vdout0_39ck990 FIND v(dout0_39) AT=500.025n

.meas tran vdout0_40ck990 FIND v(dout0_40) AT=500.025n

.meas tran vdout0_41ck990 FIND v(dout0_41) AT=500.025n

.meas tran vdout0_42ck990 FIND v(dout0_42) AT=500.025n

.meas tran vdout0_43ck990 FIND v(dout0_43) AT=500.025n

.meas tran vdout0_44ck990 FIND v(dout0_44) AT=500.025n

.meas tran vdout0_45ck990 FIND v(dout0_45) AT=500.025n

.meas tran vdout0_46ck990 FIND v(dout0_46) AT=500.025n

.meas tran vdout0_47ck990 FIND v(dout0_47) AT=500.025n

.meas tran vdout0_48ck990 FIND v(dout0_48) AT=500.025n

.meas tran vdout0_49ck990 FIND v(dout0_49) AT=500.025n

.meas tran vdout0_50ck990 FIND v(dout0_50) AT=500.025n

.meas tran vdout0_51ck990 FIND v(dout0_51) AT=500.025n

.meas tran vdout0_52ck990 FIND v(dout0_52) AT=500.025n

.meas tran vdout0_53ck990 FIND v(dout0_53) AT=500.025n

.meas tran vdout0_54ck990 FIND v(dout0_54) AT=500.025n

.meas tran vdout0_55ck990 FIND v(dout0_55) AT=500.025n

.meas tran vdout0_56ck990 FIND v(dout0_56) AT=500.025n

.meas tran vdout0_57ck990 FIND v(dout0_57) AT=500.025n

.meas tran vdout0_58ck990 FIND v(dout0_58) AT=500.025n

.meas tran vdout0_59ck990 FIND v(dout0_59) AT=500.025n

.meas tran vdout0_60ck990 FIND v(dout0_60) AT=500.025n

.meas tran vdout0_61ck990 FIND v(dout0_61) AT=500.025n

.meas tran vdout0_62ck990 FIND v(dout0_62) AT=500.025n

.meas tran vdout0_63ck990 FIND v(dout0_63) AT=500.025n

.meas tran vdout0_64ck990 FIND v(dout0_64) AT=500.025n

.meas tran vdout0_65ck990 FIND v(dout0_65) AT=500.025n

.meas tran vdout0_66ck990 FIND v(dout0_66) AT=500.025n

.meas tran vdout0_67ck990 FIND v(dout0_67) AT=500.025n

.meas tran vdout0_68ck990 FIND v(dout0_68) AT=500.025n

.meas tran vdout0_69ck990 FIND v(dout0_69) AT=500.025n

.meas tran vdout0_70ck990 FIND v(dout0_70) AT=500.025n

.meas tran vdout0_71ck990 FIND v(dout0_71) AT=500.025n

.meas tran vdout0_72ck990 FIND v(dout0_72) AT=500.025n

.meas tran vdout0_73ck990 FIND v(dout0_73) AT=500.025n

.meas tran vdout0_74ck990 FIND v(dout0_74) AT=500.025n

.meas tran vdout0_75ck990 FIND v(dout0_75) AT=500.025n

.meas tran vdout0_76ck990 FIND v(dout0_76) AT=500.025n

.meas tran vdout0_77ck990 FIND v(dout0_77) AT=500.025n

.meas tran vdout0_78ck990 FIND v(dout0_78) AT=500.025n

.meas tran vdout0_79ck990 FIND v(dout0_79) AT=500.025n

.meas tran vdout0_80ck990 FIND v(dout0_80) AT=500.025n

.meas tran vdout0_81ck990 FIND v(dout0_81) AT=500.025n

.meas tran vdout0_82ck990 FIND v(dout0_82) AT=500.025n

.meas tran vdout0_83ck990 FIND v(dout0_83) AT=500.025n

.meas tran vdout0_84ck990 FIND v(dout0_84) AT=500.025n

.meas tran vdout0_85ck990 FIND v(dout0_85) AT=500.025n

.meas tran vdout0_86ck990 FIND v(dout0_86) AT=500.025n

.meas tran vdout0_87ck990 FIND v(dout0_87) AT=500.025n

.meas tran vdout0_88ck990 FIND v(dout0_88) AT=500.025n

.meas tran vdout0_89ck990 FIND v(dout0_89) AT=500.025n

.meas tran vdout0_90ck990 FIND v(dout0_90) AT=500.025n

.meas tran vdout0_91ck990 FIND v(dout0_91) AT=500.025n

.meas tran vdout0_92ck990 FIND v(dout0_92) AT=500.025n

.meas tran vdout0_93ck990 FIND v(dout0_93) AT=500.025n

.meas tran vdout0_94ck990 FIND v(dout0_94) AT=500.025n

.meas tran vdout0_95ck990 FIND v(dout0_95) AT=500.025n

.meas tran vdout0_96ck990 FIND v(dout0_96) AT=500.025n

.meas tran vdout0_97ck990 FIND v(dout0_97) AT=500.025n

.meas tran vdout0_98ck990 FIND v(dout0_98) AT=500.025n

.meas tran vdout0_99ck990 FIND v(dout0_99) AT=500.025n

.meas tran vdout0_100ck990 FIND v(dout0_100) AT=500.025n

.meas tran vdout0_101ck990 FIND v(dout0_101) AT=500.025n

.meas tran vdout0_102ck990 FIND v(dout0_102) AT=500.025n

.meas tran vdout0_103ck990 FIND v(dout0_103) AT=500.025n

.meas tran vdout0_104ck990 FIND v(dout0_104) AT=500.025n

.meas tran vdout0_105ck990 FIND v(dout0_105) AT=500.025n

.meas tran vdout0_106ck990 FIND v(dout0_106) AT=500.025n

.meas tran vdout0_107ck990 FIND v(dout0_107) AT=500.025n

.meas tran vdout0_108ck990 FIND v(dout0_108) AT=500.025n

.meas tran vdout0_109ck990 FIND v(dout0_109) AT=500.025n

.meas tran vdout0_110ck990 FIND v(dout0_110) AT=500.025n

.meas tran vdout0_111ck990 FIND v(dout0_111) AT=500.025n

.meas tran vdout0_112ck990 FIND v(dout0_112) AT=500.025n

.meas tran vdout0_113ck990 FIND v(dout0_113) AT=500.025n

.meas tran vdout0_114ck990 FIND v(dout0_114) AT=500.025n

.meas tran vdout0_115ck990 FIND v(dout0_115) AT=500.025n

.meas tran vdout0_116ck990 FIND v(dout0_116) AT=500.025n

.meas tran vdout0_117ck990 FIND v(dout0_117) AT=500.025n

.meas tran vdout0_118ck990 FIND v(dout0_118) AT=500.025n

.meas tran vdout0_119ck990 FIND v(dout0_119) AT=500.025n

.meas tran vdout0_120ck990 FIND v(dout0_120) AT=500.025n

.meas tran vdout0_121ck990 FIND v(dout0_121) AT=500.025n

.meas tran vdout0_122ck990 FIND v(dout0_122) AT=500.025n

.meas tran vdout0_123ck990 FIND v(dout0_123) AT=500.025n

.meas tran vdout0_124ck990 FIND v(dout0_124) AT=500.025n

.meas tran vdout0_125ck990 FIND v(dout0_125) AT=500.025n

.meas tran vdout0_126ck990 FIND v(dout0_126) AT=500.025n

.meas tran vdout0_127ck990 FIND v(dout0_127) AT=500.025n

.meas tran vdout0_128ck990 FIND v(dout0_128) AT=500.025n

.meas tran vdout0_129ck990 FIND v(dout0_129) AT=500.025n

.meas tran vdout0_130ck990 FIND v(dout0_130) AT=500.025n

.meas tran vdout0_131ck990 FIND v(dout0_131) AT=500.025n

.meas tran vdout0_132ck990 FIND v(dout0_132) AT=500.025n

.meas tran vdout0_133ck990 FIND v(dout0_133) AT=500.025n

.meas tran vdout0_134ck990 FIND v(dout0_134) AT=500.025n

.meas tran vdout0_135ck990 FIND v(dout0_135) AT=500.025n

.meas tran vdout0_136ck990 FIND v(dout0_136) AT=500.025n

.meas tran vdout0_137ck990 FIND v(dout0_137) AT=500.025n

.meas tran vdout0_138ck990 FIND v(dout0_138) AT=500.025n

.meas tran vdout0_139ck990 FIND v(dout0_139) AT=500.025n

.meas tran vdout0_140ck990 FIND v(dout0_140) AT=500.025n

.meas tran vdout0_141ck990 FIND v(dout0_141) AT=500.025n

.meas tran vdout0_142ck990 FIND v(dout0_142) AT=500.025n

.meas tran vdout0_143ck990 FIND v(dout0_143) AT=500.025n

.meas tran vdout0_144ck990 FIND v(dout0_144) AT=500.025n

.meas tran vdout0_145ck990 FIND v(dout0_145) AT=500.025n

.meas tran vdout0_146ck990 FIND v(dout0_146) AT=500.025n

.meas tran vdout0_147ck990 FIND v(dout0_147) AT=500.025n

.meas tran vdout0_148ck990 FIND v(dout0_148) AT=500.025n

.meas tran vdout0_149ck990 FIND v(dout0_149) AT=500.025n

.meas tran vdout0_150ck990 FIND v(dout0_150) AT=500.025n

.meas tran vdout0_151ck990 FIND v(dout0_151) AT=500.025n

.meas tran vdout0_152ck990 FIND v(dout0_152) AT=500.025n

.meas tran vdout0_153ck990 FIND v(dout0_153) AT=500.025n

.meas tran vdout0_154ck990 FIND v(dout0_154) AT=500.025n

.meas tran vdout0_155ck990 FIND v(dout0_155) AT=500.025n

.meas tran vdout0_156ck990 FIND v(dout0_156) AT=500.025n

.meas tran vdout0_157ck990 FIND v(dout0_157) AT=500.025n

.meas tran vdout0_158ck990 FIND v(dout0_158) AT=500.025n

.meas tran vdout0_159ck990 FIND v(dout0_159) AT=500.025n

.meas tran vdout0_160ck990 FIND v(dout0_160) AT=500.025n

.meas tran vdout0_161ck990 FIND v(dout0_161) AT=500.025n

.meas tran vdout0_162ck990 FIND v(dout0_162) AT=500.025n

.meas tran vdout0_163ck990 FIND v(dout0_163) AT=500.025n

.meas tran vdout0_164ck990 FIND v(dout0_164) AT=500.025n

.meas tran vdout0_165ck990 FIND v(dout0_165) AT=500.025n

.meas tran vdout0_166ck990 FIND v(dout0_166) AT=500.025n

.meas tran vdout0_167ck990 FIND v(dout0_167) AT=500.025n

.meas tran vdout0_168ck990 FIND v(dout0_168) AT=500.025n

.meas tran vdout0_169ck990 FIND v(dout0_169) AT=500.025n

.meas tran vdout0_170ck990 FIND v(dout0_170) AT=500.025n

.meas tran vdout0_171ck990 FIND v(dout0_171) AT=500.025n

.meas tran vdout0_172ck990 FIND v(dout0_172) AT=500.025n

.meas tran vdout0_173ck990 FIND v(dout0_173) AT=500.025n

.meas tran vdout0_174ck990 FIND v(dout0_174) AT=500.025n

.meas tran vdout0_175ck990 FIND v(dout0_175) AT=500.025n

.meas tran vdout0_176ck990 FIND v(dout0_176) AT=500.025n

.meas tran vdout0_177ck990 FIND v(dout0_177) AT=500.025n

.meas tran vdout0_178ck990 FIND v(dout0_178) AT=500.025n

.meas tran vdout0_179ck990 FIND v(dout0_179) AT=500.025n

.meas tran vdout0_180ck990 FIND v(dout0_180) AT=500.025n

.meas tran vdout0_181ck990 FIND v(dout0_181) AT=500.025n

.meas tran vdout0_182ck990 FIND v(dout0_182) AT=500.025n

.meas tran vdout0_183ck990 FIND v(dout0_183) AT=500.025n

.meas tran vdout0_184ck990 FIND v(dout0_184) AT=500.025n

.meas tran vdout0_185ck990 FIND v(dout0_185) AT=500.025n

.meas tran vdout0_186ck990 FIND v(dout0_186) AT=500.025n

.meas tran vdout0_187ck990 FIND v(dout0_187) AT=500.025n

.meas tran vdout0_188ck990 FIND v(dout0_188) AT=500.025n

.meas tran vdout0_189ck990 FIND v(dout0_189) AT=500.025n

.meas tran vdout0_190ck990 FIND v(dout0_190) AT=500.025n

.meas tran vdout0_191ck990 FIND v(dout0_191) AT=500.025n

.meas tran vdout0_192ck990 FIND v(dout0_192) AT=500.025n

.meas tran vdout0_193ck990 FIND v(dout0_193) AT=500.025n

.meas tran vdout0_194ck990 FIND v(dout0_194) AT=500.025n

.meas tran vdout0_195ck990 FIND v(dout0_195) AT=500.025n

.meas tran vdout0_196ck990 FIND v(dout0_196) AT=500.025n

.meas tran vdout0_197ck990 FIND v(dout0_197) AT=500.025n

.meas tran vdout0_198ck990 FIND v(dout0_198) AT=500.025n

.meas tran vdout0_199ck990 FIND v(dout0_199) AT=500.025n

.meas tran vdout0_200ck990 FIND v(dout0_200) AT=500.025n

.meas tran vdout0_201ck990 FIND v(dout0_201) AT=500.025n

.meas tran vdout0_202ck990 FIND v(dout0_202) AT=500.025n

.meas tran vdout0_203ck990 FIND v(dout0_203) AT=500.025n

.meas tran vdout0_204ck990 FIND v(dout0_204) AT=500.025n

.meas tran vdout0_205ck990 FIND v(dout0_205) AT=500.025n

.meas tran vdout0_206ck990 FIND v(dout0_206) AT=500.025n

.meas tran vdout0_207ck990 FIND v(dout0_207) AT=500.025n

.meas tran vdout0_208ck990 FIND v(dout0_208) AT=500.025n

.meas tran vdout0_209ck990 FIND v(dout0_209) AT=500.025n

.meas tran vdout0_210ck990 FIND v(dout0_210) AT=500.025n

.meas tran vdout0_211ck990 FIND v(dout0_211) AT=500.025n

.meas tran vdout0_212ck990 FIND v(dout0_212) AT=500.025n

.meas tran vdout0_213ck990 FIND v(dout0_213) AT=500.025n

.meas tran vdout0_214ck990 FIND v(dout0_214) AT=500.025n

.meas tran vdout0_215ck990 FIND v(dout0_215) AT=500.025n

.meas tran vdout0_216ck990 FIND v(dout0_216) AT=500.025n

.meas tran vdout0_217ck990 FIND v(dout0_217) AT=500.025n

.meas tran vdout0_218ck990 FIND v(dout0_218) AT=500.025n

.meas tran vdout0_219ck990 FIND v(dout0_219) AT=500.025n

.meas tran vdout0_220ck990 FIND v(dout0_220) AT=500.025n

.meas tran vdout0_221ck990 FIND v(dout0_221) AT=500.025n

.meas tran vdout0_222ck990 FIND v(dout0_222) AT=500.025n

.meas tran vdout0_223ck990 FIND v(dout0_223) AT=500.025n

.meas tran vdout0_224ck990 FIND v(dout0_224) AT=500.025n

.meas tran vdout0_225ck990 FIND v(dout0_225) AT=500.025n

.meas tran vdout0_226ck990 FIND v(dout0_226) AT=500.025n

.meas tran vdout0_227ck990 FIND v(dout0_227) AT=500.025n

.meas tran vdout0_228ck990 FIND v(dout0_228) AT=500.025n

.meas tran vdout0_229ck990 FIND v(dout0_229) AT=500.025n

.meas tran vdout0_230ck990 FIND v(dout0_230) AT=500.025n

.meas tran vdout0_231ck990 FIND v(dout0_231) AT=500.025n

.meas tran vdout0_232ck990 FIND v(dout0_232) AT=500.025n

.meas tran vdout0_233ck990 FIND v(dout0_233) AT=500.025n

.meas tran vdout0_234ck990 FIND v(dout0_234) AT=500.025n

.meas tran vdout0_235ck990 FIND v(dout0_235) AT=500.025n

.meas tran vdout0_236ck990 FIND v(dout0_236) AT=500.025n

.meas tran vdout0_237ck990 FIND v(dout0_237) AT=500.025n

.meas tran vdout0_238ck990 FIND v(dout0_238) AT=500.025n

.meas tran vdout0_239ck990 FIND v(dout0_239) AT=500.025n

.meas tran vdout0_240ck990 FIND v(dout0_240) AT=500.025n

.meas tran vdout0_241ck990 FIND v(dout0_241) AT=500.025n

.meas tran vdout0_242ck990 FIND v(dout0_242) AT=500.025n

.meas tran vdout0_243ck990 FIND v(dout0_243) AT=500.025n

.meas tran vdout0_244ck990 FIND v(dout0_244) AT=500.025n

.meas tran vdout0_245ck990 FIND v(dout0_245) AT=500.025n

.meas tran vdout0_246ck990 FIND v(dout0_246) AT=500.025n

.meas tran vdout0_247ck990 FIND v(dout0_247) AT=500.025n

.meas tran vdout0_248ck990 FIND v(dout0_248) AT=500.025n

.meas tran vdout0_249ck990 FIND v(dout0_249) AT=500.025n

.meas tran vdout0_250ck990 FIND v(dout0_250) AT=500.025n

.meas tran vdout0_251ck990 FIND v(dout0_251) AT=500.025n

.meas tran vdout0_252ck990 FIND v(dout0_252) AT=500.025n

.meas tran vdout0_253ck990 FIND v(dout0_253) AT=500.025n

.meas tran vdout0_254ck990 FIND v(dout0_254) AT=500.025n

.meas tran vdout0_255ck990 FIND v(dout0_255) AT=500.025n

.meas tran vdout0_0ck1020 FIND v(dout0_0) AT=515.025n

.meas tran vdout0_1ck1020 FIND v(dout0_1) AT=515.025n

.meas tran vdout0_2ck1020 FIND v(dout0_2) AT=515.025n

.meas tran vdout0_3ck1020 FIND v(dout0_3) AT=515.025n

.meas tran vdout0_4ck1020 FIND v(dout0_4) AT=515.025n

.meas tran vdout0_5ck1020 FIND v(dout0_5) AT=515.025n

.meas tran vdout0_6ck1020 FIND v(dout0_6) AT=515.025n

.meas tran vdout0_7ck1020 FIND v(dout0_7) AT=515.025n

.meas tran vdout0_8ck1020 FIND v(dout0_8) AT=515.025n

.meas tran vdout0_9ck1020 FIND v(dout0_9) AT=515.025n

.meas tran vdout0_10ck1020 FIND v(dout0_10) AT=515.025n

.meas tran vdout0_11ck1020 FIND v(dout0_11) AT=515.025n

.meas tran vdout0_12ck1020 FIND v(dout0_12) AT=515.025n

.meas tran vdout0_13ck1020 FIND v(dout0_13) AT=515.025n

.meas tran vdout0_14ck1020 FIND v(dout0_14) AT=515.025n

.meas tran vdout0_15ck1020 FIND v(dout0_15) AT=515.025n

.meas tran vdout0_16ck1020 FIND v(dout0_16) AT=515.025n

.meas tran vdout0_17ck1020 FIND v(dout0_17) AT=515.025n

.meas tran vdout0_18ck1020 FIND v(dout0_18) AT=515.025n

.meas tran vdout0_19ck1020 FIND v(dout0_19) AT=515.025n

.meas tran vdout0_20ck1020 FIND v(dout0_20) AT=515.025n

.meas tran vdout0_21ck1020 FIND v(dout0_21) AT=515.025n

.meas tran vdout0_22ck1020 FIND v(dout0_22) AT=515.025n

.meas tran vdout0_23ck1020 FIND v(dout0_23) AT=515.025n

.meas tran vdout0_24ck1020 FIND v(dout0_24) AT=515.025n

.meas tran vdout0_25ck1020 FIND v(dout0_25) AT=515.025n

.meas tran vdout0_26ck1020 FIND v(dout0_26) AT=515.025n

.meas tran vdout0_27ck1020 FIND v(dout0_27) AT=515.025n

.meas tran vdout0_28ck1020 FIND v(dout0_28) AT=515.025n

.meas tran vdout0_29ck1020 FIND v(dout0_29) AT=515.025n

.meas tran vdout0_30ck1020 FIND v(dout0_30) AT=515.025n

.meas tran vdout0_31ck1020 FIND v(dout0_31) AT=515.025n

.meas tran vdout0_32ck1020 FIND v(dout0_32) AT=515.025n

.meas tran vdout0_33ck1020 FIND v(dout0_33) AT=515.025n

.meas tran vdout0_34ck1020 FIND v(dout0_34) AT=515.025n

.meas tran vdout0_35ck1020 FIND v(dout0_35) AT=515.025n

.meas tran vdout0_36ck1020 FIND v(dout0_36) AT=515.025n

.meas tran vdout0_37ck1020 FIND v(dout0_37) AT=515.025n

.meas tran vdout0_38ck1020 FIND v(dout0_38) AT=515.025n

.meas tran vdout0_39ck1020 FIND v(dout0_39) AT=515.025n

.meas tran vdout0_40ck1020 FIND v(dout0_40) AT=515.025n

.meas tran vdout0_41ck1020 FIND v(dout0_41) AT=515.025n

.meas tran vdout0_42ck1020 FIND v(dout0_42) AT=515.025n

.meas tran vdout0_43ck1020 FIND v(dout0_43) AT=515.025n

.meas tran vdout0_44ck1020 FIND v(dout0_44) AT=515.025n

.meas tran vdout0_45ck1020 FIND v(dout0_45) AT=515.025n

.meas tran vdout0_46ck1020 FIND v(dout0_46) AT=515.025n

.meas tran vdout0_47ck1020 FIND v(dout0_47) AT=515.025n

.meas tran vdout0_48ck1020 FIND v(dout0_48) AT=515.025n

.meas tran vdout0_49ck1020 FIND v(dout0_49) AT=515.025n

.meas tran vdout0_50ck1020 FIND v(dout0_50) AT=515.025n

.meas tran vdout0_51ck1020 FIND v(dout0_51) AT=515.025n

.meas tran vdout0_52ck1020 FIND v(dout0_52) AT=515.025n

.meas tran vdout0_53ck1020 FIND v(dout0_53) AT=515.025n

.meas tran vdout0_54ck1020 FIND v(dout0_54) AT=515.025n

.meas tran vdout0_55ck1020 FIND v(dout0_55) AT=515.025n

.meas tran vdout0_56ck1020 FIND v(dout0_56) AT=515.025n

.meas tran vdout0_57ck1020 FIND v(dout0_57) AT=515.025n

.meas tran vdout0_58ck1020 FIND v(dout0_58) AT=515.025n

.meas tran vdout0_59ck1020 FIND v(dout0_59) AT=515.025n

.meas tran vdout0_60ck1020 FIND v(dout0_60) AT=515.025n

.meas tran vdout0_61ck1020 FIND v(dout0_61) AT=515.025n

.meas tran vdout0_62ck1020 FIND v(dout0_62) AT=515.025n

.meas tran vdout0_63ck1020 FIND v(dout0_63) AT=515.025n

.meas tran vdout0_64ck1020 FIND v(dout0_64) AT=515.025n

.meas tran vdout0_65ck1020 FIND v(dout0_65) AT=515.025n

.meas tran vdout0_66ck1020 FIND v(dout0_66) AT=515.025n

.meas tran vdout0_67ck1020 FIND v(dout0_67) AT=515.025n

.meas tran vdout0_68ck1020 FIND v(dout0_68) AT=515.025n

.meas tran vdout0_69ck1020 FIND v(dout0_69) AT=515.025n

.meas tran vdout0_70ck1020 FIND v(dout0_70) AT=515.025n

.meas tran vdout0_71ck1020 FIND v(dout0_71) AT=515.025n

.meas tran vdout0_72ck1020 FIND v(dout0_72) AT=515.025n

.meas tran vdout0_73ck1020 FIND v(dout0_73) AT=515.025n

.meas tran vdout0_74ck1020 FIND v(dout0_74) AT=515.025n

.meas tran vdout0_75ck1020 FIND v(dout0_75) AT=515.025n

.meas tran vdout0_76ck1020 FIND v(dout0_76) AT=515.025n

.meas tran vdout0_77ck1020 FIND v(dout0_77) AT=515.025n

.meas tran vdout0_78ck1020 FIND v(dout0_78) AT=515.025n

.meas tran vdout0_79ck1020 FIND v(dout0_79) AT=515.025n

.meas tran vdout0_80ck1020 FIND v(dout0_80) AT=515.025n

.meas tran vdout0_81ck1020 FIND v(dout0_81) AT=515.025n

.meas tran vdout0_82ck1020 FIND v(dout0_82) AT=515.025n

.meas tran vdout0_83ck1020 FIND v(dout0_83) AT=515.025n

.meas tran vdout0_84ck1020 FIND v(dout0_84) AT=515.025n

.meas tran vdout0_85ck1020 FIND v(dout0_85) AT=515.025n

.meas tran vdout0_86ck1020 FIND v(dout0_86) AT=515.025n

.meas tran vdout0_87ck1020 FIND v(dout0_87) AT=515.025n

.meas tran vdout0_88ck1020 FIND v(dout0_88) AT=515.025n

.meas tran vdout0_89ck1020 FIND v(dout0_89) AT=515.025n

.meas tran vdout0_90ck1020 FIND v(dout0_90) AT=515.025n

.meas tran vdout0_91ck1020 FIND v(dout0_91) AT=515.025n

.meas tran vdout0_92ck1020 FIND v(dout0_92) AT=515.025n

.meas tran vdout0_93ck1020 FIND v(dout0_93) AT=515.025n

.meas tran vdout0_94ck1020 FIND v(dout0_94) AT=515.025n

.meas tran vdout0_95ck1020 FIND v(dout0_95) AT=515.025n

.meas tran vdout0_96ck1020 FIND v(dout0_96) AT=515.025n

.meas tran vdout0_97ck1020 FIND v(dout0_97) AT=515.025n

.meas tran vdout0_98ck1020 FIND v(dout0_98) AT=515.025n

.meas tran vdout0_99ck1020 FIND v(dout0_99) AT=515.025n

.meas tran vdout0_100ck1020 FIND v(dout0_100) AT=515.025n

.meas tran vdout0_101ck1020 FIND v(dout0_101) AT=515.025n

.meas tran vdout0_102ck1020 FIND v(dout0_102) AT=515.025n

.meas tran vdout0_103ck1020 FIND v(dout0_103) AT=515.025n

.meas tran vdout0_104ck1020 FIND v(dout0_104) AT=515.025n

.meas tran vdout0_105ck1020 FIND v(dout0_105) AT=515.025n

.meas tran vdout0_106ck1020 FIND v(dout0_106) AT=515.025n

.meas tran vdout0_107ck1020 FIND v(dout0_107) AT=515.025n

.meas tran vdout0_108ck1020 FIND v(dout0_108) AT=515.025n

.meas tran vdout0_109ck1020 FIND v(dout0_109) AT=515.025n

.meas tran vdout0_110ck1020 FIND v(dout0_110) AT=515.025n

.meas tran vdout0_111ck1020 FIND v(dout0_111) AT=515.025n

.meas tran vdout0_112ck1020 FIND v(dout0_112) AT=515.025n

.meas tran vdout0_113ck1020 FIND v(dout0_113) AT=515.025n

.meas tran vdout0_114ck1020 FIND v(dout0_114) AT=515.025n

.meas tran vdout0_115ck1020 FIND v(dout0_115) AT=515.025n

.meas tran vdout0_116ck1020 FIND v(dout0_116) AT=515.025n

.meas tran vdout0_117ck1020 FIND v(dout0_117) AT=515.025n

.meas tran vdout0_118ck1020 FIND v(dout0_118) AT=515.025n

.meas tran vdout0_119ck1020 FIND v(dout0_119) AT=515.025n

.meas tran vdout0_120ck1020 FIND v(dout0_120) AT=515.025n

.meas tran vdout0_121ck1020 FIND v(dout0_121) AT=515.025n

.meas tran vdout0_122ck1020 FIND v(dout0_122) AT=515.025n

.meas tran vdout0_123ck1020 FIND v(dout0_123) AT=515.025n

.meas tran vdout0_124ck1020 FIND v(dout0_124) AT=515.025n

.meas tran vdout0_125ck1020 FIND v(dout0_125) AT=515.025n

.meas tran vdout0_126ck1020 FIND v(dout0_126) AT=515.025n

.meas tran vdout0_127ck1020 FIND v(dout0_127) AT=515.025n

.meas tran vdout0_128ck1020 FIND v(dout0_128) AT=515.025n

.meas tran vdout0_129ck1020 FIND v(dout0_129) AT=515.025n

.meas tran vdout0_130ck1020 FIND v(dout0_130) AT=515.025n

.meas tran vdout0_131ck1020 FIND v(dout0_131) AT=515.025n

.meas tran vdout0_132ck1020 FIND v(dout0_132) AT=515.025n

.meas tran vdout0_133ck1020 FIND v(dout0_133) AT=515.025n

.meas tran vdout0_134ck1020 FIND v(dout0_134) AT=515.025n

.meas tran vdout0_135ck1020 FIND v(dout0_135) AT=515.025n

.meas tran vdout0_136ck1020 FIND v(dout0_136) AT=515.025n

.meas tran vdout0_137ck1020 FIND v(dout0_137) AT=515.025n

.meas tran vdout0_138ck1020 FIND v(dout0_138) AT=515.025n

.meas tran vdout0_139ck1020 FIND v(dout0_139) AT=515.025n

.meas tran vdout0_140ck1020 FIND v(dout0_140) AT=515.025n

.meas tran vdout0_141ck1020 FIND v(dout0_141) AT=515.025n

.meas tran vdout0_142ck1020 FIND v(dout0_142) AT=515.025n

.meas tran vdout0_143ck1020 FIND v(dout0_143) AT=515.025n

.meas tran vdout0_144ck1020 FIND v(dout0_144) AT=515.025n

.meas tran vdout0_145ck1020 FIND v(dout0_145) AT=515.025n

.meas tran vdout0_146ck1020 FIND v(dout0_146) AT=515.025n

.meas tran vdout0_147ck1020 FIND v(dout0_147) AT=515.025n

.meas tran vdout0_148ck1020 FIND v(dout0_148) AT=515.025n

.meas tran vdout0_149ck1020 FIND v(dout0_149) AT=515.025n

.meas tran vdout0_150ck1020 FIND v(dout0_150) AT=515.025n

.meas tran vdout0_151ck1020 FIND v(dout0_151) AT=515.025n

.meas tran vdout0_152ck1020 FIND v(dout0_152) AT=515.025n

.meas tran vdout0_153ck1020 FIND v(dout0_153) AT=515.025n

.meas tran vdout0_154ck1020 FIND v(dout0_154) AT=515.025n

.meas tran vdout0_155ck1020 FIND v(dout0_155) AT=515.025n

.meas tran vdout0_156ck1020 FIND v(dout0_156) AT=515.025n

.meas tran vdout0_157ck1020 FIND v(dout0_157) AT=515.025n

.meas tran vdout0_158ck1020 FIND v(dout0_158) AT=515.025n

.meas tran vdout0_159ck1020 FIND v(dout0_159) AT=515.025n

.meas tran vdout0_160ck1020 FIND v(dout0_160) AT=515.025n

.meas tran vdout0_161ck1020 FIND v(dout0_161) AT=515.025n

.meas tran vdout0_162ck1020 FIND v(dout0_162) AT=515.025n

.meas tran vdout0_163ck1020 FIND v(dout0_163) AT=515.025n

.meas tran vdout0_164ck1020 FIND v(dout0_164) AT=515.025n

.meas tran vdout0_165ck1020 FIND v(dout0_165) AT=515.025n

.meas tran vdout0_166ck1020 FIND v(dout0_166) AT=515.025n

.meas tran vdout0_167ck1020 FIND v(dout0_167) AT=515.025n

.meas tran vdout0_168ck1020 FIND v(dout0_168) AT=515.025n

.meas tran vdout0_169ck1020 FIND v(dout0_169) AT=515.025n

.meas tran vdout0_170ck1020 FIND v(dout0_170) AT=515.025n

.meas tran vdout0_171ck1020 FIND v(dout0_171) AT=515.025n

.meas tran vdout0_172ck1020 FIND v(dout0_172) AT=515.025n

.meas tran vdout0_173ck1020 FIND v(dout0_173) AT=515.025n

.meas tran vdout0_174ck1020 FIND v(dout0_174) AT=515.025n

.meas tran vdout0_175ck1020 FIND v(dout0_175) AT=515.025n

.meas tran vdout0_176ck1020 FIND v(dout0_176) AT=515.025n

.meas tran vdout0_177ck1020 FIND v(dout0_177) AT=515.025n

.meas tran vdout0_178ck1020 FIND v(dout0_178) AT=515.025n

.meas tran vdout0_179ck1020 FIND v(dout0_179) AT=515.025n

.meas tran vdout0_180ck1020 FIND v(dout0_180) AT=515.025n

.meas tran vdout0_181ck1020 FIND v(dout0_181) AT=515.025n

.meas tran vdout0_182ck1020 FIND v(dout0_182) AT=515.025n

.meas tran vdout0_183ck1020 FIND v(dout0_183) AT=515.025n

.meas tran vdout0_184ck1020 FIND v(dout0_184) AT=515.025n

.meas tran vdout0_185ck1020 FIND v(dout0_185) AT=515.025n

.meas tran vdout0_186ck1020 FIND v(dout0_186) AT=515.025n

.meas tran vdout0_187ck1020 FIND v(dout0_187) AT=515.025n

.meas tran vdout0_188ck1020 FIND v(dout0_188) AT=515.025n

.meas tran vdout0_189ck1020 FIND v(dout0_189) AT=515.025n

.meas tran vdout0_190ck1020 FIND v(dout0_190) AT=515.025n

.meas tran vdout0_191ck1020 FIND v(dout0_191) AT=515.025n

.meas tran vdout0_192ck1020 FIND v(dout0_192) AT=515.025n

.meas tran vdout0_193ck1020 FIND v(dout0_193) AT=515.025n

.meas tran vdout0_194ck1020 FIND v(dout0_194) AT=515.025n

.meas tran vdout0_195ck1020 FIND v(dout0_195) AT=515.025n

.meas tran vdout0_196ck1020 FIND v(dout0_196) AT=515.025n

.meas tran vdout0_197ck1020 FIND v(dout0_197) AT=515.025n

.meas tran vdout0_198ck1020 FIND v(dout0_198) AT=515.025n

.meas tran vdout0_199ck1020 FIND v(dout0_199) AT=515.025n

.meas tran vdout0_200ck1020 FIND v(dout0_200) AT=515.025n

.meas tran vdout0_201ck1020 FIND v(dout0_201) AT=515.025n

.meas tran vdout0_202ck1020 FIND v(dout0_202) AT=515.025n

.meas tran vdout0_203ck1020 FIND v(dout0_203) AT=515.025n

.meas tran vdout0_204ck1020 FIND v(dout0_204) AT=515.025n

.meas tran vdout0_205ck1020 FIND v(dout0_205) AT=515.025n

.meas tran vdout0_206ck1020 FIND v(dout0_206) AT=515.025n

.meas tran vdout0_207ck1020 FIND v(dout0_207) AT=515.025n

.meas tran vdout0_208ck1020 FIND v(dout0_208) AT=515.025n

.meas tran vdout0_209ck1020 FIND v(dout0_209) AT=515.025n

.meas tran vdout0_210ck1020 FIND v(dout0_210) AT=515.025n

.meas tran vdout0_211ck1020 FIND v(dout0_211) AT=515.025n

.meas tran vdout0_212ck1020 FIND v(dout0_212) AT=515.025n

.meas tran vdout0_213ck1020 FIND v(dout0_213) AT=515.025n

.meas tran vdout0_214ck1020 FIND v(dout0_214) AT=515.025n

.meas tran vdout0_215ck1020 FIND v(dout0_215) AT=515.025n

.meas tran vdout0_216ck1020 FIND v(dout0_216) AT=515.025n

.meas tran vdout0_217ck1020 FIND v(dout0_217) AT=515.025n

.meas tran vdout0_218ck1020 FIND v(dout0_218) AT=515.025n

.meas tran vdout0_219ck1020 FIND v(dout0_219) AT=515.025n

.meas tran vdout0_220ck1020 FIND v(dout0_220) AT=515.025n

.meas tran vdout0_221ck1020 FIND v(dout0_221) AT=515.025n

.meas tran vdout0_222ck1020 FIND v(dout0_222) AT=515.025n

.meas tran vdout0_223ck1020 FIND v(dout0_223) AT=515.025n

.meas tran vdout0_224ck1020 FIND v(dout0_224) AT=515.025n

.meas tran vdout0_225ck1020 FIND v(dout0_225) AT=515.025n

.meas tran vdout0_226ck1020 FIND v(dout0_226) AT=515.025n

.meas tran vdout0_227ck1020 FIND v(dout0_227) AT=515.025n

.meas tran vdout0_228ck1020 FIND v(dout0_228) AT=515.025n

.meas tran vdout0_229ck1020 FIND v(dout0_229) AT=515.025n

.meas tran vdout0_230ck1020 FIND v(dout0_230) AT=515.025n

.meas tran vdout0_231ck1020 FIND v(dout0_231) AT=515.025n

.meas tran vdout0_232ck1020 FIND v(dout0_232) AT=515.025n

.meas tran vdout0_233ck1020 FIND v(dout0_233) AT=515.025n

.meas tran vdout0_234ck1020 FIND v(dout0_234) AT=515.025n

.meas tran vdout0_235ck1020 FIND v(dout0_235) AT=515.025n

.meas tran vdout0_236ck1020 FIND v(dout0_236) AT=515.025n

.meas tran vdout0_237ck1020 FIND v(dout0_237) AT=515.025n

.meas tran vdout0_238ck1020 FIND v(dout0_238) AT=515.025n

.meas tran vdout0_239ck1020 FIND v(dout0_239) AT=515.025n

.meas tran vdout0_240ck1020 FIND v(dout0_240) AT=515.025n

.meas tran vdout0_241ck1020 FIND v(dout0_241) AT=515.025n

.meas tran vdout0_242ck1020 FIND v(dout0_242) AT=515.025n

.meas tran vdout0_243ck1020 FIND v(dout0_243) AT=515.025n

.meas tran vdout0_244ck1020 FIND v(dout0_244) AT=515.025n

.meas tran vdout0_245ck1020 FIND v(dout0_245) AT=515.025n

.meas tran vdout0_246ck1020 FIND v(dout0_246) AT=515.025n

.meas tran vdout0_247ck1020 FIND v(dout0_247) AT=515.025n

.meas tran vdout0_248ck1020 FIND v(dout0_248) AT=515.025n

.meas tran vdout0_249ck1020 FIND v(dout0_249) AT=515.025n

.meas tran vdout0_250ck1020 FIND v(dout0_250) AT=515.025n

.meas tran vdout0_251ck1020 FIND v(dout0_251) AT=515.025n

.meas tran vdout0_252ck1020 FIND v(dout0_252) AT=515.025n

.meas tran vdout0_253ck1020 FIND v(dout0_253) AT=515.025n

.meas tran vdout0_254ck1020 FIND v(dout0_254) AT=515.025n

.meas tran vdout0_255ck1020 FIND v(dout0_255) AT=515.025n

.meas tran vdout0_0ck1060 FIND v(dout0_0) AT=535.025n

.meas tran vdout0_1ck1060 FIND v(dout0_1) AT=535.025n

.meas tran vdout0_2ck1060 FIND v(dout0_2) AT=535.025n

.meas tran vdout0_3ck1060 FIND v(dout0_3) AT=535.025n

.meas tran vdout0_4ck1060 FIND v(dout0_4) AT=535.025n

.meas tran vdout0_5ck1060 FIND v(dout0_5) AT=535.025n

.meas tran vdout0_6ck1060 FIND v(dout0_6) AT=535.025n

.meas tran vdout0_7ck1060 FIND v(dout0_7) AT=535.025n

.meas tran vdout0_8ck1060 FIND v(dout0_8) AT=535.025n

.meas tran vdout0_9ck1060 FIND v(dout0_9) AT=535.025n

.meas tran vdout0_10ck1060 FIND v(dout0_10) AT=535.025n

.meas tran vdout0_11ck1060 FIND v(dout0_11) AT=535.025n

.meas tran vdout0_12ck1060 FIND v(dout0_12) AT=535.025n

.meas tran vdout0_13ck1060 FIND v(dout0_13) AT=535.025n

.meas tran vdout0_14ck1060 FIND v(dout0_14) AT=535.025n

.meas tran vdout0_15ck1060 FIND v(dout0_15) AT=535.025n

.meas tran vdout0_16ck1060 FIND v(dout0_16) AT=535.025n

.meas tran vdout0_17ck1060 FIND v(dout0_17) AT=535.025n

.meas tran vdout0_18ck1060 FIND v(dout0_18) AT=535.025n

.meas tran vdout0_19ck1060 FIND v(dout0_19) AT=535.025n

.meas tran vdout0_20ck1060 FIND v(dout0_20) AT=535.025n

.meas tran vdout0_21ck1060 FIND v(dout0_21) AT=535.025n

.meas tran vdout0_22ck1060 FIND v(dout0_22) AT=535.025n

.meas tran vdout0_23ck1060 FIND v(dout0_23) AT=535.025n

.meas tran vdout0_24ck1060 FIND v(dout0_24) AT=535.025n

.meas tran vdout0_25ck1060 FIND v(dout0_25) AT=535.025n

.meas tran vdout0_26ck1060 FIND v(dout0_26) AT=535.025n

.meas tran vdout0_27ck1060 FIND v(dout0_27) AT=535.025n

.meas tran vdout0_28ck1060 FIND v(dout0_28) AT=535.025n

.meas tran vdout0_29ck1060 FIND v(dout0_29) AT=535.025n

.meas tran vdout0_30ck1060 FIND v(dout0_30) AT=535.025n

.meas tran vdout0_31ck1060 FIND v(dout0_31) AT=535.025n

.meas tran vdout0_32ck1060 FIND v(dout0_32) AT=535.025n

.meas tran vdout0_33ck1060 FIND v(dout0_33) AT=535.025n

.meas tran vdout0_34ck1060 FIND v(dout0_34) AT=535.025n

.meas tran vdout0_35ck1060 FIND v(dout0_35) AT=535.025n

.meas tran vdout0_36ck1060 FIND v(dout0_36) AT=535.025n

.meas tran vdout0_37ck1060 FIND v(dout0_37) AT=535.025n

.meas tran vdout0_38ck1060 FIND v(dout0_38) AT=535.025n

.meas tran vdout0_39ck1060 FIND v(dout0_39) AT=535.025n

.meas tran vdout0_40ck1060 FIND v(dout0_40) AT=535.025n

.meas tran vdout0_41ck1060 FIND v(dout0_41) AT=535.025n

.meas tran vdout0_42ck1060 FIND v(dout0_42) AT=535.025n

.meas tran vdout0_43ck1060 FIND v(dout0_43) AT=535.025n

.meas tran vdout0_44ck1060 FIND v(dout0_44) AT=535.025n

.meas tran vdout0_45ck1060 FIND v(dout0_45) AT=535.025n

.meas tran vdout0_46ck1060 FIND v(dout0_46) AT=535.025n

.meas tran vdout0_47ck1060 FIND v(dout0_47) AT=535.025n

.meas tran vdout0_48ck1060 FIND v(dout0_48) AT=535.025n

.meas tran vdout0_49ck1060 FIND v(dout0_49) AT=535.025n

.meas tran vdout0_50ck1060 FIND v(dout0_50) AT=535.025n

.meas tran vdout0_51ck1060 FIND v(dout0_51) AT=535.025n

.meas tran vdout0_52ck1060 FIND v(dout0_52) AT=535.025n

.meas tran vdout0_53ck1060 FIND v(dout0_53) AT=535.025n

.meas tran vdout0_54ck1060 FIND v(dout0_54) AT=535.025n

.meas tran vdout0_55ck1060 FIND v(dout0_55) AT=535.025n

.meas tran vdout0_56ck1060 FIND v(dout0_56) AT=535.025n

.meas tran vdout0_57ck1060 FIND v(dout0_57) AT=535.025n

.meas tran vdout0_58ck1060 FIND v(dout0_58) AT=535.025n

.meas tran vdout0_59ck1060 FIND v(dout0_59) AT=535.025n

.meas tran vdout0_60ck1060 FIND v(dout0_60) AT=535.025n

.meas tran vdout0_61ck1060 FIND v(dout0_61) AT=535.025n

.meas tran vdout0_62ck1060 FIND v(dout0_62) AT=535.025n

.meas tran vdout0_63ck1060 FIND v(dout0_63) AT=535.025n

.meas tran vdout0_64ck1060 FIND v(dout0_64) AT=535.025n

.meas tran vdout0_65ck1060 FIND v(dout0_65) AT=535.025n

.meas tran vdout0_66ck1060 FIND v(dout0_66) AT=535.025n

.meas tran vdout0_67ck1060 FIND v(dout0_67) AT=535.025n

.meas tran vdout0_68ck1060 FIND v(dout0_68) AT=535.025n

.meas tran vdout0_69ck1060 FIND v(dout0_69) AT=535.025n

.meas tran vdout0_70ck1060 FIND v(dout0_70) AT=535.025n

.meas tran vdout0_71ck1060 FIND v(dout0_71) AT=535.025n

.meas tran vdout0_72ck1060 FIND v(dout0_72) AT=535.025n

.meas tran vdout0_73ck1060 FIND v(dout0_73) AT=535.025n

.meas tran vdout0_74ck1060 FIND v(dout0_74) AT=535.025n

.meas tran vdout0_75ck1060 FIND v(dout0_75) AT=535.025n

.meas tran vdout0_76ck1060 FIND v(dout0_76) AT=535.025n

.meas tran vdout0_77ck1060 FIND v(dout0_77) AT=535.025n

.meas tran vdout0_78ck1060 FIND v(dout0_78) AT=535.025n

.meas tran vdout0_79ck1060 FIND v(dout0_79) AT=535.025n

.meas tran vdout0_80ck1060 FIND v(dout0_80) AT=535.025n

.meas tran vdout0_81ck1060 FIND v(dout0_81) AT=535.025n

.meas tran vdout0_82ck1060 FIND v(dout0_82) AT=535.025n

.meas tran vdout0_83ck1060 FIND v(dout0_83) AT=535.025n

.meas tran vdout0_84ck1060 FIND v(dout0_84) AT=535.025n

.meas tran vdout0_85ck1060 FIND v(dout0_85) AT=535.025n

.meas tran vdout0_86ck1060 FIND v(dout0_86) AT=535.025n

.meas tran vdout0_87ck1060 FIND v(dout0_87) AT=535.025n

.meas tran vdout0_88ck1060 FIND v(dout0_88) AT=535.025n

.meas tran vdout0_89ck1060 FIND v(dout0_89) AT=535.025n

.meas tran vdout0_90ck1060 FIND v(dout0_90) AT=535.025n

.meas tran vdout0_91ck1060 FIND v(dout0_91) AT=535.025n

.meas tran vdout0_92ck1060 FIND v(dout0_92) AT=535.025n

.meas tran vdout0_93ck1060 FIND v(dout0_93) AT=535.025n

.meas tran vdout0_94ck1060 FIND v(dout0_94) AT=535.025n

.meas tran vdout0_95ck1060 FIND v(dout0_95) AT=535.025n

.meas tran vdout0_96ck1060 FIND v(dout0_96) AT=535.025n

.meas tran vdout0_97ck1060 FIND v(dout0_97) AT=535.025n

.meas tran vdout0_98ck1060 FIND v(dout0_98) AT=535.025n

.meas tran vdout0_99ck1060 FIND v(dout0_99) AT=535.025n

.meas tran vdout0_100ck1060 FIND v(dout0_100) AT=535.025n

.meas tran vdout0_101ck1060 FIND v(dout0_101) AT=535.025n

.meas tran vdout0_102ck1060 FIND v(dout0_102) AT=535.025n

.meas tran vdout0_103ck1060 FIND v(dout0_103) AT=535.025n

.meas tran vdout0_104ck1060 FIND v(dout0_104) AT=535.025n

.meas tran vdout0_105ck1060 FIND v(dout0_105) AT=535.025n

.meas tran vdout0_106ck1060 FIND v(dout0_106) AT=535.025n

.meas tran vdout0_107ck1060 FIND v(dout0_107) AT=535.025n

.meas tran vdout0_108ck1060 FIND v(dout0_108) AT=535.025n

.meas tran vdout0_109ck1060 FIND v(dout0_109) AT=535.025n

.meas tran vdout0_110ck1060 FIND v(dout0_110) AT=535.025n

.meas tran vdout0_111ck1060 FIND v(dout0_111) AT=535.025n

.meas tran vdout0_112ck1060 FIND v(dout0_112) AT=535.025n

.meas tran vdout0_113ck1060 FIND v(dout0_113) AT=535.025n

.meas tran vdout0_114ck1060 FIND v(dout0_114) AT=535.025n

.meas tran vdout0_115ck1060 FIND v(dout0_115) AT=535.025n

.meas tran vdout0_116ck1060 FIND v(dout0_116) AT=535.025n

.meas tran vdout0_117ck1060 FIND v(dout0_117) AT=535.025n

.meas tran vdout0_118ck1060 FIND v(dout0_118) AT=535.025n

.meas tran vdout0_119ck1060 FIND v(dout0_119) AT=535.025n

.meas tran vdout0_120ck1060 FIND v(dout0_120) AT=535.025n

.meas tran vdout0_121ck1060 FIND v(dout0_121) AT=535.025n

.meas tran vdout0_122ck1060 FIND v(dout0_122) AT=535.025n

.meas tran vdout0_123ck1060 FIND v(dout0_123) AT=535.025n

.meas tran vdout0_124ck1060 FIND v(dout0_124) AT=535.025n

.meas tran vdout0_125ck1060 FIND v(dout0_125) AT=535.025n

.meas tran vdout0_126ck1060 FIND v(dout0_126) AT=535.025n

.meas tran vdout0_127ck1060 FIND v(dout0_127) AT=535.025n

.meas tran vdout0_128ck1060 FIND v(dout0_128) AT=535.025n

.meas tran vdout0_129ck1060 FIND v(dout0_129) AT=535.025n

.meas tran vdout0_130ck1060 FIND v(dout0_130) AT=535.025n

.meas tran vdout0_131ck1060 FIND v(dout0_131) AT=535.025n

.meas tran vdout0_132ck1060 FIND v(dout0_132) AT=535.025n

.meas tran vdout0_133ck1060 FIND v(dout0_133) AT=535.025n

.meas tran vdout0_134ck1060 FIND v(dout0_134) AT=535.025n

.meas tran vdout0_135ck1060 FIND v(dout0_135) AT=535.025n

.meas tran vdout0_136ck1060 FIND v(dout0_136) AT=535.025n

.meas tran vdout0_137ck1060 FIND v(dout0_137) AT=535.025n

.meas tran vdout0_138ck1060 FIND v(dout0_138) AT=535.025n

.meas tran vdout0_139ck1060 FIND v(dout0_139) AT=535.025n

.meas tran vdout0_140ck1060 FIND v(dout0_140) AT=535.025n

.meas tran vdout0_141ck1060 FIND v(dout0_141) AT=535.025n

.meas tran vdout0_142ck1060 FIND v(dout0_142) AT=535.025n

.meas tran vdout0_143ck1060 FIND v(dout0_143) AT=535.025n

.meas tran vdout0_144ck1060 FIND v(dout0_144) AT=535.025n

.meas tran vdout0_145ck1060 FIND v(dout0_145) AT=535.025n

.meas tran vdout0_146ck1060 FIND v(dout0_146) AT=535.025n

.meas tran vdout0_147ck1060 FIND v(dout0_147) AT=535.025n

.meas tran vdout0_148ck1060 FIND v(dout0_148) AT=535.025n

.meas tran vdout0_149ck1060 FIND v(dout0_149) AT=535.025n

.meas tran vdout0_150ck1060 FIND v(dout0_150) AT=535.025n

.meas tran vdout0_151ck1060 FIND v(dout0_151) AT=535.025n

.meas tran vdout0_152ck1060 FIND v(dout0_152) AT=535.025n

.meas tran vdout0_153ck1060 FIND v(dout0_153) AT=535.025n

.meas tran vdout0_154ck1060 FIND v(dout0_154) AT=535.025n

.meas tran vdout0_155ck1060 FIND v(dout0_155) AT=535.025n

.meas tran vdout0_156ck1060 FIND v(dout0_156) AT=535.025n

.meas tran vdout0_157ck1060 FIND v(dout0_157) AT=535.025n

.meas tran vdout0_158ck1060 FIND v(dout0_158) AT=535.025n

.meas tran vdout0_159ck1060 FIND v(dout0_159) AT=535.025n

.meas tran vdout0_160ck1060 FIND v(dout0_160) AT=535.025n

.meas tran vdout0_161ck1060 FIND v(dout0_161) AT=535.025n

.meas tran vdout0_162ck1060 FIND v(dout0_162) AT=535.025n

.meas tran vdout0_163ck1060 FIND v(dout0_163) AT=535.025n

.meas tran vdout0_164ck1060 FIND v(dout0_164) AT=535.025n

.meas tran vdout0_165ck1060 FIND v(dout0_165) AT=535.025n

.meas tran vdout0_166ck1060 FIND v(dout0_166) AT=535.025n

.meas tran vdout0_167ck1060 FIND v(dout0_167) AT=535.025n

.meas tran vdout0_168ck1060 FIND v(dout0_168) AT=535.025n

.meas tran vdout0_169ck1060 FIND v(dout0_169) AT=535.025n

.meas tran vdout0_170ck1060 FIND v(dout0_170) AT=535.025n

.meas tran vdout0_171ck1060 FIND v(dout0_171) AT=535.025n

.meas tran vdout0_172ck1060 FIND v(dout0_172) AT=535.025n

.meas tran vdout0_173ck1060 FIND v(dout0_173) AT=535.025n

.meas tran vdout0_174ck1060 FIND v(dout0_174) AT=535.025n

.meas tran vdout0_175ck1060 FIND v(dout0_175) AT=535.025n

.meas tran vdout0_176ck1060 FIND v(dout0_176) AT=535.025n

.meas tran vdout0_177ck1060 FIND v(dout0_177) AT=535.025n

.meas tran vdout0_178ck1060 FIND v(dout0_178) AT=535.025n

.meas tran vdout0_179ck1060 FIND v(dout0_179) AT=535.025n

.meas tran vdout0_180ck1060 FIND v(dout0_180) AT=535.025n

.meas tran vdout0_181ck1060 FIND v(dout0_181) AT=535.025n

.meas tran vdout0_182ck1060 FIND v(dout0_182) AT=535.025n

.meas tran vdout0_183ck1060 FIND v(dout0_183) AT=535.025n

.meas tran vdout0_184ck1060 FIND v(dout0_184) AT=535.025n

.meas tran vdout0_185ck1060 FIND v(dout0_185) AT=535.025n

.meas tran vdout0_186ck1060 FIND v(dout0_186) AT=535.025n

.meas tran vdout0_187ck1060 FIND v(dout0_187) AT=535.025n

.meas tran vdout0_188ck1060 FIND v(dout0_188) AT=535.025n

.meas tran vdout0_189ck1060 FIND v(dout0_189) AT=535.025n

.meas tran vdout0_190ck1060 FIND v(dout0_190) AT=535.025n

.meas tran vdout0_191ck1060 FIND v(dout0_191) AT=535.025n

.meas tran vdout0_192ck1060 FIND v(dout0_192) AT=535.025n

.meas tran vdout0_193ck1060 FIND v(dout0_193) AT=535.025n

.meas tran vdout0_194ck1060 FIND v(dout0_194) AT=535.025n

.meas tran vdout0_195ck1060 FIND v(dout0_195) AT=535.025n

.meas tran vdout0_196ck1060 FIND v(dout0_196) AT=535.025n

.meas tran vdout0_197ck1060 FIND v(dout0_197) AT=535.025n

.meas tran vdout0_198ck1060 FIND v(dout0_198) AT=535.025n

.meas tran vdout0_199ck1060 FIND v(dout0_199) AT=535.025n

.meas tran vdout0_200ck1060 FIND v(dout0_200) AT=535.025n

.meas tran vdout0_201ck1060 FIND v(dout0_201) AT=535.025n

.meas tran vdout0_202ck1060 FIND v(dout0_202) AT=535.025n

.meas tran vdout0_203ck1060 FIND v(dout0_203) AT=535.025n

.meas tran vdout0_204ck1060 FIND v(dout0_204) AT=535.025n

.meas tran vdout0_205ck1060 FIND v(dout0_205) AT=535.025n

.meas tran vdout0_206ck1060 FIND v(dout0_206) AT=535.025n

.meas tran vdout0_207ck1060 FIND v(dout0_207) AT=535.025n

.meas tran vdout0_208ck1060 FIND v(dout0_208) AT=535.025n

.meas tran vdout0_209ck1060 FIND v(dout0_209) AT=535.025n

.meas tran vdout0_210ck1060 FIND v(dout0_210) AT=535.025n

.meas tran vdout0_211ck1060 FIND v(dout0_211) AT=535.025n

.meas tran vdout0_212ck1060 FIND v(dout0_212) AT=535.025n

.meas tran vdout0_213ck1060 FIND v(dout0_213) AT=535.025n

.meas tran vdout0_214ck1060 FIND v(dout0_214) AT=535.025n

.meas tran vdout0_215ck1060 FIND v(dout0_215) AT=535.025n

.meas tran vdout0_216ck1060 FIND v(dout0_216) AT=535.025n

.meas tran vdout0_217ck1060 FIND v(dout0_217) AT=535.025n

.meas tran vdout0_218ck1060 FIND v(dout0_218) AT=535.025n

.meas tran vdout0_219ck1060 FIND v(dout0_219) AT=535.025n

.meas tran vdout0_220ck1060 FIND v(dout0_220) AT=535.025n

.meas tran vdout0_221ck1060 FIND v(dout0_221) AT=535.025n

.meas tran vdout0_222ck1060 FIND v(dout0_222) AT=535.025n

.meas tran vdout0_223ck1060 FIND v(dout0_223) AT=535.025n

.meas tran vdout0_224ck1060 FIND v(dout0_224) AT=535.025n

.meas tran vdout0_225ck1060 FIND v(dout0_225) AT=535.025n

.meas tran vdout0_226ck1060 FIND v(dout0_226) AT=535.025n

.meas tran vdout0_227ck1060 FIND v(dout0_227) AT=535.025n

.meas tran vdout0_228ck1060 FIND v(dout0_228) AT=535.025n

.meas tran vdout0_229ck1060 FIND v(dout0_229) AT=535.025n

.meas tran vdout0_230ck1060 FIND v(dout0_230) AT=535.025n

.meas tran vdout0_231ck1060 FIND v(dout0_231) AT=535.025n

.meas tran vdout0_232ck1060 FIND v(dout0_232) AT=535.025n

.meas tran vdout0_233ck1060 FIND v(dout0_233) AT=535.025n

.meas tran vdout0_234ck1060 FIND v(dout0_234) AT=535.025n

.meas tran vdout0_235ck1060 FIND v(dout0_235) AT=535.025n

.meas tran vdout0_236ck1060 FIND v(dout0_236) AT=535.025n

.meas tran vdout0_237ck1060 FIND v(dout0_237) AT=535.025n

.meas tran vdout0_238ck1060 FIND v(dout0_238) AT=535.025n

.meas tran vdout0_239ck1060 FIND v(dout0_239) AT=535.025n

.meas tran vdout0_240ck1060 FIND v(dout0_240) AT=535.025n

.meas tran vdout0_241ck1060 FIND v(dout0_241) AT=535.025n

.meas tran vdout0_242ck1060 FIND v(dout0_242) AT=535.025n

.meas tran vdout0_243ck1060 FIND v(dout0_243) AT=535.025n

.meas tran vdout0_244ck1060 FIND v(dout0_244) AT=535.025n

.meas tran vdout0_245ck1060 FIND v(dout0_245) AT=535.025n

.meas tran vdout0_246ck1060 FIND v(dout0_246) AT=535.025n

.meas tran vdout0_247ck1060 FIND v(dout0_247) AT=535.025n

.meas tran vdout0_248ck1060 FIND v(dout0_248) AT=535.025n

.meas tran vdout0_249ck1060 FIND v(dout0_249) AT=535.025n

.meas tran vdout0_250ck1060 FIND v(dout0_250) AT=535.025n

.meas tran vdout0_251ck1060 FIND v(dout0_251) AT=535.025n

.meas tran vdout0_252ck1060 FIND v(dout0_252) AT=535.025n

.meas tran vdout0_253ck1060 FIND v(dout0_253) AT=535.025n

.meas tran vdout0_254ck1060 FIND v(dout0_254) AT=535.025n

.meas tran vdout0_255ck1060 FIND v(dout0_255) AT=535.025n

.meas tran vdout0_0ck1090 FIND v(dout0_0) AT=550.025n

.meas tran vdout0_1ck1090 FIND v(dout0_1) AT=550.025n

.meas tran vdout0_2ck1090 FIND v(dout0_2) AT=550.025n

.meas tran vdout0_3ck1090 FIND v(dout0_3) AT=550.025n

.meas tran vdout0_4ck1090 FIND v(dout0_4) AT=550.025n

.meas tran vdout0_5ck1090 FIND v(dout0_5) AT=550.025n

.meas tran vdout0_6ck1090 FIND v(dout0_6) AT=550.025n

.meas tran vdout0_7ck1090 FIND v(dout0_7) AT=550.025n

.meas tran vdout0_8ck1090 FIND v(dout0_8) AT=550.025n

.meas tran vdout0_9ck1090 FIND v(dout0_9) AT=550.025n

.meas tran vdout0_10ck1090 FIND v(dout0_10) AT=550.025n

.meas tran vdout0_11ck1090 FIND v(dout0_11) AT=550.025n

.meas tran vdout0_12ck1090 FIND v(dout0_12) AT=550.025n

.meas tran vdout0_13ck1090 FIND v(dout0_13) AT=550.025n

.meas tran vdout0_14ck1090 FIND v(dout0_14) AT=550.025n

.meas tran vdout0_15ck1090 FIND v(dout0_15) AT=550.025n

.meas tran vdout0_16ck1090 FIND v(dout0_16) AT=550.025n

.meas tran vdout0_17ck1090 FIND v(dout0_17) AT=550.025n

.meas tran vdout0_18ck1090 FIND v(dout0_18) AT=550.025n

.meas tran vdout0_19ck1090 FIND v(dout0_19) AT=550.025n

.meas tran vdout0_20ck1090 FIND v(dout0_20) AT=550.025n

.meas tran vdout0_21ck1090 FIND v(dout0_21) AT=550.025n

.meas tran vdout0_22ck1090 FIND v(dout0_22) AT=550.025n

.meas tran vdout0_23ck1090 FIND v(dout0_23) AT=550.025n

.meas tran vdout0_24ck1090 FIND v(dout0_24) AT=550.025n

.meas tran vdout0_25ck1090 FIND v(dout0_25) AT=550.025n

.meas tran vdout0_26ck1090 FIND v(dout0_26) AT=550.025n

.meas tran vdout0_27ck1090 FIND v(dout0_27) AT=550.025n

.meas tran vdout0_28ck1090 FIND v(dout0_28) AT=550.025n

.meas tran vdout0_29ck1090 FIND v(dout0_29) AT=550.025n

.meas tran vdout0_30ck1090 FIND v(dout0_30) AT=550.025n

.meas tran vdout0_31ck1090 FIND v(dout0_31) AT=550.025n

.meas tran vdout0_32ck1090 FIND v(dout0_32) AT=550.025n

.meas tran vdout0_33ck1090 FIND v(dout0_33) AT=550.025n

.meas tran vdout0_34ck1090 FIND v(dout0_34) AT=550.025n

.meas tran vdout0_35ck1090 FIND v(dout0_35) AT=550.025n

.meas tran vdout0_36ck1090 FIND v(dout0_36) AT=550.025n

.meas tran vdout0_37ck1090 FIND v(dout0_37) AT=550.025n

.meas tran vdout0_38ck1090 FIND v(dout0_38) AT=550.025n

.meas tran vdout0_39ck1090 FIND v(dout0_39) AT=550.025n

.meas tran vdout0_40ck1090 FIND v(dout0_40) AT=550.025n

.meas tran vdout0_41ck1090 FIND v(dout0_41) AT=550.025n

.meas tran vdout0_42ck1090 FIND v(dout0_42) AT=550.025n

.meas tran vdout0_43ck1090 FIND v(dout0_43) AT=550.025n

.meas tran vdout0_44ck1090 FIND v(dout0_44) AT=550.025n

.meas tran vdout0_45ck1090 FIND v(dout0_45) AT=550.025n

.meas tran vdout0_46ck1090 FIND v(dout0_46) AT=550.025n

.meas tran vdout0_47ck1090 FIND v(dout0_47) AT=550.025n

.meas tran vdout0_48ck1090 FIND v(dout0_48) AT=550.025n

.meas tran vdout0_49ck1090 FIND v(dout0_49) AT=550.025n

.meas tran vdout0_50ck1090 FIND v(dout0_50) AT=550.025n

.meas tran vdout0_51ck1090 FIND v(dout0_51) AT=550.025n

.meas tran vdout0_52ck1090 FIND v(dout0_52) AT=550.025n

.meas tran vdout0_53ck1090 FIND v(dout0_53) AT=550.025n

.meas tran vdout0_54ck1090 FIND v(dout0_54) AT=550.025n

.meas tran vdout0_55ck1090 FIND v(dout0_55) AT=550.025n

.meas tran vdout0_56ck1090 FIND v(dout0_56) AT=550.025n

.meas tran vdout0_57ck1090 FIND v(dout0_57) AT=550.025n

.meas tran vdout0_58ck1090 FIND v(dout0_58) AT=550.025n

.meas tran vdout0_59ck1090 FIND v(dout0_59) AT=550.025n

.meas tran vdout0_60ck1090 FIND v(dout0_60) AT=550.025n

.meas tran vdout0_61ck1090 FIND v(dout0_61) AT=550.025n

.meas tran vdout0_62ck1090 FIND v(dout0_62) AT=550.025n

.meas tran vdout0_63ck1090 FIND v(dout0_63) AT=550.025n

.meas tran vdout0_64ck1090 FIND v(dout0_64) AT=550.025n

.meas tran vdout0_65ck1090 FIND v(dout0_65) AT=550.025n

.meas tran vdout0_66ck1090 FIND v(dout0_66) AT=550.025n

.meas tran vdout0_67ck1090 FIND v(dout0_67) AT=550.025n

.meas tran vdout0_68ck1090 FIND v(dout0_68) AT=550.025n

.meas tran vdout0_69ck1090 FIND v(dout0_69) AT=550.025n

.meas tran vdout0_70ck1090 FIND v(dout0_70) AT=550.025n

.meas tran vdout0_71ck1090 FIND v(dout0_71) AT=550.025n

.meas tran vdout0_72ck1090 FIND v(dout0_72) AT=550.025n

.meas tran vdout0_73ck1090 FIND v(dout0_73) AT=550.025n

.meas tran vdout0_74ck1090 FIND v(dout0_74) AT=550.025n

.meas tran vdout0_75ck1090 FIND v(dout0_75) AT=550.025n

.meas tran vdout0_76ck1090 FIND v(dout0_76) AT=550.025n

.meas tran vdout0_77ck1090 FIND v(dout0_77) AT=550.025n

.meas tran vdout0_78ck1090 FIND v(dout0_78) AT=550.025n

.meas tran vdout0_79ck1090 FIND v(dout0_79) AT=550.025n

.meas tran vdout0_80ck1090 FIND v(dout0_80) AT=550.025n

.meas tran vdout0_81ck1090 FIND v(dout0_81) AT=550.025n

.meas tran vdout0_82ck1090 FIND v(dout0_82) AT=550.025n

.meas tran vdout0_83ck1090 FIND v(dout0_83) AT=550.025n

.meas tran vdout0_84ck1090 FIND v(dout0_84) AT=550.025n

.meas tran vdout0_85ck1090 FIND v(dout0_85) AT=550.025n

.meas tran vdout0_86ck1090 FIND v(dout0_86) AT=550.025n

.meas tran vdout0_87ck1090 FIND v(dout0_87) AT=550.025n

.meas tran vdout0_88ck1090 FIND v(dout0_88) AT=550.025n

.meas tran vdout0_89ck1090 FIND v(dout0_89) AT=550.025n

.meas tran vdout0_90ck1090 FIND v(dout0_90) AT=550.025n

.meas tran vdout0_91ck1090 FIND v(dout0_91) AT=550.025n

.meas tran vdout0_92ck1090 FIND v(dout0_92) AT=550.025n

.meas tran vdout0_93ck1090 FIND v(dout0_93) AT=550.025n

.meas tran vdout0_94ck1090 FIND v(dout0_94) AT=550.025n

.meas tran vdout0_95ck1090 FIND v(dout0_95) AT=550.025n

.meas tran vdout0_96ck1090 FIND v(dout0_96) AT=550.025n

.meas tran vdout0_97ck1090 FIND v(dout0_97) AT=550.025n

.meas tran vdout0_98ck1090 FIND v(dout0_98) AT=550.025n

.meas tran vdout0_99ck1090 FIND v(dout0_99) AT=550.025n

.meas tran vdout0_100ck1090 FIND v(dout0_100) AT=550.025n

.meas tran vdout0_101ck1090 FIND v(dout0_101) AT=550.025n

.meas tran vdout0_102ck1090 FIND v(dout0_102) AT=550.025n

.meas tran vdout0_103ck1090 FIND v(dout0_103) AT=550.025n

.meas tran vdout0_104ck1090 FIND v(dout0_104) AT=550.025n

.meas tran vdout0_105ck1090 FIND v(dout0_105) AT=550.025n

.meas tran vdout0_106ck1090 FIND v(dout0_106) AT=550.025n

.meas tran vdout0_107ck1090 FIND v(dout0_107) AT=550.025n

.meas tran vdout0_108ck1090 FIND v(dout0_108) AT=550.025n

.meas tran vdout0_109ck1090 FIND v(dout0_109) AT=550.025n

.meas tran vdout0_110ck1090 FIND v(dout0_110) AT=550.025n

.meas tran vdout0_111ck1090 FIND v(dout0_111) AT=550.025n

.meas tran vdout0_112ck1090 FIND v(dout0_112) AT=550.025n

.meas tran vdout0_113ck1090 FIND v(dout0_113) AT=550.025n

.meas tran vdout0_114ck1090 FIND v(dout0_114) AT=550.025n

.meas tran vdout0_115ck1090 FIND v(dout0_115) AT=550.025n

.meas tran vdout0_116ck1090 FIND v(dout0_116) AT=550.025n

.meas tran vdout0_117ck1090 FIND v(dout0_117) AT=550.025n

.meas tran vdout0_118ck1090 FIND v(dout0_118) AT=550.025n

.meas tran vdout0_119ck1090 FIND v(dout0_119) AT=550.025n

.meas tran vdout0_120ck1090 FIND v(dout0_120) AT=550.025n

.meas tran vdout0_121ck1090 FIND v(dout0_121) AT=550.025n

.meas tran vdout0_122ck1090 FIND v(dout0_122) AT=550.025n

.meas tran vdout0_123ck1090 FIND v(dout0_123) AT=550.025n

.meas tran vdout0_124ck1090 FIND v(dout0_124) AT=550.025n

.meas tran vdout0_125ck1090 FIND v(dout0_125) AT=550.025n

.meas tran vdout0_126ck1090 FIND v(dout0_126) AT=550.025n

.meas tran vdout0_127ck1090 FIND v(dout0_127) AT=550.025n

.meas tran vdout0_128ck1090 FIND v(dout0_128) AT=550.025n

.meas tran vdout0_129ck1090 FIND v(dout0_129) AT=550.025n

.meas tran vdout0_130ck1090 FIND v(dout0_130) AT=550.025n

.meas tran vdout0_131ck1090 FIND v(dout0_131) AT=550.025n

.meas tran vdout0_132ck1090 FIND v(dout0_132) AT=550.025n

.meas tran vdout0_133ck1090 FIND v(dout0_133) AT=550.025n

.meas tran vdout0_134ck1090 FIND v(dout0_134) AT=550.025n

.meas tran vdout0_135ck1090 FIND v(dout0_135) AT=550.025n

.meas tran vdout0_136ck1090 FIND v(dout0_136) AT=550.025n

.meas tran vdout0_137ck1090 FIND v(dout0_137) AT=550.025n

.meas tran vdout0_138ck1090 FIND v(dout0_138) AT=550.025n

.meas tran vdout0_139ck1090 FIND v(dout0_139) AT=550.025n

.meas tran vdout0_140ck1090 FIND v(dout0_140) AT=550.025n

.meas tran vdout0_141ck1090 FIND v(dout0_141) AT=550.025n

.meas tran vdout0_142ck1090 FIND v(dout0_142) AT=550.025n

.meas tran vdout0_143ck1090 FIND v(dout0_143) AT=550.025n

.meas tran vdout0_144ck1090 FIND v(dout0_144) AT=550.025n

.meas tran vdout0_145ck1090 FIND v(dout0_145) AT=550.025n

.meas tran vdout0_146ck1090 FIND v(dout0_146) AT=550.025n

.meas tran vdout0_147ck1090 FIND v(dout0_147) AT=550.025n

.meas tran vdout0_148ck1090 FIND v(dout0_148) AT=550.025n

.meas tran vdout0_149ck1090 FIND v(dout0_149) AT=550.025n

.meas tran vdout0_150ck1090 FIND v(dout0_150) AT=550.025n

.meas tran vdout0_151ck1090 FIND v(dout0_151) AT=550.025n

.meas tran vdout0_152ck1090 FIND v(dout0_152) AT=550.025n

.meas tran vdout0_153ck1090 FIND v(dout0_153) AT=550.025n

.meas tran vdout0_154ck1090 FIND v(dout0_154) AT=550.025n

.meas tran vdout0_155ck1090 FIND v(dout0_155) AT=550.025n

.meas tran vdout0_156ck1090 FIND v(dout0_156) AT=550.025n

.meas tran vdout0_157ck1090 FIND v(dout0_157) AT=550.025n

.meas tran vdout0_158ck1090 FIND v(dout0_158) AT=550.025n

.meas tran vdout0_159ck1090 FIND v(dout0_159) AT=550.025n

.meas tran vdout0_160ck1090 FIND v(dout0_160) AT=550.025n

.meas tran vdout0_161ck1090 FIND v(dout0_161) AT=550.025n

.meas tran vdout0_162ck1090 FIND v(dout0_162) AT=550.025n

.meas tran vdout0_163ck1090 FIND v(dout0_163) AT=550.025n

.meas tran vdout0_164ck1090 FIND v(dout0_164) AT=550.025n

.meas tran vdout0_165ck1090 FIND v(dout0_165) AT=550.025n

.meas tran vdout0_166ck1090 FIND v(dout0_166) AT=550.025n

.meas tran vdout0_167ck1090 FIND v(dout0_167) AT=550.025n

.meas tran vdout0_168ck1090 FIND v(dout0_168) AT=550.025n

.meas tran vdout0_169ck1090 FIND v(dout0_169) AT=550.025n

.meas tran vdout0_170ck1090 FIND v(dout0_170) AT=550.025n

.meas tran vdout0_171ck1090 FIND v(dout0_171) AT=550.025n

.meas tran vdout0_172ck1090 FIND v(dout0_172) AT=550.025n

.meas tran vdout0_173ck1090 FIND v(dout0_173) AT=550.025n

.meas tran vdout0_174ck1090 FIND v(dout0_174) AT=550.025n

.meas tran vdout0_175ck1090 FIND v(dout0_175) AT=550.025n

.meas tran vdout0_176ck1090 FIND v(dout0_176) AT=550.025n

.meas tran vdout0_177ck1090 FIND v(dout0_177) AT=550.025n

.meas tran vdout0_178ck1090 FIND v(dout0_178) AT=550.025n

.meas tran vdout0_179ck1090 FIND v(dout0_179) AT=550.025n

.meas tran vdout0_180ck1090 FIND v(dout0_180) AT=550.025n

.meas tran vdout0_181ck1090 FIND v(dout0_181) AT=550.025n

.meas tran vdout0_182ck1090 FIND v(dout0_182) AT=550.025n

.meas tran vdout0_183ck1090 FIND v(dout0_183) AT=550.025n

.meas tran vdout0_184ck1090 FIND v(dout0_184) AT=550.025n

.meas tran vdout0_185ck1090 FIND v(dout0_185) AT=550.025n

.meas tran vdout0_186ck1090 FIND v(dout0_186) AT=550.025n

.meas tran vdout0_187ck1090 FIND v(dout0_187) AT=550.025n

.meas tran vdout0_188ck1090 FIND v(dout0_188) AT=550.025n

.meas tran vdout0_189ck1090 FIND v(dout0_189) AT=550.025n

.meas tran vdout0_190ck1090 FIND v(dout0_190) AT=550.025n

.meas tran vdout0_191ck1090 FIND v(dout0_191) AT=550.025n

.meas tran vdout0_192ck1090 FIND v(dout0_192) AT=550.025n

.meas tran vdout0_193ck1090 FIND v(dout0_193) AT=550.025n

.meas tran vdout0_194ck1090 FIND v(dout0_194) AT=550.025n

.meas tran vdout0_195ck1090 FIND v(dout0_195) AT=550.025n

.meas tran vdout0_196ck1090 FIND v(dout0_196) AT=550.025n

.meas tran vdout0_197ck1090 FIND v(dout0_197) AT=550.025n

.meas tran vdout0_198ck1090 FIND v(dout0_198) AT=550.025n

.meas tran vdout0_199ck1090 FIND v(dout0_199) AT=550.025n

.meas tran vdout0_200ck1090 FIND v(dout0_200) AT=550.025n

.meas tran vdout0_201ck1090 FIND v(dout0_201) AT=550.025n

.meas tran vdout0_202ck1090 FIND v(dout0_202) AT=550.025n

.meas tran vdout0_203ck1090 FIND v(dout0_203) AT=550.025n

.meas tran vdout0_204ck1090 FIND v(dout0_204) AT=550.025n

.meas tran vdout0_205ck1090 FIND v(dout0_205) AT=550.025n

.meas tran vdout0_206ck1090 FIND v(dout0_206) AT=550.025n

.meas tran vdout0_207ck1090 FIND v(dout0_207) AT=550.025n

.meas tran vdout0_208ck1090 FIND v(dout0_208) AT=550.025n

.meas tran vdout0_209ck1090 FIND v(dout0_209) AT=550.025n

.meas tran vdout0_210ck1090 FIND v(dout0_210) AT=550.025n

.meas tran vdout0_211ck1090 FIND v(dout0_211) AT=550.025n

.meas tran vdout0_212ck1090 FIND v(dout0_212) AT=550.025n

.meas tran vdout0_213ck1090 FIND v(dout0_213) AT=550.025n

.meas tran vdout0_214ck1090 FIND v(dout0_214) AT=550.025n

.meas tran vdout0_215ck1090 FIND v(dout0_215) AT=550.025n

.meas tran vdout0_216ck1090 FIND v(dout0_216) AT=550.025n

.meas tran vdout0_217ck1090 FIND v(dout0_217) AT=550.025n

.meas tran vdout0_218ck1090 FIND v(dout0_218) AT=550.025n

.meas tran vdout0_219ck1090 FIND v(dout0_219) AT=550.025n

.meas tran vdout0_220ck1090 FIND v(dout0_220) AT=550.025n

.meas tran vdout0_221ck1090 FIND v(dout0_221) AT=550.025n

.meas tran vdout0_222ck1090 FIND v(dout0_222) AT=550.025n

.meas tran vdout0_223ck1090 FIND v(dout0_223) AT=550.025n

.meas tran vdout0_224ck1090 FIND v(dout0_224) AT=550.025n

.meas tran vdout0_225ck1090 FIND v(dout0_225) AT=550.025n

.meas tran vdout0_226ck1090 FIND v(dout0_226) AT=550.025n

.meas tran vdout0_227ck1090 FIND v(dout0_227) AT=550.025n

.meas tran vdout0_228ck1090 FIND v(dout0_228) AT=550.025n

.meas tran vdout0_229ck1090 FIND v(dout0_229) AT=550.025n

.meas tran vdout0_230ck1090 FIND v(dout0_230) AT=550.025n

.meas tran vdout0_231ck1090 FIND v(dout0_231) AT=550.025n

.meas tran vdout0_232ck1090 FIND v(dout0_232) AT=550.025n

.meas tran vdout0_233ck1090 FIND v(dout0_233) AT=550.025n

.meas tran vdout0_234ck1090 FIND v(dout0_234) AT=550.025n

.meas tran vdout0_235ck1090 FIND v(dout0_235) AT=550.025n

.meas tran vdout0_236ck1090 FIND v(dout0_236) AT=550.025n

.meas tran vdout0_237ck1090 FIND v(dout0_237) AT=550.025n

.meas tran vdout0_238ck1090 FIND v(dout0_238) AT=550.025n

.meas tran vdout0_239ck1090 FIND v(dout0_239) AT=550.025n

.meas tran vdout0_240ck1090 FIND v(dout0_240) AT=550.025n

.meas tran vdout0_241ck1090 FIND v(dout0_241) AT=550.025n

.meas tran vdout0_242ck1090 FIND v(dout0_242) AT=550.025n

.meas tran vdout0_243ck1090 FIND v(dout0_243) AT=550.025n

.meas tran vdout0_244ck1090 FIND v(dout0_244) AT=550.025n

.meas tran vdout0_245ck1090 FIND v(dout0_245) AT=550.025n

.meas tran vdout0_246ck1090 FIND v(dout0_246) AT=550.025n

.meas tran vdout0_247ck1090 FIND v(dout0_247) AT=550.025n

.meas tran vdout0_248ck1090 FIND v(dout0_248) AT=550.025n

.meas tran vdout0_249ck1090 FIND v(dout0_249) AT=550.025n

.meas tran vdout0_250ck1090 FIND v(dout0_250) AT=550.025n

.meas tran vdout0_251ck1090 FIND v(dout0_251) AT=550.025n

.meas tran vdout0_252ck1090 FIND v(dout0_252) AT=550.025n

.meas tran vdout0_253ck1090 FIND v(dout0_253) AT=550.025n

.meas tran vdout0_254ck1090 FIND v(dout0_254) AT=550.025n

.meas tran vdout0_255ck1090 FIND v(dout0_255) AT=550.025n

.meas tran vdout0_0ck1120 FIND v(dout0_0) AT=565.025n

.meas tran vdout0_1ck1120 FIND v(dout0_1) AT=565.025n

.meas tran vdout0_2ck1120 FIND v(dout0_2) AT=565.025n

.meas tran vdout0_3ck1120 FIND v(dout0_3) AT=565.025n

.meas tran vdout0_4ck1120 FIND v(dout0_4) AT=565.025n

.meas tran vdout0_5ck1120 FIND v(dout0_5) AT=565.025n

.meas tran vdout0_6ck1120 FIND v(dout0_6) AT=565.025n

.meas tran vdout0_7ck1120 FIND v(dout0_7) AT=565.025n

.meas tran vdout0_8ck1120 FIND v(dout0_8) AT=565.025n

.meas tran vdout0_9ck1120 FIND v(dout0_9) AT=565.025n

.meas tran vdout0_10ck1120 FIND v(dout0_10) AT=565.025n

.meas tran vdout0_11ck1120 FIND v(dout0_11) AT=565.025n

.meas tran vdout0_12ck1120 FIND v(dout0_12) AT=565.025n

.meas tran vdout0_13ck1120 FIND v(dout0_13) AT=565.025n

.meas tran vdout0_14ck1120 FIND v(dout0_14) AT=565.025n

.meas tran vdout0_15ck1120 FIND v(dout0_15) AT=565.025n

.meas tran vdout0_16ck1120 FIND v(dout0_16) AT=565.025n

.meas tran vdout0_17ck1120 FIND v(dout0_17) AT=565.025n

.meas tran vdout0_18ck1120 FIND v(dout0_18) AT=565.025n

.meas tran vdout0_19ck1120 FIND v(dout0_19) AT=565.025n

.meas tran vdout0_20ck1120 FIND v(dout0_20) AT=565.025n

.meas tran vdout0_21ck1120 FIND v(dout0_21) AT=565.025n

.meas tran vdout0_22ck1120 FIND v(dout0_22) AT=565.025n

.meas tran vdout0_23ck1120 FIND v(dout0_23) AT=565.025n

.meas tran vdout0_24ck1120 FIND v(dout0_24) AT=565.025n

.meas tran vdout0_25ck1120 FIND v(dout0_25) AT=565.025n

.meas tran vdout0_26ck1120 FIND v(dout0_26) AT=565.025n

.meas tran vdout0_27ck1120 FIND v(dout0_27) AT=565.025n

.meas tran vdout0_28ck1120 FIND v(dout0_28) AT=565.025n

.meas tran vdout0_29ck1120 FIND v(dout0_29) AT=565.025n

.meas tran vdout0_30ck1120 FIND v(dout0_30) AT=565.025n

.meas tran vdout0_31ck1120 FIND v(dout0_31) AT=565.025n

.meas tran vdout0_32ck1120 FIND v(dout0_32) AT=565.025n

.meas tran vdout0_33ck1120 FIND v(dout0_33) AT=565.025n

.meas tran vdout0_34ck1120 FIND v(dout0_34) AT=565.025n

.meas tran vdout0_35ck1120 FIND v(dout0_35) AT=565.025n

.meas tran vdout0_36ck1120 FIND v(dout0_36) AT=565.025n

.meas tran vdout0_37ck1120 FIND v(dout0_37) AT=565.025n

.meas tran vdout0_38ck1120 FIND v(dout0_38) AT=565.025n

.meas tran vdout0_39ck1120 FIND v(dout0_39) AT=565.025n

.meas tran vdout0_40ck1120 FIND v(dout0_40) AT=565.025n

.meas tran vdout0_41ck1120 FIND v(dout0_41) AT=565.025n

.meas tran vdout0_42ck1120 FIND v(dout0_42) AT=565.025n

.meas tran vdout0_43ck1120 FIND v(dout0_43) AT=565.025n

.meas tran vdout0_44ck1120 FIND v(dout0_44) AT=565.025n

.meas tran vdout0_45ck1120 FIND v(dout0_45) AT=565.025n

.meas tran vdout0_46ck1120 FIND v(dout0_46) AT=565.025n

.meas tran vdout0_47ck1120 FIND v(dout0_47) AT=565.025n

.meas tran vdout0_48ck1120 FIND v(dout0_48) AT=565.025n

.meas tran vdout0_49ck1120 FIND v(dout0_49) AT=565.025n

.meas tran vdout0_50ck1120 FIND v(dout0_50) AT=565.025n

.meas tran vdout0_51ck1120 FIND v(dout0_51) AT=565.025n

.meas tran vdout0_52ck1120 FIND v(dout0_52) AT=565.025n

.meas tran vdout0_53ck1120 FIND v(dout0_53) AT=565.025n

.meas tran vdout0_54ck1120 FIND v(dout0_54) AT=565.025n

.meas tran vdout0_55ck1120 FIND v(dout0_55) AT=565.025n

.meas tran vdout0_56ck1120 FIND v(dout0_56) AT=565.025n

.meas tran vdout0_57ck1120 FIND v(dout0_57) AT=565.025n

.meas tran vdout0_58ck1120 FIND v(dout0_58) AT=565.025n

.meas tran vdout0_59ck1120 FIND v(dout0_59) AT=565.025n

.meas tran vdout0_60ck1120 FIND v(dout0_60) AT=565.025n

.meas tran vdout0_61ck1120 FIND v(dout0_61) AT=565.025n

.meas tran vdout0_62ck1120 FIND v(dout0_62) AT=565.025n

.meas tran vdout0_63ck1120 FIND v(dout0_63) AT=565.025n

.meas tran vdout0_64ck1120 FIND v(dout0_64) AT=565.025n

.meas tran vdout0_65ck1120 FIND v(dout0_65) AT=565.025n

.meas tran vdout0_66ck1120 FIND v(dout0_66) AT=565.025n

.meas tran vdout0_67ck1120 FIND v(dout0_67) AT=565.025n

.meas tran vdout0_68ck1120 FIND v(dout0_68) AT=565.025n

.meas tran vdout0_69ck1120 FIND v(dout0_69) AT=565.025n

.meas tran vdout0_70ck1120 FIND v(dout0_70) AT=565.025n

.meas tran vdout0_71ck1120 FIND v(dout0_71) AT=565.025n

.meas tran vdout0_72ck1120 FIND v(dout0_72) AT=565.025n

.meas tran vdout0_73ck1120 FIND v(dout0_73) AT=565.025n

.meas tran vdout0_74ck1120 FIND v(dout0_74) AT=565.025n

.meas tran vdout0_75ck1120 FIND v(dout0_75) AT=565.025n

.meas tran vdout0_76ck1120 FIND v(dout0_76) AT=565.025n

.meas tran vdout0_77ck1120 FIND v(dout0_77) AT=565.025n

.meas tran vdout0_78ck1120 FIND v(dout0_78) AT=565.025n

.meas tran vdout0_79ck1120 FIND v(dout0_79) AT=565.025n

.meas tran vdout0_80ck1120 FIND v(dout0_80) AT=565.025n

.meas tran vdout0_81ck1120 FIND v(dout0_81) AT=565.025n

.meas tran vdout0_82ck1120 FIND v(dout0_82) AT=565.025n

.meas tran vdout0_83ck1120 FIND v(dout0_83) AT=565.025n

.meas tran vdout0_84ck1120 FIND v(dout0_84) AT=565.025n

.meas tran vdout0_85ck1120 FIND v(dout0_85) AT=565.025n

.meas tran vdout0_86ck1120 FIND v(dout0_86) AT=565.025n

.meas tran vdout0_87ck1120 FIND v(dout0_87) AT=565.025n

.meas tran vdout0_88ck1120 FIND v(dout0_88) AT=565.025n

.meas tran vdout0_89ck1120 FIND v(dout0_89) AT=565.025n

.meas tran vdout0_90ck1120 FIND v(dout0_90) AT=565.025n

.meas tran vdout0_91ck1120 FIND v(dout0_91) AT=565.025n

.meas tran vdout0_92ck1120 FIND v(dout0_92) AT=565.025n

.meas tran vdout0_93ck1120 FIND v(dout0_93) AT=565.025n

.meas tran vdout0_94ck1120 FIND v(dout0_94) AT=565.025n

.meas tran vdout0_95ck1120 FIND v(dout0_95) AT=565.025n

.meas tran vdout0_96ck1120 FIND v(dout0_96) AT=565.025n

.meas tran vdout0_97ck1120 FIND v(dout0_97) AT=565.025n

.meas tran vdout0_98ck1120 FIND v(dout0_98) AT=565.025n

.meas tran vdout0_99ck1120 FIND v(dout0_99) AT=565.025n

.meas tran vdout0_100ck1120 FIND v(dout0_100) AT=565.025n

.meas tran vdout0_101ck1120 FIND v(dout0_101) AT=565.025n

.meas tran vdout0_102ck1120 FIND v(dout0_102) AT=565.025n

.meas tran vdout0_103ck1120 FIND v(dout0_103) AT=565.025n

.meas tran vdout0_104ck1120 FIND v(dout0_104) AT=565.025n

.meas tran vdout0_105ck1120 FIND v(dout0_105) AT=565.025n

.meas tran vdout0_106ck1120 FIND v(dout0_106) AT=565.025n

.meas tran vdout0_107ck1120 FIND v(dout0_107) AT=565.025n

.meas tran vdout0_108ck1120 FIND v(dout0_108) AT=565.025n

.meas tran vdout0_109ck1120 FIND v(dout0_109) AT=565.025n

.meas tran vdout0_110ck1120 FIND v(dout0_110) AT=565.025n

.meas tran vdout0_111ck1120 FIND v(dout0_111) AT=565.025n

.meas tran vdout0_112ck1120 FIND v(dout0_112) AT=565.025n

.meas tran vdout0_113ck1120 FIND v(dout0_113) AT=565.025n

.meas tran vdout0_114ck1120 FIND v(dout0_114) AT=565.025n

.meas tran vdout0_115ck1120 FIND v(dout0_115) AT=565.025n

.meas tran vdout0_116ck1120 FIND v(dout0_116) AT=565.025n

.meas tran vdout0_117ck1120 FIND v(dout0_117) AT=565.025n

.meas tran vdout0_118ck1120 FIND v(dout0_118) AT=565.025n

.meas tran vdout0_119ck1120 FIND v(dout0_119) AT=565.025n

.meas tran vdout0_120ck1120 FIND v(dout0_120) AT=565.025n

.meas tran vdout0_121ck1120 FIND v(dout0_121) AT=565.025n

.meas tran vdout0_122ck1120 FIND v(dout0_122) AT=565.025n

.meas tran vdout0_123ck1120 FIND v(dout0_123) AT=565.025n

.meas tran vdout0_124ck1120 FIND v(dout0_124) AT=565.025n

.meas tran vdout0_125ck1120 FIND v(dout0_125) AT=565.025n

.meas tran vdout0_126ck1120 FIND v(dout0_126) AT=565.025n

.meas tran vdout0_127ck1120 FIND v(dout0_127) AT=565.025n

.meas tran vdout0_128ck1120 FIND v(dout0_128) AT=565.025n

.meas tran vdout0_129ck1120 FIND v(dout0_129) AT=565.025n

.meas tran vdout0_130ck1120 FIND v(dout0_130) AT=565.025n

.meas tran vdout0_131ck1120 FIND v(dout0_131) AT=565.025n

.meas tran vdout0_132ck1120 FIND v(dout0_132) AT=565.025n

.meas tran vdout0_133ck1120 FIND v(dout0_133) AT=565.025n

.meas tran vdout0_134ck1120 FIND v(dout0_134) AT=565.025n

.meas tran vdout0_135ck1120 FIND v(dout0_135) AT=565.025n

.meas tran vdout0_136ck1120 FIND v(dout0_136) AT=565.025n

.meas tran vdout0_137ck1120 FIND v(dout0_137) AT=565.025n

.meas tran vdout0_138ck1120 FIND v(dout0_138) AT=565.025n

.meas tran vdout0_139ck1120 FIND v(dout0_139) AT=565.025n

.meas tran vdout0_140ck1120 FIND v(dout0_140) AT=565.025n

.meas tran vdout0_141ck1120 FIND v(dout0_141) AT=565.025n

.meas tran vdout0_142ck1120 FIND v(dout0_142) AT=565.025n

.meas tran vdout0_143ck1120 FIND v(dout0_143) AT=565.025n

.meas tran vdout0_144ck1120 FIND v(dout0_144) AT=565.025n

.meas tran vdout0_145ck1120 FIND v(dout0_145) AT=565.025n

.meas tran vdout0_146ck1120 FIND v(dout0_146) AT=565.025n

.meas tran vdout0_147ck1120 FIND v(dout0_147) AT=565.025n

.meas tran vdout0_148ck1120 FIND v(dout0_148) AT=565.025n

.meas tran vdout0_149ck1120 FIND v(dout0_149) AT=565.025n

.meas tran vdout0_150ck1120 FIND v(dout0_150) AT=565.025n

.meas tran vdout0_151ck1120 FIND v(dout0_151) AT=565.025n

.meas tran vdout0_152ck1120 FIND v(dout0_152) AT=565.025n

.meas tran vdout0_153ck1120 FIND v(dout0_153) AT=565.025n

.meas tran vdout0_154ck1120 FIND v(dout0_154) AT=565.025n

.meas tran vdout0_155ck1120 FIND v(dout0_155) AT=565.025n

.meas tran vdout0_156ck1120 FIND v(dout0_156) AT=565.025n

.meas tran vdout0_157ck1120 FIND v(dout0_157) AT=565.025n

.meas tran vdout0_158ck1120 FIND v(dout0_158) AT=565.025n

.meas tran vdout0_159ck1120 FIND v(dout0_159) AT=565.025n

.meas tran vdout0_160ck1120 FIND v(dout0_160) AT=565.025n

.meas tran vdout0_161ck1120 FIND v(dout0_161) AT=565.025n

.meas tran vdout0_162ck1120 FIND v(dout0_162) AT=565.025n

.meas tran vdout0_163ck1120 FIND v(dout0_163) AT=565.025n

.meas tran vdout0_164ck1120 FIND v(dout0_164) AT=565.025n

.meas tran vdout0_165ck1120 FIND v(dout0_165) AT=565.025n

.meas tran vdout0_166ck1120 FIND v(dout0_166) AT=565.025n

.meas tran vdout0_167ck1120 FIND v(dout0_167) AT=565.025n

.meas tran vdout0_168ck1120 FIND v(dout0_168) AT=565.025n

.meas tran vdout0_169ck1120 FIND v(dout0_169) AT=565.025n

.meas tran vdout0_170ck1120 FIND v(dout0_170) AT=565.025n

.meas tran vdout0_171ck1120 FIND v(dout0_171) AT=565.025n

.meas tran vdout0_172ck1120 FIND v(dout0_172) AT=565.025n

.meas tran vdout0_173ck1120 FIND v(dout0_173) AT=565.025n

.meas tran vdout0_174ck1120 FIND v(dout0_174) AT=565.025n

.meas tran vdout0_175ck1120 FIND v(dout0_175) AT=565.025n

.meas tran vdout0_176ck1120 FIND v(dout0_176) AT=565.025n

.meas tran vdout0_177ck1120 FIND v(dout0_177) AT=565.025n

.meas tran vdout0_178ck1120 FIND v(dout0_178) AT=565.025n

.meas tran vdout0_179ck1120 FIND v(dout0_179) AT=565.025n

.meas tran vdout0_180ck1120 FIND v(dout0_180) AT=565.025n

.meas tran vdout0_181ck1120 FIND v(dout0_181) AT=565.025n

.meas tran vdout0_182ck1120 FIND v(dout0_182) AT=565.025n

.meas tran vdout0_183ck1120 FIND v(dout0_183) AT=565.025n

.meas tran vdout0_184ck1120 FIND v(dout0_184) AT=565.025n

.meas tran vdout0_185ck1120 FIND v(dout0_185) AT=565.025n

.meas tran vdout0_186ck1120 FIND v(dout0_186) AT=565.025n

.meas tran vdout0_187ck1120 FIND v(dout0_187) AT=565.025n

.meas tran vdout0_188ck1120 FIND v(dout0_188) AT=565.025n

.meas tran vdout0_189ck1120 FIND v(dout0_189) AT=565.025n

.meas tran vdout0_190ck1120 FIND v(dout0_190) AT=565.025n

.meas tran vdout0_191ck1120 FIND v(dout0_191) AT=565.025n

.meas tran vdout0_192ck1120 FIND v(dout0_192) AT=565.025n

.meas tran vdout0_193ck1120 FIND v(dout0_193) AT=565.025n

.meas tran vdout0_194ck1120 FIND v(dout0_194) AT=565.025n

.meas tran vdout0_195ck1120 FIND v(dout0_195) AT=565.025n

.meas tran vdout0_196ck1120 FIND v(dout0_196) AT=565.025n

.meas tran vdout0_197ck1120 FIND v(dout0_197) AT=565.025n

.meas tran vdout0_198ck1120 FIND v(dout0_198) AT=565.025n

.meas tran vdout0_199ck1120 FIND v(dout0_199) AT=565.025n

.meas tran vdout0_200ck1120 FIND v(dout0_200) AT=565.025n

.meas tran vdout0_201ck1120 FIND v(dout0_201) AT=565.025n

.meas tran vdout0_202ck1120 FIND v(dout0_202) AT=565.025n

.meas tran vdout0_203ck1120 FIND v(dout0_203) AT=565.025n

.meas tran vdout0_204ck1120 FIND v(dout0_204) AT=565.025n

.meas tran vdout0_205ck1120 FIND v(dout0_205) AT=565.025n

.meas tran vdout0_206ck1120 FIND v(dout0_206) AT=565.025n

.meas tran vdout0_207ck1120 FIND v(dout0_207) AT=565.025n

.meas tran vdout0_208ck1120 FIND v(dout0_208) AT=565.025n

.meas tran vdout0_209ck1120 FIND v(dout0_209) AT=565.025n

.meas tran vdout0_210ck1120 FIND v(dout0_210) AT=565.025n

.meas tran vdout0_211ck1120 FIND v(dout0_211) AT=565.025n

.meas tran vdout0_212ck1120 FIND v(dout0_212) AT=565.025n

.meas tran vdout0_213ck1120 FIND v(dout0_213) AT=565.025n

.meas tran vdout0_214ck1120 FIND v(dout0_214) AT=565.025n

.meas tran vdout0_215ck1120 FIND v(dout0_215) AT=565.025n

.meas tran vdout0_216ck1120 FIND v(dout0_216) AT=565.025n

.meas tran vdout0_217ck1120 FIND v(dout0_217) AT=565.025n

.meas tran vdout0_218ck1120 FIND v(dout0_218) AT=565.025n

.meas tran vdout0_219ck1120 FIND v(dout0_219) AT=565.025n

.meas tran vdout0_220ck1120 FIND v(dout0_220) AT=565.025n

.meas tran vdout0_221ck1120 FIND v(dout0_221) AT=565.025n

.meas tran vdout0_222ck1120 FIND v(dout0_222) AT=565.025n

.meas tran vdout0_223ck1120 FIND v(dout0_223) AT=565.025n

.meas tran vdout0_224ck1120 FIND v(dout0_224) AT=565.025n

.meas tran vdout0_225ck1120 FIND v(dout0_225) AT=565.025n

.meas tran vdout0_226ck1120 FIND v(dout0_226) AT=565.025n

.meas tran vdout0_227ck1120 FIND v(dout0_227) AT=565.025n

.meas tran vdout0_228ck1120 FIND v(dout0_228) AT=565.025n

.meas tran vdout0_229ck1120 FIND v(dout0_229) AT=565.025n

.meas tran vdout0_230ck1120 FIND v(dout0_230) AT=565.025n

.meas tran vdout0_231ck1120 FIND v(dout0_231) AT=565.025n

.meas tran vdout0_232ck1120 FIND v(dout0_232) AT=565.025n

.meas tran vdout0_233ck1120 FIND v(dout0_233) AT=565.025n

.meas tran vdout0_234ck1120 FIND v(dout0_234) AT=565.025n

.meas tran vdout0_235ck1120 FIND v(dout0_235) AT=565.025n

.meas tran vdout0_236ck1120 FIND v(dout0_236) AT=565.025n

.meas tran vdout0_237ck1120 FIND v(dout0_237) AT=565.025n

.meas tran vdout0_238ck1120 FIND v(dout0_238) AT=565.025n

.meas tran vdout0_239ck1120 FIND v(dout0_239) AT=565.025n

.meas tran vdout0_240ck1120 FIND v(dout0_240) AT=565.025n

.meas tran vdout0_241ck1120 FIND v(dout0_241) AT=565.025n

.meas tran vdout0_242ck1120 FIND v(dout0_242) AT=565.025n

.meas tran vdout0_243ck1120 FIND v(dout0_243) AT=565.025n

.meas tran vdout0_244ck1120 FIND v(dout0_244) AT=565.025n

.meas tran vdout0_245ck1120 FIND v(dout0_245) AT=565.025n

.meas tran vdout0_246ck1120 FIND v(dout0_246) AT=565.025n

.meas tran vdout0_247ck1120 FIND v(dout0_247) AT=565.025n

.meas tran vdout0_248ck1120 FIND v(dout0_248) AT=565.025n

.meas tran vdout0_249ck1120 FIND v(dout0_249) AT=565.025n

.meas tran vdout0_250ck1120 FIND v(dout0_250) AT=565.025n

.meas tran vdout0_251ck1120 FIND v(dout0_251) AT=565.025n

.meas tran vdout0_252ck1120 FIND v(dout0_252) AT=565.025n

.meas tran vdout0_253ck1120 FIND v(dout0_253) AT=565.025n

.meas tran vdout0_254ck1120 FIND v(dout0_254) AT=565.025n

.meas tran vdout0_255ck1120 FIND v(dout0_255) AT=565.025n

.meas tran vdout0_0ck1230 FIND v(dout0_0) AT=620.025n

.meas tran vdout0_1ck1230 FIND v(dout0_1) AT=620.025n

.meas tran vdout0_2ck1230 FIND v(dout0_2) AT=620.025n

.meas tran vdout0_3ck1230 FIND v(dout0_3) AT=620.025n

.meas tran vdout0_4ck1230 FIND v(dout0_4) AT=620.025n

.meas tran vdout0_5ck1230 FIND v(dout0_5) AT=620.025n

.meas tran vdout0_6ck1230 FIND v(dout0_6) AT=620.025n

.meas tran vdout0_7ck1230 FIND v(dout0_7) AT=620.025n

.meas tran vdout0_8ck1230 FIND v(dout0_8) AT=620.025n

.meas tran vdout0_9ck1230 FIND v(dout0_9) AT=620.025n

.meas tran vdout0_10ck1230 FIND v(dout0_10) AT=620.025n

.meas tran vdout0_11ck1230 FIND v(dout0_11) AT=620.025n

.meas tran vdout0_12ck1230 FIND v(dout0_12) AT=620.025n

.meas tran vdout0_13ck1230 FIND v(dout0_13) AT=620.025n

.meas tran vdout0_14ck1230 FIND v(dout0_14) AT=620.025n

.meas tran vdout0_15ck1230 FIND v(dout0_15) AT=620.025n

.meas tran vdout0_16ck1230 FIND v(dout0_16) AT=620.025n

.meas tran vdout0_17ck1230 FIND v(dout0_17) AT=620.025n

.meas tran vdout0_18ck1230 FIND v(dout0_18) AT=620.025n

.meas tran vdout0_19ck1230 FIND v(dout0_19) AT=620.025n

.meas tran vdout0_20ck1230 FIND v(dout0_20) AT=620.025n

.meas tran vdout0_21ck1230 FIND v(dout0_21) AT=620.025n

.meas tran vdout0_22ck1230 FIND v(dout0_22) AT=620.025n

.meas tran vdout0_23ck1230 FIND v(dout0_23) AT=620.025n

.meas tran vdout0_24ck1230 FIND v(dout0_24) AT=620.025n

.meas tran vdout0_25ck1230 FIND v(dout0_25) AT=620.025n

.meas tran vdout0_26ck1230 FIND v(dout0_26) AT=620.025n

.meas tran vdout0_27ck1230 FIND v(dout0_27) AT=620.025n

.meas tran vdout0_28ck1230 FIND v(dout0_28) AT=620.025n

.meas tran vdout0_29ck1230 FIND v(dout0_29) AT=620.025n

.meas tran vdout0_30ck1230 FIND v(dout0_30) AT=620.025n

.meas tran vdout0_31ck1230 FIND v(dout0_31) AT=620.025n

.meas tran vdout0_32ck1230 FIND v(dout0_32) AT=620.025n

.meas tran vdout0_33ck1230 FIND v(dout0_33) AT=620.025n

.meas tran vdout0_34ck1230 FIND v(dout0_34) AT=620.025n

.meas tran vdout0_35ck1230 FIND v(dout0_35) AT=620.025n

.meas tran vdout0_36ck1230 FIND v(dout0_36) AT=620.025n

.meas tran vdout0_37ck1230 FIND v(dout0_37) AT=620.025n

.meas tran vdout0_38ck1230 FIND v(dout0_38) AT=620.025n

.meas tran vdout0_39ck1230 FIND v(dout0_39) AT=620.025n

.meas tran vdout0_40ck1230 FIND v(dout0_40) AT=620.025n

.meas tran vdout0_41ck1230 FIND v(dout0_41) AT=620.025n

.meas tran vdout0_42ck1230 FIND v(dout0_42) AT=620.025n

.meas tran vdout0_43ck1230 FIND v(dout0_43) AT=620.025n

.meas tran vdout0_44ck1230 FIND v(dout0_44) AT=620.025n

.meas tran vdout0_45ck1230 FIND v(dout0_45) AT=620.025n

.meas tran vdout0_46ck1230 FIND v(dout0_46) AT=620.025n

.meas tran vdout0_47ck1230 FIND v(dout0_47) AT=620.025n

.meas tran vdout0_48ck1230 FIND v(dout0_48) AT=620.025n

.meas tran vdout0_49ck1230 FIND v(dout0_49) AT=620.025n

.meas tran vdout0_50ck1230 FIND v(dout0_50) AT=620.025n

.meas tran vdout0_51ck1230 FIND v(dout0_51) AT=620.025n

.meas tran vdout0_52ck1230 FIND v(dout0_52) AT=620.025n

.meas tran vdout0_53ck1230 FIND v(dout0_53) AT=620.025n

.meas tran vdout0_54ck1230 FIND v(dout0_54) AT=620.025n

.meas tran vdout0_55ck1230 FIND v(dout0_55) AT=620.025n

.meas tran vdout0_56ck1230 FIND v(dout0_56) AT=620.025n

.meas tran vdout0_57ck1230 FIND v(dout0_57) AT=620.025n

.meas tran vdout0_58ck1230 FIND v(dout0_58) AT=620.025n

.meas tran vdout0_59ck1230 FIND v(dout0_59) AT=620.025n

.meas tran vdout0_60ck1230 FIND v(dout0_60) AT=620.025n

.meas tran vdout0_61ck1230 FIND v(dout0_61) AT=620.025n

.meas tran vdout0_62ck1230 FIND v(dout0_62) AT=620.025n

.meas tran vdout0_63ck1230 FIND v(dout0_63) AT=620.025n

.meas tran vdout0_64ck1230 FIND v(dout0_64) AT=620.025n

.meas tran vdout0_65ck1230 FIND v(dout0_65) AT=620.025n

.meas tran vdout0_66ck1230 FIND v(dout0_66) AT=620.025n

.meas tran vdout0_67ck1230 FIND v(dout0_67) AT=620.025n

.meas tran vdout0_68ck1230 FIND v(dout0_68) AT=620.025n

.meas tran vdout0_69ck1230 FIND v(dout0_69) AT=620.025n

.meas tran vdout0_70ck1230 FIND v(dout0_70) AT=620.025n

.meas tran vdout0_71ck1230 FIND v(dout0_71) AT=620.025n

.meas tran vdout0_72ck1230 FIND v(dout0_72) AT=620.025n

.meas tran vdout0_73ck1230 FIND v(dout0_73) AT=620.025n

.meas tran vdout0_74ck1230 FIND v(dout0_74) AT=620.025n

.meas tran vdout0_75ck1230 FIND v(dout0_75) AT=620.025n

.meas tran vdout0_76ck1230 FIND v(dout0_76) AT=620.025n

.meas tran vdout0_77ck1230 FIND v(dout0_77) AT=620.025n

.meas tran vdout0_78ck1230 FIND v(dout0_78) AT=620.025n

.meas tran vdout0_79ck1230 FIND v(dout0_79) AT=620.025n

.meas tran vdout0_80ck1230 FIND v(dout0_80) AT=620.025n

.meas tran vdout0_81ck1230 FIND v(dout0_81) AT=620.025n

.meas tran vdout0_82ck1230 FIND v(dout0_82) AT=620.025n

.meas tran vdout0_83ck1230 FIND v(dout0_83) AT=620.025n

.meas tran vdout0_84ck1230 FIND v(dout0_84) AT=620.025n

.meas tran vdout0_85ck1230 FIND v(dout0_85) AT=620.025n

.meas tran vdout0_86ck1230 FIND v(dout0_86) AT=620.025n

.meas tran vdout0_87ck1230 FIND v(dout0_87) AT=620.025n

.meas tran vdout0_88ck1230 FIND v(dout0_88) AT=620.025n

.meas tran vdout0_89ck1230 FIND v(dout0_89) AT=620.025n

.meas tran vdout0_90ck1230 FIND v(dout0_90) AT=620.025n

.meas tran vdout0_91ck1230 FIND v(dout0_91) AT=620.025n

.meas tran vdout0_92ck1230 FIND v(dout0_92) AT=620.025n

.meas tran vdout0_93ck1230 FIND v(dout0_93) AT=620.025n

.meas tran vdout0_94ck1230 FIND v(dout0_94) AT=620.025n

.meas tran vdout0_95ck1230 FIND v(dout0_95) AT=620.025n

.meas tran vdout0_96ck1230 FIND v(dout0_96) AT=620.025n

.meas tran vdout0_97ck1230 FIND v(dout0_97) AT=620.025n

.meas tran vdout0_98ck1230 FIND v(dout0_98) AT=620.025n

.meas tran vdout0_99ck1230 FIND v(dout0_99) AT=620.025n

.meas tran vdout0_100ck1230 FIND v(dout0_100) AT=620.025n

.meas tran vdout0_101ck1230 FIND v(dout0_101) AT=620.025n

.meas tran vdout0_102ck1230 FIND v(dout0_102) AT=620.025n

.meas tran vdout0_103ck1230 FIND v(dout0_103) AT=620.025n

.meas tran vdout0_104ck1230 FIND v(dout0_104) AT=620.025n

.meas tran vdout0_105ck1230 FIND v(dout0_105) AT=620.025n

.meas tran vdout0_106ck1230 FIND v(dout0_106) AT=620.025n

.meas tran vdout0_107ck1230 FIND v(dout0_107) AT=620.025n

.meas tran vdout0_108ck1230 FIND v(dout0_108) AT=620.025n

.meas tran vdout0_109ck1230 FIND v(dout0_109) AT=620.025n

.meas tran vdout0_110ck1230 FIND v(dout0_110) AT=620.025n

.meas tran vdout0_111ck1230 FIND v(dout0_111) AT=620.025n

.meas tran vdout0_112ck1230 FIND v(dout0_112) AT=620.025n

.meas tran vdout0_113ck1230 FIND v(dout0_113) AT=620.025n

.meas tran vdout0_114ck1230 FIND v(dout0_114) AT=620.025n

.meas tran vdout0_115ck1230 FIND v(dout0_115) AT=620.025n

.meas tran vdout0_116ck1230 FIND v(dout0_116) AT=620.025n

.meas tran vdout0_117ck1230 FIND v(dout0_117) AT=620.025n

.meas tran vdout0_118ck1230 FIND v(dout0_118) AT=620.025n

.meas tran vdout0_119ck1230 FIND v(dout0_119) AT=620.025n

.meas tran vdout0_120ck1230 FIND v(dout0_120) AT=620.025n

.meas tran vdout0_121ck1230 FIND v(dout0_121) AT=620.025n

.meas tran vdout0_122ck1230 FIND v(dout0_122) AT=620.025n

.meas tran vdout0_123ck1230 FIND v(dout0_123) AT=620.025n

.meas tran vdout0_124ck1230 FIND v(dout0_124) AT=620.025n

.meas tran vdout0_125ck1230 FIND v(dout0_125) AT=620.025n

.meas tran vdout0_126ck1230 FIND v(dout0_126) AT=620.025n

.meas tran vdout0_127ck1230 FIND v(dout0_127) AT=620.025n

.meas tran vdout0_128ck1230 FIND v(dout0_128) AT=620.025n

.meas tran vdout0_129ck1230 FIND v(dout0_129) AT=620.025n

.meas tran vdout0_130ck1230 FIND v(dout0_130) AT=620.025n

.meas tran vdout0_131ck1230 FIND v(dout0_131) AT=620.025n

.meas tran vdout0_132ck1230 FIND v(dout0_132) AT=620.025n

.meas tran vdout0_133ck1230 FIND v(dout0_133) AT=620.025n

.meas tran vdout0_134ck1230 FIND v(dout0_134) AT=620.025n

.meas tran vdout0_135ck1230 FIND v(dout0_135) AT=620.025n

.meas tran vdout0_136ck1230 FIND v(dout0_136) AT=620.025n

.meas tran vdout0_137ck1230 FIND v(dout0_137) AT=620.025n

.meas tran vdout0_138ck1230 FIND v(dout0_138) AT=620.025n

.meas tran vdout0_139ck1230 FIND v(dout0_139) AT=620.025n

.meas tran vdout0_140ck1230 FIND v(dout0_140) AT=620.025n

.meas tran vdout0_141ck1230 FIND v(dout0_141) AT=620.025n

.meas tran vdout0_142ck1230 FIND v(dout0_142) AT=620.025n

.meas tran vdout0_143ck1230 FIND v(dout0_143) AT=620.025n

.meas tran vdout0_144ck1230 FIND v(dout0_144) AT=620.025n

.meas tran vdout0_145ck1230 FIND v(dout0_145) AT=620.025n

.meas tran vdout0_146ck1230 FIND v(dout0_146) AT=620.025n

.meas tran vdout0_147ck1230 FIND v(dout0_147) AT=620.025n

.meas tran vdout0_148ck1230 FIND v(dout0_148) AT=620.025n

.meas tran vdout0_149ck1230 FIND v(dout0_149) AT=620.025n

.meas tran vdout0_150ck1230 FIND v(dout0_150) AT=620.025n

.meas tran vdout0_151ck1230 FIND v(dout0_151) AT=620.025n

.meas tran vdout0_152ck1230 FIND v(dout0_152) AT=620.025n

.meas tran vdout0_153ck1230 FIND v(dout0_153) AT=620.025n

.meas tran vdout0_154ck1230 FIND v(dout0_154) AT=620.025n

.meas tran vdout0_155ck1230 FIND v(dout0_155) AT=620.025n

.meas tran vdout0_156ck1230 FIND v(dout0_156) AT=620.025n

.meas tran vdout0_157ck1230 FIND v(dout0_157) AT=620.025n

.meas tran vdout0_158ck1230 FIND v(dout0_158) AT=620.025n

.meas tran vdout0_159ck1230 FIND v(dout0_159) AT=620.025n

.meas tran vdout0_160ck1230 FIND v(dout0_160) AT=620.025n

.meas tran vdout0_161ck1230 FIND v(dout0_161) AT=620.025n

.meas tran vdout0_162ck1230 FIND v(dout0_162) AT=620.025n

.meas tran vdout0_163ck1230 FIND v(dout0_163) AT=620.025n

.meas tran vdout0_164ck1230 FIND v(dout0_164) AT=620.025n

.meas tran vdout0_165ck1230 FIND v(dout0_165) AT=620.025n

.meas tran vdout0_166ck1230 FIND v(dout0_166) AT=620.025n

.meas tran vdout0_167ck1230 FIND v(dout0_167) AT=620.025n

.meas tran vdout0_168ck1230 FIND v(dout0_168) AT=620.025n

.meas tran vdout0_169ck1230 FIND v(dout0_169) AT=620.025n

.meas tran vdout0_170ck1230 FIND v(dout0_170) AT=620.025n

.meas tran vdout0_171ck1230 FIND v(dout0_171) AT=620.025n

.meas tran vdout0_172ck1230 FIND v(dout0_172) AT=620.025n

.meas tran vdout0_173ck1230 FIND v(dout0_173) AT=620.025n

.meas tran vdout0_174ck1230 FIND v(dout0_174) AT=620.025n

.meas tran vdout0_175ck1230 FIND v(dout0_175) AT=620.025n

.meas tran vdout0_176ck1230 FIND v(dout0_176) AT=620.025n

.meas tran vdout0_177ck1230 FIND v(dout0_177) AT=620.025n

.meas tran vdout0_178ck1230 FIND v(dout0_178) AT=620.025n

.meas tran vdout0_179ck1230 FIND v(dout0_179) AT=620.025n

.meas tran vdout0_180ck1230 FIND v(dout0_180) AT=620.025n

.meas tran vdout0_181ck1230 FIND v(dout0_181) AT=620.025n

.meas tran vdout0_182ck1230 FIND v(dout0_182) AT=620.025n

.meas tran vdout0_183ck1230 FIND v(dout0_183) AT=620.025n

.meas tran vdout0_184ck1230 FIND v(dout0_184) AT=620.025n

.meas tran vdout0_185ck1230 FIND v(dout0_185) AT=620.025n

.meas tran vdout0_186ck1230 FIND v(dout0_186) AT=620.025n

.meas tran vdout0_187ck1230 FIND v(dout0_187) AT=620.025n

.meas tran vdout0_188ck1230 FIND v(dout0_188) AT=620.025n

.meas tran vdout0_189ck1230 FIND v(dout0_189) AT=620.025n

.meas tran vdout0_190ck1230 FIND v(dout0_190) AT=620.025n

.meas tran vdout0_191ck1230 FIND v(dout0_191) AT=620.025n

.meas tran vdout0_192ck1230 FIND v(dout0_192) AT=620.025n

.meas tran vdout0_193ck1230 FIND v(dout0_193) AT=620.025n

.meas tran vdout0_194ck1230 FIND v(dout0_194) AT=620.025n

.meas tran vdout0_195ck1230 FIND v(dout0_195) AT=620.025n

.meas tran vdout0_196ck1230 FIND v(dout0_196) AT=620.025n

.meas tran vdout0_197ck1230 FIND v(dout0_197) AT=620.025n

.meas tran vdout0_198ck1230 FIND v(dout0_198) AT=620.025n

.meas tran vdout0_199ck1230 FIND v(dout0_199) AT=620.025n

.meas tran vdout0_200ck1230 FIND v(dout0_200) AT=620.025n

.meas tran vdout0_201ck1230 FIND v(dout0_201) AT=620.025n

.meas tran vdout0_202ck1230 FIND v(dout0_202) AT=620.025n

.meas tran vdout0_203ck1230 FIND v(dout0_203) AT=620.025n

.meas tran vdout0_204ck1230 FIND v(dout0_204) AT=620.025n

.meas tran vdout0_205ck1230 FIND v(dout0_205) AT=620.025n

.meas tran vdout0_206ck1230 FIND v(dout0_206) AT=620.025n

.meas tran vdout0_207ck1230 FIND v(dout0_207) AT=620.025n

.meas tran vdout0_208ck1230 FIND v(dout0_208) AT=620.025n

.meas tran vdout0_209ck1230 FIND v(dout0_209) AT=620.025n

.meas tran vdout0_210ck1230 FIND v(dout0_210) AT=620.025n

.meas tran vdout0_211ck1230 FIND v(dout0_211) AT=620.025n

.meas tran vdout0_212ck1230 FIND v(dout0_212) AT=620.025n

.meas tran vdout0_213ck1230 FIND v(dout0_213) AT=620.025n

.meas tran vdout0_214ck1230 FIND v(dout0_214) AT=620.025n

.meas tran vdout0_215ck1230 FIND v(dout0_215) AT=620.025n

.meas tran vdout0_216ck1230 FIND v(dout0_216) AT=620.025n

.meas tran vdout0_217ck1230 FIND v(dout0_217) AT=620.025n

.meas tran vdout0_218ck1230 FIND v(dout0_218) AT=620.025n

.meas tran vdout0_219ck1230 FIND v(dout0_219) AT=620.025n

.meas tran vdout0_220ck1230 FIND v(dout0_220) AT=620.025n

.meas tran vdout0_221ck1230 FIND v(dout0_221) AT=620.025n

.meas tran vdout0_222ck1230 FIND v(dout0_222) AT=620.025n

.meas tran vdout0_223ck1230 FIND v(dout0_223) AT=620.025n

.meas tran vdout0_224ck1230 FIND v(dout0_224) AT=620.025n

.meas tran vdout0_225ck1230 FIND v(dout0_225) AT=620.025n

.meas tran vdout0_226ck1230 FIND v(dout0_226) AT=620.025n

.meas tran vdout0_227ck1230 FIND v(dout0_227) AT=620.025n

.meas tran vdout0_228ck1230 FIND v(dout0_228) AT=620.025n

.meas tran vdout0_229ck1230 FIND v(dout0_229) AT=620.025n

.meas tran vdout0_230ck1230 FIND v(dout0_230) AT=620.025n

.meas tran vdout0_231ck1230 FIND v(dout0_231) AT=620.025n

.meas tran vdout0_232ck1230 FIND v(dout0_232) AT=620.025n

.meas tran vdout0_233ck1230 FIND v(dout0_233) AT=620.025n

.meas tran vdout0_234ck1230 FIND v(dout0_234) AT=620.025n

.meas tran vdout0_235ck1230 FIND v(dout0_235) AT=620.025n

.meas tran vdout0_236ck1230 FIND v(dout0_236) AT=620.025n

.meas tran vdout0_237ck1230 FIND v(dout0_237) AT=620.025n

.meas tran vdout0_238ck1230 FIND v(dout0_238) AT=620.025n

.meas tran vdout0_239ck1230 FIND v(dout0_239) AT=620.025n

.meas tran vdout0_240ck1230 FIND v(dout0_240) AT=620.025n

.meas tran vdout0_241ck1230 FIND v(dout0_241) AT=620.025n

.meas tran vdout0_242ck1230 FIND v(dout0_242) AT=620.025n

.meas tran vdout0_243ck1230 FIND v(dout0_243) AT=620.025n

.meas tran vdout0_244ck1230 FIND v(dout0_244) AT=620.025n

.meas tran vdout0_245ck1230 FIND v(dout0_245) AT=620.025n

.meas tran vdout0_246ck1230 FIND v(dout0_246) AT=620.025n

.meas tran vdout0_247ck1230 FIND v(dout0_247) AT=620.025n

.meas tran vdout0_248ck1230 FIND v(dout0_248) AT=620.025n

.meas tran vdout0_249ck1230 FIND v(dout0_249) AT=620.025n

.meas tran vdout0_250ck1230 FIND v(dout0_250) AT=620.025n

.meas tran vdout0_251ck1230 FIND v(dout0_251) AT=620.025n

.meas tran vdout0_252ck1230 FIND v(dout0_252) AT=620.025n

.meas tran vdout0_253ck1230 FIND v(dout0_253) AT=620.025n

.meas tran vdout0_254ck1230 FIND v(dout0_254) AT=620.025n

.meas tran vdout0_255ck1230 FIND v(dout0_255) AT=620.025n

.meas tran vdout0_0ck1240 FIND v(dout0_0) AT=625.025n

.meas tran vdout0_1ck1240 FIND v(dout0_1) AT=625.025n

.meas tran vdout0_2ck1240 FIND v(dout0_2) AT=625.025n

.meas tran vdout0_3ck1240 FIND v(dout0_3) AT=625.025n

.meas tran vdout0_4ck1240 FIND v(dout0_4) AT=625.025n

.meas tran vdout0_5ck1240 FIND v(dout0_5) AT=625.025n

.meas tran vdout0_6ck1240 FIND v(dout0_6) AT=625.025n

.meas tran vdout0_7ck1240 FIND v(dout0_7) AT=625.025n

.meas tran vdout0_8ck1240 FIND v(dout0_8) AT=625.025n

.meas tran vdout0_9ck1240 FIND v(dout0_9) AT=625.025n

.meas tran vdout0_10ck1240 FIND v(dout0_10) AT=625.025n

.meas tran vdout0_11ck1240 FIND v(dout0_11) AT=625.025n

.meas tran vdout0_12ck1240 FIND v(dout0_12) AT=625.025n

.meas tran vdout0_13ck1240 FIND v(dout0_13) AT=625.025n

.meas tran vdout0_14ck1240 FIND v(dout0_14) AT=625.025n

.meas tran vdout0_15ck1240 FIND v(dout0_15) AT=625.025n

.meas tran vdout0_16ck1240 FIND v(dout0_16) AT=625.025n

.meas tran vdout0_17ck1240 FIND v(dout0_17) AT=625.025n

.meas tran vdout0_18ck1240 FIND v(dout0_18) AT=625.025n

.meas tran vdout0_19ck1240 FIND v(dout0_19) AT=625.025n

.meas tran vdout0_20ck1240 FIND v(dout0_20) AT=625.025n

.meas tran vdout0_21ck1240 FIND v(dout0_21) AT=625.025n

.meas tran vdout0_22ck1240 FIND v(dout0_22) AT=625.025n

.meas tran vdout0_23ck1240 FIND v(dout0_23) AT=625.025n

.meas tran vdout0_24ck1240 FIND v(dout0_24) AT=625.025n

.meas tran vdout0_25ck1240 FIND v(dout0_25) AT=625.025n

.meas tran vdout0_26ck1240 FIND v(dout0_26) AT=625.025n

.meas tran vdout0_27ck1240 FIND v(dout0_27) AT=625.025n

.meas tran vdout0_28ck1240 FIND v(dout0_28) AT=625.025n

.meas tran vdout0_29ck1240 FIND v(dout0_29) AT=625.025n

.meas tran vdout0_30ck1240 FIND v(dout0_30) AT=625.025n

.meas tran vdout0_31ck1240 FIND v(dout0_31) AT=625.025n

.meas tran vdout0_32ck1240 FIND v(dout0_32) AT=625.025n

.meas tran vdout0_33ck1240 FIND v(dout0_33) AT=625.025n

.meas tran vdout0_34ck1240 FIND v(dout0_34) AT=625.025n

.meas tran vdout0_35ck1240 FIND v(dout0_35) AT=625.025n

.meas tran vdout0_36ck1240 FIND v(dout0_36) AT=625.025n

.meas tran vdout0_37ck1240 FIND v(dout0_37) AT=625.025n

.meas tran vdout0_38ck1240 FIND v(dout0_38) AT=625.025n

.meas tran vdout0_39ck1240 FIND v(dout0_39) AT=625.025n

.meas tran vdout0_40ck1240 FIND v(dout0_40) AT=625.025n

.meas tran vdout0_41ck1240 FIND v(dout0_41) AT=625.025n

.meas tran vdout0_42ck1240 FIND v(dout0_42) AT=625.025n

.meas tran vdout0_43ck1240 FIND v(dout0_43) AT=625.025n

.meas tran vdout0_44ck1240 FIND v(dout0_44) AT=625.025n

.meas tran vdout0_45ck1240 FIND v(dout0_45) AT=625.025n

.meas tran vdout0_46ck1240 FIND v(dout0_46) AT=625.025n

.meas tran vdout0_47ck1240 FIND v(dout0_47) AT=625.025n

.meas tran vdout0_48ck1240 FIND v(dout0_48) AT=625.025n

.meas tran vdout0_49ck1240 FIND v(dout0_49) AT=625.025n

.meas tran vdout0_50ck1240 FIND v(dout0_50) AT=625.025n

.meas tran vdout0_51ck1240 FIND v(dout0_51) AT=625.025n

.meas tran vdout0_52ck1240 FIND v(dout0_52) AT=625.025n

.meas tran vdout0_53ck1240 FIND v(dout0_53) AT=625.025n

.meas tran vdout0_54ck1240 FIND v(dout0_54) AT=625.025n

.meas tran vdout0_55ck1240 FIND v(dout0_55) AT=625.025n

.meas tran vdout0_56ck1240 FIND v(dout0_56) AT=625.025n

.meas tran vdout0_57ck1240 FIND v(dout0_57) AT=625.025n

.meas tran vdout0_58ck1240 FIND v(dout0_58) AT=625.025n

.meas tran vdout0_59ck1240 FIND v(dout0_59) AT=625.025n

.meas tran vdout0_60ck1240 FIND v(dout0_60) AT=625.025n

.meas tran vdout0_61ck1240 FIND v(dout0_61) AT=625.025n

.meas tran vdout0_62ck1240 FIND v(dout0_62) AT=625.025n

.meas tran vdout0_63ck1240 FIND v(dout0_63) AT=625.025n

.meas tran vdout0_64ck1240 FIND v(dout0_64) AT=625.025n

.meas tran vdout0_65ck1240 FIND v(dout0_65) AT=625.025n

.meas tran vdout0_66ck1240 FIND v(dout0_66) AT=625.025n

.meas tran vdout0_67ck1240 FIND v(dout0_67) AT=625.025n

.meas tran vdout0_68ck1240 FIND v(dout0_68) AT=625.025n

.meas tran vdout0_69ck1240 FIND v(dout0_69) AT=625.025n

.meas tran vdout0_70ck1240 FIND v(dout0_70) AT=625.025n

.meas tran vdout0_71ck1240 FIND v(dout0_71) AT=625.025n

.meas tran vdout0_72ck1240 FIND v(dout0_72) AT=625.025n

.meas tran vdout0_73ck1240 FIND v(dout0_73) AT=625.025n

.meas tran vdout0_74ck1240 FIND v(dout0_74) AT=625.025n

.meas tran vdout0_75ck1240 FIND v(dout0_75) AT=625.025n

.meas tran vdout0_76ck1240 FIND v(dout0_76) AT=625.025n

.meas tran vdout0_77ck1240 FIND v(dout0_77) AT=625.025n

.meas tran vdout0_78ck1240 FIND v(dout0_78) AT=625.025n

.meas tran vdout0_79ck1240 FIND v(dout0_79) AT=625.025n

.meas tran vdout0_80ck1240 FIND v(dout0_80) AT=625.025n

.meas tran vdout0_81ck1240 FIND v(dout0_81) AT=625.025n

.meas tran vdout0_82ck1240 FIND v(dout0_82) AT=625.025n

.meas tran vdout0_83ck1240 FIND v(dout0_83) AT=625.025n

.meas tran vdout0_84ck1240 FIND v(dout0_84) AT=625.025n

.meas tran vdout0_85ck1240 FIND v(dout0_85) AT=625.025n

.meas tran vdout0_86ck1240 FIND v(dout0_86) AT=625.025n

.meas tran vdout0_87ck1240 FIND v(dout0_87) AT=625.025n

.meas tran vdout0_88ck1240 FIND v(dout0_88) AT=625.025n

.meas tran vdout0_89ck1240 FIND v(dout0_89) AT=625.025n

.meas tran vdout0_90ck1240 FIND v(dout0_90) AT=625.025n

.meas tran vdout0_91ck1240 FIND v(dout0_91) AT=625.025n

.meas tran vdout0_92ck1240 FIND v(dout0_92) AT=625.025n

.meas tran vdout0_93ck1240 FIND v(dout0_93) AT=625.025n

.meas tran vdout0_94ck1240 FIND v(dout0_94) AT=625.025n

.meas tran vdout0_95ck1240 FIND v(dout0_95) AT=625.025n

.meas tran vdout0_96ck1240 FIND v(dout0_96) AT=625.025n

.meas tran vdout0_97ck1240 FIND v(dout0_97) AT=625.025n

.meas tran vdout0_98ck1240 FIND v(dout0_98) AT=625.025n

.meas tran vdout0_99ck1240 FIND v(dout0_99) AT=625.025n

.meas tran vdout0_100ck1240 FIND v(dout0_100) AT=625.025n

.meas tran vdout0_101ck1240 FIND v(dout0_101) AT=625.025n

.meas tran vdout0_102ck1240 FIND v(dout0_102) AT=625.025n

.meas tran vdout0_103ck1240 FIND v(dout0_103) AT=625.025n

.meas tran vdout0_104ck1240 FIND v(dout0_104) AT=625.025n

.meas tran vdout0_105ck1240 FIND v(dout0_105) AT=625.025n

.meas tran vdout0_106ck1240 FIND v(dout0_106) AT=625.025n

.meas tran vdout0_107ck1240 FIND v(dout0_107) AT=625.025n

.meas tran vdout0_108ck1240 FIND v(dout0_108) AT=625.025n

.meas tran vdout0_109ck1240 FIND v(dout0_109) AT=625.025n

.meas tran vdout0_110ck1240 FIND v(dout0_110) AT=625.025n

.meas tran vdout0_111ck1240 FIND v(dout0_111) AT=625.025n

.meas tran vdout0_112ck1240 FIND v(dout0_112) AT=625.025n

.meas tran vdout0_113ck1240 FIND v(dout0_113) AT=625.025n

.meas tran vdout0_114ck1240 FIND v(dout0_114) AT=625.025n

.meas tran vdout0_115ck1240 FIND v(dout0_115) AT=625.025n

.meas tran vdout0_116ck1240 FIND v(dout0_116) AT=625.025n

.meas tran vdout0_117ck1240 FIND v(dout0_117) AT=625.025n

.meas tran vdout0_118ck1240 FIND v(dout0_118) AT=625.025n

.meas tran vdout0_119ck1240 FIND v(dout0_119) AT=625.025n

.meas tran vdout0_120ck1240 FIND v(dout0_120) AT=625.025n

.meas tran vdout0_121ck1240 FIND v(dout0_121) AT=625.025n

.meas tran vdout0_122ck1240 FIND v(dout0_122) AT=625.025n

.meas tran vdout0_123ck1240 FIND v(dout0_123) AT=625.025n

.meas tran vdout0_124ck1240 FIND v(dout0_124) AT=625.025n

.meas tran vdout0_125ck1240 FIND v(dout0_125) AT=625.025n

.meas tran vdout0_126ck1240 FIND v(dout0_126) AT=625.025n

.meas tran vdout0_127ck1240 FIND v(dout0_127) AT=625.025n

.meas tran vdout0_128ck1240 FIND v(dout0_128) AT=625.025n

.meas tran vdout0_129ck1240 FIND v(dout0_129) AT=625.025n

.meas tran vdout0_130ck1240 FIND v(dout0_130) AT=625.025n

.meas tran vdout0_131ck1240 FIND v(dout0_131) AT=625.025n

.meas tran vdout0_132ck1240 FIND v(dout0_132) AT=625.025n

.meas tran vdout0_133ck1240 FIND v(dout0_133) AT=625.025n

.meas tran vdout0_134ck1240 FIND v(dout0_134) AT=625.025n

.meas tran vdout0_135ck1240 FIND v(dout0_135) AT=625.025n

.meas tran vdout0_136ck1240 FIND v(dout0_136) AT=625.025n

.meas tran vdout0_137ck1240 FIND v(dout0_137) AT=625.025n

.meas tran vdout0_138ck1240 FIND v(dout0_138) AT=625.025n

.meas tran vdout0_139ck1240 FIND v(dout0_139) AT=625.025n

.meas tran vdout0_140ck1240 FIND v(dout0_140) AT=625.025n

.meas tran vdout0_141ck1240 FIND v(dout0_141) AT=625.025n

.meas tran vdout0_142ck1240 FIND v(dout0_142) AT=625.025n

.meas tran vdout0_143ck1240 FIND v(dout0_143) AT=625.025n

.meas tran vdout0_144ck1240 FIND v(dout0_144) AT=625.025n

.meas tran vdout0_145ck1240 FIND v(dout0_145) AT=625.025n

.meas tran vdout0_146ck1240 FIND v(dout0_146) AT=625.025n

.meas tran vdout0_147ck1240 FIND v(dout0_147) AT=625.025n

.meas tran vdout0_148ck1240 FIND v(dout0_148) AT=625.025n

.meas tran vdout0_149ck1240 FIND v(dout0_149) AT=625.025n

.meas tran vdout0_150ck1240 FIND v(dout0_150) AT=625.025n

.meas tran vdout0_151ck1240 FIND v(dout0_151) AT=625.025n

.meas tran vdout0_152ck1240 FIND v(dout0_152) AT=625.025n

.meas tran vdout0_153ck1240 FIND v(dout0_153) AT=625.025n

.meas tran vdout0_154ck1240 FIND v(dout0_154) AT=625.025n

.meas tran vdout0_155ck1240 FIND v(dout0_155) AT=625.025n

.meas tran vdout0_156ck1240 FIND v(dout0_156) AT=625.025n

.meas tran vdout0_157ck1240 FIND v(dout0_157) AT=625.025n

.meas tran vdout0_158ck1240 FIND v(dout0_158) AT=625.025n

.meas tran vdout0_159ck1240 FIND v(dout0_159) AT=625.025n

.meas tran vdout0_160ck1240 FIND v(dout0_160) AT=625.025n

.meas tran vdout0_161ck1240 FIND v(dout0_161) AT=625.025n

.meas tran vdout0_162ck1240 FIND v(dout0_162) AT=625.025n

.meas tran vdout0_163ck1240 FIND v(dout0_163) AT=625.025n

.meas tran vdout0_164ck1240 FIND v(dout0_164) AT=625.025n

.meas tran vdout0_165ck1240 FIND v(dout0_165) AT=625.025n

.meas tran vdout0_166ck1240 FIND v(dout0_166) AT=625.025n

.meas tran vdout0_167ck1240 FIND v(dout0_167) AT=625.025n

.meas tran vdout0_168ck1240 FIND v(dout0_168) AT=625.025n

.meas tran vdout0_169ck1240 FIND v(dout0_169) AT=625.025n

.meas tran vdout0_170ck1240 FIND v(dout0_170) AT=625.025n

.meas tran vdout0_171ck1240 FIND v(dout0_171) AT=625.025n

.meas tran vdout0_172ck1240 FIND v(dout0_172) AT=625.025n

.meas tran vdout0_173ck1240 FIND v(dout0_173) AT=625.025n

.meas tran vdout0_174ck1240 FIND v(dout0_174) AT=625.025n

.meas tran vdout0_175ck1240 FIND v(dout0_175) AT=625.025n

.meas tran vdout0_176ck1240 FIND v(dout0_176) AT=625.025n

.meas tran vdout0_177ck1240 FIND v(dout0_177) AT=625.025n

.meas tran vdout0_178ck1240 FIND v(dout0_178) AT=625.025n

.meas tran vdout0_179ck1240 FIND v(dout0_179) AT=625.025n

.meas tran vdout0_180ck1240 FIND v(dout0_180) AT=625.025n

.meas tran vdout0_181ck1240 FIND v(dout0_181) AT=625.025n

.meas tran vdout0_182ck1240 FIND v(dout0_182) AT=625.025n

.meas tran vdout0_183ck1240 FIND v(dout0_183) AT=625.025n

.meas tran vdout0_184ck1240 FIND v(dout0_184) AT=625.025n

.meas tran vdout0_185ck1240 FIND v(dout0_185) AT=625.025n

.meas tran vdout0_186ck1240 FIND v(dout0_186) AT=625.025n

.meas tran vdout0_187ck1240 FIND v(dout0_187) AT=625.025n

.meas tran vdout0_188ck1240 FIND v(dout0_188) AT=625.025n

.meas tran vdout0_189ck1240 FIND v(dout0_189) AT=625.025n

.meas tran vdout0_190ck1240 FIND v(dout0_190) AT=625.025n

.meas tran vdout0_191ck1240 FIND v(dout0_191) AT=625.025n

.meas tran vdout0_192ck1240 FIND v(dout0_192) AT=625.025n

.meas tran vdout0_193ck1240 FIND v(dout0_193) AT=625.025n

.meas tran vdout0_194ck1240 FIND v(dout0_194) AT=625.025n

.meas tran vdout0_195ck1240 FIND v(dout0_195) AT=625.025n

.meas tran vdout0_196ck1240 FIND v(dout0_196) AT=625.025n

.meas tran vdout0_197ck1240 FIND v(dout0_197) AT=625.025n

.meas tran vdout0_198ck1240 FIND v(dout0_198) AT=625.025n

.meas tran vdout0_199ck1240 FIND v(dout0_199) AT=625.025n

.meas tran vdout0_200ck1240 FIND v(dout0_200) AT=625.025n

.meas tran vdout0_201ck1240 FIND v(dout0_201) AT=625.025n

.meas tran vdout0_202ck1240 FIND v(dout0_202) AT=625.025n

.meas tran vdout0_203ck1240 FIND v(dout0_203) AT=625.025n

.meas tran vdout0_204ck1240 FIND v(dout0_204) AT=625.025n

.meas tran vdout0_205ck1240 FIND v(dout0_205) AT=625.025n

.meas tran vdout0_206ck1240 FIND v(dout0_206) AT=625.025n

.meas tran vdout0_207ck1240 FIND v(dout0_207) AT=625.025n

.meas tran vdout0_208ck1240 FIND v(dout0_208) AT=625.025n

.meas tran vdout0_209ck1240 FIND v(dout0_209) AT=625.025n

.meas tran vdout0_210ck1240 FIND v(dout0_210) AT=625.025n

.meas tran vdout0_211ck1240 FIND v(dout0_211) AT=625.025n

.meas tran vdout0_212ck1240 FIND v(dout0_212) AT=625.025n

.meas tran vdout0_213ck1240 FIND v(dout0_213) AT=625.025n

.meas tran vdout0_214ck1240 FIND v(dout0_214) AT=625.025n

.meas tran vdout0_215ck1240 FIND v(dout0_215) AT=625.025n

.meas tran vdout0_216ck1240 FIND v(dout0_216) AT=625.025n

.meas tran vdout0_217ck1240 FIND v(dout0_217) AT=625.025n

.meas tran vdout0_218ck1240 FIND v(dout0_218) AT=625.025n

.meas tran vdout0_219ck1240 FIND v(dout0_219) AT=625.025n

.meas tran vdout0_220ck1240 FIND v(dout0_220) AT=625.025n

.meas tran vdout0_221ck1240 FIND v(dout0_221) AT=625.025n

.meas tran vdout0_222ck1240 FIND v(dout0_222) AT=625.025n

.meas tran vdout0_223ck1240 FIND v(dout0_223) AT=625.025n

.meas tran vdout0_224ck1240 FIND v(dout0_224) AT=625.025n

.meas tran vdout0_225ck1240 FIND v(dout0_225) AT=625.025n

.meas tran vdout0_226ck1240 FIND v(dout0_226) AT=625.025n

.meas tran vdout0_227ck1240 FIND v(dout0_227) AT=625.025n

.meas tran vdout0_228ck1240 FIND v(dout0_228) AT=625.025n

.meas tran vdout0_229ck1240 FIND v(dout0_229) AT=625.025n

.meas tran vdout0_230ck1240 FIND v(dout0_230) AT=625.025n

.meas tran vdout0_231ck1240 FIND v(dout0_231) AT=625.025n

.meas tran vdout0_232ck1240 FIND v(dout0_232) AT=625.025n

.meas tran vdout0_233ck1240 FIND v(dout0_233) AT=625.025n

.meas tran vdout0_234ck1240 FIND v(dout0_234) AT=625.025n

.meas tran vdout0_235ck1240 FIND v(dout0_235) AT=625.025n

.meas tran vdout0_236ck1240 FIND v(dout0_236) AT=625.025n

.meas tran vdout0_237ck1240 FIND v(dout0_237) AT=625.025n

.meas tran vdout0_238ck1240 FIND v(dout0_238) AT=625.025n

.meas tran vdout0_239ck1240 FIND v(dout0_239) AT=625.025n

.meas tran vdout0_240ck1240 FIND v(dout0_240) AT=625.025n

.meas tran vdout0_241ck1240 FIND v(dout0_241) AT=625.025n

.meas tran vdout0_242ck1240 FIND v(dout0_242) AT=625.025n

.meas tran vdout0_243ck1240 FIND v(dout0_243) AT=625.025n

.meas tran vdout0_244ck1240 FIND v(dout0_244) AT=625.025n

.meas tran vdout0_245ck1240 FIND v(dout0_245) AT=625.025n

.meas tran vdout0_246ck1240 FIND v(dout0_246) AT=625.025n

.meas tran vdout0_247ck1240 FIND v(dout0_247) AT=625.025n

.meas tran vdout0_248ck1240 FIND v(dout0_248) AT=625.025n

.meas tran vdout0_249ck1240 FIND v(dout0_249) AT=625.025n

.meas tran vdout0_250ck1240 FIND v(dout0_250) AT=625.025n

.meas tran vdout0_251ck1240 FIND v(dout0_251) AT=625.025n

.meas tran vdout0_252ck1240 FIND v(dout0_252) AT=625.025n

.meas tran vdout0_253ck1240 FIND v(dout0_253) AT=625.025n

.meas tran vdout0_254ck1240 FIND v(dout0_254) AT=625.025n

.meas tran vdout0_255ck1240 FIND v(dout0_255) AT=625.025n

.meas tran vdout0_0ck1250 FIND v(dout0_0) AT=630.025n

.meas tran vdout0_1ck1250 FIND v(dout0_1) AT=630.025n

.meas tran vdout0_2ck1250 FIND v(dout0_2) AT=630.025n

.meas tran vdout0_3ck1250 FIND v(dout0_3) AT=630.025n

.meas tran vdout0_4ck1250 FIND v(dout0_4) AT=630.025n

.meas tran vdout0_5ck1250 FIND v(dout0_5) AT=630.025n

.meas tran vdout0_6ck1250 FIND v(dout0_6) AT=630.025n

.meas tran vdout0_7ck1250 FIND v(dout0_7) AT=630.025n

.meas tran vdout0_8ck1250 FIND v(dout0_8) AT=630.025n

.meas tran vdout0_9ck1250 FIND v(dout0_9) AT=630.025n

.meas tran vdout0_10ck1250 FIND v(dout0_10) AT=630.025n

.meas tran vdout0_11ck1250 FIND v(dout0_11) AT=630.025n

.meas tran vdout0_12ck1250 FIND v(dout0_12) AT=630.025n

.meas tran vdout0_13ck1250 FIND v(dout0_13) AT=630.025n

.meas tran vdout0_14ck1250 FIND v(dout0_14) AT=630.025n

.meas tran vdout0_15ck1250 FIND v(dout0_15) AT=630.025n

.meas tran vdout0_16ck1250 FIND v(dout0_16) AT=630.025n

.meas tran vdout0_17ck1250 FIND v(dout0_17) AT=630.025n

.meas tran vdout0_18ck1250 FIND v(dout0_18) AT=630.025n

.meas tran vdout0_19ck1250 FIND v(dout0_19) AT=630.025n

.meas tran vdout0_20ck1250 FIND v(dout0_20) AT=630.025n

.meas tran vdout0_21ck1250 FIND v(dout0_21) AT=630.025n

.meas tran vdout0_22ck1250 FIND v(dout0_22) AT=630.025n

.meas tran vdout0_23ck1250 FIND v(dout0_23) AT=630.025n

.meas tran vdout0_24ck1250 FIND v(dout0_24) AT=630.025n

.meas tran vdout0_25ck1250 FIND v(dout0_25) AT=630.025n

.meas tran vdout0_26ck1250 FIND v(dout0_26) AT=630.025n

.meas tran vdout0_27ck1250 FIND v(dout0_27) AT=630.025n

.meas tran vdout0_28ck1250 FIND v(dout0_28) AT=630.025n

.meas tran vdout0_29ck1250 FIND v(dout0_29) AT=630.025n

.meas tran vdout0_30ck1250 FIND v(dout0_30) AT=630.025n

.meas tran vdout0_31ck1250 FIND v(dout0_31) AT=630.025n

.meas tran vdout0_32ck1250 FIND v(dout0_32) AT=630.025n

.meas tran vdout0_33ck1250 FIND v(dout0_33) AT=630.025n

.meas tran vdout0_34ck1250 FIND v(dout0_34) AT=630.025n

.meas tran vdout0_35ck1250 FIND v(dout0_35) AT=630.025n

.meas tran vdout0_36ck1250 FIND v(dout0_36) AT=630.025n

.meas tran vdout0_37ck1250 FIND v(dout0_37) AT=630.025n

.meas tran vdout0_38ck1250 FIND v(dout0_38) AT=630.025n

.meas tran vdout0_39ck1250 FIND v(dout0_39) AT=630.025n

.meas tran vdout0_40ck1250 FIND v(dout0_40) AT=630.025n

.meas tran vdout0_41ck1250 FIND v(dout0_41) AT=630.025n

.meas tran vdout0_42ck1250 FIND v(dout0_42) AT=630.025n

.meas tran vdout0_43ck1250 FIND v(dout0_43) AT=630.025n

.meas tran vdout0_44ck1250 FIND v(dout0_44) AT=630.025n

.meas tran vdout0_45ck1250 FIND v(dout0_45) AT=630.025n

.meas tran vdout0_46ck1250 FIND v(dout0_46) AT=630.025n

.meas tran vdout0_47ck1250 FIND v(dout0_47) AT=630.025n

.meas tran vdout0_48ck1250 FIND v(dout0_48) AT=630.025n

.meas tran vdout0_49ck1250 FIND v(dout0_49) AT=630.025n

.meas tran vdout0_50ck1250 FIND v(dout0_50) AT=630.025n

.meas tran vdout0_51ck1250 FIND v(dout0_51) AT=630.025n

.meas tran vdout0_52ck1250 FIND v(dout0_52) AT=630.025n

.meas tran vdout0_53ck1250 FIND v(dout0_53) AT=630.025n

.meas tran vdout0_54ck1250 FIND v(dout0_54) AT=630.025n

.meas tran vdout0_55ck1250 FIND v(dout0_55) AT=630.025n

.meas tran vdout0_56ck1250 FIND v(dout0_56) AT=630.025n

.meas tran vdout0_57ck1250 FIND v(dout0_57) AT=630.025n

.meas tran vdout0_58ck1250 FIND v(dout0_58) AT=630.025n

.meas tran vdout0_59ck1250 FIND v(dout0_59) AT=630.025n

.meas tran vdout0_60ck1250 FIND v(dout0_60) AT=630.025n

.meas tran vdout0_61ck1250 FIND v(dout0_61) AT=630.025n

.meas tran vdout0_62ck1250 FIND v(dout0_62) AT=630.025n

.meas tran vdout0_63ck1250 FIND v(dout0_63) AT=630.025n

.meas tran vdout0_64ck1250 FIND v(dout0_64) AT=630.025n

.meas tran vdout0_65ck1250 FIND v(dout0_65) AT=630.025n

.meas tran vdout0_66ck1250 FIND v(dout0_66) AT=630.025n

.meas tran vdout0_67ck1250 FIND v(dout0_67) AT=630.025n

.meas tran vdout0_68ck1250 FIND v(dout0_68) AT=630.025n

.meas tran vdout0_69ck1250 FIND v(dout0_69) AT=630.025n

.meas tran vdout0_70ck1250 FIND v(dout0_70) AT=630.025n

.meas tran vdout0_71ck1250 FIND v(dout0_71) AT=630.025n

.meas tran vdout0_72ck1250 FIND v(dout0_72) AT=630.025n

.meas tran vdout0_73ck1250 FIND v(dout0_73) AT=630.025n

.meas tran vdout0_74ck1250 FIND v(dout0_74) AT=630.025n

.meas tran vdout0_75ck1250 FIND v(dout0_75) AT=630.025n

.meas tran vdout0_76ck1250 FIND v(dout0_76) AT=630.025n

.meas tran vdout0_77ck1250 FIND v(dout0_77) AT=630.025n

.meas tran vdout0_78ck1250 FIND v(dout0_78) AT=630.025n

.meas tran vdout0_79ck1250 FIND v(dout0_79) AT=630.025n

.meas tran vdout0_80ck1250 FIND v(dout0_80) AT=630.025n

.meas tran vdout0_81ck1250 FIND v(dout0_81) AT=630.025n

.meas tran vdout0_82ck1250 FIND v(dout0_82) AT=630.025n

.meas tran vdout0_83ck1250 FIND v(dout0_83) AT=630.025n

.meas tran vdout0_84ck1250 FIND v(dout0_84) AT=630.025n

.meas tran vdout0_85ck1250 FIND v(dout0_85) AT=630.025n

.meas tran vdout0_86ck1250 FIND v(dout0_86) AT=630.025n

.meas tran vdout0_87ck1250 FIND v(dout0_87) AT=630.025n

.meas tran vdout0_88ck1250 FIND v(dout0_88) AT=630.025n

.meas tran vdout0_89ck1250 FIND v(dout0_89) AT=630.025n

.meas tran vdout0_90ck1250 FIND v(dout0_90) AT=630.025n

.meas tran vdout0_91ck1250 FIND v(dout0_91) AT=630.025n

.meas tran vdout0_92ck1250 FIND v(dout0_92) AT=630.025n

.meas tran vdout0_93ck1250 FIND v(dout0_93) AT=630.025n

.meas tran vdout0_94ck1250 FIND v(dout0_94) AT=630.025n

.meas tran vdout0_95ck1250 FIND v(dout0_95) AT=630.025n

.meas tran vdout0_96ck1250 FIND v(dout0_96) AT=630.025n

.meas tran vdout0_97ck1250 FIND v(dout0_97) AT=630.025n

.meas tran vdout0_98ck1250 FIND v(dout0_98) AT=630.025n

.meas tran vdout0_99ck1250 FIND v(dout0_99) AT=630.025n

.meas tran vdout0_100ck1250 FIND v(dout0_100) AT=630.025n

.meas tran vdout0_101ck1250 FIND v(dout0_101) AT=630.025n

.meas tran vdout0_102ck1250 FIND v(dout0_102) AT=630.025n

.meas tran vdout0_103ck1250 FIND v(dout0_103) AT=630.025n

.meas tran vdout0_104ck1250 FIND v(dout0_104) AT=630.025n

.meas tran vdout0_105ck1250 FIND v(dout0_105) AT=630.025n

.meas tran vdout0_106ck1250 FIND v(dout0_106) AT=630.025n

.meas tran vdout0_107ck1250 FIND v(dout0_107) AT=630.025n

.meas tran vdout0_108ck1250 FIND v(dout0_108) AT=630.025n

.meas tran vdout0_109ck1250 FIND v(dout0_109) AT=630.025n

.meas tran vdout0_110ck1250 FIND v(dout0_110) AT=630.025n

.meas tran vdout0_111ck1250 FIND v(dout0_111) AT=630.025n

.meas tran vdout0_112ck1250 FIND v(dout0_112) AT=630.025n

.meas tran vdout0_113ck1250 FIND v(dout0_113) AT=630.025n

.meas tran vdout0_114ck1250 FIND v(dout0_114) AT=630.025n

.meas tran vdout0_115ck1250 FIND v(dout0_115) AT=630.025n

.meas tran vdout0_116ck1250 FIND v(dout0_116) AT=630.025n

.meas tran vdout0_117ck1250 FIND v(dout0_117) AT=630.025n

.meas tran vdout0_118ck1250 FIND v(dout0_118) AT=630.025n

.meas tran vdout0_119ck1250 FIND v(dout0_119) AT=630.025n

.meas tran vdout0_120ck1250 FIND v(dout0_120) AT=630.025n

.meas tran vdout0_121ck1250 FIND v(dout0_121) AT=630.025n

.meas tran vdout0_122ck1250 FIND v(dout0_122) AT=630.025n

.meas tran vdout0_123ck1250 FIND v(dout0_123) AT=630.025n

.meas tran vdout0_124ck1250 FIND v(dout0_124) AT=630.025n

.meas tran vdout0_125ck1250 FIND v(dout0_125) AT=630.025n

.meas tran vdout0_126ck1250 FIND v(dout0_126) AT=630.025n

.meas tran vdout0_127ck1250 FIND v(dout0_127) AT=630.025n

.meas tran vdout0_128ck1250 FIND v(dout0_128) AT=630.025n

.meas tran vdout0_129ck1250 FIND v(dout0_129) AT=630.025n

.meas tran vdout0_130ck1250 FIND v(dout0_130) AT=630.025n

.meas tran vdout0_131ck1250 FIND v(dout0_131) AT=630.025n

.meas tran vdout0_132ck1250 FIND v(dout0_132) AT=630.025n

.meas tran vdout0_133ck1250 FIND v(dout0_133) AT=630.025n

.meas tran vdout0_134ck1250 FIND v(dout0_134) AT=630.025n

.meas tran vdout0_135ck1250 FIND v(dout0_135) AT=630.025n

.meas tran vdout0_136ck1250 FIND v(dout0_136) AT=630.025n

.meas tran vdout0_137ck1250 FIND v(dout0_137) AT=630.025n

.meas tran vdout0_138ck1250 FIND v(dout0_138) AT=630.025n

.meas tran vdout0_139ck1250 FIND v(dout0_139) AT=630.025n

.meas tran vdout0_140ck1250 FIND v(dout0_140) AT=630.025n

.meas tran vdout0_141ck1250 FIND v(dout0_141) AT=630.025n

.meas tran vdout0_142ck1250 FIND v(dout0_142) AT=630.025n

.meas tran vdout0_143ck1250 FIND v(dout0_143) AT=630.025n

.meas tran vdout0_144ck1250 FIND v(dout0_144) AT=630.025n

.meas tran vdout0_145ck1250 FIND v(dout0_145) AT=630.025n

.meas tran vdout0_146ck1250 FIND v(dout0_146) AT=630.025n

.meas tran vdout0_147ck1250 FIND v(dout0_147) AT=630.025n

.meas tran vdout0_148ck1250 FIND v(dout0_148) AT=630.025n

.meas tran vdout0_149ck1250 FIND v(dout0_149) AT=630.025n

.meas tran vdout0_150ck1250 FIND v(dout0_150) AT=630.025n

.meas tran vdout0_151ck1250 FIND v(dout0_151) AT=630.025n

.meas tran vdout0_152ck1250 FIND v(dout0_152) AT=630.025n

.meas tran vdout0_153ck1250 FIND v(dout0_153) AT=630.025n

.meas tran vdout0_154ck1250 FIND v(dout0_154) AT=630.025n

.meas tran vdout0_155ck1250 FIND v(dout0_155) AT=630.025n

.meas tran vdout0_156ck1250 FIND v(dout0_156) AT=630.025n

.meas tran vdout0_157ck1250 FIND v(dout0_157) AT=630.025n

.meas tran vdout0_158ck1250 FIND v(dout0_158) AT=630.025n

.meas tran vdout0_159ck1250 FIND v(dout0_159) AT=630.025n

.meas tran vdout0_160ck1250 FIND v(dout0_160) AT=630.025n

.meas tran vdout0_161ck1250 FIND v(dout0_161) AT=630.025n

.meas tran vdout0_162ck1250 FIND v(dout0_162) AT=630.025n

.meas tran vdout0_163ck1250 FIND v(dout0_163) AT=630.025n

.meas tran vdout0_164ck1250 FIND v(dout0_164) AT=630.025n

.meas tran vdout0_165ck1250 FIND v(dout0_165) AT=630.025n

.meas tran vdout0_166ck1250 FIND v(dout0_166) AT=630.025n

.meas tran vdout0_167ck1250 FIND v(dout0_167) AT=630.025n

.meas tran vdout0_168ck1250 FIND v(dout0_168) AT=630.025n

.meas tran vdout0_169ck1250 FIND v(dout0_169) AT=630.025n

.meas tran vdout0_170ck1250 FIND v(dout0_170) AT=630.025n

.meas tran vdout0_171ck1250 FIND v(dout0_171) AT=630.025n

.meas tran vdout0_172ck1250 FIND v(dout0_172) AT=630.025n

.meas tran vdout0_173ck1250 FIND v(dout0_173) AT=630.025n

.meas tran vdout0_174ck1250 FIND v(dout0_174) AT=630.025n

.meas tran vdout0_175ck1250 FIND v(dout0_175) AT=630.025n

.meas tran vdout0_176ck1250 FIND v(dout0_176) AT=630.025n

.meas tran vdout0_177ck1250 FIND v(dout0_177) AT=630.025n

.meas tran vdout0_178ck1250 FIND v(dout0_178) AT=630.025n

.meas tran vdout0_179ck1250 FIND v(dout0_179) AT=630.025n

.meas tran vdout0_180ck1250 FIND v(dout0_180) AT=630.025n

.meas tran vdout0_181ck1250 FIND v(dout0_181) AT=630.025n

.meas tran vdout0_182ck1250 FIND v(dout0_182) AT=630.025n

.meas tran vdout0_183ck1250 FIND v(dout0_183) AT=630.025n

.meas tran vdout0_184ck1250 FIND v(dout0_184) AT=630.025n

.meas tran vdout0_185ck1250 FIND v(dout0_185) AT=630.025n

.meas tran vdout0_186ck1250 FIND v(dout0_186) AT=630.025n

.meas tran vdout0_187ck1250 FIND v(dout0_187) AT=630.025n

.meas tran vdout0_188ck1250 FIND v(dout0_188) AT=630.025n

.meas tran vdout0_189ck1250 FIND v(dout0_189) AT=630.025n

.meas tran vdout0_190ck1250 FIND v(dout0_190) AT=630.025n

.meas tran vdout0_191ck1250 FIND v(dout0_191) AT=630.025n

.meas tran vdout0_192ck1250 FIND v(dout0_192) AT=630.025n

.meas tran vdout0_193ck1250 FIND v(dout0_193) AT=630.025n

.meas tran vdout0_194ck1250 FIND v(dout0_194) AT=630.025n

.meas tran vdout0_195ck1250 FIND v(dout0_195) AT=630.025n

.meas tran vdout0_196ck1250 FIND v(dout0_196) AT=630.025n

.meas tran vdout0_197ck1250 FIND v(dout0_197) AT=630.025n

.meas tran vdout0_198ck1250 FIND v(dout0_198) AT=630.025n

.meas tran vdout0_199ck1250 FIND v(dout0_199) AT=630.025n

.meas tran vdout0_200ck1250 FIND v(dout0_200) AT=630.025n

.meas tran vdout0_201ck1250 FIND v(dout0_201) AT=630.025n

.meas tran vdout0_202ck1250 FIND v(dout0_202) AT=630.025n

.meas tran vdout0_203ck1250 FIND v(dout0_203) AT=630.025n

.meas tran vdout0_204ck1250 FIND v(dout0_204) AT=630.025n

.meas tran vdout0_205ck1250 FIND v(dout0_205) AT=630.025n

.meas tran vdout0_206ck1250 FIND v(dout0_206) AT=630.025n

.meas tran vdout0_207ck1250 FIND v(dout0_207) AT=630.025n

.meas tran vdout0_208ck1250 FIND v(dout0_208) AT=630.025n

.meas tran vdout0_209ck1250 FIND v(dout0_209) AT=630.025n

.meas tran vdout0_210ck1250 FIND v(dout0_210) AT=630.025n

.meas tran vdout0_211ck1250 FIND v(dout0_211) AT=630.025n

.meas tran vdout0_212ck1250 FIND v(dout0_212) AT=630.025n

.meas tran vdout0_213ck1250 FIND v(dout0_213) AT=630.025n

.meas tran vdout0_214ck1250 FIND v(dout0_214) AT=630.025n

.meas tran vdout0_215ck1250 FIND v(dout0_215) AT=630.025n

.meas tran vdout0_216ck1250 FIND v(dout0_216) AT=630.025n

.meas tran vdout0_217ck1250 FIND v(dout0_217) AT=630.025n

.meas tran vdout0_218ck1250 FIND v(dout0_218) AT=630.025n

.meas tran vdout0_219ck1250 FIND v(dout0_219) AT=630.025n

.meas tran vdout0_220ck1250 FIND v(dout0_220) AT=630.025n

.meas tran vdout0_221ck1250 FIND v(dout0_221) AT=630.025n

.meas tran vdout0_222ck1250 FIND v(dout0_222) AT=630.025n

.meas tran vdout0_223ck1250 FIND v(dout0_223) AT=630.025n

.meas tran vdout0_224ck1250 FIND v(dout0_224) AT=630.025n

.meas tran vdout0_225ck1250 FIND v(dout0_225) AT=630.025n

.meas tran vdout0_226ck1250 FIND v(dout0_226) AT=630.025n

.meas tran vdout0_227ck1250 FIND v(dout0_227) AT=630.025n

.meas tran vdout0_228ck1250 FIND v(dout0_228) AT=630.025n

.meas tran vdout0_229ck1250 FIND v(dout0_229) AT=630.025n

.meas tran vdout0_230ck1250 FIND v(dout0_230) AT=630.025n

.meas tran vdout0_231ck1250 FIND v(dout0_231) AT=630.025n

.meas tran vdout0_232ck1250 FIND v(dout0_232) AT=630.025n

.meas tran vdout0_233ck1250 FIND v(dout0_233) AT=630.025n

.meas tran vdout0_234ck1250 FIND v(dout0_234) AT=630.025n

.meas tran vdout0_235ck1250 FIND v(dout0_235) AT=630.025n

.meas tran vdout0_236ck1250 FIND v(dout0_236) AT=630.025n

.meas tran vdout0_237ck1250 FIND v(dout0_237) AT=630.025n

.meas tran vdout0_238ck1250 FIND v(dout0_238) AT=630.025n

.meas tran vdout0_239ck1250 FIND v(dout0_239) AT=630.025n

.meas tran vdout0_240ck1250 FIND v(dout0_240) AT=630.025n

.meas tran vdout0_241ck1250 FIND v(dout0_241) AT=630.025n

.meas tran vdout0_242ck1250 FIND v(dout0_242) AT=630.025n

.meas tran vdout0_243ck1250 FIND v(dout0_243) AT=630.025n

.meas tran vdout0_244ck1250 FIND v(dout0_244) AT=630.025n

.meas tran vdout0_245ck1250 FIND v(dout0_245) AT=630.025n

.meas tran vdout0_246ck1250 FIND v(dout0_246) AT=630.025n

.meas tran vdout0_247ck1250 FIND v(dout0_247) AT=630.025n

.meas tran vdout0_248ck1250 FIND v(dout0_248) AT=630.025n

.meas tran vdout0_249ck1250 FIND v(dout0_249) AT=630.025n

.meas tran vdout0_250ck1250 FIND v(dout0_250) AT=630.025n

.meas tran vdout0_251ck1250 FIND v(dout0_251) AT=630.025n

.meas tran vdout0_252ck1250 FIND v(dout0_252) AT=630.025n

.meas tran vdout0_253ck1250 FIND v(dout0_253) AT=630.025n

.meas tran vdout0_254ck1250 FIND v(dout0_254) AT=630.025n

.meas tran vdout0_255ck1250 FIND v(dout0_255) AT=630.025n

.meas tran vdout0_0ck1260 FIND v(dout0_0) AT=635.025n

.meas tran vdout0_1ck1260 FIND v(dout0_1) AT=635.025n

.meas tran vdout0_2ck1260 FIND v(dout0_2) AT=635.025n

.meas tran vdout0_3ck1260 FIND v(dout0_3) AT=635.025n

.meas tran vdout0_4ck1260 FIND v(dout0_4) AT=635.025n

.meas tran vdout0_5ck1260 FIND v(dout0_5) AT=635.025n

.meas tran vdout0_6ck1260 FIND v(dout0_6) AT=635.025n

.meas tran vdout0_7ck1260 FIND v(dout0_7) AT=635.025n

.meas tran vdout0_8ck1260 FIND v(dout0_8) AT=635.025n

.meas tran vdout0_9ck1260 FIND v(dout0_9) AT=635.025n

.meas tran vdout0_10ck1260 FIND v(dout0_10) AT=635.025n

.meas tran vdout0_11ck1260 FIND v(dout0_11) AT=635.025n

.meas tran vdout0_12ck1260 FIND v(dout0_12) AT=635.025n

.meas tran vdout0_13ck1260 FIND v(dout0_13) AT=635.025n

.meas tran vdout0_14ck1260 FIND v(dout0_14) AT=635.025n

.meas tran vdout0_15ck1260 FIND v(dout0_15) AT=635.025n

.meas tran vdout0_16ck1260 FIND v(dout0_16) AT=635.025n

.meas tran vdout0_17ck1260 FIND v(dout0_17) AT=635.025n

.meas tran vdout0_18ck1260 FIND v(dout0_18) AT=635.025n

.meas tran vdout0_19ck1260 FIND v(dout0_19) AT=635.025n

.meas tran vdout0_20ck1260 FIND v(dout0_20) AT=635.025n

.meas tran vdout0_21ck1260 FIND v(dout0_21) AT=635.025n

.meas tran vdout0_22ck1260 FIND v(dout0_22) AT=635.025n

.meas tran vdout0_23ck1260 FIND v(dout0_23) AT=635.025n

.meas tran vdout0_24ck1260 FIND v(dout0_24) AT=635.025n

.meas tran vdout0_25ck1260 FIND v(dout0_25) AT=635.025n

.meas tran vdout0_26ck1260 FIND v(dout0_26) AT=635.025n

.meas tran vdout0_27ck1260 FIND v(dout0_27) AT=635.025n

.meas tran vdout0_28ck1260 FIND v(dout0_28) AT=635.025n

.meas tran vdout0_29ck1260 FIND v(dout0_29) AT=635.025n

.meas tran vdout0_30ck1260 FIND v(dout0_30) AT=635.025n

.meas tran vdout0_31ck1260 FIND v(dout0_31) AT=635.025n

.meas tran vdout0_32ck1260 FIND v(dout0_32) AT=635.025n

.meas tran vdout0_33ck1260 FIND v(dout0_33) AT=635.025n

.meas tran vdout0_34ck1260 FIND v(dout0_34) AT=635.025n

.meas tran vdout0_35ck1260 FIND v(dout0_35) AT=635.025n

.meas tran vdout0_36ck1260 FIND v(dout0_36) AT=635.025n

.meas tran vdout0_37ck1260 FIND v(dout0_37) AT=635.025n

.meas tran vdout0_38ck1260 FIND v(dout0_38) AT=635.025n

.meas tran vdout0_39ck1260 FIND v(dout0_39) AT=635.025n

.meas tran vdout0_40ck1260 FIND v(dout0_40) AT=635.025n

.meas tran vdout0_41ck1260 FIND v(dout0_41) AT=635.025n

.meas tran vdout0_42ck1260 FIND v(dout0_42) AT=635.025n

.meas tran vdout0_43ck1260 FIND v(dout0_43) AT=635.025n

.meas tran vdout0_44ck1260 FIND v(dout0_44) AT=635.025n

.meas tran vdout0_45ck1260 FIND v(dout0_45) AT=635.025n

.meas tran vdout0_46ck1260 FIND v(dout0_46) AT=635.025n

.meas tran vdout0_47ck1260 FIND v(dout0_47) AT=635.025n

.meas tran vdout0_48ck1260 FIND v(dout0_48) AT=635.025n

.meas tran vdout0_49ck1260 FIND v(dout0_49) AT=635.025n

.meas tran vdout0_50ck1260 FIND v(dout0_50) AT=635.025n

.meas tran vdout0_51ck1260 FIND v(dout0_51) AT=635.025n

.meas tran vdout0_52ck1260 FIND v(dout0_52) AT=635.025n

.meas tran vdout0_53ck1260 FIND v(dout0_53) AT=635.025n

.meas tran vdout0_54ck1260 FIND v(dout0_54) AT=635.025n

.meas tran vdout0_55ck1260 FIND v(dout0_55) AT=635.025n

.meas tran vdout0_56ck1260 FIND v(dout0_56) AT=635.025n

.meas tran vdout0_57ck1260 FIND v(dout0_57) AT=635.025n

.meas tran vdout0_58ck1260 FIND v(dout0_58) AT=635.025n

.meas tran vdout0_59ck1260 FIND v(dout0_59) AT=635.025n

.meas tran vdout0_60ck1260 FIND v(dout0_60) AT=635.025n

.meas tran vdout0_61ck1260 FIND v(dout0_61) AT=635.025n

.meas tran vdout0_62ck1260 FIND v(dout0_62) AT=635.025n

.meas tran vdout0_63ck1260 FIND v(dout0_63) AT=635.025n

.meas tran vdout0_64ck1260 FIND v(dout0_64) AT=635.025n

.meas tran vdout0_65ck1260 FIND v(dout0_65) AT=635.025n

.meas tran vdout0_66ck1260 FIND v(dout0_66) AT=635.025n

.meas tran vdout0_67ck1260 FIND v(dout0_67) AT=635.025n

.meas tran vdout0_68ck1260 FIND v(dout0_68) AT=635.025n

.meas tran vdout0_69ck1260 FIND v(dout0_69) AT=635.025n

.meas tran vdout0_70ck1260 FIND v(dout0_70) AT=635.025n

.meas tran vdout0_71ck1260 FIND v(dout0_71) AT=635.025n

.meas tran vdout0_72ck1260 FIND v(dout0_72) AT=635.025n

.meas tran vdout0_73ck1260 FIND v(dout0_73) AT=635.025n

.meas tran vdout0_74ck1260 FIND v(dout0_74) AT=635.025n

.meas tran vdout0_75ck1260 FIND v(dout0_75) AT=635.025n

.meas tran vdout0_76ck1260 FIND v(dout0_76) AT=635.025n

.meas tran vdout0_77ck1260 FIND v(dout0_77) AT=635.025n

.meas tran vdout0_78ck1260 FIND v(dout0_78) AT=635.025n

.meas tran vdout0_79ck1260 FIND v(dout0_79) AT=635.025n

.meas tran vdout0_80ck1260 FIND v(dout0_80) AT=635.025n

.meas tran vdout0_81ck1260 FIND v(dout0_81) AT=635.025n

.meas tran vdout0_82ck1260 FIND v(dout0_82) AT=635.025n

.meas tran vdout0_83ck1260 FIND v(dout0_83) AT=635.025n

.meas tran vdout0_84ck1260 FIND v(dout0_84) AT=635.025n

.meas tran vdout0_85ck1260 FIND v(dout0_85) AT=635.025n

.meas tran vdout0_86ck1260 FIND v(dout0_86) AT=635.025n

.meas tran vdout0_87ck1260 FIND v(dout0_87) AT=635.025n

.meas tran vdout0_88ck1260 FIND v(dout0_88) AT=635.025n

.meas tran vdout0_89ck1260 FIND v(dout0_89) AT=635.025n

.meas tran vdout0_90ck1260 FIND v(dout0_90) AT=635.025n

.meas tran vdout0_91ck1260 FIND v(dout0_91) AT=635.025n

.meas tran vdout0_92ck1260 FIND v(dout0_92) AT=635.025n

.meas tran vdout0_93ck1260 FIND v(dout0_93) AT=635.025n

.meas tran vdout0_94ck1260 FIND v(dout0_94) AT=635.025n

.meas tran vdout0_95ck1260 FIND v(dout0_95) AT=635.025n

.meas tran vdout0_96ck1260 FIND v(dout0_96) AT=635.025n

.meas tran vdout0_97ck1260 FIND v(dout0_97) AT=635.025n

.meas tran vdout0_98ck1260 FIND v(dout0_98) AT=635.025n

.meas tran vdout0_99ck1260 FIND v(dout0_99) AT=635.025n

.meas tran vdout0_100ck1260 FIND v(dout0_100) AT=635.025n

.meas tran vdout0_101ck1260 FIND v(dout0_101) AT=635.025n

.meas tran vdout0_102ck1260 FIND v(dout0_102) AT=635.025n

.meas tran vdout0_103ck1260 FIND v(dout0_103) AT=635.025n

.meas tran vdout0_104ck1260 FIND v(dout0_104) AT=635.025n

.meas tran vdout0_105ck1260 FIND v(dout0_105) AT=635.025n

.meas tran vdout0_106ck1260 FIND v(dout0_106) AT=635.025n

.meas tran vdout0_107ck1260 FIND v(dout0_107) AT=635.025n

.meas tran vdout0_108ck1260 FIND v(dout0_108) AT=635.025n

.meas tran vdout0_109ck1260 FIND v(dout0_109) AT=635.025n

.meas tran vdout0_110ck1260 FIND v(dout0_110) AT=635.025n

.meas tran vdout0_111ck1260 FIND v(dout0_111) AT=635.025n

.meas tran vdout0_112ck1260 FIND v(dout0_112) AT=635.025n

.meas tran vdout0_113ck1260 FIND v(dout0_113) AT=635.025n

.meas tran vdout0_114ck1260 FIND v(dout0_114) AT=635.025n

.meas tran vdout0_115ck1260 FIND v(dout0_115) AT=635.025n

.meas tran vdout0_116ck1260 FIND v(dout0_116) AT=635.025n

.meas tran vdout0_117ck1260 FIND v(dout0_117) AT=635.025n

.meas tran vdout0_118ck1260 FIND v(dout0_118) AT=635.025n

.meas tran vdout0_119ck1260 FIND v(dout0_119) AT=635.025n

.meas tran vdout0_120ck1260 FIND v(dout0_120) AT=635.025n

.meas tran vdout0_121ck1260 FIND v(dout0_121) AT=635.025n

.meas tran vdout0_122ck1260 FIND v(dout0_122) AT=635.025n

.meas tran vdout0_123ck1260 FIND v(dout0_123) AT=635.025n

.meas tran vdout0_124ck1260 FIND v(dout0_124) AT=635.025n

.meas tran vdout0_125ck1260 FIND v(dout0_125) AT=635.025n

.meas tran vdout0_126ck1260 FIND v(dout0_126) AT=635.025n

.meas tran vdout0_127ck1260 FIND v(dout0_127) AT=635.025n

.meas tran vdout0_128ck1260 FIND v(dout0_128) AT=635.025n

.meas tran vdout0_129ck1260 FIND v(dout0_129) AT=635.025n

.meas tran vdout0_130ck1260 FIND v(dout0_130) AT=635.025n

.meas tran vdout0_131ck1260 FIND v(dout0_131) AT=635.025n

.meas tran vdout0_132ck1260 FIND v(dout0_132) AT=635.025n

.meas tran vdout0_133ck1260 FIND v(dout0_133) AT=635.025n

.meas tran vdout0_134ck1260 FIND v(dout0_134) AT=635.025n

.meas tran vdout0_135ck1260 FIND v(dout0_135) AT=635.025n

.meas tran vdout0_136ck1260 FIND v(dout0_136) AT=635.025n

.meas tran vdout0_137ck1260 FIND v(dout0_137) AT=635.025n

.meas tran vdout0_138ck1260 FIND v(dout0_138) AT=635.025n

.meas tran vdout0_139ck1260 FIND v(dout0_139) AT=635.025n

.meas tran vdout0_140ck1260 FIND v(dout0_140) AT=635.025n

.meas tran vdout0_141ck1260 FIND v(dout0_141) AT=635.025n

.meas tran vdout0_142ck1260 FIND v(dout0_142) AT=635.025n

.meas tran vdout0_143ck1260 FIND v(dout0_143) AT=635.025n

.meas tran vdout0_144ck1260 FIND v(dout0_144) AT=635.025n

.meas tran vdout0_145ck1260 FIND v(dout0_145) AT=635.025n

.meas tran vdout0_146ck1260 FIND v(dout0_146) AT=635.025n

.meas tran vdout0_147ck1260 FIND v(dout0_147) AT=635.025n

.meas tran vdout0_148ck1260 FIND v(dout0_148) AT=635.025n

.meas tran vdout0_149ck1260 FIND v(dout0_149) AT=635.025n

.meas tran vdout0_150ck1260 FIND v(dout0_150) AT=635.025n

.meas tran vdout0_151ck1260 FIND v(dout0_151) AT=635.025n

.meas tran vdout0_152ck1260 FIND v(dout0_152) AT=635.025n

.meas tran vdout0_153ck1260 FIND v(dout0_153) AT=635.025n

.meas tran vdout0_154ck1260 FIND v(dout0_154) AT=635.025n

.meas tran vdout0_155ck1260 FIND v(dout0_155) AT=635.025n

.meas tran vdout0_156ck1260 FIND v(dout0_156) AT=635.025n

.meas tran vdout0_157ck1260 FIND v(dout0_157) AT=635.025n

.meas tran vdout0_158ck1260 FIND v(dout0_158) AT=635.025n

.meas tran vdout0_159ck1260 FIND v(dout0_159) AT=635.025n

.meas tran vdout0_160ck1260 FIND v(dout0_160) AT=635.025n

.meas tran vdout0_161ck1260 FIND v(dout0_161) AT=635.025n

.meas tran vdout0_162ck1260 FIND v(dout0_162) AT=635.025n

.meas tran vdout0_163ck1260 FIND v(dout0_163) AT=635.025n

.meas tran vdout0_164ck1260 FIND v(dout0_164) AT=635.025n

.meas tran vdout0_165ck1260 FIND v(dout0_165) AT=635.025n

.meas tran vdout0_166ck1260 FIND v(dout0_166) AT=635.025n

.meas tran vdout0_167ck1260 FIND v(dout0_167) AT=635.025n

.meas tran vdout0_168ck1260 FIND v(dout0_168) AT=635.025n

.meas tran vdout0_169ck1260 FIND v(dout0_169) AT=635.025n

.meas tran vdout0_170ck1260 FIND v(dout0_170) AT=635.025n

.meas tran vdout0_171ck1260 FIND v(dout0_171) AT=635.025n

.meas tran vdout0_172ck1260 FIND v(dout0_172) AT=635.025n

.meas tran vdout0_173ck1260 FIND v(dout0_173) AT=635.025n

.meas tran vdout0_174ck1260 FIND v(dout0_174) AT=635.025n

.meas tran vdout0_175ck1260 FIND v(dout0_175) AT=635.025n

.meas tran vdout0_176ck1260 FIND v(dout0_176) AT=635.025n

.meas tran vdout0_177ck1260 FIND v(dout0_177) AT=635.025n

.meas tran vdout0_178ck1260 FIND v(dout0_178) AT=635.025n

.meas tran vdout0_179ck1260 FIND v(dout0_179) AT=635.025n

.meas tran vdout0_180ck1260 FIND v(dout0_180) AT=635.025n

.meas tran vdout0_181ck1260 FIND v(dout0_181) AT=635.025n

.meas tran vdout0_182ck1260 FIND v(dout0_182) AT=635.025n

.meas tran vdout0_183ck1260 FIND v(dout0_183) AT=635.025n

.meas tran vdout0_184ck1260 FIND v(dout0_184) AT=635.025n

.meas tran vdout0_185ck1260 FIND v(dout0_185) AT=635.025n

.meas tran vdout0_186ck1260 FIND v(dout0_186) AT=635.025n

.meas tran vdout0_187ck1260 FIND v(dout0_187) AT=635.025n

.meas tran vdout0_188ck1260 FIND v(dout0_188) AT=635.025n

.meas tran vdout0_189ck1260 FIND v(dout0_189) AT=635.025n

.meas tran vdout0_190ck1260 FIND v(dout0_190) AT=635.025n

.meas tran vdout0_191ck1260 FIND v(dout0_191) AT=635.025n

.meas tran vdout0_192ck1260 FIND v(dout0_192) AT=635.025n

.meas tran vdout0_193ck1260 FIND v(dout0_193) AT=635.025n

.meas tran vdout0_194ck1260 FIND v(dout0_194) AT=635.025n

.meas tran vdout0_195ck1260 FIND v(dout0_195) AT=635.025n

.meas tran vdout0_196ck1260 FIND v(dout0_196) AT=635.025n

.meas tran vdout0_197ck1260 FIND v(dout0_197) AT=635.025n

.meas tran vdout0_198ck1260 FIND v(dout0_198) AT=635.025n

.meas tran vdout0_199ck1260 FIND v(dout0_199) AT=635.025n

.meas tran vdout0_200ck1260 FIND v(dout0_200) AT=635.025n

.meas tran vdout0_201ck1260 FIND v(dout0_201) AT=635.025n

.meas tran vdout0_202ck1260 FIND v(dout0_202) AT=635.025n

.meas tran vdout0_203ck1260 FIND v(dout0_203) AT=635.025n

.meas tran vdout0_204ck1260 FIND v(dout0_204) AT=635.025n

.meas tran vdout0_205ck1260 FIND v(dout0_205) AT=635.025n

.meas tran vdout0_206ck1260 FIND v(dout0_206) AT=635.025n

.meas tran vdout0_207ck1260 FIND v(dout0_207) AT=635.025n

.meas tran vdout0_208ck1260 FIND v(dout0_208) AT=635.025n

.meas tran vdout0_209ck1260 FIND v(dout0_209) AT=635.025n

.meas tran vdout0_210ck1260 FIND v(dout0_210) AT=635.025n

.meas tran vdout0_211ck1260 FIND v(dout0_211) AT=635.025n

.meas tran vdout0_212ck1260 FIND v(dout0_212) AT=635.025n

.meas tran vdout0_213ck1260 FIND v(dout0_213) AT=635.025n

.meas tran vdout0_214ck1260 FIND v(dout0_214) AT=635.025n

.meas tran vdout0_215ck1260 FIND v(dout0_215) AT=635.025n

.meas tran vdout0_216ck1260 FIND v(dout0_216) AT=635.025n

.meas tran vdout0_217ck1260 FIND v(dout0_217) AT=635.025n

.meas tran vdout0_218ck1260 FIND v(dout0_218) AT=635.025n

.meas tran vdout0_219ck1260 FIND v(dout0_219) AT=635.025n

.meas tran vdout0_220ck1260 FIND v(dout0_220) AT=635.025n

.meas tran vdout0_221ck1260 FIND v(dout0_221) AT=635.025n

.meas tran vdout0_222ck1260 FIND v(dout0_222) AT=635.025n

.meas tran vdout0_223ck1260 FIND v(dout0_223) AT=635.025n

.meas tran vdout0_224ck1260 FIND v(dout0_224) AT=635.025n

.meas tran vdout0_225ck1260 FIND v(dout0_225) AT=635.025n

.meas tran vdout0_226ck1260 FIND v(dout0_226) AT=635.025n

.meas tran vdout0_227ck1260 FIND v(dout0_227) AT=635.025n

.meas tran vdout0_228ck1260 FIND v(dout0_228) AT=635.025n

.meas tran vdout0_229ck1260 FIND v(dout0_229) AT=635.025n

.meas tran vdout0_230ck1260 FIND v(dout0_230) AT=635.025n

.meas tran vdout0_231ck1260 FIND v(dout0_231) AT=635.025n

.meas tran vdout0_232ck1260 FIND v(dout0_232) AT=635.025n

.meas tran vdout0_233ck1260 FIND v(dout0_233) AT=635.025n

.meas tran vdout0_234ck1260 FIND v(dout0_234) AT=635.025n

.meas tran vdout0_235ck1260 FIND v(dout0_235) AT=635.025n

.meas tran vdout0_236ck1260 FIND v(dout0_236) AT=635.025n

.meas tran vdout0_237ck1260 FIND v(dout0_237) AT=635.025n

.meas tran vdout0_238ck1260 FIND v(dout0_238) AT=635.025n

.meas tran vdout0_239ck1260 FIND v(dout0_239) AT=635.025n

.meas tran vdout0_240ck1260 FIND v(dout0_240) AT=635.025n

.meas tran vdout0_241ck1260 FIND v(dout0_241) AT=635.025n

.meas tran vdout0_242ck1260 FIND v(dout0_242) AT=635.025n

.meas tran vdout0_243ck1260 FIND v(dout0_243) AT=635.025n

.meas tran vdout0_244ck1260 FIND v(dout0_244) AT=635.025n

.meas tran vdout0_245ck1260 FIND v(dout0_245) AT=635.025n

.meas tran vdout0_246ck1260 FIND v(dout0_246) AT=635.025n

.meas tran vdout0_247ck1260 FIND v(dout0_247) AT=635.025n

.meas tran vdout0_248ck1260 FIND v(dout0_248) AT=635.025n

.meas tran vdout0_249ck1260 FIND v(dout0_249) AT=635.025n

.meas tran vdout0_250ck1260 FIND v(dout0_250) AT=635.025n

.meas tran vdout0_251ck1260 FIND v(dout0_251) AT=635.025n

.meas tran vdout0_252ck1260 FIND v(dout0_252) AT=635.025n

.meas tran vdout0_253ck1260 FIND v(dout0_253) AT=635.025n

.meas tran vdout0_254ck1260 FIND v(dout0_254) AT=635.025n

.meas tran vdout0_255ck1260 FIND v(dout0_255) AT=635.025n

.meas tran vdout0_0ck1280 FIND v(dout0_0) AT=645.025n

.meas tran vdout0_1ck1280 FIND v(dout0_1) AT=645.025n

.meas tran vdout0_2ck1280 FIND v(dout0_2) AT=645.025n

.meas tran vdout0_3ck1280 FIND v(dout0_3) AT=645.025n

.meas tran vdout0_4ck1280 FIND v(dout0_4) AT=645.025n

.meas tran vdout0_5ck1280 FIND v(dout0_5) AT=645.025n

.meas tran vdout0_6ck1280 FIND v(dout0_6) AT=645.025n

.meas tran vdout0_7ck1280 FIND v(dout0_7) AT=645.025n

.meas tran vdout0_8ck1280 FIND v(dout0_8) AT=645.025n

.meas tran vdout0_9ck1280 FIND v(dout0_9) AT=645.025n

.meas tran vdout0_10ck1280 FIND v(dout0_10) AT=645.025n

.meas tran vdout0_11ck1280 FIND v(dout0_11) AT=645.025n

.meas tran vdout0_12ck1280 FIND v(dout0_12) AT=645.025n

.meas tran vdout0_13ck1280 FIND v(dout0_13) AT=645.025n

.meas tran vdout0_14ck1280 FIND v(dout0_14) AT=645.025n

.meas tran vdout0_15ck1280 FIND v(dout0_15) AT=645.025n

.meas tran vdout0_16ck1280 FIND v(dout0_16) AT=645.025n

.meas tran vdout0_17ck1280 FIND v(dout0_17) AT=645.025n

.meas tran vdout0_18ck1280 FIND v(dout0_18) AT=645.025n

.meas tran vdout0_19ck1280 FIND v(dout0_19) AT=645.025n

.meas tran vdout0_20ck1280 FIND v(dout0_20) AT=645.025n

.meas tran vdout0_21ck1280 FIND v(dout0_21) AT=645.025n

.meas tran vdout0_22ck1280 FIND v(dout0_22) AT=645.025n

.meas tran vdout0_23ck1280 FIND v(dout0_23) AT=645.025n

.meas tran vdout0_24ck1280 FIND v(dout0_24) AT=645.025n

.meas tran vdout0_25ck1280 FIND v(dout0_25) AT=645.025n

.meas tran vdout0_26ck1280 FIND v(dout0_26) AT=645.025n

.meas tran vdout0_27ck1280 FIND v(dout0_27) AT=645.025n

.meas tran vdout0_28ck1280 FIND v(dout0_28) AT=645.025n

.meas tran vdout0_29ck1280 FIND v(dout0_29) AT=645.025n

.meas tran vdout0_30ck1280 FIND v(dout0_30) AT=645.025n

.meas tran vdout0_31ck1280 FIND v(dout0_31) AT=645.025n

.meas tran vdout0_32ck1280 FIND v(dout0_32) AT=645.025n

.meas tran vdout0_33ck1280 FIND v(dout0_33) AT=645.025n

.meas tran vdout0_34ck1280 FIND v(dout0_34) AT=645.025n

.meas tran vdout0_35ck1280 FIND v(dout0_35) AT=645.025n

.meas tran vdout0_36ck1280 FIND v(dout0_36) AT=645.025n

.meas tran vdout0_37ck1280 FIND v(dout0_37) AT=645.025n

.meas tran vdout0_38ck1280 FIND v(dout0_38) AT=645.025n

.meas tran vdout0_39ck1280 FIND v(dout0_39) AT=645.025n

.meas tran vdout0_40ck1280 FIND v(dout0_40) AT=645.025n

.meas tran vdout0_41ck1280 FIND v(dout0_41) AT=645.025n

.meas tran vdout0_42ck1280 FIND v(dout0_42) AT=645.025n

.meas tran vdout0_43ck1280 FIND v(dout0_43) AT=645.025n

.meas tran vdout0_44ck1280 FIND v(dout0_44) AT=645.025n

.meas tran vdout0_45ck1280 FIND v(dout0_45) AT=645.025n

.meas tran vdout0_46ck1280 FIND v(dout0_46) AT=645.025n

.meas tran vdout0_47ck1280 FIND v(dout0_47) AT=645.025n

.meas tran vdout0_48ck1280 FIND v(dout0_48) AT=645.025n

.meas tran vdout0_49ck1280 FIND v(dout0_49) AT=645.025n

.meas tran vdout0_50ck1280 FIND v(dout0_50) AT=645.025n

.meas tran vdout0_51ck1280 FIND v(dout0_51) AT=645.025n

.meas tran vdout0_52ck1280 FIND v(dout0_52) AT=645.025n

.meas tran vdout0_53ck1280 FIND v(dout0_53) AT=645.025n

.meas tran vdout0_54ck1280 FIND v(dout0_54) AT=645.025n

.meas tran vdout0_55ck1280 FIND v(dout0_55) AT=645.025n

.meas tran vdout0_56ck1280 FIND v(dout0_56) AT=645.025n

.meas tran vdout0_57ck1280 FIND v(dout0_57) AT=645.025n

.meas tran vdout0_58ck1280 FIND v(dout0_58) AT=645.025n

.meas tran vdout0_59ck1280 FIND v(dout0_59) AT=645.025n

.meas tran vdout0_60ck1280 FIND v(dout0_60) AT=645.025n

.meas tran vdout0_61ck1280 FIND v(dout0_61) AT=645.025n

.meas tran vdout0_62ck1280 FIND v(dout0_62) AT=645.025n

.meas tran vdout0_63ck1280 FIND v(dout0_63) AT=645.025n

.meas tran vdout0_64ck1280 FIND v(dout0_64) AT=645.025n

.meas tran vdout0_65ck1280 FIND v(dout0_65) AT=645.025n

.meas tran vdout0_66ck1280 FIND v(dout0_66) AT=645.025n

.meas tran vdout0_67ck1280 FIND v(dout0_67) AT=645.025n

.meas tran vdout0_68ck1280 FIND v(dout0_68) AT=645.025n

.meas tran vdout0_69ck1280 FIND v(dout0_69) AT=645.025n

.meas tran vdout0_70ck1280 FIND v(dout0_70) AT=645.025n

.meas tran vdout0_71ck1280 FIND v(dout0_71) AT=645.025n

.meas tran vdout0_72ck1280 FIND v(dout0_72) AT=645.025n

.meas tran vdout0_73ck1280 FIND v(dout0_73) AT=645.025n

.meas tran vdout0_74ck1280 FIND v(dout0_74) AT=645.025n

.meas tran vdout0_75ck1280 FIND v(dout0_75) AT=645.025n

.meas tran vdout0_76ck1280 FIND v(dout0_76) AT=645.025n

.meas tran vdout0_77ck1280 FIND v(dout0_77) AT=645.025n

.meas tran vdout0_78ck1280 FIND v(dout0_78) AT=645.025n

.meas tran vdout0_79ck1280 FIND v(dout0_79) AT=645.025n

.meas tran vdout0_80ck1280 FIND v(dout0_80) AT=645.025n

.meas tran vdout0_81ck1280 FIND v(dout0_81) AT=645.025n

.meas tran vdout0_82ck1280 FIND v(dout0_82) AT=645.025n

.meas tran vdout0_83ck1280 FIND v(dout0_83) AT=645.025n

.meas tran vdout0_84ck1280 FIND v(dout0_84) AT=645.025n

.meas tran vdout0_85ck1280 FIND v(dout0_85) AT=645.025n

.meas tran vdout0_86ck1280 FIND v(dout0_86) AT=645.025n

.meas tran vdout0_87ck1280 FIND v(dout0_87) AT=645.025n

.meas tran vdout0_88ck1280 FIND v(dout0_88) AT=645.025n

.meas tran vdout0_89ck1280 FIND v(dout0_89) AT=645.025n

.meas tran vdout0_90ck1280 FIND v(dout0_90) AT=645.025n

.meas tran vdout0_91ck1280 FIND v(dout0_91) AT=645.025n

.meas tran vdout0_92ck1280 FIND v(dout0_92) AT=645.025n

.meas tran vdout0_93ck1280 FIND v(dout0_93) AT=645.025n

.meas tran vdout0_94ck1280 FIND v(dout0_94) AT=645.025n

.meas tran vdout0_95ck1280 FIND v(dout0_95) AT=645.025n

.meas tran vdout0_96ck1280 FIND v(dout0_96) AT=645.025n

.meas tran vdout0_97ck1280 FIND v(dout0_97) AT=645.025n

.meas tran vdout0_98ck1280 FIND v(dout0_98) AT=645.025n

.meas tran vdout0_99ck1280 FIND v(dout0_99) AT=645.025n

.meas tran vdout0_100ck1280 FIND v(dout0_100) AT=645.025n

.meas tran vdout0_101ck1280 FIND v(dout0_101) AT=645.025n

.meas tran vdout0_102ck1280 FIND v(dout0_102) AT=645.025n

.meas tran vdout0_103ck1280 FIND v(dout0_103) AT=645.025n

.meas tran vdout0_104ck1280 FIND v(dout0_104) AT=645.025n

.meas tran vdout0_105ck1280 FIND v(dout0_105) AT=645.025n

.meas tran vdout0_106ck1280 FIND v(dout0_106) AT=645.025n

.meas tran vdout0_107ck1280 FIND v(dout0_107) AT=645.025n

.meas tran vdout0_108ck1280 FIND v(dout0_108) AT=645.025n

.meas tran vdout0_109ck1280 FIND v(dout0_109) AT=645.025n

.meas tran vdout0_110ck1280 FIND v(dout0_110) AT=645.025n

.meas tran vdout0_111ck1280 FIND v(dout0_111) AT=645.025n

.meas tran vdout0_112ck1280 FIND v(dout0_112) AT=645.025n

.meas tran vdout0_113ck1280 FIND v(dout0_113) AT=645.025n

.meas tran vdout0_114ck1280 FIND v(dout0_114) AT=645.025n

.meas tran vdout0_115ck1280 FIND v(dout0_115) AT=645.025n

.meas tran vdout0_116ck1280 FIND v(dout0_116) AT=645.025n

.meas tran vdout0_117ck1280 FIND v(dout0_117) AT=645.025n

.meas tran vdout0_118ck1280 FIND v(dout0_118) AT=645.025n

.meas tran vdout0_119ck1280 FIND v(dout0_119) AT=645.025n

.meas tran vdout0_120ck1280 FIND v(dout0_120) AT=645.025n

.meas tran vdout0_121ck1280 FIND v(dout0_121) AT=645.025n

.meas tran vdout0_122ck1280 FIND v(dout0_122) AT=645.025n

.meas tran vdout0_123ck1280 FIND v(dout0_123) AT=645.025n

.meas tran vdout0_124ck1280 FIND v(dout0_124) AT=645.025n

.meas tran vdout0_125ck1280 FIND v(dout0_125) AT=645.025n

.meas tran vdout0_126ck1280 FIND v(dout0_126) AT=645.025n

.meas tran vdout0_127ck1280 FIND v(dout0_127) AT=645.025n

.meas tran vdout0_128ck1280 FIND v(dout0_128) AT=645.025n

.meas tran vdout0_129ck1280 FIND v(dout0_129) AT=645.025n

.meas tran vdout0_130ck1280 FIND v(dout0_130) AT=645.025n

.meas tran vdout0_131ck1280 FIND v(dout0_131) AT=645.025n

.meas tran vdout0_132ck1280 FIND v(dout0_132) AT=645.025n

.meas tran vdout0_133ck1280 FIND v(dout0_133) AT=645.025n

.meas tran vdout0_134ck1280 FIND v(dout0_134) AT=645.025n

.meas tran vdout0_135ck1280 FIND v(dout0_135) AT=645.025n

.meas tran vdout0_136ck1280 FIND v(dout0_136) AT=645.025n

.meas tran vdout0_137ck1280 FIND v(dout0_137) AT=645.025n

.meas tran vdout0_138ck1280 FIND v(dout0_138) AT=645.025n

.meas tran vdout0_139ck1280 FIND v(dout0_139) AT=645.025n

.meas tran vdout0_140ck1280 FIND v(dout0_140) AT=645.025n

.meas tran vdout0_141ck1280 FIND v(dout0_141) AT=645.025n

.meas tran vdout0_142ck1280 FIND v(dout0_142) AT=645.025n

.meas tran vdout0_143ck1280 FIND v(dout0_143) AT=645.025n

.meas tran vdout0_144ck1280 FIND v(dout0_144) AT=645.025n

.meas tran vdout0_145ck1280 FIND v(dout0_145) AT=645.025n

.meas tran vdout0_146ck1280 FIND v(dout0_146) AT=645.025n

.meas tran vdout0_147ck1280 FIND v(dout0_147) AT=645.025n

.meas tran vdout0_148ck1280 FIND v(dout0_148) AT=645.025n

.meas tran vdout0_149ck1280 FIND v(dout0_149) AT=645.025n

.meas tran vdout0_150ck1280 FIND v(dout0_150) AT=645.025n

.meas tran vdout0_151ck1280 FIND v(dout0_151) AT=645.025n

.meas tran vdout0_152ck1280 FIND v(dout0_152) AT=645.025n

.meas tran vdout0_153ck1280 FIND v(dout0_153) AT=645.025n

.meas tran vdout0_154ck1280 FIND v(dout0_154) AT=645.025n

.meas tran vdout0_155ck1280 FIND v(dout0_155) AT=645.025n

.meas tran vdout0_156ck1280 FIND v(dout0_156) AT=645.025n

.meas tran vdout0_157ck1280 FIND v(dout0_157) AT=645.025n

.meas tran vdout0_158ck1280 FIND v(dout0_158) AT=645.025n

.meas tran vdout0_159ck1280 FIND v(dout0_159) AT=645.025n

.meas tran vdout0_160ck1280 FIND v(dout0_160) AT=645.025n

.meas tran vdout0_161ck1280 FIND v(dout0_161) AT=645.025n

.meas tran vdout0_162ck1280 FIND v(dout0_162) AT=645.025n

.meas tran vdout0_163ck1280 FIND v(dout0_163) AT=645.025n

.meas tran vdout0_164ck1280 FIND v(dout0_164) AT=645.025n

.meas tran vdout0_165ck1280 FIND v(dout0_165) AT=645.025n

.meas tran vdout0_166ck1280 FIND v(dout0_166) AT=645.025n

.meas tran vdout0_167ck1280 FIND v(dout0_167) AT=645.025n

.meas tran vdout0_168ck1280 FIND v(dout0_168) AT=645.025n

.meas tran vdout0_169ck1280 FIND v(dout0_169) AT=645.025n

.meas tran vdout0_170ck1280 FIND v(dout0_170) AT=645.025n

.meas tran vdout0_171ck1280 FIND v(dout0_171) AT=645.025n

.meas tran vdout0_172ck1280 FIND v(dout0_172) AT=645.025n

.meas tran vdout0_173ck1280 FIND v(dout0_173) AT=645.025n

.meas tran vdout0_174ck1280 FIND v(dout0_174) AT=645.025n

.meas tran vdout0_175ck1280 FIND v(dout0_175) AT=645.025n

.meas tran vdout0_176ck1280 FIND v(dout0_176) AT=645.025n

.meas tran vdout0_177ck1280 FIND v(dout0_177) AT=645.025n

.meas tran vdout0_178ck1280 FIND v(dout0_178) AT=645.025n

.meas tran vdout0_179ck1280 FIND v(dout0_179) AT=645.025n

.meas tran vdout0_180ck1280 FIND v(dout0_180) AT=645.025n

.meas tran vdout0_181ck1280 FIND v(dout0_181) AT=645.025n

.meas tran vdout0_182ck1280 FIND v(dout0_182) AT=645.025n

.meas tran vdout0_183ck1280 FIND v(dout0_183) AT=645.025n

.meas tran vdout0_184ck1280 FIND v(dout0_184) AT=645.025n

.meas tran vdout0_185ck1280 FIND v(dout0_185) AT=645.025n

.meas tran vdout0_186ck1280 FIND v(dout0_186) AT=645.025n

.meas tran vdout0_187ck1280 FIND v(dout0_187) AT=645.025n

.meas tran vdout0_188ck1280 FIND v(dout0_188) AT=645.025n

.meas tran vdout0_189ck1280 FIND v(dout0_189) AT=645.025n

.meas tran vdout0_190ck1280 FIND v(dout0_190) AT=645.025n

.meas tran vdout0_191ck1280 FIND v(dout0_191) AT=645.025n

.meas tran vdout0_192ck1280 FIND v(dout0_192) AT=645.025n

.meas tran vdout0_193ck1280 FIND v(dout0_193) AT=645.025n

.meas tran vdout0_194ck1280 FIND v(dout0_194) AT=645.025n

.meas tran vdout0_195ck1280 FIND v(dout0_195) AT=645.025n

.meas tran vdout0_196ck1280 FIND v(dout0_196) AT=645.025n

.meas tran vdout0_197ck1280 FIND v(dout0_197) AT=645.025n

.meas tran vdout0_198ck1280 FIND v(dout0_198) AT=645.025n

.meas tran vdout0_199ck1280 FIND v(dout0_199) AT=645.025n

.meas tran vdout0_200ck1280 FIND v(dout0_200) AT=645.025n

.meas tran vdout0_201ck1280 FIND v(dout0_201) AT=645.025n

.meas tran vdout0_202ck1280 FIND v(dout0_202) AT=645.025n

.meas tran vdout0_203ck1280 FIND v(dout0_203) AT=645.025n

.meas tran vdout0_204ck1280 FIND v(dout0_204) AT=645.025n

.meas tran vdout0_205ck1280 FIND v(dout0_205) AT=645.025n

.meas tran vdout0_206ck1280 FIND v(dout0_206) AT=645.025n

.meas tran vdout0_207ck1280 FIND v(dout0_207) AT=645.025n

.meas tran vdout0_208ck1280 FIND v(dout0_208) AT=645.025n

.meas tran vdout0_209ck1280 FIND v(dout0_209) AT=645.025n

.meas tran vdout0_210ck1280 FIND v(dout0_210) AT=645.025n

.meas tran vdout0_211ck1280 FIND v(dout0_211) AT=645.025n

.meas tran vdout0_212ck1280 FIND v(dout0_212) AT=645.025n

.meas tran vdout0_213ck1280 FIND v(dout0_213) AT=645.025n

.meas tran vdout0_214ck1280 FIND v(dout0_214) AT=645.025n

.meas tran vdout0_215ck1280 FIND v(dout0_215) AT=645.025n

.meas tran vdout0_216ck1280 FIND v(dout0_216) AT=645.025n

.meas tran vdout0_217ck1280 FIND v(dout0_217) AT=645.025n

.meas tran vdout0_218ck1280 FIND v(dout0_218) AT=645.025n

.meas tran vdout0_219ck1280 FIND v(dout0_219) AT=645.025n

.meas tran vdout0_220ck1280 FIND v(dout0_220) AT=645.025n

.meas tran vdout0_221ck1280 FIND v(dout0_221) AT=645.025n

.meas tran vdout0_222ck1280 FIND v(dout0_222) AT=645.025n

.meas tran vdout0_223ck1280 FIND v(dout0_223) AT=645.025n

.meas tran vdout0_224ck1280 FIND v(dout0_224) AT=645.025n

.meas tran vdout0_225ck1280 FIND v(dout0_225) AT=645.025n

.meas tran vdout0_226ck1280 FIND v(dout0_226) AT=645.025n

.meas tran vdout0_227ck1280 FIND v(dout0_227) AT=645.025n

.meas tran vdout0_228ck1280 FIND v(dout0_228) AT=645.025n

.meas tran vdout0_229ck1280 FIND v(dout0_229) AT=645.025n

.meas tran vdout0_230ck1280 FIND v(dout0_230) AT=645.025n

.meas tran vdout0_231ck1280 FIND v(dout0_231) AT=645.025n

.meas tran vdout0_232ck1280 FIND v(dout0_232) AT=645.025n

.meas tran vdout0_233ck1280 FIND v(dout0_233) AT=645.025n

.meas tran vdout0_234ck1280 FIND v(dout0_234) AT=645.025n

.meas tran vdout0_235ck1280 FIND v(dout0_235) AT=645.025n

.meas tran vdout0_236ck1280 FIND v(dout0_236) AT=645.025n

.meas tran vdout0_237ck1280 FIND v(dout0_237) AT=645.025n

.meas tran vdout0_238ck1280 FIND v(dout0_238) AT=645.025n

.meas tran vdout0_239ck1280 FIND v(dout0_239) AT=645.025n

.meas tran vdout0_240ck1280 FIND v(dout0_240) AT=645.025n

.meas tran vdout0_241ck1280 FIND v(dout0_241) AT=645.025n

.meas tran vdout0_242ck1280 FIND v(dout0_242) AT=645.025n

.meas tran vdout0_243ck1280 FIND v(dout0_243) AT=645.025n

.meas tran vdout0_244ck1280 FIND v(dout0_244) AT=645.025n

.meas tran vdout0_245ck1280 FIND v(dout0_245) AT=645.025n

.meas tran vdout0_246ck1280 FIND v(dout0_246) AT=645.025n

.meas tran vdout0_247ck1280 FIND v(dout0_247) AT=645.025n

.meas tran vdout0_248ck1280 FIND v(dout0_248) AT=645.025n

.meas tran vdout0_249ck1280 FIND v(dout0_249) AT=645.025n

.meas tran vdout0_250ck1280 FIND v(dout0_250) AT=645.025n

.meas tran vdout0_251ck1280 FIND v(dout0_251) AT=645.025n

.meas tran vdout0_252ck1280 FIND v(dout0_252) AT=645.025n

.meas tran vdout0_253ck1280 FIND v(dout0_253) AT=645.025n

.meas tran vdout0_254ck1280 FIND v(dout0_254) AT=645.025n

.meas tran vdout0_255ck1280 FIND v(dout0_255) AT=645.025n

.meas tran vdout0_0ck1300 FIND v(dout0_0) AT=655.025n

.meas tran vdout0_1ck1300 FIND v(dout0_1) AT=655.025n

.meas tran vdout0_2ck1300 FIND v(dout0_2) AT=655.025n

.meas tran vdout0_3ck1300 FIND v(dout0_3) AT=655.025n

.meas tran vdout0_4ck1300 FIND v(dout0_4) AT=655.025n

.meas tran vdout0_5ck1300 FIND v(dout0_5) AT=655.025n

.meas tran vdout0_6ck1300 FIND v(dout0_6) AT=655.025n

.meas tran vdout0_7ck1300 FIND v(dout0_7) AT=655.025n

.meas tran vdout0_8ck1300 FIND v(dout0_8) AT=655.025n

.meas tran vdout0_9ck1300 FIND v(dout0_9) AT=655.025n

.meas tran vdout0_10ck1300 FIND v(dout0_10) AT=655.025n

.meas tran vdout0_11ck1300 FIND v(dout0_11) AT=655.025n

.meas tran vdout0_12ck1300 FIND v(dout0_12) AT=655.025n

.meas tran vdout0_13ck1300 FIND v(dout0_13) AT=655.025n

.meas tran vdout0_14ck1300 FIND v(dout0_14) AT=655.025n

.meas tran vdout0_15ck1300 FIND v(dout0_15) AT=655.025n

.meas tran vdout0_16ck1300 FIND v(dout0_16) AT=655.025n

.meas tran vdout0_17ck1300 FIND v(dout0_17) AT=655.025n

.meas tran vdout0_18ck1300 FIND v(dout0_18) AT=655.025n

.meas tran vdout0_19ck1300 FIND v(dout0_19) AT=655.025n

.meas tran vdout0_20ck1300 FIND v(dout0_20) AT=655.025n

.meas tran vdout0_21ck1300 FIND v(dout0_21) AT=655.025n

.meas tran vdout0_22ck1300 FIND v(dout0_22) AT=655.025n

.meas tran vdout0_23ck1300 FIND v(dout0_23) AT=655.025n

.meas tran vdout0_24ck1300 FIND v(dout0_24) AT=655.025n

.meas tran vdout0_25ck1300 FIND v(dout0_25) AT=655.025n

.meas tran vdout0_26ck1300 FIND v(dout0_26) AT=655.025n

.meas tran vdout0_27ck1300 FIND v(dout0_27) AT=655.025n

.meas tran vdout0_28ck1300 FIND v(dout0_28) AT=655.025n

.meas tran vdout0_29ck1300 FIND v(dout0_29) AT=655.025n

.meas tran vdout0_30ck1300 FIND v(dout0_30) AT=655.025n

.meas tran vdout0_31ck1300 FIND v(dout0_31) AT=655.025n

.meas tran vdout0_32ck1300 FIND v(dout0_32) AT=655.025n

.meas tran vdout0_33ck1300 FIND v(dout0_33) AT=655.025n

.meas tran vdout0_34ck1300 FIND v(dout0_34) AT=655.025n

.meas tran vdout0_35ck1300 FIND v(dout0_35) AT=655.025n

.meas tran vdout0_36ck1300 FIND v(dout0_36) AT=655.025n

.meas tran vdout0_37ck1300 FIND v(dout0_37) AT=655.025n

.meas tran vdout0_38ck1300 FIND v(dout0_38) AT=655.025n

.meas tran vdout0_39ck1300 FIND v(dout0_39) AT=655.025n

.meas tran vdout0_40ck1300 FIND v(dout0_40) AT=655.025n

.meas tran vdout0_41ck1300 FIND v(dout0_41) AT=655.025n

.meas tran vdout0_42ck1300 FIND v(dout0_42) AT=655.025n

.meas tran vdout0_43ck1300 FIND v(dout0_43) AT=655.025n

.meas tran vdout0_44ck1300 FIND v(dout0_44) AT=655.025n

.meas tran vdout0_45ck1300 FIND v(dout0_45) AT=655.025n

.meas tran vdout0_46ck1300 FIND v(dout0_46) AT=655.025n

.meas tran vdout0_47ck1300 FIND v(dout0_47) AT=655.025n

.meas tran vdout0_48ck1300 FIND v(dout0_48) AT=655.025n

.meas tran vdout0_49ck1300 FIND v(dout0_49) AT=655.025n

.meas tran vdout0_50ck1300 FIND v(dout0_50) AT=655.025n

.meas tran vdout0_51ck1300 FIND v(dout0_51) AT=655.025n

.meas tran vdout0_52ck1300 FIND v(dout0_52) AT=655.025n

.meas tran vdout0_53ck1300 FIND v(dout0_53) AT=655.025n

.meas tran vdout0_54ck1300 FIND v(dout0_54) AT=655.025n

.meas tran vdout0_55ck1300 FIND v(dout0_55) AT=655.025n

.meas tran vdout0_56ck1300 FIND v(dout0_56) AT=655.025n

.meas tran vdout0_57ck1300 FIND v(dout0_57) AT=655.025n

.meas tran vdout0_58ck1300 FIND v(dout0_58) AT=655.025n

.meas tran vdout0_59ck1300 FIND v(dout0_59) AT=655.025n

.meas tran vdout0_60ck1300 FIND v(dout0_60) AT=655.025n

.meas tran vdout0_61ck1300 FIND v(dout0_61) AT=655.025n

.meas tran vdout0_62ck1300 FIND v(dout0_62) AT=655.025n

.meas tran vdout0_63ck1300 FIND v(dout0_63) AT=655.025n

.meas tran vdout0_64ck1300 FIND v(dout0_64) AT=655.025n

.meas tran vdout0_65ck1300 FIND v(dout0_65) AT=655.025n

.meas tran vdout0_66ck1300 FIND v(dout0_66) AT=655.025n

.meas tran vdout0_67ck1300 FIND v(dout0_67) AT=655.025n

.meas tran vdout0_68ck1300 FIND v(dout0_68) AT=655.025n

.meas tran vdout0_69ck1300 FIND v(dout0_69) AT=655.025n

.meas tran vdout0_70ck1300 FIND v(dout0_70) AT=655.025n

.meas tran vdout0_71ck1300 FIND v(dout0_71) AT=655.025n

.meas tran vdout0_72ck1300 FIND v(dout0_72) AT=655.025n

.meas tran vdout0_73ck1300 FIND v(dout0_73) AT=655.025n

.meas tran vdout0_74ck1300 FIND v(dout0_74) AT=655.025n

.meas tran vdout0_75ck1300 FIND v(dout0_75) AT=655.025n

.meas tran vdout0_76ck1300 FIND v(dout0_76) AT=655.025n

.meas tran vdout0_77ck1300 FIND v(dout0_77) AT=655.025n

.meas tran vdout0_78ck1300 FIND v(dout0_78) AT=655.025n

.meas tran vdout0_79ck1300 FIND v(dout0_79) AT=655.025n

.meas tran vdout0_80ck1300 FIND v(dout0_80) AT=655.025n

.meas tran vdout0_81ck1300 FIND v(dout0_81) AT=655.025n

.meas tran vdout0_82ck1300 FIND v(dout0_82) AT=655.025n

.meas tran vdout0_83ck1300 FIND v(dout0_83) AT=655.025n

.meas tran vdout0_84ck1300 FIND v(dout0_84) AT=655.025n

.meas tran vdout0_85ck1300 FIND v(dout0_85) AT=655.025n

.meas tran vdout0_86ck1300 FIND v(dout0_86) AT=655.025n

.meas tran vdout0_87ck1300 FIND v(dout0_87) AT=655.025n

.meas tran vdout0_88ck1300 FIND v(dout0_88) AT=655.025n

.meas tran vdout0_89ck1300 FIND v(dout0_89) AT=655.025n

.meas tran vdout0_90ck1300 FIND v(dout0_90) AT=655.025n

.meas tran vdout0_91ck1300 FIND v(dout0_91) AT=655.025n

.meas tran vdout0_92ck1300 FIND v(dout0_92) AT=655.025n

.meas tran vdout0_93ck1300 FIND v(dout0_93) AT=655.025n

.meas tran vdout0_94ck1300 FIND v(dout0_94) AT=655.025n

.meas tran vdout0_95ck1300 FIND v(dout0_95) AT=655.025n

.meas tran vdout0_96ck1300 FIND v(dout0_96) AT=655.025n

.meas tran vdout0_97ck1300 FIND v(dout0_97) AT=655.025n

.meas tran vdout0_98ck1300 FIND v(dout0_98) AT=655.025n

.meas tran vdout0_99ck1300 FIND v(dout0_99) AT=655.025n

.meas tran vdout0_100ck1300 FIND v(dout0_100) AT=655.025n

.meas tran vdout0_101ck1300 FIND v(dout0_101) AT=655.025n

.meas tran vdout0_102ck1300 FIND v(dout0_102) AT=655.025n

.meas tran vdout0_103ck1300 FIND v(dout0_103) AT=655.025n

.meas tran vdout0_104ck1300 FIND v(dout0_104) AT=655.025n

.meas tran vdout0_105ck1300 FIND v(dout0_105) AT=655.025n

.meas tran vdout0_106ck1300 FIND v(dout0_106) AT=655.025n

.meas tran vdout0_107ck1300 FIND v(dout0_107) AT=655.025n

.meas tran vdout0_108ck1300 FIND v(dout0_108) AT=655.025n

.meas tran vdout0_109ck1300 FIND v(dout0_109) AT=655.025n

.meas tran vdout0_110ck1300 FIND v(dout0_110) AT=655.025n

.meas tran vdout0_111ck1300 FIND v(dout0_111) AT=655.025n

.meas tran vdout0_112ck1300 FIND v(dout0_112) AT=655.025n

.meas tran vdout0_113ck1300 FIND v(dout0_113) AT=655.025n

.meas tran vdout0_114ck1300 FIND v(dout0_114) AT=655.025n

.meas tran vdout0_115ck1300 FIND v(dout0_115) AT=655.025n

.meas tran vdout0_116ck1300 FIND v(dout0_116) AT=655.025n

.meas tran vdout0_117ck1300 FIND v(dout0_117) AT=655.025n

.meas tran vdout0_118ck1300 FIND v(dout0_118) AT=655.025n

.meas tran vdout0_119ck1300 FIND v(dout0_119) AT=655.025n

.meas tran vdout0_120ck1300 FIND v(dout0_120) AT=655.025n

.meas tran vdout0_121ck1300 FIND v(dout0_121) AT=655.025n

.meas tran vdout0_122ck1300 FIND v(dout0_122) AT=655.025n

.meas tran vdout0_123ck1300 FIND v(dout0_123) AT=655.025n

.meas tran vdout0_124ck1300 FIND v(dout0_124) AT=655.025n

.meas tran vdout0_125ck1300 FIND v(dout0_125) AT=655.025n

.meas tran vdout0_126ck1300 FIND v(dout0_126) AT=655.025n

.meas tran vdout0_127ck1300 FIND v(dout0_127) AT=655.025n

.meas tran vdout0_128ck1300 FIND v(dout0_128) AT=655.025n

.meas tran vdout0_129ck1300 FIND v(dout0_129) AT=655.025n

.meas tran vdout0_130ck1300 FIND v(dout0_130) AT=655.025n

.meas tran vdout0_131ck1300 FIND v(dout0_131) AT=655.025n

.meas tran vdout0_132ck1300 FIND v(dout0_132) AT=655.025n

.meas tran vdout0_133ck1300 FIND v(dout0_133) AT=655.025n

.meas tran vdout0_134ck1300 FIND v(dout0_134) AT=655.025n

.meas tran vdout0_135ck1300 FIND v(dout0_135) AT=655.025n

.meas tran vdout0_136ck1300 FIND v(dout0_136) AT=655.025n

.meas tran vdout0_137ck1300 FIND v(dout0_137) AT=655.025n

.meas tran vdout0_138ck1300 FIND v(dout0_138) AT=655.025n

.meas tran vdout0_139ck1300 FIND v(dout0_139) AT=655.025n

.meas tran vdout0_140ck1300 FIND v(dout0_140) AT=655.025n

.meas tran vdout0_141ck1300 FIND v(dout0_141) AT=655.025n

.meas tran vdout0_142ck1300 FIND v(dout0_142) AT=655.025n

.meas tran vdout0_143ck1300 FIND v(dout0_143) AT=655.025n

.meas tran vdout0_144ck1300 FIND v(dout0_144) AT=655.025n

.meas tran vdout0_145ck1300 FIND v(dout0_145) AT=655.025n

.meas tran vdout0_146ck1300 FIND v(dout0_146) AT=655.025n

.meas tran vdout0_147ck1300 FIND v(dout0_147) AT=655.025n

.meas tran vdout0_148ck1300 FIND v(dout0_148) AT=655.025n

.meas tran vdout0_149ck1300 FIND v(dout0_149) AT=655.025n

.meas tran vdout0_150ck1300 FIND v(dout0_150) AT=655.025n

.meas tran vdout0_151ck1300 FIND v(dout0_151) AT=655.025n

.meas tran vdout0_152ck1300 FIND v(dout0_152) AT=655.025n

.meas tran vdout0_153ck1300 FIND v(dout0_153) AT=655.025n

.meas tran vdout0_154ck1300 FIND v(dout0_154) AT=655.025n

.meas tran vdout0_155ck1300 FIND v(dout0_155) AT=655.025n

.meas tran vdout0_156ck1300 FIND v(dout0_156) AT=655.025n

.meas tran vdout0_157ck1300 FIND v(dout0_157) AT=655.025n

.meas tran vdout0_158ck1300 FIND v(dout0_158) AT=655.025n

.meas tran vdout0_159ck1300 FIND v(dout0_159) AT=655.025n

.meas tran vdout0_160ck1300 FIND v(dout0_160) AT=655.025n

.meas tran vdout0_161ck1300 FIND v(dout0_161) AT=655.025n

.meas tran vdout0_162ck1300 FIND v(dout0_162) AT=655.025n

.meas tran vdout0_163ck1300 FIND v(dout0_163) AT=655.025n

.meas tran vdout0_164ck1300 FIND v(dout0_164) AT=655.025n

.meas tran vdout0_165ck1300 FIND v(dout0_165) AT=655.025n

.meas tran vdout0_166ck1300 FIND v(dout0_166) AT=655.025n

.meas tran vdout0_167ck1300 FIND v(dout0_167) AT=655.025n

.meas tran vdout0_168ck1300 FIND v(dout0_168) AT=655.025n

.meas tran vdout0_169ck1300 FIND v(dout0_169) AT=655.025n

.meas tran vdout0_170ck1300 FIND v(dout0_170) AT=655.025n

.meas tran vdout0_171ck1300 FIND v(dout0_171) AT=655.025n

.meas tran vdout0_172ck1300 FIND v(dout0_172) AT=655.025n

.meas tran vdout0_173ck1300 FIND v(dout0_173) AT=655.025n

.meas tran vdout0_174ck1300 FIND v(dout0_174) AT=655.025n

.meas tran vdout0_175ck1300 FIND v(dout0_175) AT=655.025n

.meas tran vdout0_176ck1300 FIND v(dout0_176) AT=655.025n

.meas tran vdout0_177ck1300 FIND v(dout0_177) AT=655.025n

.meas tran vdout0_178ck1300 FIND v(dout0_178) AT=655.025n

.meas tran vdout0_179ck1300 FIND v(dout0_179) AT=655.025n

.meas tran vdout0_180ck1300 FIND v(dout0_180) AT=655.025n

.meas tran vdout0_181ck1300 FIND v(dout0_181) AT=655.025n

.meas tran vdout0_182ck1300 FIND v(dout0_182) AT=655.025n

.meas tran vdout0_183ck1300 FIND v(dout0_183) AT=655.025n

.meas tran vdout0_184ck1300 FIND v(dout0_184) AT=655.025n

.meas tran vdout0_185ck1300 FIND v(dout0_185) AT=655.025n

.meas tran vdout0_186ck1300 FIND v(dout0_186) AT=655.025n

.meas tran vdout0_187ck1300 FIND v(dout0_187) AT=655.025n

.meas tran vdout0_188ck1300 FIND v(dout0_188) AT=655.025n

.meas tran vdout0_189ck1300 FIND v(dout0_189) AT=655.025n

.meas tran vdout0_190ck1300 FIND v(dout0_190) AT=655.025n

.meas tran vdout0_191ck1300 FIND v(dout0_191) AT=655.025n

.meas tran vdout0_192ck1300 FIND v(dout0_192) AT=655.025n

.meas tran vdout0_193ck1300 FIND v(dout0_193) AT=655.025n

.meas tran vdout0_194ck1300 FIND v(dout0_194) AT=655.025n

.meas tran vdout0_195ck1300 FIND v(dout0_195) AT=655.025n

.meas tran vdout0_196ck1300 FIND v(dout0_196) AT=655.025n

.meas tran vdout0_197ck1300 FIND v(dout0_197) AT=655.025n

.meas tran vdout0_198ck1300 FIND v(dout0_198) AT=655.025n

.meas tran vdout0_199ck1300 FIND v(dout0_199) AT=655.025n

.meas tran vdout0_200ck1300 FIND v(dout0_200) AT=655.025n

.meas tran vdout0_201ck1300 FIND v(dout0_201) AT=655.025n

.meas tran vdout0_202ck1300 FIND v(dout0_202) AT=655.025n

.meas tran vdout0_203ck1300 FIND v(dout0_203) AT=655.025n

.meas tran vdout0_204ck1300 FIND v(dout0_204) AT=655.025n

.meas tran vdout0_205ck1300 FIND v(dout0_205) AT=655.025n

.meas tran vdout0_206ck1300 FIND v(dout0_206) AT=655.025n

.meas tran vdout0_207ck1300 FIND v(dout0_207) AT=655.025n

.meas tran vdout0_208ck1300 FIND v(dout0_208) AT=655.025n

.meas tran vdout0_209ck1300 FIND v(dout0_209) AT=655.025n

.meas tran vdout0_210ck1300 FIND v(dout0_210) AT=655.025n

.meas tran vdout0_211ck1300 FIND v(dout0_211) AT=655.025n

.meas tran vdout0_212ck1300 FIND v(dout0_212) AT=655.025n

.meas tran vdout0_213ck1300 FIND v(dout0_213) AT=655.025n

.meas tran vdout0_214ck1300 FIND v(dout0_214) AT=655.025n

.meas tran vdout0_215ck1300 FIND v(dout0_215) AT=655.025n

.meas tran vdout0_216ck1300 FIND v(dout0_216) AT=655.025n

.meas tran vdout0_217ck1300 FIND v(dout0_217) AT=655.025n

.meas tran vdout0_218ck1300 FIND v(dout0_218) AT=655.025n

.meas tran vdout0_219ck1300 FIND v(dout0_219) AT=655.025n

.meas tran vdout0_220ck1300 FIND v(dout0_220) AT=655.025n

.meas tran vdout0_221ck1300 FIND v(dout0_221) AT=655.025n

.meas tran vdout0_222ck1300 FIND v(dout0_222) AT=655.025n

.meas tran vdout0_223ck1300 FIND v(dout0_223) AT=655.025n

.meas tran vdout0_224ck1300 FIND v(dout0_224) AT=655.025n

.meas tran vdout0_225ck1300 FIND v(dout0_225) AT=655.025n

.meas tran vdout0_226ck1300 FIND v(dout0_226) AT=655.025n

.meas tran vdout0_227ck1300 FIND v(dout0_227) AT=655.025n

.meas tran vdout0_228ck1300 FIND v(dout0_228) AT=655.025n

.meas tran vdout0_229ck1300 FIND v(dout0_229) AT=655.025n

.meas tran vdout0_230ck1300 FIND v(dout0_230) AT=655.025n

.meas tran vdout0_231ck1300 FIND v(dout0_231) AT=655.025n

.meas tran vdout0_232ck1300 FIND v(dout0_232) AT=655.025n

.meas tran vdout0_233ck1300 FIND v(dout0_233) AT=655.025n

.meas tran vdout0_234ck1300 FIND v(dout0_234) AT=655.025n

.meas tran vdout0_235ck1300 FIND v(dout0_235) AT=655.025n

.meas tran vdout0_236ck1300 FIND v(dout0_236) AT=655.025n

.meas tran vdout0_237ck1300 FIND v(dout0_237) AT=655.025n

.meas tran vdout0_238ck1300 FIND v(dout0_238) AT=655.025n

.meas tran vdout0_239ck1300 FIND v(dout0_239) AT=655.025n

.meas tran vdout0_240ck1300 FIND v(dout0_240) AT=655.025n

.meas tran vdout0_241ck1300 FIND v(dout0_241) AT=655.025n

.meas tran vdout0_242ck1300 FIND v(dout0_242) AT=655.025n

.meas tran vdout0_243ck1300 FIND v(dout0_243) AT=655.025n

.meas tran vdout0_244ck1300 FIND v(dout0_244) AT=655.025n

.meas tran vdout0_245ck1300 FIND v(dout0_245) AT=655.025n

.meas tran vdout0_246ck1300 FIND v(dout0_246) AT=655.025n

.meas tran vdout0_247ck1300 FIND v(dout0_247) AT=655.025n

.meas tran vdout0_248ck1300 FIND v(dout0_248) AT=655.025n

.meas tran vdout0_249ck1300 FIND v(dout0_249) AT=655.025n

.meas tran vdout0_250ck1300 FIND v(dout0_250) AT=655.025n

.meas tran vdout0_251ck1300 FIND v(dout0_251) AT=655.025n

.meas tran vdout0_252ck1300 FIND v(dout0_252) AT=655.025n

.meas tran vdout0_253ck1300 FIND v(dout0_253) AT=655.025n

.meas tran vdout0_254ck1300 FIND v(dout0_254) AT=655.025n

.meas tran vdout0_255ck1300 FIND v(dout0_255) AT=655.025n

.meas tran vdout0_0ck1320 FIND v(dout0_0) AT=665.025n

.meas tran vdout0_1ck1320 FIND v(dout0_1) AT=665.025n

.meas tran vdout0_2ck1320 FIND v(dout0_2) AT=665.025n

.meas tran vdout0_3ck1320 FIND v(dout0_3) AT=665.025n

.meas tran vdout0_4ck1320 FIND v(dout0_4) AT=665.025n

.meas tran vdout0_5ck1320 FIND v(dout0_5) AT=665.025n

.meas tran vdout0_6ck1320 FIND v(dout0_6) AT=665.025n

.meas tran vdout0_7ck1320 FIND v(dout0_7) AT=665.025n

.meas tran vdout0_8ck1320 FIND v(dout0_8) AT=665.025n

.meas tran vdout0_9ck1320 FIND v(dout0_9) AT=665.025n

.meas tran vdout0_10ck1320 FIND v(dout0_10) AT=665.025n

.meas tran vdout0_11ck1320 FIND v(dout0_11) AT=665.025n

.meas tran vdout0_12ck1320 FIND v(dout0_12) AT=665.025n

.meas tran vdout0_13ck1320 FIND v(dout0_13) AT=665.025n

.meas tran vdout0_14ck1320 FIND v(dout0_14) AT=665.025n

.meas tran vdout0_15ck1320 FIND v(dout0_15) AT=665.025n

.meas tran vdout0_16ck1320 FIND v(dout0_16) AT=665.025n

.meas tran vdout0_17ck1320 FIND v(dout0_17) AT=665.025n

.meas tran vdout0_18ck1320 FIND v(dout0_18) AT=665.025n

.meas tran vdout0_19ck1320 FIND v(dout0_19) AT=665.025n

.meas tran vdout0_20ck1320 FIND v(dout0_20) AT=665.025n

.meas tran vdout0_21ck1320 FIND v(dout0_21) AT=665.025n

.meas tran vdout0_22ck1320 FIND v(dout0_22) AT=665.025n

.meas tran vdout0_23ck1320 FIND v(dout0_23) AT=665.025n

.meas tran vdout0_24ck1320 FIND v(dout0_24) AT=665.025n

.meas tran vdout0_25ck1320 FIND v(dout0_25) AT=665.025n

.meas tran vdout0_26ck1320 FIND v(dout0_26) AT=665.025n

.meas tran vdout0_27ck1320 FIND v(dout0_27) AT=665.025n

.meas tran vdout0_28ck1320 FIND v(dout0_28) AT=665.025n

.meas tran vdout0_29ck1320 FIND v(dout0_29) AT=665.025n

.meas tran vdout0_30ck1320 FIND v(dout0_30) AT=665.025n

.meas tran vdout0_31ck1320 FIND v(dout0_31) AT=665.025n

.meas tran vdout0_32ck1320 FIND v(dout0_32) AT=665.025n

.meas tran vdout0_33ck1320 FIND v(dout0_33) AT=665.025n

.meas tran vdout0_34ck1320 FIND v(dout0_34) AT=665.025n

.meas tran vdout0_35ck1320 FIND v(dout0_35) AT=665.025n

.meas tran vdout0_36ck1320 FIND v(dout0_36) AT=665.025n

.meas tran vdout0_37ck1320 FIND v(dout0_37) AT=665.025n

.meas tran vdout0_38ck1320 FIND v(dout0_38) AT=665.025n

.meas tran vdout0_39ck1320 FIND v(dout0_39) AT=665.025n

.meas tran vdout0_40ck1320 FIND v(dout0_40) AT=665.025n

.meas tran vdout0_41ck1320 FIND v(dout0_41) AT=665.025n

.meas tran vdout0_42ck1320 FIND v(dout0_42) AT=665.025n

.meas tran vdout0_43ck1320 FIND v(dout0_43) AT=665.025n

.meas tran vdout0_44ck1320 FIND v(dout0_44) AT=665.025n

.meas tran vdout0_45ck1320 FIND v(dout0_45) AT=665.025n

.meas tran vdout0_46ck1320 FIND v(dout0_46) AT=665.025n

.meas tran vdout0_47ck1320 FIND v(dout0_47) AT=665.025n

.meas tran vdout0_48ck1320 FIND v(dout0_48) AT=665.025n

.meas tran vdout0_49ck1320 FIND v(dout0_49) AT=665.025n

.meas tran vdout0_50ck1320 FIND v(dout0_50) AT=665.025n

.meas tran vdout0_51ck1320 FIND v(dout0_51) AT=665.025n

.meas tran vdout0_52ck1320 FIND v(dout0_52) AT=665.025n

.meas tran vdout0_53ck1320 FIND v(dout0_53) AT=665.025n

.meas tran vdout0_54ck1320 FIND v(dout0_54) AT=665.025n

.meas tran vdout0_55ck1320 FIND v(dout0_55) AT=665.025n

.meas tran vdout0_56ck1320 FIND v(dout0_56) AT=665.025n

.meas tran vdout0_57ck1320 FIND v(dout0_57) AT=665.025n

.meas tran vdout0_58ck1320 FIND v(dout0_58) AT=665.025n

.meas tran vdout0_59ck1320 FIND v(dout0_59) AT=665.025n

.meas tran vdout0_60ck1320 FIND v(dout0_60) AT=665.025n

.meas tran vdout0_61ck1320 FIND v(dout0_61) AT=665.025n

.meas tran vdout0_62ck1320 FIND v(dout0_62) AT=665.025n

.meas tran vdout0_63ck1320 FIND v(dout0_63) AT=665.025n

.meas tran vdout0_64ck1320 FIND v(dout0_64) AT=665.025n

.meas tran vdout0_65ck1320 FIND v(dout0_65) AT=665.025n

.meas tran vdout0_66ck1320 FIND v(dout0_66) AT=665.025n

.meas tran vdout0_67ck1320 FIND v(dout0_67) AT=665.025n

.meas tran vdout0_68ck1320 FIND v(dout0_68) AT=665.025n

.meas tran vdout0_69ck1320 FIND v(dout0_69) AT=665.025n

.meas tran vdout0_70ck1320 FIND v(dout0_70) AT=665.025n

.meas tran vdout0_71ck1320 FIND v(dout0_71) AT=665.025n

.meas tran vdout0_72ck1320 FIND v(dout0_72) AT=665.025n

.meas tran vdout0_73ck1320 FIND v(dout0_73) AT=665.025n

.meas tran vdout0_74ck1320 FIND v(dout0_74) AT=665.025n

.meas tran vdout0_75ck1320 FIND v(dout0_75) AT=665.025n

.meas tran vdout0_76ck1320 FIND v(dout0_76) AT=665.025n

.meas tran vdout0_77ck1320 FIND v(dout0_77) AT=665.025n

.meas tran vdout0_78ck1320 FIND v(dout0_78) AT=665.025n

.meas tran vdout0_79ck1320 FIND v(dout0_79) AT=665.025n

.meas tran vdout0_80ck1320 FIND v(dout0_80) AT=665.025n

.meas tran vdout0_81ck1320 FIND v(dout0_81) AT=665.025n

.meas tran vdout0_82ck1320 FIND v(dout0_82) AT=665.025n

.meas tran vdout0_83ck1320 FIND v(dout0_83) AT=665.025n

.meas tran vdout0_84ck1320 FIND v(dout0_84) AT=665.025n

.meas tran vdout0_85ck1320 FIND v(dout0_85) AT=665.025n

.meas tran vdout0_86ck1320 FIND v(dout0_86) AT=665.025n

.meas tran vdout0_87ck1320 FIND v(dout0_87) AT=665.025n

.meas tran vdout0_88ck1320 FIND v(dout0_88) AT=665.025n

.meas tran vdout0_89ck1320 FIND v(dout0_89) AT=665.025n

.meas tran vdout0_90ck1320 FIND v(dout0_90) AT=665.025n

.meas tran vdout0_91ck1320 FIND v(dout0_91) AT=665.025n

.meas tran vdout0_92ck1320 FIND v(dout0_92) AT=665.025n

.meas tran vdout0_93ck1320 FIND v(dout0_93) AT=665.025n

.meas tran vdout0_94ck1320 FIND v(dout0_94) AT=665.025n

.meas tran vdout0_95ck1320 FIND v(dout0_95) AT=665.025n

.meas tran vdout0_96ck1320 FIND v(dout0_96) AT=665.025n

.meas tran vdout0_97ck1320 FIND v(dout0_97) AT=665.025n

.meas tran vdout0_98ck1320 FIND v(dout0_98) AT=665.025n

.meas tran vdout0_99ck1320 FIND v(dout0_99) AT=665.025n

.meas tran vdout0_100ck1320 FIND v(dout0_100) AT=665.025n

.meas tran vdout0_101ck1320 FIND v(dout0_101) AT=665.025n

.meas tran vdout0_102ck1320 FIND v(dout0_102) AT=665.025n

.meas tran vdout0_103ck1320 FIND v(dout0_103) AT=665.025n

.meas tran vdout0_104ck1320 FIND v(dout0_104) AT=665.025n

.meas tran vdout0_105ck1320 FIND v(dout0_105) AT=665.025n

.meas tran vdout0_106ck1320 FIND v(dout0_106) AT=665.025n

.meas tran vdout0_107ck1320 FIND v(dout0_107) AT=665.025n

.meas tran vdout0_108ck1320 FIND v(dout0_108) AT=665.025n

.meas tran vdout0_109ck1320 FIND v(dout0_109) AT=665.025n

.meas tran vdout0_110ck1320 FIND v(dout0_110) AT=665.025n

.meas tran vdout0_111ck1320 FIND v(dout0_111) AT=665.025n

.meas tran vdout0_112ck1320 FIND v(dout0_112) AT=665.025n

.meas tran vdout0_113ck1320 FIND v(dout0_113) AT=665.025n

.meas tran vdout0_114ck1320 FIND v(dout0_114) AT=665.025n

.meas tran vdout0_115ck1320 FIND v(dout0_115) AT=665.025n

.meas tran vdout0_116ck1320 FIND v(dout0_116) AT=665.025n

.meas tran vdout0_117ck1320 FIND v(dout0_117) AT=665.025n

.meas tran vdout0_118ck1320 FIND v(dout0_118) AT=665.025n

.meas tran vdout0_119ck1320 FIND v(dout0_119) AT=665.025n

.meas tran vdout0_120ck1320 FIND v(dout0_120) AT=665.025n

.meas tran vdout0_121ck1320 FIND v(dout0_121) AT=665.025n

.meas tran vdout0_122ck1320 FIND v(dout0_122) AT=665.025n

.meas tran vdout0_123ck1320 FIND v(dout0_123) AT=665.025n

.meas tran vdout0_124ck1320 FIND v(dout0_124) AT=665.025n

.meas tran vdout0_125ck1320 FIND v(dout0_125) AT=665.025n

.meas tran vdout0_126ck1320 FIND v(dout0_126) AT=665.025n

.meas tran vdout0_127ck1320 FIND v(dout0_127) AT=665.025n

.meas tran vdout0_128ck1320 FIND v(dout0_128) AT=665.025n

.meas tran vdout0_129ck1320 FIND v(dout0_129) AT=665.025n

.meas tran vdout0_130ck1320 FIND v(dout0_130) AT=665.025n

.meas tran vdout0_131ck1320 FIND v(dout0_131) AT=665.025n

.meas tran vdout0_132ck1320 FIND v(dout0_132) AT=665.025n

.meas tran vdout0_133ck1320 FIND v(dout0_133) AT=665.025n

.meas tran vdout0_134ck1320 FIND v(dout0_134) AT=665.025n

.meas tran vdout0_135ck1320 FIND v(dout0_135) AT=665.025n

.meas tran vdout0_136ck1320 FIND v(dout0_136) AT=665.025n

.meas tran vdout0_137ck1320 FIND v(dout0_137) AT=665.025n

.meas tran vdout0_138ck1320 FIND v(dout0_138) AT=665.025n

.meas tran vdout0_139ck1320 FIND v(dout0_139) AT=665.025n

.meas tran vdout0_140ck1320 FIND v(dout0_140) AT=665.025n

.meas tran vdout0_141ck1320 FIND v(dout0_141) AT=665.025n

.meas tran vdout0_142ck1320 FIND v(dout0_142) AT=665.025n

.meas tran vdout0_143ck1320 FIND v(dout0_143) AT=665.025n

.meas tran vdout0_144ck1320 FIND v(dout0_144) AT=665.025n

.meas tran vdout0_145ck1320 FIND v(dout0_145) AT=665.025n

.meas tran vdout0_146ck1320 FIND v(dout0_146) AT=665.025n

.meas tran vdout0_147ck1320 FIND v(dout0_147) AT=665.025n

.meas tran vdout0_148ck1320 FIND v(dout0_148) AT=665.025n

.meas tran vdout0_149ck1320 FIND v(dout0_149) AT=665.025n

.meas tran vdout0_150ck1320 FIND v(dout0_150) AT=665.025n

.meas tran vdout0_151ck1320 FIND v(dout0_151) AT=665.025n

.meas tran vdout0_152ck1320 FIND v(dout0_152) AT=665.025n

.meas tran vdout0_153ck1320 FIND v(dout0_153) AT=665.025n

.meas tran vdout0_154ck1320 FIND v(dout0_154) AT=665.025n

.meas tran vdout0_155ck1320 FIND v(dout0_155) AT=665.025n

.meas tran vdout0_156ck1320 FIND v(dout0_156) AT=665.025n

.meas tran vdout0_157ck1320 FIND v(dout0_157) AT=665.025n

.meas tran vdout0_158ck1320 FIND v(dout0_158) AT=665.025n

.meas tran vdout0_159ck1320 FIND v(dout0_159) AT=665.025n

.meas tran vdout0_160ck1320 FIND v(dout0_160) AT=665.025n

.meas tran vdout0_161ck1320 FIND v(dout0_161) AT=665.025n

.meas tran vdout0_162ck1320 FIND v(dout0_162) AT=665.025n

.meas tran vdout0_163ck1320 FIND v(dout0_163) AT=665.025n

.meas tran vdout0_164ck1320 FIND v(dout0_164) AT=665.025n

.meas tran vdout0_165ck1320 FIND v(dout0_165) AT=665.025n

.meas tran vdout0_166ck1320 FIND v(dout0_166) AT=665.025n

.meas tran vdout0_167ck1320 FIND v(dout0_167) AT=665.025n

.meas tran vdout0_168ck1320 FIND v(dout0_168) AT=665.025n

.meas tran vdout0_169ck1320 FIND v(dout0_169) AT=665.025n

.meas tran vdout0_170ck1320 FIND v(dout0_170) AT=665.025n

.meas tran vdout0_171ck1320 FIND v(dout0_171) AT=665.025n

.meas tran vdout0_172ck1320 FIND v(dout0_172) AT=665.025n

.meas tran vdout0_173ck1320 FIND v(dout0_173) AT=665.025n

.meas tran vdout0_174ck1320 FIND v(dout0_174) AT=665.025n

.meas tran vdout0_175ck1320 FIND v(dout0_175) AT=665.025n

.meas tran vdout0_176ck1320 FIND v(dout0_176) AT=665.025n

.meas tran vdout0_177ck1320 FIND v(dout0_177) AT=665.025n

.meas tran vdout0_178ck1320 FIND v(dout0_178) AT=665.025n

.meas tran vdout0_179ck1320 FIND v(dout0_179) AT=665.025n

.meas tran vdout0_180ck1320 FIND v(dout0_180) AT=665.025n

.meas tran vdout0_181ck1320 FIND v(dout0_181) AT=665.025n

.meas tran vdout0_182ck1320 FIND v(dout0_182) AT=665.025n

.meas tran vdout0_183ck1320 FIND v(dout0_183) AT=665.025n

.meas tran vdout0_184ck1320 FIND v(dout0_184) AT=665.025n

.meas tran vdout0_185ck1320 FIND v(dout0_185) AT=665.025n

.meas tran vdout0_186ck1320 FIND v(dout0_186) AT=665.025n

.meas tran vdout0_187ck1320 FIND v(dout0_187) AT=665.025n

.meas tran vdout0_188ck1320 FIND v(dout0_188) AT=665.025n

.meas tran vdout0_189ck1320 FIND v(dout0_189) AT=665.025n

.meas tran vdout0_190ck1320 FIND v(dout0_190) AT=665.025n

.meas tran vdout0_191ck1320 FIND v(dout0_191) AT=665.025n

.meas tran vdout0_192ck1320 FIND v(dout0_192) AT=665.025n

.meas tran vdout0_193ck1320 FIND v(dout0_193) AT=665.025n

.meas tran vdout0_194ck1320 FIND v(dout0_194) AT=665.025n

.meas tran vdout0_195ck1320 FIND v(dout0_195) AT=665.025n

.meas tran vdout0_196ck1320 FIND v(dout0_196) AT=665.025n

.meas tran vdout0_197ck1320 FIND v(dout0_197) AT=665.025n

.meas tran vdout0_198ck1320 FIND v(dout0_198) AT=665.025n

.meas tran vdout0_199ck1320 FIND v(dout0_199) AT=665.025n

.meas tran vdout0_200ck1320 FIND v(dout0_200) AT=665.025n

.meas tran vdout0_201ck1320 FIND v(dout0_201) AT=665.025n

.meas tran vdout0_202ck1320 FIND v(dout0_202) AT=665.025n

.meas tran vdout0_203ck1320 FIND v(dout0_203) AT=665.025n

.meas tran vdout0_204ck1320 FIND v(dout0_204) AT=665.025n

.meas tran vdout0_205ck1320 FIND v(dout0_205) AT=665.025n

.meas tran vdout0_206ck1320 FIND v(dout0_206) AT=665.025n

.meas tran vdout0_207ck1320 FIND v(dout0_207) AT=665.025n

.meas tran vdout0_208ck1320 FIND v(dout0_208) AT=665.025n

.meas tran vdout0_209ck1320 FIND v(dout0_209) AT=665.025n

.meas tran vdout0_210ck1320 FIND v(dout0_210) AT=665.025n

.meas tran vdout0_211ck1320 FIND v(dout0_211) AT=665.025n

.meas tran vdout0_212ck1320 FIND v(dout0_212) AT=665.025n

.meas tran vdout0_213ck1320 FIND v(dout0_213) AT=665.025n

.meas tran vdout0_214ck1320 FIND v(dout0_214) AT=665.025n

.meas tran vdout0_215ck1320 FIND v(dout0_215) AT=665.025n

.meas tran vdout0_216ck1320 FIND v(dout0_216) AT=665.025n

.meas tran vdout0_217ck1320 FIND v(dout0_217) AT=665.025n

.meas tran vdout0_218ck1320 FIND v(dout0_218) AT=665.025n

.meas tran vdout0_219ck1320 FIND v(dout0_219) AT=665.025n

.meas tran vdout0_220ck1320 FIND v(dout0_220) AT=665.025n

.meas tran vdout0_221ck1320 FIND v(dout0_221) AT=665.025n

.meas tran vdout0_222ck1320 FIND v(dout0_222) AT=665.025n

.meas tran vdout0_223ck1320 FIND v(dout0_223) AT=665.025n

.meas tran vdout0_224ck1320 FIND v(dout0_224) AT=665.025n

.meas tran vdout0_225ck1320 FIND v(dout0_225) AT=665.025n

.meas tran vdout0_226ck1320 FIND v(dout0_226) AT=665.025n

.meas tran vdout0_227ck1320 FIND v(dout0_227) AT=665.025n

.meas tran vdout0_228ck1320 FIND v(dout0_228) AT=665.025n

.meas tran vdout0_229ck1320 FIND v(dout0_229) AT=665.025n

.meas tran vdout0_230ck1320 FIND v(dout0_230) AT=665.025n

.meas tran vdout0_231ck1320 FIND v(dout0_231) AT=665.025n

.meas tran vdout0_232ck1320 FIND v(dout0_232) AT=665.025n

.meas tran vdout0_233ck1320 FIND v(dout0_233) AT=665.025n

.meas tran vdout0_234ck1320 FIND v(dout0_234) AT=665.025n

.meas tran vdout0_235ck1320 FIND v(dout0_235) AT=665.025n

.meas tran vdout0_236ck1320 FIND v(dout0_236) AT=665.025n

.meas tran vdout0_237ck1320 FIND v(dout0_237) AT=665.025n

.meas tran vdout0_238ck1320 FIND v(dout0_238) AT=665.025n

.meas tran vdout0_239ck1320 FIND v(dout0_239) AT=665.025n

.meas tran vdout0_240ck1320 FIND v(dout0_240) AT=665.025n

.meas tran vdout0_241ck1320 FIND v(dout0_241) AT=665.025n

.meas tran vdout0_242ck1320 FIND v(dout0_242) AT=665.025n

.meas tran vdout0_243ck1320 FIND v(dout0_243) AT=665.025n

.meas tran vdout0_244ck1320 FIND v(dout0_244) AT=665.025n

.meas tran vdout0_245ck1320 FIND v(dout0_245) AT=665.025n

.meas tran vdout0_246ck1320 FIND v(dout0_246) AT=665.025n

.meas tran vdout0_247ck1320 FIND v(dout0_247) AT=665.025n

.meas tran vdout0_248ck1320 FIND v(dout0_248) AT=665.025n

.meas tran vdout0_249ck1320 FIND v(dout0_249) AT=665.025n

.meas tran vdout0_250ck1320 FIND v(dout0_250) AT=665.025n

.meas tran vdout0_251ck1320 FIND v(dout0_251) AT=665.025n

.meas tran vdout0_252ck1320 FIND v(dout0_252) AT=665.025n

.meas tran vdout0_253ck1320 FIND v(dout0_253) AT=665.025n

.meas tran vdout0_254ck1320 FIND v(dout0_254) AT=665.025n

.meas tran vdout0_255ck1320 FIND v(dout0_255) AT=665.025n

.meas tran vdout0_0ck1360 FIND v(dout0_0) AT=685.025n

.meas tran vdout0_1ck1360 FIND v(dout0_1) AT=685.025n

.meas tran vdout0_2ck1360 FIND v(dout0_2) AT=685.025n

.meas tran vdout0_3ck1360 FIND v(dout0_3) AT=685.025n

.meas tran vdout0_4ck1360 FIND v(dout0_4) AT=685.025n

.meas tran vdout0_5ck1360 FIND v(dout0_5) AT=685.025n

.meas tran vdout0_6ck1360 FIND v(dout0_6) AT=685.025n

.meas tran vdout0_7ck1360 FIND v(dout0_7) AT=685.025n

.meas tran vdout0_8ck1360 FIND v(dout0_8) AT=685.025n

.meas tran vdout0_9ck1360 FIND v(dout0_9) AT=685.025n

.meas tran vdout0_10ck1360 FIND v(dout0_10) AT=685.025n

.meas tran vdout0_11ck1360 FIND v(dout0_11) AT=685.025n

.meas tran vdout0_12ck1360 FIND v(dout0_12) AT=685.025n

.meas tran vdout0_13ck1360 FIND v(dout0_13) AT=685.025n

.meas tran vdout0_14ck1360 FIND v(dout0_14) AT=685.025n

.meas tran vdout0_15ck1360 FIND v(dout0_15) AT=685.025n

.meas tran vdout0_16ck1360 FIND v(dout0_16) AT=685.025n

.meas tran vdout0_17ck1360 FIND v(dout0_17) AT=685.025n

.meas tran vdout0_18ck1360 FIND v(dout0_18) AT=685.025n

.meas tran vdout0_19ck1360 FIND v(dout0_19) AT=685.025n

.meas tran vdout0_20ck1360 FIND v(dout0_20) AT=685.025n

.meas tran vdout0_21ck1360 FIND v(dout0_21) AT=685.025n

.meas tran vdout0_22ck1360 FIND v(dout0_22) AT=685.025n

.meas tran vdout0_23ck1360 FIND v(dout0_23) AT=685.025n

.meas tran vdout0_24ck1360 FIND v(dout0_24) AT=685.025n

.meas tran vdout0_25ck1360 FIND v(dout0_25) AT=685.025n

.meas tran vdout0_26ck1360 FIND v(dout0_26) AT=685.025n

.meas tran vdout0_27ck1360 FIND v(dout0_27) AT=685.025n

.meas tran vdout0_28ck1360 FIND v(dout0_28) AT=685.025n

.meas tran vdout0_29ck1360 FIND v(dout0_29) AT=685.025n

.meas tran vdout0_30ck1360 FIND v(dout0_30) AT=685.025n

.meas tran vdout0_31ck1360 FIND v(dout0_31) AT=685.025n

.meas tran vdout0_32ck1360 FIND v(dout0_32) AT=685.025n

.meas tran vdout0_33ck1360 FIND v(dout0_33) AT=685.025n

.meas tran vdout0_34ck1360 FIND v(dout0_34) AT=685.025n

.meas tran vdout0_35ck1360 FIND v(dout0_35) AT=685.025n

.meas tran vdout0_36ck1360 FIND v(dout0_36) AT=685.025n

.meas tran vdout0_37ck1360 FIND v(dout0_37) AT=685.025n

.meas tran vdout0_38ck1360 FIND v(dout0_38) AT=685.025n

.meas tran vdout0_39ck1360 FIND v(dout0_39) AT=685.025n

.meas tran vdout0_40ck1360 FIND v(dout0_40) AT=685.025n

.meas tran vdout0_41ck1360 FIND v(dout0_41) AT=685.025n

.meas tran vdout0_42ck1360 FIND v(dout0_42) AT=685.025n

.meas tran vdout0_43ck1360 FIND v(dout0_43) AT=685.025n

.meas tran vdout0_44ck1360 FIND v(dout0_44) AT=685.025n

.meas tran vdout0_45ck1360 FIND v(dout0_45) AT=685.025n

.meas tran vdout0_46ck1360 FIND v(dout0_46) AT=685.025n

.meas tran vdout0_47ck1360 FIND v(dout0_47) AT=685.025n

.meas tran vdout0_48ck1360 FIND v(dout0_48) AT=685.025n

.meas tran vdout0_49ck1360 FIND v(dout0_49) AT=685.025n

.meas tran vdout0_50ck1360 FIND v(dout0_50) AT=685.025n

.meas tran vdout0_51ck1360 FIND v(dout0_51) AT=685.025n

.meas tran vdout0_52ck1360 FIND v(dout0_52) AT=685.025n

.meas tran vdout0_53ck1360 FIND v(dout0_53) AT=685.025n

.meas tran vdout0_54ck1360 FIND v(dout0_54) AT=685.025n

.meas tran vdout0_55ck1360 FIND v(dout0_55) AT=685.025n

.meas tran vdout0_56ck1360 FIND v(dout0_56) AT=685.025n

.meas tran vdout0_57ck1360 FIND v(dout0_57) AT=685.025n

.meas tran vdout0_58ck1360 FIND v(dout0_58) AT=685.025n

.meas tran vdout0_59ck1360 FIND v(dout0_59) AT=685.025n

.meas tran vdout0_60ck1360 FIND v(dout0_60) AT=685.025n

.meas tran vdout0_61ck1360 FIND v(dout0_61) AT=685.025n

.meas tran vdout0_62ck1360 FIND v(dout0_62) AT=685.025n

.meas tran vdout0_63ck1360 FIND v(dout0_63) AT=685.025n

.meas tran vdout0_64ck1360 FIND v(dout0_64) AT=685.025n

.meas tran vdout0_65ck1360 FIND v(dout0_65) AT=685.025n

.meas tran vdout0_66ck1360 FIND v(dout0_66) AT=685.025n

.meas tran vdout0_67ck1360 FIND v(dout0_67) AT=685.025n

.meas tran vdout0_68ck1360 FIND v(dout0_68) AT=685.025n

.meas tran vdout0_69ck1360 FIND v(dout0_69) AT=685.025n

.meas tran vdout0_70ck1360 FIND v(dout0_70) AT=685.025n

.meas tran vdout0_71ck1360 FIND v(dout0_71) AT=685.025n

.meas tran vdout0_72ck1360 FIND v(dout0_72) AT=685.025n

.meas tran vdout0_73ck1360 FIND v(dout0_73) AT=685.025n

.meas tran vdout0_74ck1360 FIND v(dout0_74) AT=685.025n

.meas tran vdout0_75ck1360 FIND v(dout0_75) AT=685.025n

.meas tran vdout0_76ck1360 FIND v(dout0_76) AT=685.025n

.meas tran vdout0_77ck1360 FIND v(dout0_77) AT=685.025n

.meas tran vdout0_78ck1360 FIND v(dout0_78) AT=685.025n

.meas tran vdout0_79ck1360 FIND v(dout0_79) AT=685.025n

.meas tran vdout0_80ck1360 FIND v(dout0_80) AT=685.025n

.meas tran vdout0_81ck1360 FIND v(dout0_81) AT=685.025n

.meas tran vdout0_82ck1360 FIND v(dout0_82) AT=685.025n

.meas tran vdout0_83ck1360 FIND v(dout0_83) AT=685.025n

.meas tran vdout0_84ck1360 FIND v(dout0_84) AT=685.025n

.meas tran vdout0_85ck1360 FIND v(dout0_85) AT=685.025n

.meas tran vdout0_86ck1360 FIND v(dout0_86) AT=685.025n

.meas tran vdout0_87ck1360 FIND v(dout0_87) AT=685.025n

.meas tran vdout0_88ck1360 FIND v(dout0_88) AT=685.025n

.meas tran vdout0_89ck1360 FIND v(dout0_89) AT=685.025n

.meas tran vdout0_90ck1360 FIND v(dout0_90) AT=685.025n

.meas tran vdout0_91ck1360 FIND v(dout0_91) AT=685.025n

.meas tran vdout0_92ck1360 FIND v(dout0_92) AT=685.025n

.meas tran vdout0_93ck1360 FIND v(dout0_93) AT=685.025n

.meas tran vdout0_94ck1360 FIND v(dout0_94) AT=685.025n

.meas tran vdout0_95ck1360 FIND v(dout0_95) AT=685.025n

.meas tran vdout0_96ck1360 FIND v(dout0_96) AT=685.025n

.meas tran vdout0_97ck1360 FIND v(dout0_97) AT=685.025n

.meas tran vdout0_98ck1360 FIND v(dout0_98) AT=685.025n

.meas tran vdout0_99ck1360 FIND v(dout0_99) AT=685.025n

.meas tran vdout0_100ck1360 FIND v(dout0_100) AT=685.025n

.meas tran vdout0_101ck1360 FIND v(dout0_101) AT=685.025n

.meas tran vdout0_102ck1360 FIND v(dout0_102) AT=685.025n

.meas tran vdout0_103ck1360 FIND v(dout0_103) AT=685.025n

.meas tran vdout0_104ck1360 FIND v(dout0_104) AT=685.025n

.meas tran vdout0_105ck1360 FIND v(dout0_105) AT=685.025n

.meas tran vdout0_106ck1360 FIND v(dout0_106) AT=685.025n

.meas tran vdout0_107ck1360 FIND v(dout0_107) AT=685.025n

.meas tran vdout0_108ck1360 FIND v(dout0_108) AT=685.025n

.meas tran vdout0_109ck1360 FIND v(dout0_109) AT=685.025n

.meas tran vdout0_110ck1360 FIND v(dout0_110) AT=685.025n

.meas tran vdout0_111ck1360 FIND v(dout0_111) AT=685.025n

.meas tran vdout0_112ck1360 FIND v(dout0_112) AT=685.025n

.meas tran vdout0_113ck1360 FIND v(dout0_113) AT=685.025n

.meas tran vdout0_114ck1360 FIND v(dout0_114) AT=685.025n

.meas tran vdout0_115ck1360 FIND v(dout0_115) AT=685.025n

.meas tran vdout0_116ck1360 FIND v(dout0_116) AT=685.025n

.meas tran vdout0_117ck1360 FIND v(dout0_117) AT=685.025n

.meas tran vdout0_118ck1360 FIND v(dout0_118) AT=685.025n

.meas tran vdout0_119ck1360 FIND v(dout0_119) AT=685.025n

.meas tran vdout0_120ck1360 FIND v(dout0_120) AT=685.025n

.meas tran vdout0_121ck1360 FIND v(dout0_121) AT=685.025n

.meas tran vdout0_122ck1360 FIND v(dout0_122) AT=685.025n

.meas tran vdout0_123ck1360 FIND v(dout0_123) AT=685.025n

.meas tran vdout0_124ck1360 FIND v(dout0_124) AT=685.025n

.meas tran vdout0_125ck1360 FIND v(dout0_125) AT=685.025n

.meas tran vdout0_126ck1360 FIND v(dout0_126) AT=685.025n

.meas tran vdout0_127ck1360 FIND v(dout0_127) AT=685.025n

.meas tran vdout0_128ck1360 FIND v(dout0_128) AT=685.025n

.meas tran vdout0_129ck1360 FIND v(dout0_129) AT=685.025n

.meas tran vdout0_130ck1360 FIND v(dout0_130) AT=685.025n

.meas tran vdout0_131ck1360 FIND v(dout0_131) AT=685.025n

.meas tran vdout0_132ck1360 FIND v(dout0_132) AT=685.025n

.meas tran vdout0_133ck1360 FIND v(dout0_133) AT=685.025n

.meas tran vdout0_134ck1360 FIND v(dout0_134) AT=685.025n

.meas tran vdout0_135ck1360 FIND v(dout0_135) AT=685.025n

.meas tran vdout0_136ck1360 FIND v(dout0_136) AT=685.025n

.meas tran vdout0_137ck1360 FIND v(dout0_137) AT=685.025n

.meas tran vdout0_138ck1360 FIND v(dout0_138) AT=685.025n

.meas tran vdout0_139ck1360 FIND v(dout0_139) AT=685.025n

.meas tran vdout0_140ck1360 FIND v(dout0_140) AT=685.025n

.meas tran vdout0_141ck1360 FIND v(dout0_141) AT=685.025n

.meas tran vdout0_142ck1360 FIND v(dout0_142) AT=685.025n

.meas tran vdout0_143ck1360 FIND v(dout0_143) AT=685.025n

.meas tran vdout0_144ck1360 FIND v(dout0_144) AT=685.025n

.meas tran vdout0_145ck1360 FIND v(dout0_145) AT=685.025n

.meas tran vdout0_146ck1360 FIND v(dout0_146) AT=685.025n

.meas tran vdout0_147ck1360 FIND v(dout0_147) AT=685.025n

.meas tran vdout0_148ck1360 FIND v(dout0_148) AT=685.025n

.meas tran vdout0_149ck1360 FIND v(dout0_149) AT=685.025n

.meas tran vdout0_150ck1360 FIND v(dout0_150) AT=685.025n

.meas tran vdout0_151ck1360 FIND v(dout0_151) AT=685.025n

.meas tran vdout0_152ck1360 FIND v(dout0_152) AT=685.025n

.meas tran vdout0_153ck1360 FIND v(dout0_153) AT=685.025n

.meas tran vdout0_154ck1360 FIND v(dout0_154) AT=685.025n

.meas tran vdout0_155ck1360 FIND v(dout0_155) AT=685.025n

.meas tran vdout0_156ck1360 FIND v(dout0_156) AT=685.025n

.meas tran vdout0_157ck1360 FIND v(dout0_157) AT=685.025n

.meas tran vdout0_158ck1360 FIND v(dout0_158) AT=685.025n

.meas tran vdout0_159ck1360 FIND v(dout0_159) AT=685.025n

.meas tran vdout0_160ck1360 FIND v(dout0_160) AT=685.025n

.meas tran vdout0_161ck1360 FIND v(dout0_161) AT=685.025n

.meas tran vdout0_162ck1360 FIND v(dout0_162) AT=685.025n

.meas tran vdout0_163ck1360 FIND v(dout0_163) AT=685.025n

.meas tran vdout0_164ck1360 FIND v(dout0_164) AT=685.025n

.meas tran vdout0_165ck1360 FIND v(dout0_165) AT=685.025n

.meas tran vdout0_166ck1360 FIND v(dout0_166) AT=685.025n

.meas tran vdout0_167ck1360 FIND v(dout0_167) AT=685.025n

.meas tran vdout0_168ck1360 FIND v(dout0_168) AT=685.025n

.meas tran vdout0_169ck1360 FIND v(dout0_169) AT=685.025n

.meas tran vdout0_170ck1360 FIND v(dout0_170) AT=685.025n

.meas tran vdout0_171ck1360 FIND v(dout0_171) AT=685.025n

.meas tran vdout0_172ck1360 FIND v(dout0_172) AT=685.025n

.meas tran vdout0_173ck1360 FIND v(dout0_173) AT=685.025n

.meas tran vdout0_174ck1360 FIND v(dout0_174) AT=685.025n

.meas tran vdout0_175ck1360 FIND v(dout0_175) AT=685.025n

.meas tran vdout0_176ck1360 FIND v(dout0_176) AT=685.025n

.meas tran vdout0_177ck1360 FIND v(dout0_177) AT=685.025n

.meas tran vdout0_178ck1360 FIND v(dout0_178) AT=685.025n

.meas tran vdout0_179ck1360 FIND v(dout0_179) AT=685.025n

.meas tran vdout0_180ck1360 FIND v(dout0_180) AT=685.025n

.meas tran vdout0_181ck1360 FIND v(dout0_181) AT=685.025n

.meas tran vdout0_182ck1360 FIND v(dout0_182) AT=685.025n

.meas tran vdout0_183ck1360 FIND v(dout0_183) AT=685.025n

.meas tran vdout0_184ck1360 FIND v(dout0_184) AT=685.025n

.meas tran vdout0_185ck1360 FIND v(dout0_185) AT=685.025n

.meas tran vdout0_186ck1360 FIND v(dout0_186) AT=685.025n

.meas tran vdout0_187ck1360 FIND v(dout0_187) AT=685.025n

.meas tran vdout0_188ck1360 FIND v(dout0_188) AT=685.025n

.meas tran vdout0_189ck1360 FIND v(dout0_189) AT=685.025n

.meas tran vdout0_190ck1360 FIND v(dout0_190) AT=685.025n

.meas tran vdout0_191ck1360 FIND v(dout0_191) AT=685.025n

.meas tran vdout0_192ck1360 FIND v(dout0_192) AT=685.025n

.meas tran vdout0_193ck1360 FIND v(dout0_193) AT=685.025n

.meas tran vdout0_194ck1360 FIND v(dout0_194) AT=685.025n

.meas tran vdout0_195ck1360 FIND v(dout0_195) AT=685.025n

.meas tran vdout0_196ck1360 FIND v(dout0_196) AT=685.025n

.meas tran vdout0_197ck1360 FIND v(dout0_197) AT=685.025n

.meas tran vdout0_198ck1360 FIND v(dout0_198) AT=685.025n

.meas tran vdout0_199ck1360 FIND v(dout0_199) AT=685.025n

.meas tran vdout0_200ck1360 FIND v(dout0_200) AT=685.025n

.meas tran vdout0_201ck1360 FIND v(dout0_201) AT=685.025n

.meas tran vdout0_202ck1360 FIND v(dout0_202) AT=685.025n

.meas tran vdout0_203ck1360 FIND v(dout0_203) AT=685.025n

.meas tran vdout0_204ck1360 FIND v(dout0_204) AT=685.025n

.meas tran vdout0_205ck1360 FIND v(dout0_205) AT=685.025n

.meas tran vdout0_206ck1360 FIND v(dout0_206) AT=685.025n

.meas tran vdout0_207ck1360 FIND v(dout0_207) AT=685.025n

.meas tran vdout0_208ck1360 FIND v(dout0_208) AT=685.025n

.meas tran vdout0_209ck1360 FIND v(dout0_209) AT=685.025n

.meas tran vdout0_210ck1360 FIND v(dout0_210) AT=685.025n

.meas tran vdout0_211ck1360 FIND v(dout0_211) AT=685.025n

.meas tran vdout0_212ck1360 FIND v(dout0_212) AT=685.025n

.meas tran vdout0_213ck1360 FIND v(dout0_213) AT=685.025n

.meas tran vdout0_214ck1360 FIND v(dout0_214) AT=685.025n

.meas tran vdout0_215ck1360 FIND v(dout0_215) AT=685.025n

.meas tran vdout0_216ck1360 FIND v(dout0_216) AT=685.025n

.meas tran vdout0_217ck1360 FIND v(dout0_217) AT=685.025n

.meas tran vdout0_218ck1360 FIND v(dout0_218) AT=685.025n

.meas tran vdout0_219ck1360 FIND v(dout0_219) AT=685.025n

.meas tran vdout0_220ck1360 FIND v(dout0_220) AT=685.025n

.meas tran vdout0_221ck1360 FIND v(dout0_221) AT=685.025n

.meas tran vdout0_222ck1360 FIND v(dout0_222) AT=685.025n

.meas tran vdout0_223ck1360 FIND v(dout0_223) AT=685.025n

.meas tran vdout0_224ck1360 FIND v(dout0_224) AT=685.025n

.meas tran vdout0_225ck1360 FIND v(dout0_225) AT=685.025n

.meas tran vdout0_226ck1360 FIND v(dout0_226) AT=685.025n

.meas tran vdout0_227ck1360 FIND v(dout0_227) AT=685.025n

.meas tran vdout0_228ck1360 FIND v(dout0_228) AT=685.025n

.meas tran vdout0_229ck1360 FIND v(dout0_229) AT=685.025n

.meas tran vdout0_230ck1360 FIND v(dout0_230) AT=685.025n

.meas tran vdout0_231ck1360 FIND v(dout0_231) AT=685.025n

.meas tran vdout0_232ck1360 FIND v(dout0_232) AT=685.025n

.meas tran vdout0_233ck1360 FIND v(dout0_233) AT=685.025n

.meas tran vdout0_234ck1360 FIND v(dout0_234) AT=685.025n

.meas tran vdout0_235ck1360 FIND v(dout0_235) AT=685.025n

.meas tran vdout0_236ck1360 FIND v(dout0_236) AT=685.025n

.meas tran vdout0_237ck1360 FIND v(dout0_237) AT=685.025n

.meas tran vdout0_238ck1360 FIND v(dout0_238) AT=685.025n

.meas tran vdout0_239ck1360 FIND v(dout0_239) AT=685.025n

.meas tran vdout0_240ck1360 FIND v(dout0_240) AT=685.025n

.meas tran vdout0_241ck1360 FIND v(dout0_241) AT=685.025n

.meas tran vdout0_242ck1360 FIND v(dout0_242) AT=685.025n

.meas tran vdout0_243ck1360 FIND v(dout0_243) AT=685.025n

.meas tran vdout0_244ck1360 FIND v(dout0_244) AT=685.025n

.meas tran vdout0_245ck1360 FIND v(dout0_245) AT=685.025n

.meas tran vdout0_246ck1360 FIND v(dout0_246) AT=685.025n

.meas tran vdout0_247ck1360 FIND v(dout0_247) AT=685.025n

.meas tran vdout0_248ck1360 FIND v(dout0_248) AT=685.025n

.meas tran vdout0_249ck1360 FIND v(dout0_249) AT=685.025n

.meas tran vdout0_250ck1360 FIND v(dout0_250) AT=685.025n

.meas tran vdout0_251ck1360 FIND v(dout0_251) AT=685.025n

.meas tran vdout0_252ck1360 FIND v(dout0_252) AT=685.025n

.meas tran vdout0_253ck1360 FIND v(dout0_253) AT=685.025n

.meas tran vdout0_254ck1360 FIND v(dout0_254) AT=685.025n

.meas tran vdout0_255ck1360 FIND v(dout0_255) AT=685.025n

.meas tran vdout0_0ck1370 FIND v(dout0_0) AT=690.025n

.meas tran vdout0_1ck1370 FIND v(dout0_1) AT=690.025n

.meas tran vdout0_2ck1370 FIND v(dout0_2) AT=690.025n

.meas tran vdout0_3ck1370 FIND v(dout0_3) AT=690.025n

.meas tran vdout0_4ck1370 FIND v(dout0_4) AT=690.025n

.meas tran vdout0_5ck1370 FIND v(dout0_5) AT=690.025n

.meas tran vdout0_6ck1370 FIND v(dout0_6) AT=690.025n

.meas tran vdout0_7ck1370 FIND v(dout0_7) AT=690.025n

.meas tran vdout0_8ck1370 FIND v(dout0_8) AT=690.025n

.meas tran vdout0_9ck1370 FIND v(dout0_9) AT=690.025n

.meas tran vdout0_10ck1370 FIND v(dout0_10) AT=690.025n

.meas tran vdout0_11ck1370 FIND v(dout0_11) AT=690.025n

.meas tran vdout0_12ck1370 FIND v(dout0_12) AT=690.025n

.meas tran vdout0_13ck1370 FIND v(dout0_13) AT=690.025n

.meas tran vdout0_14ck1370 FIND v(dout0_14) AT=690.025n

.meas tran vdout0_15ck1370 FIND v(dout0_15) AT=690.025n

.meas tran vdout0_16ck1370 FIND v(dout0_16) AT=690.025n

.meas tran vdout0_17ck1370 FIND v(dout0_17) AT=690.025n

.meas tran vdout0_18ck1370 FIND v(dout0_18) AT=690.025n

.meas tran vdout0_19ck1370 FIND v(dout0_19) AT=690.025n

.meas tran vdout0_20ck1370 FIND v(dout0_20) AT=690.025n

.meas tran vdout0_21ck1370 FIND v(dout0_21) AT=690.025n

.meas tran vdout0_22ck1370 FIND v(dout0_22) AT=690.025n

.meas tran vdout0_23ck1370 FIND v(dout0_23) AT=690.025n

.meas tran vdout0_24ck1370 FIND v(dout0_24) AT=690.025n

.meas tran vdout0_25ck1370 FIND v(dout0_25) AT=690.025n

.meas tran vdout0_26ck1370 FIND v(dout0_26) AT=690.025n

.meas tran vdout0_27ck1370 FIND v(dout0_27) AT=690.025n

.meas tran vdout0_28ck1370 FIND v(dout0_28) AT=690.025n

.meas tran vdout0_29ck1370 FIND v(dout0_29) AT=690.025n

.meas tran vdout0_30ck1370 FIND v(dout0_30) AT=690.025n

.meas tran vdout0_31ck1370 FIND v(dout0_31) AT=690.025n

.meas tran vdout0_32ck1370 FIND v(dout0_32) AT=690.025n

.meas tran vdout0_33ck1370 FIND v(dout0_33) AT=690.025n

.meas tran vdout0_34ck1370 FIND v(dout0_34) AT=690.025n

.meas tran vdout0_35ck1370 FIND v(dout0_35) AT=690.025n

.meas tran vdout0_36ck1370 FIND v(dout0_36) AT=690.025n

.meas tran vdout0_37ck1370 FIND v(dout0_37) AT=690.025n

.meas tran vdout0_38ck1370 FIND v(dout0_38) AT=690.025n

.meas tran vdout0_39ck1370 FIND v(dout0_39) AT=690.025n

.meas tran vdout0_40ck1370 FIND v(dout0_40) AT=690.025n

.meas tran vdout0_41ck1370 FIND v(dout0_41) AT=690.025n

.meas tran vdout0_42ck1370 FIND v(dout0_42) AT=690.025n

.meas tran vdout0_43ck1370 FIND v(dout0_43) AT=690.025n

.meas tran vdout0_44ck1370 FIND v(dout0_44) AT=690.025n

.meas tran vdout0_45ck1370 FIND v(dout0_45) AT=690.025n

.meas tran vdout0_46ck1370 FIND v(dout0_46) AT=690.025n

.meas tran vdout0_47ck1370 FIND v(dout0_47) AT=690.025n

.meas tran vdout0_48ck1370 FIND v(dout0_48) AT=690.025n

.meas tran vdout0_49ck1370 FIND v(dout0_49) AT=690.025n

.meas tran vdout0_50ck1370 FIND v(dout0_50) AT=690.025n

.meas tran vdout0_51ck1370 FIND v(dout0_51) AT=690.025n

.meas tran vdout0_52ck1370 FIND v(dout0_52) AT=690.025n

.meas tran vdout0_53ck1370 FIND v(dout0_53) AT=690.025n

.meas tran vdout0_54ck1370 FIND v(dout0_54) AT=690.025n

.meas tran vdout0_55ck1370 FIND v(dout0_55) AT=690.025n

.meas tran vdout0_56ck1370 FIND v(dout0_56) AT=690.025n

.meas tran vdout0_57ck1370 FIND v(dout0_57) AT=690.025n

.meas tran vdout0_58ck1370 FIND v(dout0_58) AT=690.025n

.meas tran vdout0_59ck1370 FIND v(dout0_59) AT=690.025n

.meas tran vdout0_60ck1370 FIND v(dout0_60) AT=690.025n

.meas tran vdout0_61ck1370 FIND v(dout0_61) AT=690.025n

.meas tran vdout0_62ck1370 FIND v(dout0_62) AT=690.025n

.meas tran vdout0_63ck1370 FIND v(dout0_63) AT=690.025n

.meas tran vdout0_64ck1370 FIND v(dout0_64) AT=690.025n

.meas tran vdout0_65ck1370 FIND v(dout0_65) AT=690.025n

.meas tran vdout0_66ck1370 FIND v(dout0_66) AT=690.025n

.meas tran vdout0_67ck1370 FIND v(dout0_67) AT=690.025n

.meas tran vdout0_68ck1370 FIND v(dout0_68) AT=690.025n

.meas tran vdout0_69ck1370 FIND v(dout0_69) AT=690.025n

.meas tran vdout0_70ck1370 FIND v(dout0_70) AT=690.025n

.meas tran vdout0_71ck1370 FIND v(dout0_71) AT=690.025n

.meas tran vdout0_72ck1370 FIND v(dout0_72) AT=690.025n

.meas tran vdout0_73ck1370 FIND v(dout0_73) AT=690.025n

.meas tran vdout0_74ck1370 FIND v(dout0_74) AT=690.025n

.meas tran vdout0_75ck1370 FIND v(dout0_75) AT=690.025n

.meas tran vdout0_76ck1370 FIND v(dout0_76) AT=690.025n

.meas tran vdout0_77ck1370 FIND v(dout0_77) AT=690.025n

.meas tran vdout0_78ck1370 FIND v(dout0_78) AT=690.025n

.meas tran vdout0_79ck1370 FIND v(dout0_79) AT=690.025n

.meas tran vdout0_80ck1370 FIND v(dout0_80) AT=690.025n

.meas tran vdout0_81ck1370 FIND v(dout0_81) AT=690.025n

.meas tran vdout0_82ck1370 FIND v(dout0_82) AT=690.025n

.meas tran vdout0_83ck1370 FIND v(dout0_83) AT=690.025n

.meas tran vdout0_84ck1370 FIND v(dout0_84) AT=690.025n

.meas tran vdout0_85ck1370 FIND v(dout0_85) AT=690.025n

.meas tran vdout0_86ck1370 FIND v(dout0_86) AT=690.025n

.meas tran vdout0_87ck1370 FIND v(dout0_87) AT=690.025n

.meas tran vdout0_88ck1370 FIND v(dout0_88) AT=690.025n

.meas tran vdout0_89ck1370 FIND v(dout0_89) AT=690.025n

.meas tran vdout0_90ck1370 FIND v(dout0_90) AT=690.025n

.meas tran vdout0_91ck1370 FIND v(dout0_91) AT=690.025n

.meas tran vdout0_92ck1370 FIND v(dout0_92) AT=690.025n

.meas tran vdout0_93ck1370 FIND v(dout0_93) AT=690.025n

.meas tran vdout0_94ck1370 FIND v(dout0_94) AT=690.025n

.meas tran vdout0_95ck1370 FIND v(dout0_95) AT=690.025n

.meas tran vdout0_96ck1370 FIND v(dout0_96) AT=690.025n

.meas tran vdout0_97ck1370 FIND v(dout0_97) AT=690.025n

.meas tran vdout0_98ck1370 FIND v(dout0_98) AT=690.025n

.meas tran vdout0_99ck1370 FIND v(dout0_99) AT=690.025n

.meas tran vdout0_100ck1370 FIND v(dout0_100) AT=690.025n

.meas tran vdout0_101ck1370 FIND v(dout0_101) AT=690.025n

.meas tran vdout0_102ck1370 FIND v(dout0_102) AT=690.025n

.meas tran vdout0_103ck1370 FIND v(dout0_103) AT=690.025n

.meas tran vdout0_104ck1370 FIND v(dout0_104) AT=690.025n

.meas tran vdout0_105ck1370 FIND v(dout0_105) AT=690.025n

.meas tran vdout0_106ck1370 FIND v(dout0_106) AT=690.025n

.meas tran vdout0_107ck1370 FIND v(dout0_107) AT=690.025n

.meas tran vdout0_108ck1370 FIND v(dout0_108) AT=690.025n

.meas tran vdout0_109ck1370 FIND v(dout0_109) AT=690.025n

.meas tran vdout0_110ck1370 FIND v(dout0_110) AT=690.025n

.meas tran vdout0_111ck1370 FIND v(dout0_111) AT=690.025n

.meas tran vdout0_112ck1370 FIND v(dout0_112) AT=690.025n

.meas tran vdout0_113ck1370 FIND v(dout0_113) AT=690.025n

.meas tran vdout0_114ck1370 FIND v(dout0_114) AT=690.025n

.meas tran vdout0_115ck1370 FIND v(dout0_115) AT=690.025n

.meas tran vdout0_116ck1370 FIND v(dout0_116) AT=690.025n

.meas tran vdout0_117ck1370 FIND v(dout0_117) AT=690.025n

.meas tran vdout0_118ck1370 FIND v(dout0_118) AT=690.025n

.meas tran vdout0_119ck1370 FIND v(dout0_119) AT=690.025n

.meas tran vdout0_120ck1370 FIND v(dout0_120) AT=690.025n

.meas tran vdout0_121ck1370 FIND v(dout0_121) AT=690.025n

.meas tran vdout0_122ck1370 FIND v(dout0_122) AT=690.025n

.meas tran vdout0_123ck1370 FIND v(dout0_123) AT=690.025n

.meas tran vdout0_124ck1370 FIND v(dout0_124) AT=690.025n

.meas tran vdout0_125ck1370 FIND v(dout0_125) AT=690.025n

.meas tran vdout0_126ck1370 FIND v(dout0_126) AT=690.025n

.meas tran vdout0_127ck1370 FIND v(dout0_127) AT=690.025n

.meas tran vdout0_128ck1370 FIND v(dout0_128) AT=690.025n

.meas tran vdout0_129ck1370 FIND v(dout0_129) AT=690.025n

.meas tran vdout0_130ck1370 FIND v(dout0_130) AT=690.025n

.meas tran vdout0_131ck1370 FIND v(dout0_131) AT=690.025n

.meas tran vdout0_132ck1370 FIND v(dout0_132) AT=690.025n

.meas tran vdout0_133ck1370 FIND v(dout0_133) AT=690.025n

.meas tran vdout0_134ck1370 FIND v(dout0_134) AT=690.025n

.meas tran vdout0_135ck1370 FIND v(dout0_135) AT=690.025n

.meas tran vdout0_136ck1370 FIND v(dout0_136) AT=690.025n

.meas tran vdout0_137ck1370 FIND v(dout0_137) AT=690.025n

.meas tran vdout0_138ck1370 FIND v(dout0_138) AT=690.025n

.meas tran vdout0_139ck1370 FIND v(dout0_139) AT=690.025n

.meas tran vdout0_140ck1370 FIND v(dout0_140) AT=690.025n

.meas tran vdout0_141ck1370 FIND v(dout0_141) AT=690.025n

.meas tran vdout0_142ck1370 FIND v(dout0_142) AT=690.025n

.meas tran vdout0_143ck1370 FIND v(dout0_143) AT=690.025n

.meas tran vdout0_144ck1370 FIND v(dout0_144) AT=690.025n

.meas tran vdout0_145ck1370 FIND v(dout0_145) AT=690.025n

.meas tran vdout0_146ck1370 FIND v(dout0_146) AT=690.025n

.meas tran vdout0_147ck1370 FIND v(dout0_147) AT=690.025n

.meas tran vdout0_148ck1370 FIND v(dout0_148) AT=690.025n

.meas tran vdout0_149ck1370 FIND v(dout0_149) AT=690.025n

.meas tran vdout0_150ck1370 FIND v(dout0_150) AT=690.025n

.meas tran vdout0_151ck1370 FIND v(dout0_151) AT=690.025n

.meas tran vdout0_152ck1370 FIND v(dout0_152) AT=690.025n

.meas tran vdout0_153ck1370 FIND v(dout0_153) AT=690.025n

.meas tran vdout0_154ck1370 FIND v(dout0_154) AT=690.025n

.meas tran vdout0_155ck1370 FIND v(dout0_155) AT=690.025n

.meas tran vdout0_156ck1370 FIND v(dout0_156) AT=690.025n

.meas tran vdout0_157ck1370 FIND v(dout0_157) AT=690.025n

.meas tran vdout0_158ck1370 FIND v(dout0_158) AT=690.025n

.meas tran vdout0_159ck1370 FIND v(dout0_159) AT=690.025n

.meas tran vdout0_160ck1370 FIND v(dout0_160) AT=690.025n

.meas tran vdout0_161ck1370 FIND v(dout0_161) AT=690.025n

.meas tran vdout0_162ck1370 FIND v(dout0_162) AT=690.025n

.meas tran vdout0_163ck1370 FIND v(dout0_163) AT=690.025n

.meas tran vdout0_164ck1370 FIND v(dout0_164) AT=690.025n

.meas tran vdout0_165ck1370 FIND v(dout0_165) AT=690.025n

.meas tran vdout0_166ck1370 FIND v(dout0_166) AT=690.025n

.meas tran vdout0_167ck1370 FIND v(dout0_167) AT=690.025n

.meas tran vdout0_168ck1370 FIND v(dout0_168) AT=690.025n

.meas tran vdout0_169ck1370 FIND v(dout0_169) AT=690.025n

.meas tran vdout0_170ck1370 FIND v(dout0_170) AT=690.025n

.meas tran vdout0_171ck1370 FIND v(dout0_171) AT=690.025n

.meas tran vdout0_172ck1370 FIND v(dout0_172) AT=690.025n

.meas tran vdout0_173ck1370 FIND v(dout0_173) AT=690.025n

.meas tran vdout0_174ck1370 FIND v(dout0_174) AT=690.025n

.meas tran vdout0_175ck1370 FIND v(dout0_175) AT=690.025n

.meas tran vdout0_176ck1370 FIND v(dout0_176) AT=690.025n

.meas tran vdout0_177ck1370 FIND v(dout0_177) AT=690.025n

.meas tran vdout0_178ck1370 FIND v(dout0_178) AT=690.025n

.meas tran vdout0_179ck1370 FIND v(dout0_179) AT=690.025n

.meas tran vdout0_180ck1370 FIND v(dout0_180) AT=690.025n

.meas tran vdout0_181ck1370 FIND v(dout0_181) AT=690.025n

.meas tran vdout0_182ck1370 FIND v(dout0_182) AT=690.025n

.meas tran vdout0_183ck1370 FIND v(dout0_183) AT=690.025n

.meas tran vdout0_184ck1370 FIND v(dout0_184) AT=690.025n

.meas tran vdout0_185ck1370 FIND v(dout0_185) AT=690.025n

.meas tran vdout0_186ck1370 FIND v(dout0_186) AT=690.025n

.meas tran vdout0_187ck1370 FIND v(dout0_187) AT=690.025n

.meas tran vdout0_188ck1370 FIND v(dout0_188) AT=690.025n

.meas tran vdout0_189ck1370 FIND v(dout0_189) AT=690.025n

.meas tran vdout0_190ck1370 FIND v(dout0_190) AT=690.025n

.meas tran vdout0_191ck1370 FIND v(dout0_191) AT=690.025n

.meas tran vdout0_192ck1370 FIND v(dout0_192) AT=690.025n

.meas tran vdout0_193ck1370 FIND v(dout0_193) AT=690.025n

.meas tran vdout0_194ck1370 FIND v(dout0_194) AT=690.025n

.meas tran vdout0_195ck1370 FIND v(dout0_195) AT=690.025n

.meas tran vdout0_196ck1370 FIND v(dout0_196) AT=690.025n

.meas tran vdout0_197ck1370 FIND v(dout0_197) AT=690.025n

.meas tran vdout0_198ck1370 FIND v(dout0_198) AT=690.025n

.meas tran vdout0_199ck1370 FIND v(dout0_199) AT=690.025n

.meas tran vdout0_200ck1370 FIND v(dout0_200) AT=690.025n

.meas tran vdout0_201ck1370 FIND v(dout0_201) AT=690.025n

.meas tran vdout0_202ck1370 FIND v(dout0_202) AT=690.025n

.meas tran vdout0_203ck1370 FIND v(dout0_203) AT=690.025n

.meas tran vdout0_204ck1370 FIND v(dout0_204) AT=690.025n

.meas tran vdout0_205ck1370 FIND v(dout0_205) AT=690.025n

.meas tran vdout0_206ck1370 FIND v(dout0_206) AT=690.025n

.meas tran vdout0_207ck1370 FIND v(dout0_207) AT=690.025n

.meas tran vdout0_208ck1370 FIND v(dout0_208) AT=690.025n

.meas tran vdout0_209ck1370 FIND v(dout0_209) AT=690.025n

.meas tran vdout0_210ck1370 FIND v(dout0_210) AT=690.025n

.meas tran vdout0_211ck1370 FIND v(dout0_211) AT=690.025n

.meas tran vdout0_212ck1370 FIND v(dout0_212) AT=690.025n

.meas tran vdout0_213ck1370 FIND v(dout0_213) AT=690.025n

.meas tran vdout0_214ck1370 FIND v(dout0_214) AT=690.025n

.meas tran vdout0_215ck1370 FIND v(dout0_215) AT=690.025n

.meas tran vdout0_216ck1370 FIND v(dout0_216) AT=690.025n

.meas tran vdout0_217ck1370 FIND v(dout0_217) AT=690.025n

.meas tran vdout0_218ck1370 FIND v(dout0_218) AT=690.025n

.meas tran vdout0_219ck1370 FIND v(dout0_219) AT=690.025n

.meas tran vdout0_220ck1370 FIND v(dout0_220) AT=690.025n

.meas tran vdout0_221ck1370 FIND v(dout0_221) AT=690.025n

.meas tran vdout0_222ck1370 FIND v(dout0_222) AT=690.025n

.meas tran vdout0_223ck1370 FIND v(dout0_223) AT=690.025n

.meas tran vdout0_224ck1370 FIND v(dout0_224) AT=690.025n

.meas tran vdout0_225ck1370 FIND v(dout0_225) AT=690.025n

.meas tran vdout0_226ck1370 FIND v(dout0_226) AT=690.025n

.meas tran vdout0_227ck1370 FIND v(dout0_227) AT=690.025n

.meas tran vdout0_228ck1370 FIND v(dout0_228) AT=690.025n

.meas tran vdout0_229ck1370 FIND v(dout0_229) AT=690.025n

.meas tran vdout0_230ck1370 FIND v(dout0_230) AT=690.025n

.meas tran vdout0_231ck1370 FIND v(dout0_231) AT=690.025n

.meas tran vdout0_232ck1370 FIND v(dout0_232) AT=690.025n

.meas tran vdout0_233ck1370 FIND v(dout0_233) AT=690.025n

.meas tran vdout0_234ck1370 FIND v(dout0_234) AT=690.025n

.meas tran vdout0_235ck1370 FIND v(dout0_235) AT=690.025n

.meas tran vdout0_236ck1370 FIND v(dout0_236) AT=690.025n

.meas tran vdout0_237ck1370 FIND v(dout0_237) AT=690.025n

.meas tran vdout0_238ck1370 FIND v(dout0_238) AT=690.025n

.meas tran vdout0_239ck1370 FIND v(dout0_239) AT=690.025n

.meas tran vdout0_240ck1370 FIND v(dout0_240) AT=690.025n

.meas tran vdout0_241ck1370 FIND v(dout0_241) AT=690.025n

.meas tran vdout0_242ck1370 FIND v(dout0_242) AT=690.025n

.meas tran vdout0_243ck1370 FIND v(dout0_243) AT=690.025n

.meas tran vdout0_244ck1370 FIND v(dout0_244) AT=690.025n

.meas tran vdout0_245ck1370 FIND v(dout0_245) AT=690.025n

.meas tran vdout0_246ck1370 FIND v(dout0_246) AT=690.025n

.meas tran vdout0_247ck1370 FIND v(dout0_247) AT=690.025n

.meas tran vdout0_248ck1370 FIND v(dout0_248) AT=690.025n

.meas tran vdout0_249ck1370 FIND v(dout0_249) AT=690.025n

.meas tran vdout0_250ck1370 FIND v(dout0_250) AT=690.025n

.meas tran vdout0_251ck1370 FIND v(dout0_251) AT=690.025n

.meas tran vdout0_252ck1370 FIND v(dout0_252) AT=690.025n

.meas tran vdout0_253ck1370 FIND v(dout0_253) AT=690.025n

.meas tran vdout0_254ck1370 FIND v(dout0_254) AT=690.025n

.meas tran vdout0_255ck1370 FIND v(dout0_255) AT=690.025n

.meas tran vdout0_0ck1410 FIND v(dout0_0) AT=710.025n

.meas tran vdout0_1ck1410 FIND v(dout0_1) AT=710.025n

.meas tran vdout0_2ck1410 FIND v(dout0_2) AT=710.025n

.meas tran vdout0_3ck1410 FIND v(dout0_3) AT=710.025n

.meas tran vdout0_4ck1410 FIND v(dout0_4) AT=710.025n

.meas tran vdout0_5ck1410 FIND v(dout0_5) AT=710.025n

.meas tran vdout0_6ck1410 FIND v(dout0_6) AT=710.025n

.meas tran vdout0_7ck1410 FIND v(dout0_7) AT=710.025n

.meas tran vdout0_8ck1410 FIND v(dout0_8) AT=710.025n

.meas tran vdout0_9ck1410 FIND v(dout0_9) AT=710.025n

.meas tran vdout0_10ck1410 FIND v(dout0_10) AT=710.025n

.meas tran vdout0_11ck1410 FIND v(dout0_11) AT=710.025n

.meas tran vdout0_12ck1410 FIND v(dout0_12) AT=710.025n

.meas tran vdout0_13ck1410 FIND v(dout0_13) AT=710.025n

.meas tran vdout0_14ck1410 FIND v(dout0_14) AT=710.025n

.meas tran vdout0_15ck1410 FIND v(dout0_15) AT=710.025n

.meas tran vdout0_16ck1410 FIND v(dout0_16) AT=710.025n

.meas tran vdout0_17ck1410 FIND v(dout0_17) AT=710.025n

.meas tran vdout0_18ck1410 FIND v(dout0_18) AT=710.025n

.meas tran vdout0_19ck1410 FIND v(dout0_19) AT=710.025n

.meas tran vdout0_20ck1410 FIND v(dout0_20) AT=710.025n

.meas tran vdout0_21ck1410 FIND v(dout0_21) AT=710.025n

.meas tran vdout0_22ck1410 FIND v(dout0_22) AT=710.025n

.meas tran vdout0_23ck1410 FIND v(dout0_23) AT=710.025n

.meas tran vdout0_24ck1410 FIND v(dout0_24) AT=710.025n

.meas tran vdout0_25ck1410 FIND v(dout0_25) AT=710.025n

.meas tran vdout0_26ck1410 FIND v(dout0_26) AT=710.025n

.meas tran vdout0_27ck1410 FIND v(dout0_27) AT=710.025n

.meas tran vdout0_28ck1410 FIND v(dout0_28) AT=710.025n

.meas tran vdout0_29ck1410 FIND v(dout0_29) AT=710.025n

.meas tran vdout0_30ck1410 FIND v(dout0_30) AT=710.025n

.meas tran vdout0_31ck1410 FIND v(dout0_31) AT=710.025n

.meas tran vdout0_32ck1410 FIND v(dout0_32) AT=710.025n

.meas tran vdout0_33ck1410 FIND v(dout0_33) AT=710.025n

.meas tran vdout0_34ck1410 FIND v(dout0_34) AT=710.025n

.meas tran vdout0_35ck1410 FIND v(dout0_35) AT=710.025n

.meas tran vdout0_36ck1410 FIND v(dout0_36) AT=710.025n

.meas tran vdout0_37ck1410 FIND v(dout0_37) AT=710.025n

.meas tran vdout0_38ck1410 FIND v(dout0_38) AT=710.025n

.meas tran vdout0_39ck1410 FIND v(dout0_39) AT=710.025n

.meas tran vdout0_40ck1410 FIND v(dout0_40) AT=710.025n

.meas tran vdout0_41ck1410 FIND v(dout0_41) AT=710.025n

.meas tran vdout0_42ck1410 FIND v(dout0_42) AT=710.025n

.meas tran vdout0_43ck1410 FIND v(dout0_43) AT=710.025n

.meas tran vdout0_44ck1410 FIND v(dout0_44) AT=710.025n

.meas tran vdout0_45ck1410 FIND v(dout0_45) AT=710.025n

.meas tran vdout0_46ck1410 FIND v(dout0_46) AT=710.025n

.meas tran vdout0_47ck1410 FIND v(dout0_47) AT=710.025n

.meas tran vdout0_48ck1410 FIND v(dout0_48) AT=710.025n

.meas tran vdout0_49ck1410 FIND v(dout0_49) AT=710.025n

.meas tran vdout0_50ck1410 FIND v(dout0_50) AT=710.025n

.meas tran vdout0_51ck1410 FIND v(dout0_51) AT=710.025n

.meas tran vdout0_52ck1410 FIND v(dout0_52) AT=710.025n

.meas tran vdout0_53ck1410 FIND v(dout0_53) AT=710.025n

.meas tran vdout0_54ck1410 FIND v(dout0_54) AT=710.025n

.meas tran vdout0_55ck1410 FIND v(dout0_55) AT=710.025n

.meas tran vdout0_56ck1410 FIND v(dout0_56) AT=710.025n

.meas tran vdout0_57ck1410 FIND v(dout0_57) AT=710.025n

.meas tran vdout0_58ck1410 FIND v(dout0_58) AT=710.025n

.meas tran vdout0_59ck1410 FIND v(dout0_59) AT=710.025n

.meas tran vdout0_60ck1410 FIND v(dout0_60) AT=710.025n

.meas tran vdout0_61ck1410 FIND v(dout0_61) AT=710.025n

.meas tran vdout0_62ck1410 FIND v(dout0_62) AT=710.025n

.meas tran vdout0_63ck1410 FIND v(dout0_63) AT=710.025n

.meas tran vdout0_64ck1410 FIND v(dout0_64) AT=710.025n

.meas tran vdout0_65ck1410 FIND v(dout0_65) AT=710.025n

.meas tran vdout0_66ck1410 FIND v(dout0_66) AT=710.025n

.meas tran vdout0_67ck1410 FIND v(dout0_67) AT=710.025n

.meas tran vdout0_68ck1410 FIND v(dout0_68) AT=710.025n

.meas tran vdout0_69ck1410 FIND v(dout0_69) AT=710.025n

.meas tran vdout0_70ck1410 FIND v(dout0_70) AT=710.025n

.meas tran vdout0_71ck1410 FIND v(dout0_71) AT=710.025n

.meas tran vdout0_72ck1410 FIND v(dout0_72) AT=710.025n

.meas tran vdout0_73ck1410 FIND v(dout0_73) AT=710.025n

.meas tran vdout0_74ck1410 FIND v(dout0_74) AT=710.025n

.meas tran vdout0_75ck1410 FIND v(dout0_75) AT=710.025n

.meas tran vdout0_76ck1410 FIND v(dout0_76) AT=710.025n

.meas tran vdout0_77ck1410 FIND v(dout0_77) AT=710.025n

.meas tran vdout0_78ck1410 FIND v(dout0_78) AT=710.025n

.meas tran vdout0_79ck1410 FIND v(dout0_79) AT=710.025n

.meas tran vdout0_80ck1410 FIND v(dout0_80) AT=710.025n

.meas tran vdout0_81ck1410 FIND v(dout0_81) AT=710.025n

.meas tran vdout0_82ck1410 FIND v(dout0_82) AT=710.025n

.meas tran vdout0_83ck1410 FIND v(dout0_83) AT=710.025n

.meas tran vdout0_84ck1410 FIND v(dout0_84) AT=710.025n

.meas tran vdout0_85ck1410 FIND v(dout0_85) AT=710.025n

.meas tran vdout0_86ck1410 FIND v(dout0_86) AT=710.025n

.meas tran vdout0_87ck1410 FIND v(dout0_87) AT=710.025n

.meas tran vdout0_88ck1410 FIND v(dout0_88) AT=710.025n

.meas tran vdout0_89ck1410 FIND v(dout0_89) AT=710.025n

.meas tran vdout0_90ck1410 FIND v(dout0_90) AT=710.025n

.meas tran vdout0_91ck1410 FIND v(dout0_91) AT=710.025n

.meas tran vdout0_92ck1410 FIND v(dout0_92) AT=710.025n

.meas tran vdout0_93ck1410 FIND v(dout0_93) AT=710.025n

.meas tran vdout0_94ck1410 FIND v(dout0_94) AT=710.025n

.meas tran vdout0_95ck1410 FIND v(dout0_95) AT=710.025n

.meas tran vdout0_96ck1410 FIND v(dout0_96) AT=710.025n

.meas tran vdout0_97ck1410 FIND v(dout0_97) AT=710.025n

.meas tran vdout0_98ck1410 FIND v(dout0_98) AT=710.025n

.meas tran vdout0_99ck1410 FIND v(dout0_99) AT=710.025n

.meas tran vdout0_100ck1410 FIND v(dout0_100) AT=710.025n

.meas tran vdout0_101ck1410 FIND v(dout0_101) AT=710.025n

.meas tran vdout0_102ck1410 FIND v(dout0_102) AT=710.025n

.meas tran vdout0_103ck1410 FIND v(dout0_103) AT=710.025n

.meas tran vdout0_104ck1410 FIND v(dout0_104) AT=710.025n

.meas tran vdout0_105ck1410 FIND v(dout0_105) AT=710.025n

.meas tran vdout0_106ck1410 FIND v(dout0_106) AT=710.025n

.meas tran vdout0_107ck1410 FIND v(dout0_107) AT=710.025n

.meas tran vdout0_108ck1410 FIND v(dout0_108) AT=710.025n

.meas tran vdout0_109ck1410 FIND v(dout0_109) AT=710.025n

.meas tran vdout0_110ck1410 FIND v(dout0_110) AT=710.025n

.meas tran vdout0_111ck1410 FIND v(dout0_111) AT=710.025n

.meas tran vdout0_112ck1410 FIND v(dout0_112) AT=710.025n

.meas tran vdout0_113ck1410 FIND v(dout0_113) AT=710.025n

.meas tran vdout0_114ck1410 FIND v(dout0_114) AT=710.025n

.meas tran vdout0_115ck1410 FIND v(dout0_115) AT=710.025n

.meas tran vdout0_116ck1410 FIND v(dout0_116) AT=710.025n

.meas tran vdout0_117ck1410 FIND v(dout0_117) AT=710.025n

.meas tran vdout0_118ck1410 FIND v(dout0_118) AT=710.025n

.meas tran vdout0_119ck1410 FIND v(dout0_119) AT=710.025n

.meas tran vdout0_120ck1410 FIND v(dout0_120) AT=710.025n

.meas tran vdout0_121ck1410 FIND v(dout0_121) AT=710.025n

.meas tran vdout0_122ck1410 FIND v(dout0_122) AT=710.025n

.meas tran vdout0_123ck1410 FIND v(dout0_123) AT=710.025n

.meas tran vdout0_124ck1410 FIND v(dout0_124) AT=710.025n

.meas tran vdout0_125ck1410 FIND v(dout0_125) AT=710.025n

.meas tran vdout0_126ck1410 FIND v(dout0_126) AT=710.025n

.meas tran vdout0_127ck1410 FIND v(dout0_127) AT=710.025n

.meas tran vdout0_128ck1410 FIND v(dout0_128) AT=710.025n

.meas tran vdout0_129ck1410 FIND v(dout0_129) AT=710.025n

.meas tran vdout0_130ck1410 FIND v(dout0_130) AT=710.025n

.meas tran vdout0_131ck1410 FIND v(dout0_131) AT=710.025n

.meas tran vdout0_132ck1410 FIND v(dout0_132) AT=710.025n

.meas tran vdout0_133ck1410 FIND v(dout0_133) AT=710.025n

.meas tran vdout0_134ck1410 FIND v(dout0_134) AT=710.025n

.meas tran vdout0_135ck1410 FIND v(dout0_135) AT=710.025n

.meas tran vdout0_136ck1410 FIND v(dout0_136) AT=710.025n

.meas tran vdout0_137ck1410 FIND v(dout0_137) AT=710.025n

.meas tran vdout0_138ck1410 FIND v(dout0_138) AT=710.025n

.meas tran vdout0_139ck1410 FIND v(dout0_139) AT=710.025n

.meas tran vdout0_140ck1410 FIND v(dout0_140) AT=710.025n

.meas tran vdout0_141ck1410 FIND v(dout0_141) AT=710.025n

.meas tran vdout0_142ck1410 FIND v(dout0_142) AT=710.025n

.meas tran vdout0_143ck1410 FIND v(dout0_143) AT=710.025n

.meas tran vdout0_144ck1410 FIND v(dout0_144) AT=710.025n

.meas tran vdout0_145ck1410 FIND v(dout0_145) AT=710.025n

.meas tran vdout0_146ck1410 FIND v(dout0_146) AT=710.025n

.meas tran vdout0_147ck1410 FIND v(dout0_147) AT=710.025n

.meas tran vdout0_148ck1410 FIND v(dout0_148) AT=710.025n

.meas tran vdout0_149ck1410 FIND v(dout0_149) AT=710.025n

.meas tran vdout0_150ck1410 FIND v(dout0_150) AT=710.025n

.meas tran vdout0_151ck1410 FIND v(dout0_151) AT=710.025n

.meas tran vdout0_152ck1410 FIND v(dout0_152) AT=710.025n

.meas tran vdout0_153ck1410 FIND v(dout0_153) AT=710.025n

.meas tran vdout0_154ck1410 FIND v(dout0_154) AT=710.025n

.meas tran vdout0_155ck1410 FIND v(dout0_155) AT=710.025n

.meas tran vdout0_156ck1410 FIND v(dout0_156) AT=710.025n

.meas tran vdout0_157ck1410 FIND v(dout0_157) AT=710.025n

.meas tran vdout0_158ck1410 FIND v(dout0_158) AT=710.025n

.meas tran vdout0_159ck1410 FIND v(dout0_159) AT=710.025n

.meas tran vdout0_160ck1410 FIND v(dout0_160) AT=710.025n

.meas tran vdout0_161ck1410 FIND v(dout0_161) AT=710.025n

.meas tran vdout0_162ck1410 FIND v(dout0_162) AT=710.025n

.meas tran vdout0_163ck1410 FIND v(dout0_163) AT=710.025n

.meas tran vdout0_164ck1410 FIND v(dout0_164) AT=710.025n

.meas tran vdout0_165ck1410 FIND v(dout0_165) AT=710.025n

.meas tran vdout0_166ck1410 FIND v(dout0_166) AT=710.025n

.meas tran vdout0_167ck1410 FIND v(dout0_167) AT=710.025n

.meas tran vdout0_168ck1410 FIND v(dout0_168) AT=710.025n

.meas tran vdout0_169ck1410 FIND v(dout0_169) AT=710.025n

.meas tran vdout0_170ck1410 FIND v(dout0_170) AT=710.025n

.meas tran vdout0_171ck1410 FIND v(dout0_171) AT=710.025n

.meas tran vdout0_172ck1410 FIND v(dout0_172) AT=710.025n

.meas tran vdout0_173ck1410 FIND v(dout0_173) AT=710.025n

.meas tran vdout0_174ck1410 FIND v(dout0_174) AT=710.025n

.meas tran vdout0_175ck1410 FIND v(dout0_175) AT=710.025n

.meas tran vdout0_176ck1410 FIND v(dout0_176) AT=710.025n

.meas tran vdout0_177ck1410 FIND v(dout0_177) AT=710.025n

.meas tran vdout0_178ck1410 FIND v(dout0_178) AT=710.025n

.meas tran vdout0_179ck1410 FIND v(dout0_179) AT=710.025n

.meas tran vdout0_180ck1410 FIND v(dout0_180) AT=710.025n

.meas tran vdout0_181ck1410 FIND v(dout0_181) AT=710.025n

.meas tran vdout0_182ck1410 FIND v(dout0_182) AT=710.025n

.meas tran vdout0_183ck1410 FIND v(dout0_183) AT=710.025n

.meas tran vdout0_184ck1410 FIND v(dout0_184) AT=710.025n

.meas tran vdout0_185ck1410 FIND v(dout0_185) AT=710.025n

.meas tran vdout0_186ck1410 FIND v(dout0_186) AT=710.025n

.meas tran vdout0_187ck1410 FIND v(dout0_187) AT=710.025n

.meas tran vdout0_188ck1410 FIND v(dout0_188) AT=710.025n

.meas tran vdout0_189ck1410 FIND v(dout0_189) AT=710.025n

.meas tran vdout0_190ck1410 FIND v(dout0_190) AT=710.025n

.meas tran vdout0_191ck1410 FIND v(dout0_191) AT=710.025n

.meas tran vdout0_192ck1410 FIND v(dout0_192) AT=710.025n

.meas tran vdout0_193ck1410 FIND v(dout0_193) AT=710.025n

.meas tran vdout0_194ck1410 FIND v(dout0_194) AT=710.025n

.meas tran vdout0_195ck1410 FIND v(dout0_195) AT=710.025n

.meas tran vdout0_196ck1410 FIND v(dout0_196) AT=710.025n

.meas tran vdout0_197ck1410 FIND v(dout0_197) AT=710.025n

.meas tran vdout0_198ck1410 FIND v(dout0_198) AT=710.025n

.meas tran vdout0_199ck1410 FIND v(dout0_199) AT=710.025n

.meas tran vdout0_200ck1410 FIND v(dout0_200) AT=710.025n

.meas tran vdout0_201ck1410 FIND v(dout0_201) AT=710.025n

.meas tran vdout0_202ck1410 FIND v(dout0_202) AT=710.025n

.meas tran vdout0_203ck1410 FIND v(dout0_203) AT=710.025n

.meas tran vdout0_204ck1410 FIND v(dout0_204) AT=710.025n

.meas tran vdout0_205ck1410 FIND v(dout0_205) AT=710.025n

.meas tran vdout0_206ck1410 FIND v(dout0_206) AT=710.025n

.meas tran vdout0_207ck1410 FIND v(dout0_207) AT=710.025n

.meas tran vdout0_208ck1410 FIND v(dout0_208) AT=710.025n

.meas tran vdout0_209ck1410 FIND v(dout0_209) AT=710.025n

.meas tran vdout0_210ck1410 FIND v(dout0_210) AT=710.025n

.meas tran vdout0_211ck1410 FIND v(dout0_211) AT=710.025n

.meas tran vdout0_212ck1410 FIND v(dout0_212) AT=710.025n

.meas tran vdout0_213ck1410 FIND v(dout0_213) AT=710.025n

.meas tran vdout0_214ck1410 FIND v(dout0_214) AT=710.025n

.meas tran vdout0_215ck1410 FIND v(dout0_215) AT=710.025n

.meas tran vdout0_216ck1410 FIND v(dout0_216) AT=710.025n

.meas tran vdout0_217ck1410 FIND v(dout0_217) AT=710.025n

.meas tran vdout0_218ck1410 FIND v(dout0_218) AT=710.025n

.meas tran vdout0_219ck1410 FIND v(dout0_219) AT=710.025n

.meas tran vdout0_220ck1410 FIND v(dout0_220) AT=710.025n

.meas tran vdout0_221ck1410 FIND v(dout0_221) AT=710.025n

.meas tran vdout0_222ck1410 FIND v(dout0_222) AT=710.025n

.meas tran vdout0_223ck1410 FIND v(dout0_223) AT=710.025n

.meas tran vdout0_224ck1410 FIND v(dout0_224) AT=710.025n

.meas tran vdout0_225ck1410 FIND v(dout0_225) AT=710.025n

.meas tran vdout0_226ck1410 FIND v(dout0_226) AT=710.025n

.meas tran vdout0_227ck1410 FIND v(dout0_227) AT=710.025n

.meas tran vdout0_228ck1410 FIND v(dout0_228) AT=710.025n

.meas tran vdout0_229ck1410 FIND v(dout0_229) AT=710.025n

.meas tran vdout0_230ck1410 FIND v(dout0_230) AT=710.025n

.meas tran vdout0_231ck1410 FIND v(dout0_231) AT=710.025n

.meas tran vdout0_232ck1410 FIND v(dout0_232) AT=710.025n

.meas tran vdout0_233ck1410 FIND v(dout0_233) AT=710.025n

.meas tran vdout0_234ck1410 FIND v(dout0_234) AT=710.025n

.meas tran vdout0_235ck1410 FIND v(dout0_235) AT=710.025n

.meas tran vdout0_236ck1410 FIND v(dout0_236) AT=710.025n

.meas tran vdout0_237ck1410 FIND v(dout0_237) AT=710.025n

.meas tran vdout0_238ck1410 FIND v(dout0_238) AT=710.025n

.meas tran vdout0_239ck1410 FIND v(dout0_239) AT=710.025n

.meas tran vdout0_240ck1410 FIND v(dout0_240) AT=710.025n

.meas tran vdout0_241ck1410 FIND v(dout0_241) AT=710.025n

.meas tran vdout0_242ck1410 FIND v(dout0_242) AT=710.025n

.meas tran vdout0_243ck1410 FIND v(dout0_243) AT=710.025n

.meas tran vdout0_244ck1410 FIND v(dout0_244) AT=710.025n

.meas tran vdout0_245ck1410 FIND v(dout0_245) AT=710.025n

.meas tran vdout0_246ck1410 FIND v(dout0_246) AT=710.025n

.meas tran vdout0_247ck1410 FIND v(dout0_247) AT=710.025n

.meas tran vdout0_248ck1410 FIND v(dout0_248) AT=710.025n

.meas tran vdout0_249ck1410 FIND v(dout0_249) AT=710.025n

.meas tran vdout0_250ck1410 FIND v(dout0_250) AT=710.025n

.meas tran vdout0_251ck1410 FIND v(dout0_251) AT=710.025n

.meas tran vdout0_252ck1410 FIND v(dout0_252) AT=710.025n

.meas tran vdout0_253ck1410 FIND v(dout0_253) AT=710.025n

.meas tran vdout0_254ck1410 FIND v(dout0_254) AT=710.025n

.meas tran vdout0_255ck1410 FIND v(dout0_255) AT=710.025n

.meas tran vdout0_0ck1550 FIND v(dout0_0) AT=780.025n

.meas tran vdout0_1ck1550 FIND v(dout0_1) AT=780.025n

.meas tran vdout0_2ck1550 FIND v(dout0_2) AT=780.025n

.meas tran vdout0_3ck1550 FIND v(dout0_3) AT=780.025n

.meas tran vdout0_4ck1550 FIND v(dout0_4) AT=780.025n

.meas tran vdout0_5ck1550 FIND v(dout0_5) AT=780.025n

.meas tran vdout0_6ck1550 FIND v(dout0_6) AT=780.025n

.meas tran vdout0_7ck1550 FIND v(dout0_7) AT=780.025n

.meas tran vdout0_8ck1550 FIND v(dout0_8) AT=780.025n

.meas tran vdout0_9ck1550 FIND v(dout0_9) AT=780.025n

.meas tran vdout0_10ck1550 FIND v(dout0_10) AT=780.025n

.meas tran vdout0_11ck1550 FIND v(dout0_11) AT=780.025n

.meas tran vdout0_12ck1550 FIND v(dout0_12) AT=780.025n

.meas tran vdout0_13ck1550 FIND v(dout0_13) AT=780.025n

.meas tran vdout0_14ck1550 FIND v(dout0_14) AT=780.025n

.meas tran vdout0_15ck1550 FIND v(dout0_15) AT=780.025n

.meas tran vdout0_16ck1550 FIND v(dout0_16) AT=780.025n

.meas tran vdout0_17ck1550 FIND v(dout0_17) AT=780.025n

.meas tran vdout0_18ck1550 FIND v(dout0_18) AT=780.025n

.meas tran vdout0_19ck1550 FIND v(dout0_19) AT=780.025n

.meas tran vdout0_20ck1550 FIND v(dout0_20) AT=780.025n

.meas tran vdout0_21ck1550 FIND v(dout0_21) AT=780.025n

.meas tran vdout0_22ck1550 FIND v(dout0_22) AT=780.025n

.meas tran vdout0_23ck1550 FIND v(dout0_23) AT=780.025n

.meas tran vdout0_24ck1550 FIND v(dout0_24) AT=780.025n

.meas tran vdout0_25ck1550 FIND v(dout0_25) AT=780.025n

.meas tran vdout0_26ck1550 FIND v(dout0_26) AT=780.025n

.meas tran vdout0_27ck1550 FIND v(dout0_27) AT=780.025n

.meas tran vdout0_28ck1550 FIND v(dout0_28) AT=780.025n

.meas tran vdout0_29ck1550 FIND v(dout0_29) AT=780.025n

.meas tran vdout0_30ck1550 FIND v(dout0_30) AT=780.025n

.meas tran vdout0_31ck1550 FIND v(dout0_31) AT=780.025n

.meas tran vdout0_32ck1550 FIND v(dout0_32) AT=780.025n

.meas tran vdout0_33ck1550 FIND v(dout0_33) AT=780.025n

.meas tran vdout0_34ck1550 FIND v(dout0_34) AT=780.025n

.meas tran vdout0_35ck1550 FIND v(dout0_35) AT=780.025n

.meas tran vdout0_36ck1550 FIND v(dout0_36) AT=780.025n

.meas tran vdout0_37ck1550 FIND v(dout0_37) AT=780.025n

.meas tran vdout0_38ck1550 FIND v(dout0_38) AT=780.025n

.meas tran vdout0_39ck1550 FIND v(dout0_39) AT=780.025n

.meas tran vdout0_40ck1550 FIND v(dout0_40) AT=780.025n

.meas tran vdout0_41ck1550 FIND v(dout0_41) AT=780.025n

.meas tran vdout0_42ck1550 FIND v(dout0_42) AT=780.025n

.meas tran vdout0_43ck1550 FIND v(dout0_43) AT=780.025n

.meas tran vdout0_44ck1550 FIND v(dout0_44) AT=780.025n

.meas tran vdout0_45ck1550 FIND v(dout0_45) AT=780.025n

.meas tran vdout0_46ck1550 FIND v(dout0_46) AT=780.025n

.meas tran vdout0_47ck1550 FIND v(dout0_47) AT=780.025n

.meas tran vdout0_48ck1550 FIND v(dout0_48) AT=780.025n

.meas tran vdout0_49ck1550 FIND v(dout0_49) AT=780.025n

.meas tran vdout0_50ck1550 FIND v(dout0_50) AT=780.025n

.meas tran vdout0_51ck1550 FIND v(dout0_51) AT=780.025n

.meas tran vdout0_52ck1550 FIND v(dout0_52) AT=780.025n

.meas tran vdout0_53ck1550 FIND v(dout0_53) AT=780.025n

.meas tran vdout0_54ck1550 FIND v(dout0_54) AT=780.025n

.meas tran vdout0_55ck1550 FIND v(dout0_55) AT=780.025n

.meas tran vdout0_56ck1550 FIND v(dout0_56) AT=780.025n

.meas tran vdout0_57ck1550 FIND v(dout0_57) AT=780.025n

.meas tran vdout0_58ck1550 FIND v(dout0_58) AT=780.025n

.meas tran vdout0_59ck1550 FIND v(dout0_59) AT=780.025n

.meas tran vdout0_60ck1550 FIND v(dout0_60) AT=780.025n

.meas tran vdout0_61ck1550 FIND v(dout0_61) AT=780.025n

.meas tran vdout0_62ck1550 FIND v(dout0_62) AT=780.025n

.meas tran vdout0_63ck1550 FIND v(dout0_63) AT=780.025n

.meas tran vdout0_64ck1550 FIND v(dout0_64) AT=780.025n

.meas tran vdout0_65ck1550 FIND v(dout0_65) AT=780.025n

.meas tran vdout0_66ck1550 FIND v(dout0_66) AT=780.025n

.meas tran vdout0_67ck1550 FIND v(dout0_67) AT=780.025n

.meas tran vdout0_68ck1550 FIND v(dout0_68) AT=780.025n

.meas tran vdout0_69ck1550 FIND v(dout0_69) AT=780.025n

.meas tran vdout0_70ck1550 FIND v(dout0_70) AT=780.025n

.meas tran vdout0_71ck1550 FIND v(dout0_71) AT=780.025n

.meas tran vdout0_72ck1550 FIND v(dout0_72) AT=780.025n

.meas tran vdout0_73ck1550 FIND v(dout0_73) AT=780.025n

.meas tran vdout0_74ck1550 FIND v(dout0_74) AT=780.025n

.meas tran vdout0_75ck1550 FIND v(dout0_75) AT=780.025n

.meas tran vdout0_76ck1550 FIND v(dout0_76) AT=780.025n

.meas tran vdout0_77ck1550 FIND v(dout0_77) AT=780.025n

.meas tran vdout0_78ck1550 FIND v(dout0_78) AT=780.025n

.meas tran vdout0_79ck1550 FIND v(dout0_79) AT=780.025n

.meas tran vdout0_80ck1550 FIND v(dout0_80) AT=780.025n

.meas tran vdout0_81ck1550 FIND v(dout0_81) AT=780.025n

.meas tran vdout0_82ck1550 FIND v(dout0_82) AT=780.025n

.meas tran vdout0_83ck1550 FIND v(dout0_83) AT=780.025n

.meas tran vdout0_84ck1550 FIND v(dout0_84) AT=780.025n

.meas tran vdout0_85ck1550 FIND v(dout0_85) AT=780.025n

.meas tran vdout0_86ck1550 FIND v(dout0_86) AT=780.025n

.meas tran vdout0_87ck1550 FIND v(dout0_87) AT=780.025n

.meas tran vdout0_88ck1550 FIND v(dout0_88) AT=780.025n

.meas tran vdout0_89ck1550 FIND v(dout0_89) AT=780.025n

.meas tran vdout0_90ck1550 FIND v(dout0_90) AT=780.025n

.meas tran vdout0_91ck1550 FIND v(dout0_91) AT=780.025n

.meas tran vdout0_92ck1550 FIND v(dout0_92) AT=780.025n

.meas tran vdout0_93ck1550 FIND v(dout0_93) AT=780.025n

.meas tran vdout0_94ck1550 FIND v(dout0_94) AT=780.025n

.meas tran vdout0_95ck1550 FIND v(dout0_95) AT=780.025n

.meas tran vdout0_96ck1550 FIND v(dout0_96) AT=780.025n

.meas tran vdout0_97ck1550 FIND v(dout0_97) AT=780.025n

.meas tran vdout0_98ck1550 FIND v(dout0_98) AT=780.025n

.meas tran vdout0_99ck1550 FIND v(dout0_99) AT=780.025n

.meas tran vdout0_100ck1550 FIND v(dout0_100) AT=780.025n

.meas tran vdout0_101ck1550 FIND v(dout0_101) AT=780.025n

.meas tran vdout0_102ck1550 FIND v(dout0_102) AT=780.025n

.meas tran vdout0_103ck1550 FIND v(dout0_103) AT=780.025n

.meas tran vdout0_104ck1550 FIND v(dout0_104) AT=780.025n

.meas tran vdout0_105ck1550 FIND v(dout0_105) AT=780.025n

.meas tran vdout0_106ck1550 FIND v(dout0_106) AT=780.025n

.meas tran vdout0_107ck1550 FIND v(dout0_107) AT=780.025n

.meas tran vdout0_108ck1550 FIND v(dout0_108) AT=780.025n

.meas tran vdout0_109ck1550 FIND v(dout0_109) AT=780.025n

.meas tran vdout0_110ck1550 FIND v(dout0_110) AT=780.025n

.meas tran vdout0_111ck1550 FIND v(dout0_111) AT=780.025n

.meas tran vdout0_112ck1550 FIND v(dout0_112) AT=780.025n

.meas tran vdout0_113ck1550 FIND v(dout0_113) AT=780.025n

.meas tran vdout0_114ck1550 FIND v(dout0_114) AT=780.025n

.meas tran vdout0_115ck1550 FIND v(dout0_115) AT=780.025n

.meas tran vdout0_116ck1550 FIND v(dout0_116) AT=780.025n

.meas tran vdout0_117ck1550 FIND v(dout0_117) AT=780.025n

.meas tran vdout0_118ck1550 FIND v(dout0_118) AT=780.025n

.meas tran vdout0_119ck1550 FIND v(dout0_119) AT=780.025n

.meas tran vdout0_120ck1550 FIND v(dout0_120) AT=780.025n

.meas tran vdout0_121ck1550 FIND v(dout0_121) AT=780.025n

.meas tran vdout0_122ck1550 FIND v(dout0_122) AT=780.025n

.meas tran vdout0_123ck1550 FIND v(dout0_123) AT=780.025n

.meas tran vdout0_124ck1550 FIND v(dout0_124) AT=780.025n

.meas tran vdout0_125ck1550 FIND v(dout0_125) AT=780.025n

.meas tran vdout0_126ck1550 FIND v(dout0_126) AT=780.025n

.meas tran vdout0_127ck1550 FIND v(dout0_127) AT=780.025n

.meas tran vdout0_128ck1550 FIND v(dout0_128) AT=780.025n

.meas tran vdout0_129ck1550 FIND v(dout0_129) AT=780.025n

.meas tran vdout0_130ck1550 FIND v(dout0_130) AT=780.025n

.meas tran vdout0_131ck1550 FIND v(dout0_131) AT=780.025n

.meas tran vdout0_132ck1550 FIND v(dout0_132) AT=780.025n

.meas tran vdout0_133ck1550 FIND v(dout0_133) AT=780.025n

.meas tran vdout0_134ck1550 FIND v(dout0_134) AT=780.025n

.meas tran vdout0_135ck1550 FIND v(dout0_135) AT=780.025n

.meas tran vdout0_136ck1550 FIND v(dout0_136) AT=780.025n

.meas tran vdout0_137ck1550 FIND v(dout0_137) AT=780.025n

.meas tran vdout0_138ck1550 FIND v(dout0_138) AT=780.025n

.meas tran vdout0_139ck1550 FIND v(dout0_139) AT=780.025n

.meas tran vdout0_140ck1550 FIND v(dout0_140) AT=780.025n

.meas tran vdout0_141ck1550 FIND v(dout0_141) AT=780.025n

.meas tran vdout0_142ck1550 FIND v(dout0_142) AT=780.025n

.meas tran vdout0_143ck1550 FIND v(dout0_143) AT=780.025n

.meas tran vdout0_144ck1550 FIND v(dout0_144) AT=780.025n

.meas tran vdout0_145ck1550 FIND v(dout0_145) AT=780.025n

.meas tran vdout0_146ck1550 FIND v(dout0_146) AT=780.025n

.meas tran vdout0_147ck1550 FIND v(dout0_147) AT=780.025n

.meas tran vdout0_148ck1550 FIND v(dout0_148) AT=780.025n

.meas tran vdout0_149ck1550 FIND v(dout0_149) AT=780.025n

.meas tran vdout0_150ck1550 FIND v(dout0_150) AT=780.025n

.meas tran vdout0_151ck1550 FIND v(dout0_151) AT=780.025n

.meas tran vdout0_152ck1550 FIND v(dout0_152) AT=780.025n

.meas tran vdout0_153ck1550 FIND v(dout0_153) AT=780.025n

.meas tran vdout0_154ck1550 FIND v(dout0_154) AT=780.025n

.meas tran vdout0_155ck1550 FIND v(dout0_155) AT=780.025n

.meas tran vdout0_156ck1550 FIND v(dout0_156) AT=780.025n

.meas tran vdout0_157ck1550 FIND v(dout0_157) AT=780.025n

.meas tran vdout0_158ck1550 FIND v(dout0_158) AT=780.025n

.meas tran vdout0_159ck1550 FIND v(dout0_159) AT=780.025n

.meas tran vdout0_160ck1550 FIND v(dout0_160) AT=780.025n

.meas tran vdout0_161ck1550 FIND v(dout0_161) AT=780.025n

.meas tran vdout0_162ck1550 FIND v(dout0_162) AT=780.025n

.meas tran vdout0_163ck1550 FIND v(dout0_163) AT=780.025n

.meas tran vdout0_164ck1550 FIND v(dout0_164) AT=780.025n

.meas tran vdout0_165ck1550 FIND v(dout0_165) AT=780.025n

.meas tran vdout0_166ck1550 FIND v(dout0_166) AT=780.025n

.meas tran vdout0_167ck1550 FIND v(dout0_167) AT=780.025n

.meas tran vdout0_168ck1550 FIND v(dout0_168) AT=780.025n

.meas tran vdout0_169ck1550 FIND v(dout0_169) AT=780.025n

.meas tran vdout0_170ck1550 FIND v(dout0_170) AT=780.025n

.meas tran vdout0_171ck1550 FIND v(dout0_171) AT=780.025n

.meas tran vdout0_172ck1550 FIND v(dout0_172) AT=780.025n

.meas tran vdout0_173ck1550 FIND v(dout0_173) AT=780.025n

.meas tran vdout0_174ck1550 FIND v(dout0_174) AT=780.025n

.meas tran vdout0_175ck1550 FIND v(dout0_175) AT=780.025n

.meas tran vdout0_176ck1550 FIND v(dout0_176) AT=780.025n

.meas tran vdout0_177ck1550 FIND v(dout0_177) AT=780.025n

.meas tran vdout0_178ck1550 FIND v(dout0_178) AT=780.025n

.meas tran vdout0_179ck1550 FIND v(dout0_179) AT=780.025n

.meas tran vdout0_180ck1550 FIND v(dout0_180) AT=780.025n

.meas tran vdout0_181ck1550 FIND v(dout0_181) AT=780.025n

.meas tran vdout0_182ck1550 FIND v(dout0_182) AT=780.025n

.meas tran vdout0_183ck1550 FIND v(dout0_183) AT=780.025n

.meas tran vdout0_184ck1550 FIND v(dout0_184) AT=780.025n

.meas tran vdout0_185ck1550 FIND v(dout0_185) AT=780.025n

.meas tran vdout0_186ck1550 FIND v(dout0_186) AT=780.025n

.meas tran vdout0_187ck1550 FIND v(dout0_187) AT=780.025n

.meas tran vdout0_188ck1550 FIND v(dout0_188) AT=780.025n

.meas tran vdout0_189ck1550 FIND v(dout0_189) AT=780.025n

.meas tran vdout0_190ck1550 FIND v(dout0_190) AT=780.025n

.meas tran vdout0_191ck1550 FIND v(dout0_191) AT=780.025n

.meas tran vdout0_192ck1550 FIND v(dout0_192) AT=780.025n

.meas tran vdout0_193ck1550 FIND v(dout0_193) AT=780.025n

.meas tran vdout0_194ck1550 FIND v(dout0_194) AT=780.025n

.meas tran vdout0_195ck1550 FIND v(dout0_195) AT=780.025n

.meas tran vdout0_196ck1550 FIND v(dout0_196) AT=780.025n

.meas tran vdout0_197ck1550 FIND v(dout0_197) AT=780.025n

.meas tran vdout0_198ck1550 FIND v(dout0_198) AT=780.025n

.meas tran vdout0_199ck1550 FIND v(dout0_199) AT=780.025n

.meas tran vdout0_200ck1550 FIND v(dout0_200) AT=780.025n

.meas tran vdout0_201ck1550 FIND v(dout0_201) AT=780.025n

.meas tran vdout0_202ck1550 FIND v(dout0_202) AT=780.025n

.meas tran vdout0_203ck1550 FIND v(dout0_203) AT=780.025n

.meas tran vdout0_204ck1550 FIND v(dout0_204) AT=780.025n

.meas tran vdout0_205ck1550 FIND v(dout0_205) AT=780.025n

.meas tran vdout0_206ck1550 FIND v(dout0_206) AT=780.025n

.meas tran vdout0_207ck1550 FIND v(dout0_207) AT=780.025n

.meas tran vdout0_208ck1550 FIND v(dout0_208) AT=780.025n

.meas tran vdout0_209ck1550 FIND v(dout0_209) AT=780.025n

.meas tran vdout0_210ck1550 FIND v(dout0_210) AT=780.025n

.meas tran vdout0_211ck1550 FIND v(dout0_211) AT=780.025n

.meas tran vdout0_212ck1550 FIND v(dout0_212) AT=780.025n

.meas tran vdout0_213ck1550 FIND v(dout0_213) AT=780.025n

.meas tran vdout0_214ck1550 FIND v(dout0_214) AT=780.025n

.meas tran vdout0_215ck1550 FIND v(dout0_215) AT=780.025n

.meas tran vdout0_216ck1550 FIND v(dout0_216) AT=780.025n

.meas tran vdout0_217ck1550 FIND v(dout0_217) AT=780.025n

.meas tran vdout0_218ck1550 FIND v(dout0_218) AT=780.025n

.meas tran vdout0_219ck1550 FIND v(dout0_219) AT=780.025n

.meas tran vdout0_220ck1550 FIND v(dout0_220) AT=780.025n

.meas tran vdout0_221ck1550 FIND v(dout0_221) AT=780.025n

.meas tran vdout0_222ck1550 FIND v(dout0_222) AT=780.025n

.meas tran vdout0_223ck1550 FIND v(dout0_223) AT=780.025n

.meas tran vdout0_224ck1550 FIND v(dout0_224) AT=780.025n

.meas tran vdout0_225ck1550 FIND v(dout0_225) AT=780.025n

.meas tran vdout0_226ck1550 FIND v(dout0_226) AT=780.025n

.meas tran vdout0_227ck1550 FIND v(dout0_227) AT=780.025n

.meas tran vdout0_228ck1550 FIND v(dout0_228) AT=780.025n

.meas tran vdout0_229ck1550 FIND v(dout0_229) AT=780.025n

.meas tran vdout0_230ck1550 FIND v(dout0_230) AT=780.025n

.meas tran vdout0_231ck1550 FIND v(dout0_231) AT=780.025n

.meas tran vdout0_232ck1550 FIND v(dout0_232) AT=780.025n

.meas tran vdout0_233ck1550 FIND v(dout0_233) AT=780.025n

.meas tran vdout0_234ck1550 FIND v(dout0_234) AT=780.025n

.meas tran vdout0_235ck1550 FIND v(dout0_235) AT=780.025n

.meas tran vdout0_236ck1550 FIND v(dout0_236) AT=780.025n

.meas tran vdout0_237ck1550 FIND v(dout0_237) AT=780.025n

.meas tran vdout0_238ck1550 FIND v(dout0_238) AT=780.025n

.meas tran vdout0_239ck1550 FIND v(dout0_239) AT=780.025n

.meas tran vdout0_240ck1550 FIND v(dout0_240) AT=780.025n

.meas tran vdout0_241ck1550 FIND v(dout0_241) AT=780.025n

.meas tran vdout0_242ck1550 FIND v(dout0_242) AT=780.025n

.meas tran vdout0_243ck1550 FIND v(dout0_243) AT=780.025n

.meas tran vdout0_244ck1550 FIND v(dout0_244) AT=780.025n

.meas tran vdout0_245ck1550 FIND v(dout0_245) AT=780.025n

.meas tran vdout0_246ck1550 FIND v(dout0_246) AT=780.025n

.meas tran vdout0_247ck1550 FIND v(dout0_247) AT=780.025n

.meas tran vdout0_248ck1550 FIND v(dout0_248) AT=780.025n

.meas tran vdout0_249ck1550 FIND v(dout0_249) AT=780.025n

.meas tran vdout0_250ck1550 FIND v(dout0_250) AT=780.025n

.meas tran vdout0_251ck1550 FIND v(dout0_251) AT=780.025n

.meas tran vdout0_252ck1550 FIND v(dout0_252) AT=780.025n

.meas tran vdout0_253ck1550 FIND v(dout0_253) AT=780.025n

.meas tran vdout0_254ck1550 FIND v(dout0_254) AT=780.025n

.meas tran vdout0_255ck1550 FIND v(dout0_255) AT=780.025n

.meas tran vdout0_0ck1620 FIND v(dout0_0) AT=815.025n

.meas tran vdout0_1ck1620 FIND v(dout0_1) AT=815.025n

.meas tran vdout0_2ck1620 FIND v(dout0_2) AT=815.025n

.meas tran vdout0_3ck1620 FIND v(dout0_3) AT=815.025n

.meas tran vdout0_4ck1620 FIND v(dout0_4) AT=815.025n

.meas tran vdout0_5ck1620 FIND v(dout0_5) AT=815.025n

.meas tran vdout0_6ck1620 FIND v(dout0_6) AT=815.025n

.meas tran vdout0_7ck1620 FIND v(dout0_7) AT=815.025n

.meas tran vdout0_8ck1620 FIND v(dout0_8) AT=815.025n

.meas tran vdout0_9ck1620 FIND v(dout0_9) AT=815.025n

.meas tran vdout0_10ck1620 FIND v(dout0_10) AT=815.025n

.meas tran vdout0_11ck1620 FIND v(dout0_11) AT=815.025n

.meas tran vdout0_12ck1620 FIND v(dout0_12) AT=815.025n

.meas tran vdout0_13ck1620 FIND v(dout0_13) AT=815.025n

.meas tran vdout0_14ck1620 FIND v(dout0_14) AT=815.025n

.meas tran vdout0_15ck1620 FIND v(dout0_15) AT=815.025n

.meas tran vdout0_16ck1620 FIND v(dout0_16) AT=815.025n

.meas tran vdout0_17ck1620 FIND v(dout0_17) AT=815.025n

.meas tran vdout0_18ck1620 FIND v(dout0_18) AT=815.025n

.meas tran vdout0_19ck1620 FIND v(dout0_19) AT=815.025n

.meas tran vdout0_20ck1620 FIND v(dout0_20) AT=815.025n

.meas tran vdout0_21ck1620 FIND v(dout0_21) AT=815.025n

.meas tran vdout0_22ck1620 FIND v(dout0_22) AT=815.025n

.meas tran vdout0_23ck1620 FIND v(dout0_23) AT=815.025n

.meas tran vdout0_24ck1620 FIND v(dout0_24) AT=815.025n

.meas tran vdout0_25ck1620 FIND v(dout0_25) AT=815.025n

.meas tran vdout0_26ck1620 FIND v(dout0_26) AT=815.025n

.meas tran vdout0_27ck1620 FIND v(dout0_27) AT=815.025n

.meas tran vdout0_28ck1620 FIND v(dout0_28) AT=815.025n

.meas tran vdout0_29ck1620 FIND v(dout0_29) AT=815.025n

.meas tran vdout0_30ck1620 FIND v(dout0_30) AT=815.025n

.meas tran vdout0_31ck1620 FIND v(dout0_31) AT=815.025n

.meas tran vdout0_32ck1620 FIND v(dout0_32) AT=815.025n

.meas tran vdout0_33ck1620 FIND v(dout0_33) AT=815.025n

.meas tran vdout0_34ck1620 FIND v(dout0_34) AT=815.025n

.meas tran vdout0_35ck1620 FIND v(dout0_35) AT=815.025n

.meas tran vdout0_36ck1620 FIND v(dout0_36) AT=815.025n

.meas tran vdout0_37ck1620 FIND v(dout0_37) AT=815.025n

.meas tran vdout0_38ck1620 FIND v(dout0_38) AT=815.025n

.meas tran vdout0_39ck1620 FIND v(dout0_39) AT=815.025n

.meas tran vdout0_40ck1620 FIND v(dout0_40) AT=815.025n

.meas tran vdout0_41ck1620 FIND v(dout0_41) AT=815.025n

.meas tran vdout0_42ck1620 FIND v(dout0_42) AT=815.025n

.meas tran vdout0_43ck1620 FIND v(dout0_43) AT=815.025n

.meas tran vdout0_44ck1620 FIND v(dout0_44) AT=815.025n

.meas tran vdout0_45ck1620 FIND v(dout0_45) AT=815.025n

.meas tran vdout0_46ck1620 FIND v(dout0_46) AT=815.025n

.meas tran vdout0_47ck1620 FIND v(dout0_47) AT=815.025n

.meas tran vdout0_48ck1620 FIND v(dout0_48) AT=815.025n

.meas tran vdout0_49ck1620 FIND v(dout0_49) AT=815.025n

.meas tran vdout0_50ck1620 FIND v(dout0_50) AT=815.025n

.meas tran vdout0_51ck1620 FIND v(dout0_51) AT=815.025n

.meas tran vdout0_52ck1620 FIND v(dout0_52) AT=815.025n

.meas tran vdout0_53ck1620 FIND v(dout0_53) AT=815.025n

.meas tran vdout0_54ck1620 FIND v(dout0_54) AT=815.025n

.meas tran vdout0_55ck1620 FIND v(dout0_55) AT=815.025n

.meas tran vdout0_56ck1620 FIND v(dout0_56) AT=815.025n

.meas tran vdout0_57ck1620 FIND v(dout0_57) AT=815.025n

.meas tran vdout0_58ck1620 FIND v(dout0_58) AT=815.025n

.meas tran vdout0_59ck1620 FIND v(dout0_59) AT=815.025n

.meas tran vdout0_60ck1620 FIND v(dout0_60) AT=815.025n

.meas tran vdout0_61ck1620 FIND v(dout0_61) AT=815.025n

.meas tran vdout0_62ck1620 FIND v(dout0_62) AT=815.025n

.meas tran vdout0_63ck1620 FIND v(dout0_63) AT=815.025n

.meas tran vdout0_64ck1620 FIND v(dout0_64) AT=815.025n

.meas tran vdout0_65ck1620 FIND v(dout0_65) AT=815.025n

.meas tran vdout0_66ck1620 FIND v(dout0_66) AT=815.025n

.meas tran vdout0_67ck1620 FIND v(dout0_67) AT=815.025n

.meas tran vdout0_68ck1620 FIND v(dout0_68) AT=815.025n

.meas tran vdout0_69ck1620 FIND v(dout0_69) AT=815.025n

.meas tran vdout0_70ck1620 FIND v(dout0_70) AT=815.025n

.meas tran vdout0_71ck1620 FIND v(dout0_71) AT=815.025n

.meas tran vdout0_72ck1620 FIND v(dout0_72) AT=815.025n

.meas tran vdout0_73ck1620 FIND v(dout0_73) AT=815.025n

.meas tran vdout0_74ck1620 FIND v(dout0_74) AT=815.025n

.meas tran vdout0_75ck1620 FIND v(dout0_75) AT=815.025n

.meas tran vdout0_76ck1620 FIND v(dout0_76) AT=815.025n

.meas tran vdout0_77ck1620 FIND v(dout0_77) AT=815.025n

.meas tran vdout0_78ck1620 FIND v(dout0_78) AT=815.025n

.meas tran vdout0_79ck1620 FIND v(dout0_79) AT=815.025n

.meas tran vdout0_80ck1620 FIND v(dout0_80) AT=815.025n

.meas tran vdout0_81ck1620 FIND v(dout0_81) AT=815.025n

.meas tran vdout0_82ck1620 FIND v(dout0_82) AT=815.025n

.meas tran vdout0_83ck1620 FIND v(dout0_83) AT=815.025n

.meas tran vdout0_84ck1620 FIND v(dout0_84) AT=815.025n

.meas tran vdout0_85ck1620 FIND v(dout0_85) AT=815.025n

.meas tran vdout0_86ck1620 FIND v(dout0_86) AT=815.025n

.meas tran vdout0_87ck1620 FIND v(dout0_87) AT=815.025n

.meas tran vdout0_88ck1620 FIND v(dout0_88) AT=815.025n

.meas tran vdout0_89ck1620 FIND v(dout0_89) AT=815.025n

.meas tran vdout0_90ck1620 FIND v(dout0_90) AT=815.025n

.meas tran vdout0_91ck1620 FIND v(dout0_91) AT=815.025n

.meas tran vdout0_92ck1620 FIND v(dout0_92) AT=815.025n

.meas tran vdout0_93ck1620 FIND v(dout0_93) AT=815.025n

.meas tran vdout0_94ck1620 FIND v(dout0_94) AT=815.025n

.meas tran vdout0_95ck1620 FIND v(dout0_95) AT=815.025n

.meas tran vdout0_96ck1620 FIND v(dout0_96) AT=815.025n

.meas tran vdout0_97ck1620 FIND v(dout0_97) AT=815.025n

.meas tran vdout0_98ck1620 FIND v(dout0_98) AT=815.025n

.meas tran vdout0_99ck1620 FIND v(dout0_99) AT=815.025n

.meas tran vdout0_100ck1620 FIND v(dout0_100) AT=815.025n

.meas tran vdout0_101ck1620 FIND v(dout0_101) AT=815.025n

.meas tran vdout0_102ck1620 FIND v(dout0_102) AT=815.025n

.meas tran vdout0_103ck1620 FIND v(dout0_103) AT=815.025n

.meas tran vdout0_104ck1620 FIND v(dout0_104) AT=815.025n

.meas tran vdout0_105ck1620 FIND v(dout0_105) AT=815.025n

.meas tran vdout0_106ck1620 FIND v(dout0_106) AT=815.025n

.meas tran vdout0_107ck1620 FIND v(dout0_107) AT=815.025n

.meas tran vdout0_108ck1620 FIND v(dout0_108) AT=815.025n

.meas tran vdout0_109ck1620 FIND v(dout0_109) AT=815.025n

.meas tran vdout0_110ck1620 FIND v(dout0_110) AT=815.025n

.meas tran vdout0_111ck1620 FIND v(dout0_111) AT=815.025n

.meas tran vdout0_112ck1620 FIND v(dout0_112) AT=815.025n

.meas tran vdout0_113ck1620 FIND v(dout0_113) AT=815.025n

.meas tran vdout0_114ck1620 FIND v(dout0_114) AT=815.025n

.meas tran vdout0_115ck1620 FIND v(dout0_115) AT=815.025n

.meas tran vdout0_116ck1620 FIND v(dout0_116) AT=815.025n

.meas tran vdout0_117ck1620 FIND v(dout0_117) AT=815.025n

.meas tran vdout0_118ck1620 FIND v(dout0_118) AT=815.025n

.meas tran vdout0_119ck1620 FIND v(dout0_119) AT=815.025n

.meas tran vdout0_120ck1620 FIND v(dout0_120) AT=815.025n

.meas tran vdout0_121ck1620 FIND v(dout0_121) AT=815.025n

.meas tran vdout0_122ck1620 FIND v(dout0_122) AT=815.025n

.meas tran vdout0_123ck1620 FIND v(dout0_123) AT=815.025n

.meas tran vdout0_124ck1620 FIND v(dout0_124) AT=815.025n

.meas tran vdout0_125ck1620 FIND v(dout0_125) AT=815.025n

.meas tran vdout0_126ck1620 FIND v(dout0_126) AT=815.025n

.meas tran vdout0_127ck1620 FIND v(dout0_127) AT=815.025n

.meas tran vdout0_128ck1620 FIND v(dout0_128) AT=815.025n

.meas tran vdout0_129ck1620 FIND v(dout0_129) AT=815.025n

.meas tran vdout0_130ck1620 FIND v(dout0_130) AT=815.025n

.meas tran vdout0_131ck1620 FIND v(dout0_131) AT=815.025n

.meas tran vdout0_132ck1620 FIND v(dout0_132) AT=815.025n

.meas tran vdout0_133ck1620 FIND v(dout0_133) AT=815.025n

.meas tran vdout0_134ck1620 FIND v(dout0_134) AT=815.025n

.meas tran vdout0_135ck1620 FIND v(dout0_135) AT=815.025n

.meas tran vdout0_136ck1620 FIND v(dout0_136) AT=815.025n

.meas tran vdout0_137ck1620 FIND v(dout0_137) AT=815.025n

.meas tran vdout0_138ck1620 FIND v(dout0_138) AT=815.025n

.meas tran vdout0_139ck1620 FIND v(dout0_139) AT=815.025n

.meas tran vdout0_140ck1620 FIND v(dout0_140) AT=815.025n

.meas tran vdout0_141ck1620 FIND v(dout0_141) AT=815.025n

.meas tran vdout0_142ck1620 FIND v(dout0_142) AT=815.025n

.meas tran vdout0_143ck1620 FIND v(dout0_143) AT=815.025n

.meas tran vdout0_144ck1620 FIND v(dout0_144) AT=815.025n

.meas tran vdout0_145ck1620 FIND v(dout0_145) AT=815.025n

.meas tran vdout0_146ck1620 FIND v(dout0_146) AT=815.025n

.meas tran vdout0_147ck1620 FIND v(dout0_147) AT=815.025n

.meas tran vdout0_148ck1620 FIND v(dout0_148) AT=815.025n

.meas tran vdout0_149ck1620 FIND v(dout0_149) AT=815.025n

.meas tran vdout0_150ck1620 FIND v(dout0_150) AT=815.025n

.meas tran vdout0_151ck1620 FIND v(dout0_151) AT=815.025n

.meas tran vdout0_152ck1620 FIND v(dout0_152) AT=815.025n

.meas tran vdout0_153ck1620 FIND v(dout0_153) AT=815.025n

.meas tran vdout0_154ck1620 FIND v(dout0_154) AT=815.025n

.meas tran vdout0_155ck1620 FIND v(dout0_155) AT=815.025n

.meas tran vdout0_156ck1620 FIND v(dout0_156) AT=815.025n

.meas tran vdout0_157ck1620 FIND v(dout0_157) AT=815.025n

.meas tran vdout0_158ck1620 FIND v(dout0_158) AT=815.025n

.meas tran vdout0_159ck1620 FIND v(dout0_159) AT=815.025n

.meas tran vdout0_160ck1620 FIND v(dout0_160) AT=815.025n

.meas tran vdout0_161ck1620 FIND v(dout0_161) AT=815.025n

.meas tran vdout0_162ck1620 FIND v(dout0_162) AT=815.025n

.meas tran vdout0_163ck1620 FIND v(dout0_163) AT=815.025n

.meas tran vdout0_164ck1620 FIND v(dout0_164) AT=815.025n

.meas tran vdout0_165ck1620 FIND v(dout0_165) AT=815.025n

.meas tran vdout0_166ck1620 FIND v(dout0_166) AT=815.025n

.meas tran vdout0_167ck1620 FIND v(dout0_167) AT=815.025n

.meas tran vdout0_168ck1620 FIND v(dout0_168) AT=815.025n

.meas tran vdout0_169ck1620 FIND v(dout0_169) AT=815.025n

.meas tran vdout0_170ck1620 FIND v(dout0_170) AT=815.025n

.meas tran vdout0_171ck1620 FIND v(dout0_171) AT=815.025n

.meas tran vdout0_172ck1620 FIND v(dout0_172) AT=815.025n

.meas tran vdout0_173ck1620 FIND v(dout0_173) AT=815.025n

.meas tran vdout0_174ck1620 FIND v(dout0_174) AT=815.025n

.meas tran vdout0_175ck1620 FIND v(dout0_175) AT=815.025n

.meas tran vdout0_176ck1620 FIND v(dout0_176) AT=815.025n

.meas tran vdout0_177ck1620 FIND v(dout0_177) AT=815.025n

.meas tran vdout0_178ck1620 FIND v(dout0_178) AT=815.025n

.meas tran vdout0_179ck1620 FIND v(dout0_179) AT=815.025n

.meas tran vdout0_180ck1620 FIND v(dout0_180) AT=815.025n

.meas tran vdout0_181ck1620 FIND v(dout0_181) AT=815.025n

.meas tran vdout0_182ck1620 FIND v(dout0_182) AT=815.025n

.meas tran vdout0_183ck1620 FIND v(dout0_183) AT=815.025n

.meas tran vdout0_184ck1620 FIND v(dout0_184) AT=815.025n

.meas tran vdout0_185ck1620 FIND v(dout0_185) AT=815.025n

.meas tran vdout0_186ck1620 FIND v(dout0_186) AT=815.025n

.meas tran vdout0_187ck1620 FIND v(dout0_187) AT=815.025n

.meas tran vdout0_188ck1620 FIND v(dout0_188) AT=815.025n

.meas tran vdout0_189ck1620 FIND v(dout0_189) AT=815.025n

.meas tran vdout0_190ck1620 FIND v(dout0_190) AT=815.025n

.meas tran vdout0_191ck1620 FIND v(dout0_191) AT=815.025n

.meas tran vdout0_192ck1620 FIND v(dout0_192) AT=815.025n

.meas tran vdout0_193ck1620 FIND v(dout0_193) AT=815.025n

.meas tran vdout0_194ck1620 FIND v(dout0_194) AT=815.025n

.meas tran vdout0_195ck1620 FIND v(dout0_195) AT=815.025n

.meas tran vdout0_196ck1620 FIND v(dout0_196) AT=815.025n

.meas tran vdout0_197ck1620 FIND v(dout0_197) AT=815.025n

.meas tran vdout0_198ck1620 FIND v(dout0_198) AT=815.025n

.meas tran vdout0_199ck1620 FIND v(dout0_199) AT=815.025n

.meas tran vdout0_200ck1620 FIND v(dout0_200) AT=815.025n

.meas tran vdout0_201ck1620 FIND v(dout0_201) AT=815.025n

.meas tran vdout0_202ck1620 FIND v(dout0_202) AT=815.025n

.meas tran vdout0_203ck1620 FIND v(dout0_203) AT=815.025n

.meas tran vdout0_204ck1620 FIND v(dout0_204) AT=815.025n

.meas tran vdout0_205ck1620 FIND v(dout0_205) AT=815.025n

.meas tran vdout0_206ck1620 FIND v(dout0_206) AT=815.025n

.meas tran vdout0_207ck1620 FIND v(dout0_207) AT=815.025n

.meas tran vdout0_208ck1620 FIND v(dout0_208) AT=815.025n

.meas tran vdout0_209ck1620 FIND v(dout0_209) AT=815.025n

.meas tran vdout0_210ck1620 FIND v(dout0_210) AT=815.025n

.meas tran vdout0_211ck1620 FIND v(dout0_211) AT=815.025n

.meas tran vdout0_212ck1620 FIND v(dout0_212) AT=815.025n

.meas tran vdout0_213ck1620 FIND v(dout0_213) AT=815.025n

.meas tran vdout0_214ck1620 FIND v(dout0_214) AT=815.025n

.meas tran vdout0_215ck1620 FIND v(dout0_215) AT=815.025n

.meas tran vdout0_216ck1620 FIND v(dout0_216) AT=815.025n

.meas tran vdout0_217ck1620 FIND v(dout0_217) AT=815.025n

.meas tran vdout0_218ck1620 FIND v(dout0_218) AT=815.025n

.meas tran vdout0_219ck1620 FIND v(dout0_219) AT=815.025n

.meas tran vdout0_220ck1620 FIND v(dout0_220) AT=815.025n

.meas tran vdout0_221ck1620 FIND v(dout0_221) AT=815.025n

.meas tran vdout0_222ck1620 FIND v(dout0_222) AT=815.025n

.meas tran vdout0_223ck1620 FIND v(dout0_223) AT=815.025n

.meas tran vdout0_224ck1620 FIND v(dout0_224) AT=815.025n

.meas tran vdout0_225ck1620 FIND v(dout0_225) AT=815.025n

.meas tran vdout0_226ck1620 FIND v(dout0_226) AT=815.025n

.meas tran vdout0_227ck1620 FIND v(dout0_227) AT=815.025n

.meas tran vdout0_228ck1620 FIND v(dout0_228) AT=815.025n

.meas tran vdout0_229ck1620 FIND v(dout0_229) AT=815.025n

.meas tran vdout0_230ck1620 FIND v(dout0_230) AT=815.025n

.meas tran vdout0_231ck1620 FIND v(dout0_231) AT=815.025n

.meas tran vdout0_232ck1620 FIND v(dout0_232) AT=815.025n

.meas tran vdout0_233ck1620 FIND v(dout0_233) AT=815.025n

.meas tran vdout0_234ck1620 FIND v(dout0_234) AT=815.025n

.meas tran vdout0_235ck1620 FIND v(dout0_235) AT=815.025n

.meas tran vdout0_236ck1620 FIND v(dout0_236) AT=815.025n

.meas tran vdout0_237ck1620 FIND v(dout0_237) AT=815.025n

.meas tran vdout0_238ck1620 FIND v(dout0_238) AT=815.025n

.meas tran vdout0_239ck1620 FIND v(dout0_239) AT=815.025n

.meas tran vdout0_240ck1620 FIND v(dout0_240) AT=815.025n

.meas tran vdout0_241ck1620 FIND v(dout0_241) AT=815.025n

.meas tran vdout0_242ck1620 FIND v(dout0_242) AT=815.025n

.meas tran vdout0_243ck1620 FIND v(dout0_243) AT=815.025n

.meas tran vdout0_244ck1620 FIND v(dout0_244) AT=815.025n

.meas tran vdout0_245ck1620 FIND v(dout0_245) AT=815.025n

.meas tran vdout0_246ck1620 FIND v(dout0_246) AT=815.025n

.meas tran vdout0_247ck1620 FIND v(dout0_247) AT=815.025n

.meas tran vdout0_248ck1620 FIND v(dout0_248) AT=815.025n

.meas tran vdout0_249ck1620 FIND v(dout0_249) AT=815.025n

.meas tran vdout0_250ck1620 FIND v(dout0_250) AT=815.025n

.meas tran vdout0_251ck1620 FIND v(dout0_251) AT=815.025n

.meas tran vdout0_252ck1620 FIND v(dout0_252) AT=815.025n

.meas tran vdout0_253ck1620 FIND v(dout0_253) AT=815.025n

.meas tran vdout0_254ck1620 FIND v(dout0_254) AT=815.025n

.meas tran vdout0_255ck1620 FIND v(dout0_255) AT=815.025n

.meas tran vdout0_0ck1630 FIND v(dout0_0) AT=820.025n

.meas tran vdout0_1ck1630 FIND v(dout0_1) AT=820.025n

.meas tran vdout0_2ck1630 FIND v(dout0_2) AT=820.025n

.meas tran vdout0_3ck1630 FIND v(dout0_3) AT=820.025n

.meas tran vdout0_4ck1630 FIND v(dout0_4) AT=820.025n

.meas tran vdout0_5ck1630 FIND v(dout0_5) AT=820.025n

.meas tran vdout0_6ck1630 FIND v(dout0_6) AT=820.025n

.meas tran vdout0_7ck1630 FIND v(dout0_7) AT=820.025n

.meas tran vdout0_8ck1630 FIND v(dout0_8) AT=820.025n

.meas tran vdout0_9ck1630 FIND v(dout0_9) AT=820.025n

.meas tran vdout0_10ck1630 FIND v(dout0_10) AT=820.025n

.meas tran vdout0_11ck1630 FIND v(dout0_11) AT=820.025n

.meas tran vdout0_12ck1630 FIND v(dout0_12) AT=820.025n

.meas tran vdout0_13ck1630 FIND v(dout0_13) AT=820.025n

.meas tran vdout0_14ck1630 FIND v(dout0_14) AT=820.025n

.meas tran vdout0_15ck1630 FIND v(dout0_15) AT=820.025n

.meas tran vdout0_16ck1630 FIND v(dout0_16) AT=820.025n

.meas tran vdout0_17ck1630 FIND v(dout0_17) AT=820.025n

.meas tran vdout0_18ck1630 FIND v(dout0_18) AT=820.025n

.meas tran vdout0_19ck1630 FIND v(dout0_19) AT=820.025n

.meas tran vdout0_20ck1630 FIND v(dout0_20) AT=820.025n

.meas tran vdout0_21ck1630 FIND v(dout0_21) AT=820.025n

.meas tran vdout0_22ck1630 FIND v(dout0_22) AT=820.025n

.meas tran vdout0_23ck1630 FIND v(dout0_23) AT=820.025n

.meas tran vdout0_24ck1630 FIND v(dout0_24) AT=820.025n

.meas tran vdout0_25ck1630 FIND v(dout0_25) AT=820.025n

.meas tran vdout0_26ck1630 FIND v(dout0_26) AT=820.025n

.meas tran vdout0_27ck1630 FIND v(dout0_27) AT=820.025n

.meas tran vdout0_28ck1630 FIND v(dout0_28) AT=820.025n

.meas tran vdout0_29ck1630 FIND v(dout0_29) AT=820.025n

.meas tran vdout0_30ck1630 FIND v(dout0_30) AT=820.025n

.meas tran vdout0_31ck1630 FIND v(dout0_31) AT=820.025n

.meas tran vdout0_32ck1630 FIND v(dout0_32) AT=820.025n

.meas tran vdout0_33ck1630 FIND v(dout0_33) AT=820.025n

.meas tran vdout0_34ck1630 FIND v(dout0_34) AT=820.025n

.meas tran vdout0_35ck1630 FIND v(dout0_35) AT=820.025n

.meas tran vdout0_36ck1630 FIND v(dout0_36) AT=820.025n

.meas tran vdout0_37ck1630 FIND v(dout0_37) AT=820.025n

.meas tran vdout0_38ck1630 FIND v(dout0_38) AT=820.025n

.meas tran vdout0_39ck1630 FIND v(dout0_39) AT=820.025n

.meas tran vdout0_40ck1630 FIND v(dout0_40) AT=820.025n

.meas tran vdout0_41ck1630 FIND v(dout0_41) AT=820.025n

.meas tran vdout0_42ck1630 FIND v(dout0_42) AT=820.025n

.meas tran vdout0_43ck1630 FIND v(dout0_43) AT=820.025n

.meas tran vdout0_44ck1630 FIND v(dout0_44) AT=820.025n

.meas tran vdout0_45ck1630 FIND v(dout0_45) AT=820.025n

.meas tran vdout0_46ck1630 FIND v(dout0_46) AT=820.025n

.meas tran vdout0_47ck1630 FIND v(dout0_47) AT=820.025n

.meas tran vdout0_48ck1630 FIND v(dout0_48) AT=820.025n

.meas tran vdout0_49ck1630 FIND v(dout0_49) AT=820.025n

.meas tran vdout0_50ck1630 FIND v(dout0_50) AT=820.025n

.meas tran vdout0_51ck1630 FIND v(dout0_51) AT=820.025n

.meas tran vdout0_52ck1630 FIND v(dout0_52) AT=820.025n

.meas tran vdout0_53ck1630 FIND v(dout0_53) AT=820.025n

.meas tran vdout0_54ck1630 FIND v(dout0_54) AT=820.025n

.meas tran vdout0_55ck1630 FIND v(dout0_55) AT=820.025n

.meas tran vdout0_56ck1630 FIND v(dout0_56) AT=820.025n

.meas tran vdout0_57ck1630 FIND v(dout0_57) AT=820.025n

.meas tran vdout0_58ck1630 FIND v(dout0_58) AT=820.025n

.meas tran vdout0_59ck1630 FIND v(dout0_59) AT=820.025n

.meas tran vdout0_60ck1630 FIND v(dout0_60) AT=820.025n

.meas tran vdout0_61ck1630 FIND v(dout0_61) AT=820.025n

.meas tran vdout0_62ck1630 FIND v(dout0_62) AT=820.025n

.meas tran vdout0_63ck1630 FIND v(dout0_63) AT=820.025n

.meas tran vdout0_64ck1630 FIND v(dout0_64) AT=820.025n

.meas tran vdout0_65ck1630 FIND v(dout0_65) AT=820.025n

.meas tran vdout0_66ck1630 FIND v(dout0_66) AT=820.025n

.meas tran vdout0_67ck1630 FIND v(dout0_67) AT=820.025n

.meas tran vdout0_68ck1630 FIND v(dout0_68) AT=820.025n

.meas tran vdout0_69ck1630 FIND v(dout0_69) AT=820.025n

.meas tran vdout0_70ck1630 FIND v(dout0_70) AT=820.025n

.meas tran vdout0_71ck1630 FIND v(dout0_71) AT=820.025n

.meas tran vdout0_72ck1630 FIND v(dout0_72) AT=820.025n

.meas tran vdout0_73ck1630 FIND v(dout0_73) AT=820.025n

.meas tran vdout0_74ck1630 FIND v(dout0_74) AT=820.025n

.meas tran vdout0_75ck1630 FIND v(dout0_75) AT=820.025n

.meas tran vdout0_76ck1630 FIND v(dout0_76) AT=820.025n

.meas tran vdout0_77ck1630 FIND v(dout0_77) AT=820.025n

.meas tran vdout0_78ck1630 FIND v(dout0_78) AT=820.025n

.meas tran vdout0_79ck1630 FIND v(dout0_79) AT=820.025n

.meas tran vdout0_80ck1630 FIND v(dout0_80) AT=820.025n

.meas tran vdout0_81ck1630 FIND v(dout0_81) AT=820.025n

.meas tran vdout0_82ck1630 FIND v(dout0_82) AT=820.025n

.meas tran vdout0_83ck1630 FIND v(dout0_83) AT=820.025n

.meas tran vdout0_84ck1630 FIND v(dout0_84) AT=820.025n

.meas tran vdout0_85ck1630 FIND v(dout0_85) AT=820.025n

.meas tran vdout0_86ck1630 FIND v(dout0_86) AT=820.025n

.meas tran vdout0_87ck1630 FIND v(dout0_87) AT=820.025n

.meas tran vdout0_88ck1630 FIND v(dout0_88) AT=820.025n

.meas tran vdout0_89ck1630 FIND v(dout0_89) AT=820.025n

.meas tran vdout0_90ck1630 FIND v(dout0_90) AT=820.025n

.meas tran vdout0_91ck1630 FIND v(dout0_91) AT=820.025n

.meas tran vdout0_92ck1630 FIND v(dout0_92) AT=820.025n

.meas tran vdout0_93ck1630 FIND v(dout0_93) AT=820.025n

.meas tran vdout0_94ck1630 FIND v(dout0_94) AT=820.025n

.meas tran vdout0_95ck1630 FIND v(dout0_95) AT=820.025n

.meas tran vdout0_96ck1630 FIND v(dout0_96) AT=820.025n

.meas tran vdout0_97ck1630 FIND v(dout0_97) AT=820.025n

.meas tran vdout0_98ck1630 FIND v(dout0_98) AT=820.025n

.meas tran vdout0_99ck1630 FIND v(dout0_99) AT=820.025n

.meas tran vdout0_100ck1630 FIND v(dout0_100) AT=820.025n

.meas tran vdout0_101ck1630 FIND v(dout0_101) AT=820.025n

.meas tran vdout0_102ck1630 FIND v(dout0_102) AT=820.025n

.meas tran vdout0_103ck1630 FIND v(dout0_103) AT=820.025n

.meas tran vdout0_104ck1630 FIND v(dout0_104) AT=820.025n

.meas tran vdout0_105ck1630 FIND v(dout0_105) AT=820.025n

.meas tran vdout0_106ck1630 FIND v(dout0_106) AT=820.025n

.meas tran vdout0_107ck1630 FIND v(dout0_107) AT=820.025n

.meas tran vdout0_108ck1630 FIND v(dout0_108) AT=820.025n

.meas tran vdout0_109ck1630 FIND v(dout0_109) AT=820.025n

.meas tran vdout0_110ck1630 FIND v(dout0_110) AT=820.025n

.meas tran vdout0_111ck1630 FIND v(dout0_111) AT=820.025n

.meas tran vdout0_112ck1630 FIND v(dout0_112) AT=820.025n

.meas tran vdout0_113ck1630 FIND v(dout0_113) AT=820.025n

.meas tran vdout0_114ck1630 FIND v(dout0_114) AT=820.025n

.meas tran vdout0_115ck1630 FIND v(dout0_115) AT=820.025n

.meas tran vdout0_116ck1630 FIND v(dout0_116) AT=820.025n

.meas tran vdout0_117ck1630 FIND v(dout0_117) AT=820.025n

.meas tran vdout0_118ck1630 FIND v(dout0_118) AT=820.025n

.meas tran vdout0_119ck1630 FIND v(dout0_119) AT=820.025n

.meas tran vdout0_120ck1630 FIND v(dout0_120) AT=820.025n

.meas tran vdout0_121ck1630 FIND v(dout0_121) AT=820.025n

.meas tran vdout0_122ck1630 FIND v(dout0_122) AT=820.025n

.meas tran vdout0_123ck1630 FIND v(dout0_123) AT=820.025n

.meas tran vdout0_124ck1630 FIND v(dout0_124) AT=820.025n

.meas tran vdout0_125ck1630 FIND v(dout0_125) AT=820.025n

.meas tran vdout0_126ck1630 FIND v(dout0_126) AT=820.025n

.meas tran vdout0_127ck1630 FIND v(dout0_127) AT=820.025n

.meas tran vdout0_128ck1630 FIND v(dout0_128) AT=820.025n

.meas tran vdout0_129ck1630 FIND v(dout0_129) AT=820.025n

.meas tran vdout0_130ck1630 FIND v(dout0_130) AT=820.025n

.meas tran vdout0_131ck1630 FIND v(dout0_131) AT=820.025n

.meas tran vdout0_132ck1630 FIND v(dout0_132) AT=820.025n

.meas tran vdout0_133ck1630 FIND v(dout0_133) AT=820.025n

.meas tran vdout0_134ck1630 FIND v(dout0_134) AT=820.025n

.meas tran vdout0_135ck1630 FIND v(dout0_135) AT=820.025n

.meas tran vdout0_136ck1630 FIND v(dout0_136) AT=820.025n

.meas tran vdout0_137ck1630 FIND v(dout0_137) AT=820.025n

.meas tran vdout0_138ck1630 FIND v(dout0_138) AT=820.025n

.meas tran vdout0_139ck1630 FIND v(dout0_139) AT=820.025n

.meas tran vdout0_140ck1630 FIND v(dout0_140) AT=820.025n

.meas tran vdout0_141ck1630 FIND v(dout0_141) AT=820.025n

.meas tran vdout0_142ck1630 FIND v(dout0_142) AT=820.025n

.meas tran vdout0_143ck1630 FIND v(dout0_143) AT=820.025n

.meas tran vdout0_144ck1630 FIND v(dout0_144) AT=820.025n

.meas tran vdout0_145ck1630 FIND v(dout0_145) AT=820.025n

.meas tran vdout0_146ck1630 FIND v(dout0_146) AT=820.025n

.meas tran vdout0_147ck1630 FIND v(dout0_147) AT=820.025n

.meas tran vdout0_148ck1630 FIND v(dout0_148) AT=820.025n

.meas tran vdout0_149ck1630 FIND v(dout0_149) AT=820.025n

.meas tran vdout0_150ck1630 FIND v(dout0_150) AT=820.025n

.meas tran vdout0_151ck1630 FIND v(dout0_151) AT=820.025n

.meas tran vdout0_152ck1630 FIND v(dout0_152) AT=820.025n

.meas tran vdout0_153ck1630 FIND v(dout0_153) AT=820.025n

.meas tran vdout0_154ck1630 FIND v(dout0_154) AT=820.025n

.meas tran vdout0_155ck1630 FIND v(dout0_155) AT=820.025n

.meas tran vdout0_156ck1630 FIND v(dout0_156) AT=820.025n

.meas tran vdout0_157ck1630 FIND v(dout0_157) AT=820.025n

.meas tran vdout0_158ck1630 FIND v(dout0_158) AT=820.025n

.meas tran vdout0_159ck1630 FIND v(dout0_159) AT=820.025n

.meas tran vdout0_160ck1630 FIND v(dout0_160) AT=820.025n

.meas tran vdout0_161ck1630 FIND v(dout0_161) AT=820.025n

.meas tran vdout0_162ck1630 FIND v(dout0_162) AT=820.025n

.meas tran vdout0_163ck1630 FIND v(dout0_163) AT=820.025n

.meas tran vdout0_164ck1630 FIND v(dout0_164) AT=820.025n

.meas tran vdout0_165ck1630 FIND v(dout0_165) AT=820.025n

.meas tran vdout0_166ck1630 FIND v(dout0_166) AT=820.025n

.meas tran vdout0_167ck1630 FIND v(dout0_167) AT=820.025n

.meas tran vdout0_168ck1630 FIND v(dout0_168) AT=820.025n

.meas tran vdout0_169ck1630 FIND v(dout0_169) AT=820.025n

.meas tran vdout0_170ck1630 FIND v(dout0_170) AT=820.025n

.meas tran vdout0_171ck1630 FIND v(dout0_171) AT=820.025n

.meas tran vdout0_172ck1630 FIND v(dout0_172) AT=820.025n

.meas tran vdout0_173ck1630 FIND v(dout0_173) AT=820.025n

.meas tran vdout0_174ck1630 FIND v(dout0_174) AT=820.025n

.meas tran vdout0_175ck1630 FIND v(dout0_175) AT=820.025n

.meas tran vdout0_176ck1630 FIND v(dout0_176) AT=820.025n

.meas tran vdout0_177ck1630 FIND v(dout0_177) AT=820.025n

.meas tran vdout0_178ck1630 FIND v(dout0_178) AT=820.025n

.meas tran vdout0_179ck1630 FIND v(dout0_179) AT=820.025n

.meas tran vdout0_180ck1630 FIND v(dout0_180) AT=820.025n

.meas tran vdout0_181ck1630 FIND v(dout0_181) AT=820.025n

.meas tran vdout0_182ck1630 FIND v(dout0_182) AT=820.025n

.meas tran vdout0_183ck1630 FIND v(dout0_183) AT=820.025n

.meas tran vdout0_184ck1630 FIND v(dout0_184) AT=820.025n

.meas tran vdout0_185ck1630 FIND v(dout0_185) AT=820.025n

.meas tran vdout0_186ck1630 FIND v(dout0_186) AT=820.025n

.meas tran vdout0_187ck1630 FIND v(dout0_187) AT=820.025n

.meas tran vdout0_188ck1630 FIND v(dout0_188) AT=820.025n

.meas tran vdout0_189ck1630 FIND v(dout0_189) AT=820.025n

.meas tran vdout0_190ck1630 FIND v(dout0_190) AT=820.025n

.meas tran vdout0_191ck1630 FIND v(dout0_191) AT=820.025n

.meas tran vdout0_192ck1630 FIND v(dout0_192) AT=820.025n

.meas tran vdout0_193ck1630 FIND v(dout0_193) AT=820.025n

.meas tran vdout0_194ck1630 FIND v(dout0_194) AT=820.025n

.meas tran vdout0_195ck1630 FIND v(dout0_195) AT=820.025n

.meas tran vdout0_196ck1630 FIND v(dout0_196) AT=820.025n

.meas tran vdout0_197ck1630 FIND v(dout0_197) AT=820.025n

.meas tran vdout0_198ck1630 FIND v(dout0_198) AT=820.025n

.meas tran vdout0_199ck1630 FIND v(dout0_199) AT=820.025n

.meas tran vdout0_200ck1630 FIND v(dout0_200) AT=820.025n

.meas tran vdout0_201ck1630 FIND v(dout0_201) AT=820.025n

.meas tran vdout0_202ck1630 FIND v(dout0_202) AT=820.025n

.meas tran vdout0_203ck1630 FIND v(dout0_203) AT=820.025n

.meas tran vdout0_204ck1630 FIND v(dout0_204) AT=820.025n

.meas tran vdout0_205ck1630 FIND v(dout0_205) AT=820.025n

.meas tran vdout0_206ck1630 FIND v(dout0_206) AT=820.025n

.meas tran vdout0_207ck1630 FIND v(dout0_207) AT=820.025n

.meas tran vdout0_208ck1630 FIND v(dout0_208) AT=820.025n

.meas tran vdout0_209ck1630 FIND v(dout0_209) AT=820.025n

.meas tran vdout0_210ck1630 FIND v(dout0_210) AT=820.025n

.meas tran vdout0_211ck1630 FIND v(dout0_211) AT=820.025n

.meas tran vdout0_212ck1630 FIND v(dout0_212) AT=820.025n

.meas tran vdout0_213ck1630 FIND v(dout0_213) AT=820.025n

.meas tran vdout0_214ck1630 FIND v(dout0_214) AT=820.025n

.meas tran vdout0_215ck1630 FIND v(dout0_215) AT=820.025n

.meas tran vdout0_216ck1630 FIND v(dout0_216) AT=820.025n

.meas tran vdout0_217ck1630 FIND v(dout0_217) AT=820.025n

.meas tran vdout0_218ck1630 FIND v(dout0_218) AT=820.025n

.meas tran vdout0_219ck1630 FIND v(dout0_219) AT=820.025n

.meas tran vdout0_220ck1630 FIND v(dout0_220) AT=820.025n

.meas tran vdout0_221ck1630 FIND v(dout0_221) AT=820.025n

.meas tran vdout0_222ck1630 FIND v(dout0_222) AT=820.025n

.meas tran vdout0_223ck1630 FIND v(dout0_223) AT=820.025n

.meas tran vdout0_224ck1630 FIND v(dout0_224) AT=820.025n

.meas tran vdout0_225ck1630 FIND v(dout0_225) AT=820.025n

.meas tran vdout0_226ck1630 FIND v(dout0_226) AT=820.025n

.meas tran vdout0_227ck1630 FIND v(dout0_227) AT=820.025n

.meas tran vdout0_228ck1630 FIND v(dout0_228) AT=820.025n

.meas tran vdout0_229ck1630 FIND v(dout0_229) AT=820.025n

.meas tran vdout0_230ck1630 FIND v(dout0_230) AT=820.025n

.meas tran vdout0_231ck1630 FIND v(dout0_231) AT=820.025n

.meas tran vdout0_232ck1630 FIND v(dout0_232) AT=820.025n

.meas tran vdout0_233ck1630 FIND v(dout0_233) AT=820.025n

.meas tran vdout0_234ck1630 FIND v(dout0_234) AT=820.025n

.meas tran vdout0_235ck1630 FIND v(dout0_235) AT=820.025n

.meas tran vdout0_236ck1630 FIND v(dout0_236) AT=820.025n

.meas tran vdout0_237ck1630 FIND v(dout0_237) AT=820.025n

.meas tran vdout0_238ck1630 FIND v(dout0_238) AT=820.025n

.meas tran vdout0_239ck1630 FIND v(dout0_239) AT=820.025n

.meas tran vdout0_240ck1630 FIND v(dout0_240) AT=820.025n

.meas tran vdout0_241ck1630 FIND v(dout0_241) AT=820.025n

.meas tran vdout0_242ck1630 FIND v(dout0_242) AT=820.025n

.meas tran vdout0_243ck1630 FIND v(dout0_243) AT=820.025n

.meas tran vdout0_244ck1630 FIND v(dout0_244) AT=820.025n

.meas tran vdout0_245ck1630 FIND v(dout0_245) AT=820.025n

.meas tran vdout0_246ck1630 FIND v(dout0_246) AT=820.025n

.meas tran vdout0_247ck1630 FIND v(dout0_247) AT=820.025n

.meas tran vdout0_248ck1630 FIND v(dout0_248) AT=820.025n

.meas tran vdout0_249ck1630 FIND v(dout0_249) AT=820.025n

.meas tran vdout0_250ck1630 FIND v(dout0_250) AT=820.025n

.meas tran vdout0_251ck1630 FIND v(dout0_251) AT=820.025n

.meas tran vdout0_252ck1630 FIND v(dout0_252) AT=820.025n

.meas tran vdout0_253ck1630 FIND v(dout0_253) AT=820.025n

.meas tran vdout0_254ck1630 FIND v(dout0_254) AT=820.025n

.meas tran vdout0_255ck1630 FIND v(dout0_255) AT=820.025n

.meas tran vdout0_0ck1640 FIND v(dout0_0) AT=825.025n

.meas tran vdout0_1ck1640 FIND v(dout0_1) AT=825.025n

.meas tran vdout0_2ck1640 FIND v(dout0_2) AT=825.025n

.meas tran vdout0_3ck1640 FIND v(dout0_3) AT=825.025n

.meas tran vdout0_4ck1640 FIND v(dout0_4) AT=825.025n

.meas tran vdout0_5ck1640 FIND v(dout0_5) AT=825.025n

.meas tran vdout0_6ck1640 FIND v(dout0_6) AT=825.025n

.meas tran vdout0_7ck1640 FIND v(dout0_7) AT=825.025n

.meas tran vdout0_8ck1640 FIND v(dout0_8) AT=825.025n

.meas tran vdout0_9ck1640 FIND v(dout0_9) AT=825.025n

.meas tran vdout0_10ck1640 FIND v(dout0_10) AT=825.025n

.meas tran vdout0_11ck1640 FIND v(dout0_11) AT=825.025n

.meas tran vdout0_12ck1640 FIND v(dout0_12) AT=825.025n

.meas tran vdout0_13ck1640 FIND v(dout0_13) AT=825.025n

.meas tran vdout0_14ck1640 FIND v(dout0_14) AT=825.025n

.meas tran vdout0_15ck1640 FIND v(dout0_15) AT=825.025n

.meas tran vdout0_16ck1640 FIND v(dout0_16) AT=825.025n

.meas tran vdout0_17ck1640 FIND v(dout0_17) AT=825.025n

.meas tran vdout0_18ck1640 FIND v(dout0_18) AT=825.025n

.meas tran vdout0_19ck1640 FIND v(dout0_19) AT=825.025n

.meas tran vdout0_20ck1640 FIND v(dout0_20) AT=825.025n

.meas tran vdout0_21ck1640 FIND v(dout0_21) AT=825.025n

.meas tran vdout0_22ck1640 FIND v(dout0_22) AT=825.025n

.meas tran vdout0_23ck1640 FIND v(dout0_23) AT=825.025n

.meas tran vdout0_24ck1640 FIND v(dout0_24) AT=825.025n

.meas tran vdout0_25ck1640 FIND v(dout0_25) AT=825.025n

.meas tran vdout0_26ck1640 FIND v(dout0_26) AT=825.025n

.meas tran vdout0_27ck1640 FIND v(dout0_27) AT=825.025n

.meas tran vdout0_28ck1640 FIND v(dout0_28) AT=825.025n

.meas tran vdout0_29ck1640 FIND v(dout0_29) AT=825.025n

.meas tran vdout0_30ck1640 FIND v(dout0_30) AT=825.025n

.meas tran vdout0_31ck1640 FIND v(dout0_31) AT=825.025n

.meas tran vdout0_32ck1640 FIND v(dout0_32) AT=825.025n

.meas tran vdout0_33ck1640 FIND v(dout0_33) AT=825.025n

.meas tran vdout0_34ck1640 FIND v(dout0_34) AT=825.025n

.meas tran vdout0_35ck1640 FIND v(dout0_35) AT=825.025n

.meas tran vdout0_36ck1640 FIND v(dout0_36) AT=825.025n

.meas tran vdout0_37ck1640 FIND v(dout0_37) AT=825.025n

.meas tran vdout0_38ck1640 FIND v(dout0_38) AT=825.025n

.meas tran vdout0_39ck1640 FIND v(dout0_39) AT=825.025n

.meas tran vdout0_40ck1640 FIND v(dout0_40) AT=825.025n

.meas tran vdout0_41ck1640 FIND v(dout0_41) AT=825.025n

.meas tran vdout0_42ck1640 FIND v(dout0_42) AT=825.025n

.meas tran vdout0_43ck1640 FIND v(dout0_43) AT=825.025n

.meas tran vdout0_44ck1640 FIND v(dout0_44) AT=825.025n

.meas tran vdout0_45ck1640 FIND v(dout0_45) AT=825.025n

.meas tran vdout0_46ck1640 FIND v(dout0_46) AT=825.025n

.meas tran vdout0_47ck1640 FIND v(dout0_47) AT=825.025n

.meas tran vdout0_48ck1640 FIND v(dout0_48) AT=825.025n

.meas tran vdout0_49ck1640 FIND v(dout0_49) AT=825.025n

.meas tran vdout0_50ck1640 FIND v(dout0_50) AT=825.025n

.meas tran vdout0_51ck1640 FIND v(dout0_51) AT=825.025n

.meas tran vdout0_52ck1640 FIND v(dout0_52) AT=825.025n

.meas tran vdout0_53ck1640 FIND v(dout0_53) AT=825.025n

.meas tran vdout0_54ck1640 FIND v(dout0_54) AT=825.025n

.meas tran vdout0_55ck1640 FIND v(dout0_55) AT=825.025n

.meas tran vdout0_56ck1640 FIND v(dout0_56) AT=825.025n

.meas tran vdout0_57ck1640 FIND v(dout0_57) AT=825.025n

.meas tran vdout0_58ck1640 FIND v(dout0_58) AT=825.025n

.meas tran vdout0_59ck1640 FIND v(dout0_59) AT=825.025n

.meas tran vdout0_60ck1640 FIND v(dout0_60) AT=825.025n

.meas tran vdout0_61ck1640 FIND v(dout0_61) AT=825.025n

.meas tran vdout0_62ck1640 FIND v(dout0_62) AT=825.025n

.meas tran vdout0_63ck1640 FIND v(dout0_63) AT=825.025n

.meas tran vdout0_64ck1640 FIND v(dout0_64) AT=825.025n

.meas tran vdout0_65ck1640 FIND v(dout0_65) AT=825.025n

.meas tran vdout0_66ck1640 FIND v(dout0_66) AT=825.025n

.meas tran vdout0_67ck1640 FIND v(dout0_67) AT=825.025n

.meas tran vdout0_68ck1640 FIND v(dout0_68) AT=825.025n

.meas tran vdout0_69ck1640 FIND v(dout0_69) AT=825.025n

.meas tran vdout0_70ck1640 FIND v(dout0_70) AT=825.025n

.meas tran vdout0_71ck1640 FIND v(dout0_71) AT=825.025n

.meas tran vdout0_72ck1640 FIND v(dout0_72) AT=825.025n

.meas tran vdout0_73ck1640 FIND v(dout0_73) AT=825.025n

.meas tran vdout0_74ck1640 FIND v(dout0_74) AT=825.025n

.meas tran vdout0_75ck1640 FIND v(dout0_75) AT=825.025n

.meas tran vdout0_76ck1640 FIND v(dout0_76) AT=825.025n

.meas tran vdout0_77ck1640 FIND v(dout0_77) AT=825.025n

.meas tran vdout0_78ck1640 FIND v(dout0_78) AT=825.025n

.meas tran vdout0_79ck1640 FIND v(dout0_79) AT=825.025n

.meas tran vdout0_80ck1640 FIND v(dout0_80) AT=825.025n

.meas tran vdout0_81ck1640 FIND v(dout0_81) AT=825.025n

.meas tran vdout0_82ck1640 FIND v(dout0_82) AT=825.025n

.meas tran vdout0_83ck1640 FIND v(dout0_83) AT=825.025n

.meas tran vdout0_84ck1640 FIND v(dout0_84) AT=825.025n

.meas tran vdout0_85ck1640 FIND v(dout0_85) AT=825.025n

.meas tran vdout0_86ck1640 FIND v(dout0_86) AT=825.025n

.meas tran vdout0_87ck1640 FIND v(dout0_87) AT=825.025n

.meas tran vdout0_88ck1640 FIND v(dout0_88) AT=825.025n

.meas tran vdout0_89ck1640 FIND v(dout0_89) AT=825.025n

.meas tran vdout0_90ck1640 FIND v(dout0_90) AT=825.025n

.meas tran vdout0_91ck1640 FIND v(dout0_91) AT=825.025n

.meas tran vdout0_92ck1640 FIND v(dout0_92) AT=825.025n

.meas tran vdout0_93ck1640 FIND v(dout0_93) AT=825.025n

.meas tran vdout0_94ck1640 FIND v(dout0_94) AT=825.025n

.meas tran vdout0_95ck1640 FIND v(dout0_95) AT=825.025n

.meas tran vdout0_96ck1640 FIND v(dout0_96) AT=825.025n

.meas tran vdout0_97ck1640 FIND v(dout0_97) AT=825.025n

.meas tran vdout0_98ck1640 FIND v(dout0_98) AT=825.025n

.meas tran vdout0_99ck1640 FIND v(dout0_99) AT=825.025n

.meas tran vdout0_100ck1640 FIND v(dout0_100) AT=825.025n

.meas tran vdout0_101ck1640 FIND v(dout0_101) AT=825.025n

.meas tran vdout0_102ck1640 FIND v(dout0_102) AT=825.025n

.meas tran vdout0_103ck1640 FIND v(dout0_103) AT=825.025n

.meas tran vdout0_104ck1640 FIND v(dout0_104) AT=825.025n

.meas tran vdout0_105ck1640 FIND v(dout0_105) AT=825.025n

.meas tran vdout0_106ck1640 FIND v(dout0_106) AT=825.025n

.meas tran vdout0_107ck1640 FIND v(dout0_107) AT=825.025n

.meas tran vdout0_108ck1640 FIND v(dout0_108) AT=825.025n

.meas tran vdout0_109ck1640 FIND v(dout0_109) AT=825.025n

.meas tran vdout0_110ck1640 FIND v(dout0_110) AT=825.025n

.meas tran vdout0_111ck1640 FIND v(dout0_111) AT=825.025n

.meas tran vdout0_112ck1640 FIND v(dout0_112) AT=825.025n

.meas tran vdout0_113ck1640 FIND v(dout0_113) AT=825.025n

.meas tran vdout0_114ck1640 FIND v(dout0_114) AT=825.025n

.meas tran vdout0_115ck1640 FIND v(dout0_115) AT=825.025n

.meas tran vdout0_116ck1640 FIND v(dout0_116) AT=825.025n

.meas tran vdout0_117ck1640 FIND v(dout0_117) AT=825.025n

.meas tran vdout0_118ck1640 FIND v(dout0_118) AT=825.025n

.meas tran vdout0_119ck1640 FIND v(dout0_119) AT=825.025n

.meas tran vdout0_120ck1640 FIND v(dout0_120) AT=825.025n

.meas tran vdout0_121ck1640 FIND v(dout0_121) AT=825.025n

.meas tran vdout0_122ck1640 FIND v(dout0_122) AT=825.025n

.meas tran vdout0_123ck1640 FIND v(dout0_123) AT=825.025n

.meas tran vdout0_124ck1640 FIND v(dout0_124) AT=825.025n

.meas tran vdout0_125ck1640 FIND v(dout0_125) AT=825.025n

.meas tran vdout0_126ck1640 FIND v(dout0_126) AT=825.025n

.meas tran vdout0_127ck1640 FIND v(dout0_127) AT=825.025n

.meas tran vdout0_128ck1640 FIND v(dout0_128) AT=825.025n

.meas tran vdout0_129ck1640 FIND v(dout0_129) AT=825.025n

.meas tran vdout0_130ck1640 FIND v(dout0_130) AT=825.025n

.meas tran vdout0_131ck1640 FIND v(dout0_131) AT=825.025n

.meas tran vdout0_132ck1640 FIND v(dout0_132) AT=825.025n

.meas tran vdout0_133ck1640 FIND v(dout0_133) AT=825.025n

.meas tran vdout0_134ck1640 FIND v(dout0_134) AT=825.025n

.meas tran vdout0_135ck1640 FIND v(dout0_135) AT=825.025n

.meas tran vdout0_136ck1640 FIND v(dout0_136) AT=825.025n

.meas tran vdout0_137ck1640 FIND v(dout0_137) AT=825.025n

.meas tran vdout0_138ck1640 FIND v(dout0_138) AT=825.025n

.meas tran vdout0_139ck1640 FIND v(dout0_139) AT=825.025n

.meas tran vdout0_140ck1640 FIND v(dout0_140) AT=825.025n

.meas tran vdout0_141ck1640 FIND v(dout0_141) AT=825.025n

.meas tran vdout0_142ck1640 FIND v(dout0_142) AT=825.025n

.meas tran vdout0_143ck1640 FIND v(dout0_143) AT=825.025n

.meas tran vdout0_144ck1640 FIND v(dout0_144) AT=825.025n

.meas tran vdout0_145ck1640 FIND v(dout0_145) AT=825.025n

.meas tran vdout0_146ck1640 FIND v(dout0_146) AT=825.025n

.meas tran vdout0_147ck1640 FIND v(dout0_147) AT=825.025n

.meas tran vdout0_148ck1640 FIND v(dout0_148) AT=825.025n

.meas tran vdout0_149ck1640 FIND v(dout0_149) AT=825.025n

.meas tran vdout0_150ck1640 FIND v(dout0_150) AT=825.025n

.meas tran vdout0_151ck1640 FIND v(dout0_151) AT=825.025n

.meas tran vdout0_152ck1640 FIND v(dout0_152) AT=825.025n

.meas tran vdout0_153ck1640 FIND v(dout0_153) AT=825.025n

.meas tran vdout0_154ck1640 FIND v(dout0_154) AT=825.025n

.meas tran vdout0_155ck1640 FIND v(dout0_155) AT=825.025n

.meas tran vdout0_156ck1640 FIND v(dout0_156) AT=825.025n

.meas tran vdout0_157ck1640 FIND v(dout0_157) AT=825.025n

.meas tran vdout0_158ck1640 FIND v(dout0_158) AT=825.025n

.meas tran vdout0_159ck1640 FIND v(dout0_159) AT=825.025n

.meas tran vdout0_160ck1640 FIND v(dout0_160) AT=825.025n

.meas tran vdout0_161ck1640 FIND v(dout0_161) AT=825.025n

.meas tran vdout0_162ck1640 FIND v(dout0_162) AT=825.025n

.meas tran vdout0_163ck1640 FIND v(dout0_163) AT=825.025n

.meas tran vdout0_164ck1640 FIND v(dout0_164) AT=825.025n

.meas tran vdout0_165ck1640 FIND v(dout0_165) AT=825.025n

.meas tran vdout0_166ck1640 FIND v(dout0_166) AT=825.025n

.meas tran vdout0_167ck1640 FIND v(dout0_167) AT=825.025n

.meas tran vdout0_168ck1640 FIND v(dout0_168) AT=825.025n

.meas tran vdout0_169ck1640 FIND v(dout0_169) AT=825.025n

.meas tran vdout0_170ck1640 FIND v(dout0_170) AT=825.025n

.meas tran vdout0_171ck1640 FIND v(dout0_171) AT=825.025n

.meas tran vdout0_172ck1640 FIND v(dout0_172) AT=825.025n

.meas tran vdout0_173ck1640 FIND v(dout0_173) AT=825.025n

.meas tran vdout0_174ck1640 FIND v(dout0_174) AT=825.025n

.meas tran vdout0_175ck1640 FIND v(dout0_175) AT=825.025n

.meas tran vdout0_176ck1640 FIND v(dout0_176) AT=825.025n

.meas tran vdout0_177ck1640 FIND v(dout0_177) AT=825.025n

.meas tran vdout0_178ck1640 FIND v(dout0_178) AT=825.025n

.meas tran vdout0_179ck1640 FIND v(dout0_179) AT=825.025n

.meas tran vdout0_180ck1640 FIND v(dout0_180) AT=825.025n

.meas tran vdout0_181ck1640 FIND v(dout0_181) AT=825.025n

.meas tran vdout0_182ck1640 FIND v(dout0_182) AT=825.025n

.meas tran vdout0_183ck1640 FIND v(dout0_183) AT=825.025n

.meas tran vdout0_184ck1640 FIND v(dout0_184) AT=825.025n

.meas tran vdout0_185ck1640 FIND v(dout0_185) AT=825.025n

.meas tran vdout0_186ck1640 FIND v(dout0_186) AT=825.025n

.meas tran vdout0_187ck1640 FIND v(dout0_187) AT=825.025n

.meas tran vdout0_188ck1640 FIND v(dout0_188) AT=825.025n

.meas tran vdout0_189ck1640 FIND v(dout0_189) AT=825.025n

.meas tran vdout0_190ck1640 FIND v(dout0_190) AT=825.025n

.meas tran vdout0_191ck1640 FIND v(dout0_191) AT=825.025n

.meas tran vdout0_192ck1640 FIND v(dout0_192) AT=825.025n

.meas tran vdout0_193ck1640 FIND v(dout0_193) AT=825.025n

.meas tran vdout0_194ck1640 FIND v(dout0_194) AT=825.025n

.meas tran vdout0_195ck1640 FIND v(dout0_195) AT=825.025n

.meas tran vdout0_196ck1640 FIND v(dout0_196) AT=825.025n

.meas tran vdout0_197ck1640 FIND v(dout0_197) AT=825.025n

.meas tran vdout0_198ck1640 FIND v(dout0_198) AT=825.025n

.meas tran vdout0_199ck1640 FIND v(dout0_199) AT=825.025n

.meas tran vdout0_200ck1640 FIND v(dout0_200) AT=825.025n

.meas tran vdout0_201ck1640 FIND v(dout0_201) AT=825.025n

.meas tran vdout0_202ck1640 FIND v(dout0_202) AT=825.025n

.meas tran vdout0_203ck1640 FIND v(dout0_203) AT=825.025n

.meas tran vdout0_204ck1640 FIND v(dout0_204) AT=825.025n

.meas tran vdout0_205ck1640 FIND v(dout0_205) AT=825.025n

.meas tran vdout0_206ck1640 FIND v(dout0_206) AT=825.025n

.meas tran vdout0_207ck1640 FIND v(dout0_207) AT=825.025n

.meas tran vdout0_208ck1640 FIND v(dout0_208) AT=825.025n

.meas tran vdout0_209ck1640 FIND v(dout0_209) AT=825.025n

.meas tran vdout0_210ck1640 FIND v(dout0_210) AT=825.025n

.meas tran vdout0_211ck1640 FIND v(dout0_211) AT=825.025n

.meas tran vdout0_212ck1640 FIND v(dout0_212) AT=825.025n

.meas tran vdout0_213ck1640 FIND v(dout0_213) AT=825.025n

.meas tran vdout0_214ck1640 FIND v(dout0_214) AT=825.025n

.meas tran vdout0_215ck1640 FIND v(dout0_215) AT=825.025n

.meas tran vdout0_216ck1640 FIND v(dout0_216) AT=825.025n

.meas tran vdout0_217ck1640 FIND v(dout0_217) AT=825.025n

.meas tran vdout0_218ck1640 FIND v(dout0_218) AT=825.025n

.meas tran vdout0_219ck1640 FIND v(dout0_219) AT=825.025n

.meas tran vdout0_220ck1640 FIND v(dout0_220) AT=825.025n

.meas tran vdout0_221ck1640 FIND v(dout0_221) AT=825.025n

.meas tran vdout0_222ck1640 FIND v(dout0_222) AT=825.025n

.meas tran vdout0_223ck1640 FIND v(dout0_223) AT=825.025n

.meas tran vdout0_224ck1640 FIND v(dout0_224) AT=825.025n

.meas tran vdout0_225ck1640 FIND v(dout0_225) AT=825.025n

.meas tran vdout0_226ck1640 FIND v(dout0_226) AT=825.025n

.meas tran vdout0_227ck1640 FIND v(dout0_227) AT=825.025n

.meas tran vdout0_228ck1640 FIND v(dout0_228) AT=825.025n

.meas tran vdout0_229ck1640 FIND v(dout0_229) AT=825.025n

.meas tran vdout0_230ck1640 FIND v(dout0_230) AT=825.025n

.meas tran vdout0_231ck1640 FIND v(dout0_231) AT=825.025n

.meas tran vdout0_232ck1640 FIND v(dout0_232) AT=825.025n

.meas tran vdout0_233ck1640 FIND v(dout0_233) AT=825.025n

.meas tran vdout0_234ck1640 FIND v(dout0_234) AT=825.025n

.meas tran vdout0_235ck1640 FIND v(dout0_235) AT=825.025n

.meas tran vdout0_236ck1640 FIND v(dout0_236) AT=825.025n

.meas tran vdout0_237ck1640 FIND v(dout0_237) AT=825.025n

.meas tran vdout0_238ck1640 FIND v(dout0_238) AT=825.025n

.meas tran vdout0_239ck1640 FIND v(dout0_239) AT=825.025n

.meas tran vdout0_240ck1640 FIND v(dout0_240) AT=825.025n

.meas tran vdout0_241ck1640 FIND v(dout0_241) AT=825.025n

.meas tran vdout0_242ck1640 FIND v(dout0_242) AT=825.025n

.meas tran vdout0_243ck1640 FIND v(dout0_243) AT=825.025n

.meas tran vdout0_244ck1640 FIND v(dout0_244) AT=825.025n

.meas tran vdout0_245ck1640 FIND v(dout0_245) AT=825.025n

.meas tran vdout0_246ck1640 FIND v(dout0_246) AT=825.025n

.meas tran vdout0_247ck1640 FIND v(dout0_247) AT=825.025n

.meas tran vdout0_248ck1640 FIND v(dout0_248) AT=825.025n

.meas tran vdout0_249ck1640 FIND v(dout0_249) AT=825.025n

.meas tran vdout0_250ck1640 FIND v(dout0_250) AT=825.025n

.meas tran vdout0_251ck1640 FIND v(dout0_251) AT=825.025n

.meas tran vdout0_252ck1640 FIND v(dout0_252) AT=825.025n

.meas tran vdout0_253ck1640 FIND v(dout0_253) AT=825.025n

.meas tran vdout0_254ck1640 FIND v(dout0_254) AT=825.025n

.meas tran vdout0_255ck1640 FIND v(dout0_255) AT=825.025n

.meas tran vdout0_0ck1660 FIND v(dout0_0) AT=835.025n

.meas tran vdout0_1ck1660 FIND v(dout0_1) AT=835.025n

.meas tran vdout0_2ck1660 FIND v(dout0_2) AT=835.025n

.meas tran vdout0_3ck1660 FIND v(dout0_3) AT=835.025n

.meas tran vdout0_4ck1660 FIND v(dout0_4) AT=835.025n

.meas tran vdout0_5ck1660 FIND v(dout0_5) AT=835.025n

.meas tran vdout0_6ck1660 FIND v(dout0_6) AT=835.025n

.meas tran vdout0_7ck1660 FIND v(dout0_7) AT=835.025n

.meas tran vdout0_8ck1660 FIND v(dout0_8) AT=835.025n

.meas tran vdout0_9ck1660 FIND v(dout0_9) AT=835.025n

.meas tran vdout0_10ck1660 FIND v(dout0_10) AT=835.025n

.meas tran vdout0_11ck1660 FIND v(dout0_11) AT=835.025n

.meas tran vdout0_12ck1660 FIND v(dout0_12) AT=835.025n

.meas tran vdout0_13ck1660 FIND v(dout0_13) AT=835.025n

.meas tran vdout0_14ck1660 FIND v(dout0_14) AT=835.025n

.meas tran vdout0_15ck1660 FIND v(dout0_15) AT=835.025n

.meas tran vdout0_16ck1660 FIND v(dout0_16) AT=835.025n

.meas tran vdout0_17ck1660 FIND v(dout0_17) AT=835.025n

.meas tran vdout0_18ck1660 FIND v(dout0_18) AT=835.025n

.meas tran vdout0_19ck1660 FIND v(dout0_19) AT=835.025n

.meas tran vdout0_20ck1660 FIND v(dout0_20) AT=835.025n

.meas tran vdout0_21ck1660 FIND v(dout0_21) AT=835.025n

.meas tran vdout0_22ck1660 FIND v(dout0_22) AT=835.025n

.meas tran vdout0_23ck1660 FIND v(dout0_23) AT=835.025n

.meas tran vdout0_24ck1660 FIND v(dout0_24) AT=835.025n

.meas tran vdout0_25ck1660 FIND v(dout0_25) AT=835.025n

.meas tran vdout0_26ck1660 FIND v(dout0_26) AT=835.025n

.meas tran vdout0_27ck1660 FIND v(dout0_27) AT=835.025n

.meas tran vdout0_28ck1660 FIND v(dout0_28) AT=835.025n

.meas tran vdout0_29ck1660 FIND v(dout0_29) AT=835.025n

.meas tran vdout0_30ck1660 FIND v(dout0_30) AT=835.025n

.meas tran vdout0_31ck1660 FIND v(dout0_31) AT=835.025n

.meas tran vdout0_32ck1660 FIND v(dout0_32) AT=835.025n

.meas tran vdout0_33ck1660 FIND v(dout0_33) AT=835.025n

.meas tran vdout0_34ck1660 FIND v(dout0_34) AT=835.025n

.meas tran vdout0_35ck1660 FIND v(dout0_35) AT=835.025n

.meas tran vdout0_36ck1660 FIND v(dout0_36) AT=835.025n

.meas tran vdout0_37ck1660 FIND v(dout0_37) AT=835.025n

.meas tran vdout0_38ck1660 FIND v(dout0_38) AT=835.025n

.meas tran vdout0_39ck1660 FIND v(dout0_39) AT=835.025n

.meas tran vdout0_40ck1660 FIND v(dout0_40) AT=835.025n

.meas tran vdout0_41ck1660 FIND v(dout0_41) AT=835.025n

.meas tran vdout0_42ck1660 FIND v(dout0_42) AT=835.025n

.meas tran vdout0_43ck1660 FIND v(dout0_43) AT=835.025n

.meas tran vdout0_44ck1660 FIND v(dout0_44) AT=835.025n

.meas tran vdout0_45ck1660 FIND v(dout0_45) AT=835.025n

.meas tran vdout0_46ck1660 FIND v(dout0_46) AT=835.025n

.meas tran vdout0_47ck1660 FIND v(dout0_47) AT=835.025n

.meas tran vdout0_48ck1660 FIND v(dout0_48) AT=835.025n

.meas tran vdout0_49ck1660 FIND v(dout0_49) AT=835.025n

.meas tran vdout0_50ck1660 FIND v(dout0_50) AT=835.025n

.meas tran vdout0_51ck1660 FIND v(dout0_51) AT=835.025n

.meas tran vdout0_52ck1660 FIND v(dout0_52) AT=835.025n

.meas tran vdout0_53ck1660 FIND v(dout0_53) AT=835.025n

.meas tran vdout0_54ck1660 FIND v(dout0_54) AT=835.025n

.meas tran vdout0_55ck1660 FIND v(dout0_55) AT=835.025n

.meas tran vdout0_56ck1660 FIND v(dout0_56) AT=835.025n

.meas tran vdout0_57ck1660 FIND v(dout0_57) AT=835.025n

.meas tran vdout0_58ck1660 FIND v(dout0_58) AT=835.025n

.meas tran vdout0_59ck1660 FIND v(dout0_59) AT=835.025n

.meas tran vdout0_60ck1660 FIND v(dout0_60) AT=835.025n

.meas tran vdout0_61ck1660 FIND v(dout0_61) AT=835.025n

.meas tran vdout0_62ck1660 FIND v(dout0_62) AT=835.025n

.meas tran vdout0_63ck1660 FIND v(dout0_63) AT=835.025n

.meas tran vdout0_64ck1660 FIND v(dout0_64) AT=835.025n

.meas tran vdout0_65ck1660 FIND v(dout0_65) AT=835.025n

.meas tran vdout0_66ck1660 FIND v(dout0_66) AT=835.025n

.meas tran vdout0_67ck1660 FIND v(dout0_67) AT=835.025n

.meas tran vdout0_68ck1660 FIND v(dout0_68) AT=835.025n

.meas tran vdout0_69ck1660 FIND v(dout0_69) AT=835.025n

.meas tran vdout0_70ck1660 FIND v(dout0_70) AT=835.025n

.meas tran vdout0_71ck1660 FIND v(dout0_71) AT=835.025n

.meas tran vdout0_72ck1660 FIND v(dout0_72) AT=835.025n

.meas tran vdout0_73ck1660 FIND v(dout0_73) AT=835.025n

.meas tran vdout0_74ck1660 FIND v(dout0_74) AT=835.025n

.meas tran vdout0_75ck1660 FIND v(dout0_75) AT=835.025n

.meas tran vdout0_76ck1660 FIND v(dout0_76) AT=835.025n

.meas tran vdout0_77ck1660 FIND v(dout0_77) AT=835.025n

.meas tran vdout0_78ck1660 FIND v(dout0_78) AT=835.025n

.meas tran vdout0_79ck1660 FIND v(dout0_79) AT=835.025n

.meas tran vdout0_80ck1660 FIND v(dout0_80) AT=835.025n

.meas tran vdout0_81ck1660 FIND v(dout0_81) AT=835.025n

.meas tran vdout0_82ck1660 FIND v(dout0_82) AT=835.025n

.meas tran vdout0_83ck1660 FIND v(dout0_83) AT=835.025n

.meas tran vdout0_84ck1660 FIND v(dout0_84) AT=835.025n

.meas tran vdout0_85ck1660 FIND v(dout0_85) AT=835.025n

.meas tran vdout0_86ck1660 FIND v(dout0_86) AT=835.025n

.meas tran vdout0_87ck1660 FIND v(dout0_87) AT=835.025n

.meas tran vdout0_88ck1660 FIND v(dout0_88) AT=835.025n

.meas tran vdout0_89ck1660 FIND v(dout0_89) AT=835.025n

.meas tran vdout0_90ck1660 FIND v(dout0_90) AT=835.025n

.meas tran vdout0_91ck1660 FIND v(dout0_91) AT=835.025n

.meas tran vdout0_92ck1660 FIND v(dout0_92) AT=835.025n

.meas tran vdout0_93ck1660 FIND v(dout0_93) AT=835.025n

.meas tran vdout0_94ck1660 FIND v(dout0_94) AT=835.025n

.meas tran vdout0_95ck1660 FIND v(dout0_95) AT=835.025n

.meas tran vdout0_96ck1660 FIND v(dout0_96) AT=835.025n

.meas tran vdout0_97ck1660 FIND v(dout0_97) AT=835.025n

.meas tran vdout0_98ck1660 FIND v(dout0_98) AT=835.025n

.meas tran vdout0_99ck1660 FIND v(dout0_99) AT=835.025n

.meas tran vdout0_100ck1660 FIND v(dout0_100) AT=835.025n

.meas tran vdout0_101ck1660 FIND v(dout0_101) AT=835.025n

.meas tran vdout0_102ck1660 FIND v(dout0_102) AT=835.025n

.meas tran vdout0_103ck1660 FIND v(dout0_103) AT=835.025n

.meas tran vdout0_104ck1660 FIND v(dout0_104) AT=835.025n

.meas tran vdout0_105ck1660 FIND v(dout0_105) AT=835.025n

.meas tran vdout0_106ck1660 FIND v(dout0_106) AT=835.025n

.meas tran vdout0_107ck1660 FIND v(dout0_107) AT=835.025n

.meas tran vdout0_108ck1660 FIND v(dout0_108) AT=835.025n

.meas tran vdout0_109ck1660 FIND v(dout0_109) AT=835.025n

.meas tran vdout0_110ck1660 FIND v(dout0_110) AT=835.025n

.meas tran vdout0_111ck1660 FIND v(dout0_111) AT=835.025n

.meas tran vdout0_112ck1660 FIND v(dout0_112) AT=835.025n

.meas tran vdout0_113ck1660 FIND v(dout0_113) AT=835.025n

.meas tran vdout0_114ck1660 FIND v(dout0_114) AT=835.025n

.meas tran vdout0_115ck1660 FIND v(dout0_115) AT=835.025n

.meas tran vdout0_116ck1660 FIND v(dout0_116) AT=835.025n

.meas tran vdout0_117ck1660 FIND v(dout0_117) AT=835.025n

.meas tran vdout0_118ck1660 FIND v(dout0_118) AT=835.025n

.meas tran vdout0_119ck1660 FIND v(dout0_119) AT=835.025n

.meas tran vdout0_120ck1660 FIND v(dout0_120) AT=835.025n

.meas tran vdout0_121ck1660 FIND v(dout0_121) AT=835.025n

.meas tran vdout0_122ck1660 FIND v(dout0_122) AT=835.025n

.meas tran vdout0_123ck1660 FIND v(dout0_123) AT=835.025n

.meas tran vdout0_124ck1660 FIND v(dout0_124) AT=835.025n

.meas tran vdout0_125ck1660 FIND v(dout0_125) AT=835.025n

.meas tran vdout0_126ck1660 FIND v(dout0_126) AT=835.025n

.meas tran vdout0_127ck1660 FIND v(dout0_127) AT=835.025n

.meas tran vdout0_128ck1660 FIND v(dout0_128) AT=835.025n

.meas tran vdout0_129ck1660 FIND v(dout0_129) AT=835.025n

.meas tran vdout0_130ck1660 FIND v(dout0_130) AT=835.025n

.meas tran vdout0_131ck1660 FIND v(dout0_131) AT=835.025n

.meas tran vdout0_132ck1660 FIND v(dout0_132) AT=835.025n

.meas tran vdout0_133ck1660 FIND v(dout0_133) AT=835.025n

.meas tran vdout0_134ck1660 FIND v(dout0_134) AT=835.025n

.meas tran vdout0_135ck1660 FIND v(dout0_135) AT=835.025n

.meas tran vdout0_136ck1660 FIND v(dout0_136) AT=835.025n

.meas tran vdout0_137ck1660 FIND v(dout0_137) AT=835.025n

.meas tran vdout0_138ck1660 FIND v(dout0_138) AT=835.025n

.meas tran vdout0_139ck1660 FIND v(dout0_139) AT=835.025n

.meas tran vdout0_140ck1660 FIND v(dout0_140) AT=835.025n

.meas tran vdout0_141ck1660 FIND v(dout0_141) AT=835.025n

.meas tran vdout0_142ck1660 FIND v(dout0_142) AT=835.025n

.meas tran vdout0_143ck1660 FIND v(dout0_143) AT=835.025n

.meas tran vdout0_144ck1660 FIND v(dout0_144) AT=835.025n

.meas tran vdout0_145ck1660 FIND v(dout0_145) AT=835.025n

.meas tran vdout0_146ck1660 FIND v(dout0_146) AT=835.025n

.meas tran vdout0_147ck1660 FIND v(dout0_147) AT=835.025n

.meas tran vdout0_148ck1660 FIND v(dout0_148) AT=835.025n

.meas tran vdout0_149ck1660 FIND v(dout0_149) AT=835.025n

.meas tran vdout0_150ck1660 FIND v(dout0_150) AT=835.025n

.meas tran vdout0_151ck1660 FIND v(dout0_151) AT=835.025n

.meas tran vdout0_152ck1660 FIND v(dout0_152) AT=835.025n

.meas tran vdout0_153ck1660 FIND v(dout0_153) AT=835.025n

.meas tran vdout0_154ck1660 FIND v(dout0_154) AT=835.025n

.meas tran vdout0_155ck1660 FIND v(dout0_155) AT=835.025n

.meas tran vdout0_156ck1660 FIND v(dout0_156) AT=835.025n

.meas tran vdout0_157ck1660 FIND v(dout0_157) AT=835.025n

.meas tran vdout0_158ck1660 FIND v(dout0_158) AT=835.025n

.meas tran vdout0_159ck1660 FIND v(dout0_159) AT=835.025n

.meas tran vdout0_160ck1660 FIND v(dout0_160) AT=835.025n

.meas tran vdout0_161ck1660 FIND v(dout0_161) AT=835.025n

.meas tran vdout0_162ck1660 FIND v(dout0_162) AT=835.025n

.meas tran vdout0_163ck1660 FIND v(dout0_163) AT=835.025n

.meas tran vdout0_164ck1660 FIND v(dout0_164) AT=835.025n

.meas tran vdout0_165ck1660 FIND v(dout0_165) AT=835.025n

.meas tran vdout0_166ck1660 FIND v(dout0_166) AT=835.025n

.meas tran vdout0_167ck1660 FIND v(dout0_167) AT=835.025n

.meas tran vdout0_168ck1660 FIND v(dout0_168) AT=835.025n

.meas tran vdout0_169ck1660 FIND v(dout0_169) AT=835.025n

.meas tran vdout0_170ck1660 FIND v(dout0_170) AT=835.025n

.meas tran vdout0_171ck1660 FIND v(dout0_171) AT=835.025n

.meas tran vdout0_172ck1660 FIND v(dout0_172) AT=835.025n

.meas tran vdout0_173ck1660 FIND v(dout0_173) AT=835.025n

.meas tran vdout0_174ck1660 FIND v(dout0_174) AT=835.025n

.meas tran vdout0_175ck1660 FIND v(dout0_175) AT=835.025n

.meas tran vdout0_176ck1660 FIND v(dout0_176) AT=835.025n

.meas tran vdout0_177ck1660 FIND v(dout0_177) AT=835.025n

.meas tran vdout0_178ck1660 FIND v(dout0_178) AT=835.025n

.meas tran vdout0_179ck1660 FIND v(dout0_179) AT=835.025n

.meas tran vdout0_180ck1660 FIND v(dout0_180) AT=835.025n

.meas tran vdout0_181ck1660 FIND v(dout0_181) AT=835.025n

.meas tran vdout0_182ck1660 FIND v(dout0_182) AT=835.025n

.meas tran vdout0_183ck1660 FIND v(dout0_183) AT=835.025n

.meas tran vdout0_184ck1660 FIND v(dout0_184) AT=835.025n

.meas tran vdout0_185ck1660 FIND v(dout0_185) AT=835.025n

.meas tran vdout0_186ck1660 FIND v(dout0_186) AT=835.025n

.meas tran vdout0_187ck1660 FIND v(dout0_187) AT=835.025n

.meas tran vdout0_188ck1660 FIND v(dout0_188) AT=835.025n

.meas tran vdout0_189ck1660 FIND v(dout0_189) AT=835.025n

.meas tran vdout0_190ck1660 FIND v(dout0_190) AT=835.025n

.meas tran vdout0_191ck1660 FIND v(dout0_191) AT=835.025n

.meas tran vdout0_192ck1660 FIND v(dout0_192) AT=835.025n

.meas tran vdout0_193ck1660 FIND v(dout0_193) AT=835.025n

.meas tran vdout0_194ck1660 FIND v(dout0_194) AT=835.025n

.meas tran vdout0_195ck1660 FIND v(dout0_195) AT=835.025n

.meas tran vdout0_196ck1660 FIND v(dout0_196) AT=835.025n

.meas tran vdout0_197ck1660 FIND v(dout0_197) AT=835.025n

.meas tran vdout0_198ck1660 FIND v(dout0_198) AT=835.025n

.meas tran vdout0_199ck1660 FIND v(dout0_199) AT=835.025n

.meas tran vdout0_200ck1660 FIND v(dout0_200) AT=835.025n

.meas tran vdout0_201ck1660 FIND v(dout0_201) AT=835.025n

.meas tran vdout0_202ck1660 FIND v(dout0_202) AT=835.025n

.meas tran vdout0_203ck1660 FIND v(dout0_203) AT=835.025n

.meas tran vdout0_204ck1660 FIND v(dout0_204) AT=835.025n

.meas tran vdout0_205ck1660 FIND v(dout0_205) AT=835.025n

.meas tran vdout0_206ck1660 FIND v(dout0_206) AT=835.025n

.meas tran vdout0_207ck1660 FIND v(dout0_207) AT=835.025n

.meas tran vdout0_208ck1660 FIND v(dout0_208) AT=835.025n

.meas tran vdout0_209ck1660 FIND v(dout0_209) AT=835.025n

.meas tran vdout0_210ck1660 FIND v(dout0_210) AT=835.025n

.meas tran vdout0_211ck1660 FIND v(dout0_211) AT=835.025n

.meas tran vdout0_212ck1660 FIND v(dout0_212) AT=835.025n

.meas tran vdout0_213ck1660 FIND v(dout0_213) AT=835.025n

.meas tran vdout0_214ck1660 FIND v(dout0_214) AT=835.025n

.meas tran vdout0_215ck1660 FIND v(dout0_215) AT=835.025n

.meas tran vdout0_216ck1660 FIND v(dout0_216) AT=835.025n

.meas tran vdout0_217ck1660 FIND v(dout0_217) AT=835.025n

.meas tran vdout0_218ck1660 FIND v(dout0_218) AT=835.025n

.meas tran vdout0_219ck1660 FIND v(dout0_219) AT=835.025n

.meas tran vdout0_220ck1660 FIND v(dout0_220) AT=835.025n

.meas tran vdout0_221ck1660 FIND v(dout0_221) AT=835.025n

.meas tran vdout0_222ck1660 FIND v(dout0_222) AT=835.025n

.meas tran vdout0_223ck1660 FIND v(dout0_223) AT=835.025n

.meas tran vdout0_224ck1660 FIND v(dout0_224) AT=835.025n

.meas tran vdout0_225ck1660 FIND v(dout0_225) AT=835.025n

.meas tran vdout0_226ck1660 FIND v(dout0_226) AT=835.025n

.meas tran vdout0_227ck1660 FIND v(dout0_227) AT=835.025n

.meas tran vdout0_228ck1660 FIND v(dout0_228) AT=835.025n

.meas tran vdout0_229ck1660 FIND v(dout0_229) AT=835.025n

.meas tran vdout0_230ck1660 FIND v(dout0_230) AT=835.025n

.meas tran vdout0_231ck1660 FIND v(dout0_231) AT=835.025n

.meas tran vdout0_232ck1660 FIND v(dout0_232) AT=835.025n

.meas tran vdout0_233ck1660 FIND v(dout0_233) AT=835.025n

.meas tran vdout0_234ck1660 FIND v(dout0_234) AT=835.025n

.meas tran vdout0_235ck1660 FIND v(dout0_235) AT=835.025n

.meas tran vdout0_236ck1660 FIND v(dout0_236) AT=835.025n

.meas tran vdout0_237ck1660 FIND v(dout0_237) AT=835.025n

.meas tran vdout0_238ck1660 FIND v(dout0_238) AT=835.025n

.meas tran vdout0_239ck1660 FIND v(dout0_239) AT=835.025n

.meas tran vdout0_240ck1660 FIND v(dout0_240) AT=835.025n

.meas tran vdout0_241ck1660 FIND v(dout0_241) AT=835.025n

.meas tran vdout0_242ck1660 FIND v(dout0_242) AT=835.025n

.meas tran vdout0_243ck1660 FIND v(dout0_243) AT=835.025n

.meas tran vdout0_244ck1660 FIND v(dout0_244) AT=835.025n

.meas tran vdout0_245ck1660 FIND v(dout0_245) AT=835.025n

.meas tran vdout0_246ck1660 FIND v(dout0_246) AT=835.025n

.meas tran vdout0_247ck1660 FIND v(dout0_247) AT=835.025n

.meas tran vdout0_248ck1660 FIND v(dout0_248) AT=835.025n

.meas tran vdout0_249ck1660 FIND v(dout0_249) AT=835.025n

.meas tran vdout0_250ck1660 FIND v(dout0_250) AT=835.025n

.meas tran vdout0_251ck1660 FIND v(dout0_251) AT=835.025n

.meas tran vdout0_252ck1660 FIND v(dout0_252) AT=835.025n

.meas tran vdout0_253ck1660 FIND v(dout0_253) AT=835.025n

.meas tran vdout0_254ck1660 FIND v(dout0_254) AT=835.025n

.meas tran vdout0_255ck1660 FIND v(dout0_255) AT=835.025n

.meas tran vdout0_0ck1670 FIND v(dout0_0) AT=840.025n

.meas tran vdout0_1ck1670 FIND v(dout0_1) AT=840.025n

.meas tran vdout0_2ck1670 FIND v(dout0_2) AT=840.025n

.meas tran vdout0_3ck1670 FIND v(dout0_3) AT=840.025n

.meas tran vdout0_4ck1670 FIND v(dout0_4) AT=840.025n

.meas tran vdout0_5ck1670 FIND v(dout0_5) AT=840.025n

.meas tran vdout0_6ck1670 FIND v(dout0_6) AT=840.025n

.meas tran vdout0_7ck1670 FIND v(dout0_7) AT=840.025n

.meas tran vdout0_8ck1670 FIND v(dout0_8) AT=840.025n

.meas tran vdout0_9ck1670 FIND v(dout0_9) AT=840.025n

.meas tran vdout0_10ck1670 FIND v(dout0_10) AT=840.025n

.meas tran vdout0_11ck1670 FIND v(dout0_11) AT=840.025n

.meas tran vdout0_12ck1670 FIND v(dout0_12) AT=840.025n

.meas tran vdout0_13ck1670 FIND v(dout0_13) AT=840.025n

.meas tran vdout0_14ck1670 FIND v(dout0_14) AT=840.025n

.meas tran vdout0_15ck1670 FIND v(dout0_15) AT=840.025n

.meas tran vdout0_16ck1670 FIND v(dout0_16) AT=840.025n

.meas tran vdout0_17ck1670 FIND v(dout0_17) AT=840.025n

.meas tran vdout0_18ck1670 FIND v(dout0_18) AT=840.025n

.meas tran vdout0_19ck1670 FIND v(dout0_19) AT=840.025n

.meas tran vdout0_20ck1670 FIND v(dout0_20) AT=840.025n

.meas tran vdout0_21ck1670 FIND v(dout0_21) AT=840.025n

.meas tran vdout0_22ck1670 FIND v(dout0_22) AT=840.025n

.meas tran vdout0_23ck1670 FIND v(dout0_23) AT=840.025n

.meas tran vdout0_24ck1670 FIND v(dout0_24) AT=840.025n

.meas tran vdout0_25ck1670 FIND v(dout0_25) AT=840.025n

.meas tran vdout0_26ck1670 FIND v(dout0_26) AT=840.025n

.meas tran vdout0_27ck1670 FIND v(dout0_27) AT=840.025n

.meas tran vdout0_28ck1670 FIND v(dout0_28) AT=840.025n

.meas tran vdout0_29ck1670 FIND v(dout0_29) AT=840.025n

.meas tran vdout0_30ck1670 FIND v(dout0_30) AT=840.025n

.meas tran vdout0_31ck1670 FIND v(dout0_31) AT=840.025n

.meas tran vdout0_32ck1670 FIND v(dout0_32) AT=840.025n

.meas tran vdout0_33ck1670 FIND v(dout0_33) AT=840.025n

.meas tran vdout0_34ck1670 FIND v(dout0_34) AT=840.025n

.meas tran vdout0_35ck1670 FIND v(dout0_35) AT=840.025n

.meas tran vdout0_36ck1670 FIND v(dout0_36) AT=840.025n

.meas tran vdout0_37ck1670 FIND v(dout0_37) AT=840.025n

.meas tran vdout0_38ck1670 FIND v(dout0_38) AT=840.025n

.meas tran vdout0_39ck1670 FIND v(dout0_39) AT=840.025n

.meas tran vdout0_40ck1670 FIND v(dout0_40) AT=840.025n

.meas tran vdout0_41ck1670 FIND v(dout0_41) AT=840.025n

.meas tran vdout0_42ck1670 FIND v(dout0_42) AT=840.025n

.meas tran vdout0_43ck1670 FIND v(dout0_43) AT=840.025n

.meas tran vdout0_44ck1670 FIND v(dout0_44) AT=840.025n

.meas tran vdout0_45ck1670 FIND v(dout0_45) AT=840.025n

.meas tran vdout0_46ck1670 FIND v(dout0_46) AT=840.025n

.meas tran vdout0_47ck1670 FIND v(dout0_47) AT=840.025n

.meas tran vdout0_48ck1670 FIND v(dout0_48) AT=840.025n

.meas tran vdout0_49ck1670 FIND v(dout0_49) AT=840.025n

.meas tran vdout0_50ck1670 FIND v(dout0_50) AT=840.025n

.meas tran vdout0_51ck1670 FIND v(dout0_51) AT=840.025n

.meas tran vdout0_52ck1670 FIND v(dout0_52) AT=840.025n

.meas tran vdout0_53ck1670 FIND v(dout0_53) AT=840.025n

.meas tran vdout0_54ck1670 FIND v(dout0_54) AT=840.025n

.meas tran vdout0_55ck1670 FIND v(dout0_55) AT=840.025n

.meas tran vdout0_56ck1670 FIND v(dout0_56) AT=840.025n

.meas tran vdout0_57ck1670 FIND v(dout0_57) AT=840.025n

.meas tran vdout0_58ck1670 FIND v(dout0_58) AT=840.025n

.meas tran vdout0_59ck1670 FIND v(dout0_59) AT=840.025n

.meas tran vdout0_60ck1670 FIND v(dout0_60) AT=840.025n

.meas tran vdout0_61ck1670 FIND v(dout0_61) AT=840.025n

.meas tran vdout0_62ck1670 FIND v(dout0_62) AT=840.025n

.meas tran vdout0_63ck1670 FIND v(dout0_63) AT=840.025n

.meas tran vdout0_64ck1670 FIND v(dout0_64) AT=840.025n

.meas tran vdout0_65ck1670 FIND v(dout0_65) AT=840.025n

.meas tran vdout0_66ck1670 FIND v(dout0_66) AT=840.025n

.meas tran vdout0_67ck1670 FIND v(dout0_67) AT=840.025n

.meas tran vdout0_68ck1670 FIND v(dout0_68) AT=840.025n

.meas tran vdout0_69ck1670 FIND v(dout0_69) AT=840.025n

.meas tran vdout0_70ck1670 FIND v(dout0_70) AT=840.025n

.meas tran vdout0_71ck1670 FIND v(dout0_71) AT=840.025n

.meas tran vdout0_72ck1670 FIND v(dout0_72) AT=840.025n

.meas tran vdout0_73ck1670 FIND v(dout0_73) AT=840.025n

.meas tran vdout0_74ck1670 FIND v(dout0_74) AT=840.025n

.meas tran vdout0_75ck1670 FIND v(dout0_75) AT=840.025n

.meas tran vdout0_76ck1670 FIND v(dout0_76) AT=840.025n

.meas tran vdout0_77ck1670 FIND v(dout0_77) AT=840.025n

.meas tran vdout0_78ck1670 FIND v(dout0_78) AT=840.025n

.meas tran vdout0_79ck1670 FIND v(dout0_79) AT=840.025n

.meas tran vdout0_80ck1670 FIND v(dout0_80) AT=840.025n

.meas tran vdout0_81ck1670 FIND v(dout0_81) AT=840.025n

.meas tran vdout0_82ck1670 FIND v(dout0_82) AT=840.025n

.meas tran vdout0_83ck1670 FIND v(dout0_83) AT=840.025n

.meas tran vdout0_84ck1670 FIND v(dout0_84) AT=840.025n

.meas tran vdout0_85ck1670 FIND v(dout0_85) AT=840.025n

.meas tran vdout0_86ck1670 FIND v(dout0_86) AT=840.025n

.meas tran vdout0_87ck1670 FIND v(dout0_87) AT=840.025n

.meas tran vdout0_88ck1670 FIND v(dout0_88) AT=840.025n

.meas tran vdout0_89ck1670 FIND v(dout0_89) AT=840.025n

.meas tran vdout0_90ck1670 FIND v(dout0_90) AT=840.025n

.meas tran vdout0_91ck1670 FIND v(dout0_91) AT=840.025n

.meas tran vdout0_92ck1670 FIND v(dout0_92) AT=840.025n

.meas tran vdout0_93ck1670 FIND v(dout0_93) AT=840.025n

.meas tran vdout0_94ck1670 FIND v(dout0_94) AT=840.025n

.meas tran vdout0_95ck1670 FIND v(dout0_95) AT=840.025n

.meas tran vdout0_96ck1670 FIND v(dout0_96) AT=840.025n

.meas tran vdout0_97ck1670 FIND v(dout0_97) AT=840.025n

.meas tran vdout0_98ck1670 FIND v(dout0_98) AT=840.025n

.meas tran vdout0_99ck1670 FIND v(dout0_99) AT=840.025n

.meas tran vdout0_100ck1670 FIND v(dout0_100) AT=840.025n

.meas tran vdout0_101ck1670 FIND v(dout0_101) AT=840.025n

.meas tran vdout0_102ck1670 FIND v(dout0_102) AT=840.025n

.meas tran vdout0_103ck1670 FIND v(dout0_103) AT=840.025n

.meas tran vdout0_104ck1670 FIND v(dout0_104) AT=840.025n

.meas tran vdout0_105ck1670 FIND v(dout0_105) AT=840.025n

.meas tran vdout0_106ck1670 FIND v(dout0_106) AT=840.025n

.meas tran vdout0_107ck1670 FIND v(dout0_107) AT=840.025n

.meas tran vdout0_108ck1670 FIND v(dout0_108) AT=840.025n

.meas tran vdout0_109ck1670 FIND v(dout0_109) AT=840.025n

.meas tran vdout0_110ck1670 FIND v(dout0_110) AT=840.025n

.meas tran vdout0_111ck1670 FIND v(dout0_111) AT=840.025n

.meas tran vdout0_112ck1670 FIND v(dout0_112) AT=840.025n

.meas tran vdout0_113ck1670 FIND v(dout0_113) AT=840.025n

.meas tran vdout0_114ck1670 FIND v(dout0_114) AT=840.025n

.meas tran vdout0_115ck1670 FIND v(dout0_115) AT=840.025n

.meas tran vdout0_116ck1670 FIND v(dout0_116) AT=840.025n

.meas tran vdout0_117ck1670 FIND v(dout0_117) AT=840.025n

.meas tran vdout0_118ck1670 FIND v(dout0_118) AT=840.025n

.meas tran vdout0_119ck1670 FIND v(dout0_119) AT=840.025n

.meas tran vdout0_120ck1670 FIND v(dout0_120) AT=840.025n

.meas tran vdout0_121ck1670 FIND v(dout0_121) AT=840.025n

.meas tran vdout0_122ck1670 FIND v(dout0_122) AT=840.025n

.meas tran vdout0_123ck1670 FIND v(dout0_123) AT=840.025n

.meas tran vdout0_124ck1670 FIND v(dout0_124) AT=840.025n

.meas tran vdout0_125ck1670 FIND v(dout0_125) AT=840.025n

.meas tran vdout0_126ck1670 FIND v(dout0_126) AT=840.025n

.meas tran vdout0_127ck1670 FIND v(dout0_127) AT=840.025n

.meas tran vdout0_128ck1670 FIND v(dout0_128) AT=840.025n

.meas tran vdout0_129ck1670 FIND v(dout0_129) AT=840.025n

.meas tran vdout0_130ck1670 FIND v(dout0_130) AT=840.025n

.meas tran vdout0_131ck1670 FIND v(dout0_131) AT=840.025n

.meas tran vdout0_132ck1670 FIND v(dout0_132) AT=840.025n

.meas tran vdout0_133ck1670 FIND v(dout0_133) AT=840.025n

.meas tran vdout0_134ck1670 FIND v(dout0_134) AT=840.025n

.meas tran vdout0_135ck1670 FIND v(dout0_135) AT=840.025n

.meas tran vdout0_136ck1670 FIND v(dout0_136) AT=840.025n

.meas tran vdout0_137ck1670 FIND v(dout0_137) AT=840.025n

.meas tran vdout0_138ck1670 FIND v(dout0_138) AT=840.025n

.meas tran vdout0_139ck1670 FIND v(dout0_139) AT=840.025n

.meas tran vdout0_140ck1670 FIND v(dout0_140) AT=840.025n

.meas tran vdout0_141ck1670 FIND v(dout0_141) AT=840.025n

.meas tran vdout0_142ck1670 FIND v(dout0_142) AT=840.025n

.meas tran vdout0_143ck1670 FIND v(dout0_143) AT=840.025n

.meas tran vdout0_144ck1670 FIND v(dout0_144) AT=840.025n

.meas tran vdout0_145ck1670 FIND v(dout0_145) AT=840.025n

.meas tran vdout0_146ck1670 FIND v(dout0_146) AT=840.025n

.meas tran vdout0_147ck1670 FIND v(dout0_147) AT=840.025n

.meas tran vdout0_148ck1670 FIND v(dout0_148) AT=840.025n

.meas tran vdout0_149ck1670 FIND v(dout0_149) AT=840.025n

.meas tran vdout0_150ck1670 FIND v(dout0_150) AT=840.025n

.meas tran vdout0_151ck1670 FIND v(dout0_151) AT=840.025n

.meas tran vdout0_152ck1670 FIND v(dout0_152) AT=840.025n

.meas tran vdout0_153ck1670 FIND v(dout0_153) AT=840.025n

.meas tran vdout0_154ck1670 FIND v(dout0_154) AT=840.025n

.meas tran vdout0_155ck1670 FIND v(dout0_155) AT=840.025n

.meas tran vdout0_156ck1670 FIND v(dout0_156) AT=840.025n

.meas tran vdout0_157ck1670 FIND v(dout0_157) AT=840.025n

.meas tran vdout0_158ck1670 FIND v(dout0_158) AT=840.025n

.meas tran vdout0_159ck1670 FIND v(dout0_159) AT=840.025n

.meas tran vdout0_160ck1670 FIND v(dout0_160) AT=840.025n

.meas tran vdout0_161ck1670 FIND v(dout0_161) AT=840.025n

.meas tran vdout0_162ck1670 FIND v(dout0_162) AT=840.025n

.meas tran vdout0_163ck1670 FIND v(dout0_163) AT=840.025n

.meas tran vdout0_164ck1670 FIND v(dout0_164) AT=840.025n

.meas tran vdout0_165ck1670 FIND v(dout0_165) AT=840.025n

.meas tran vdout0_166ck1670 FIND v(dout0_166) AT=840.025n

.meas tran vdout0_167ck1670 FIND v(dout0_167) AT=840.025n

.meas tran vdout0_168ck1670 FIND v(dout0_168) AT=840.025n

.meas tran vdout0_169ck1670 FIND v(dout0_169) AT=840.025n

.meas tran vdout0_170ck1670 FIND v(dout0_170) AT=840.025n

.meas tran vdout0_171ck1670 FIND v(dout0_171) AT=840.025n

.meas tran vdout0_172ck1670 FIND v(dout0_172) AT=840.025n

.meas tran vdout0_173ck1670 FIND v(dout0_173) AT=840.025n

.meas tran vdout0_174ck1670 FIND v(dout0_174) AT=840.025n

.meas tran vdout0_175ck1670 FIND v(dout0_175) AT=840.025n

.meas tran vdout0_176ck1670 FIND v(dout0_176) AT=840.025n

.meas tran vdout0_177ck1670 FIND v(dout0_177) AT=840.025n

.meas tran vdout0_178ck1670 FIND v(dout0_178) AT=840.025n

.meas tran vdout0_179ck1670 FIND v(dout0_179) AT=840.025n

.meas tran vdout0_180ck1670 FIND v(dout0_180) AT=840.025n

.meas tran vdout0_181ck1670 FIND v(dout0_181) AT=840.025n

.meas tran vdout0_182ck1670 FIND v(dout0_182) AT=840.025n

.meas tran vdout0_183ck1670 FIND v(dout0_183) AT=840.025n

.meas tran vdout0_184ck1670 FIND v(dout0_184) AT=840.025n

.meas tran vdout0_185ck1670 FIND v(dout0_185) AT=840.025n

.meas tran vdout0_186ck1670 FIND v(dout0_186) AT=840.025n

.meas tran vdout0_187ck1670 FIND v(dout0_187) AT=840.025n

.meas tran vdout0_188ck1670 FIND v(dout0_188) AT=840.025n

.meas tran vdout0_189ck1670 FIND v(dout0_189) AT=840.025n

.meas tran vdout0_190ck1670 FIND v(dout0_190) AT=840.025n

.meas tran vdout0_191ck1670 FIND v(dout0_191) AT=840.025n

.meas tran vdout0_192ck1670 FIND v(dout0_192) AT=840.025n

.meas tran vdout0_193ck1670 FIND v(dout0_193) AT=840.025n

.meas tran vdout0_194ck1670 FIND v(dout0_194) AT=840.025n

.meas tran vdout0_195ck1670 FIND v(dout0_195) AT=840.025n

.meas tran vdout0_196ck1670 FIND v(dout0_196) AT=840.025n

.meas tran vdout0_197ck1670 FIND v(dout0_197) AT=840.025n

.meas tran vdout0_198ck1670 FIND v(dout0_198) AT=840.025n

.meas tran vdout0_199ck1670 FIND v(dout0_199) AT=840.025n

.meas tran vdout0_200ck1670 FIND v(dout0_200) AT=840.025n

.meas tran vdout0_201ck1670 FIND v(dout0_201) AT=840.025n

.meas tran vdout0_202ck1670 FIND v(dout0_202) AT=840.025n

.meas tran vdout0_203ck1670 FIND v(dout0_203) AT=840.025n

.meas tran vdout0_204ck1670 FIND v(dout0_204) AT=840.025n

.meas tran vdout0_205ck1670 FIND v(dout0_205) AT=840.025n

.meas tran vdout0_206ck1670 FIND v(dout0_206) AT=840.025n

.meas tran vdout0_207ck1670 FIND v(dout0_207) AT=840.025n

.meas tran vdout0_208ck1670 FIND v(dout0_208) AT=840.025n

.meas tran vdout0_209ck1670 FIND v(dout0_209) AT=840.025n

.meas tran vdout0_210ck1670 FIND v(dout0_210) AT=840.025n

.meas tran vdout0_211ck1670 FIND v(dout0_211) AT=840.025n

.meas tran vdout0_212ck1670 FIND v(dout0_212) AT=840.025n

.meas tran vdout0_213ck1670 FIND v(dout0_213) AT=840.025n

.meas tran vdout0_214ck1670 FIND v(dout0_214) AT=840.025n

.meas tran vdout0_215ck1670 FIND v(dout0_215) AT=840.025n

.meas tran vdout0_216ck1670 FIND v(dout0_216) AT=840.025n

.meas tran vdout0_217ck1670 FIND v(dout0_217) AT=840.025n

.meas tran vdout0_218ck1670 FIND v(dout0_218) AT=840.025n

.meas tran vdout0_219ck1670 FIND v(dout0_219) AT=840.025n

.meas tran vdout0_220ck1670 FIND v(dout0_220) AT=840.025n

.meas tran vdout0_221ck1670 FIND v(dout0_221) AT=840.025n

.meas tran vdout0_222ck1670 FIND v(dout0_222) AT=840.025n

.meas tran vdout0_223ck1670 FIND v(dout0_223) AT=840.025n

.meas tran vdout0_224ck1670 FIND v(dout0_224) AT=840.025n

.meas tran vdout0_225ck1670 FIND v(dout0_225) AT=840.025n

.meas tran vdout0_226ck1670 FIND v(dout0_226) AT=840.025n

.meas tran vdout0_227ck1670 FIND v(dout0_227) AT=840.025n

.meas tran vdout0_228ck1670 FIND v(dout0_228) AT=840.025n

.meas tran vdout0_229ck1670 FIND v(dout0_229) AT=840.025n

.meas tran vdout0_230ck1670 FIND v(dout0_230) AT=840.025n

.meas tran vdout0_231ck1670 FIND v(dout0_231) AT=840.025n

.meas tran vdout0_232ck1670 FIND v(dout0_232) AT=840.025n

.meas tran vdout0_233ck1670 FIND v(dout0_233) AT=840.025n

.meas tran vdout0_234ck1670 FIND v(dout0_234) AT=840.025n

.meas tran vdout0_235ck1670 FIND v(dout0_235) AT=840.025n

.meas tran vdout0_236ck1670 FIND v(dout0_236) AT=840.025n

.meas tran vdout0_237ck1670 FIND v(dout0_237) AT=840.025n

.meas tran vdout0_238ck1670 FIND v(dout0_238) AT=840.025n

.meas tran vdout0_239ck1670 FIND v(dout0_239) AT=840.025n

.meas tran vdout0_240ck1670 FIND v(dout0_240) AT=840.025n

.meas tran vdout0_241ck1670 FIND v(dout0_241) AT=840.025n

.meas tran vdout0_242ck1670 FIND v(dout0_242) AT=840.025n

.meas tran vdout0_243ck1670 FIND v(dout0_243) AT=840.025n

.meas tran vdout0_244ck1670 FIND v(dout0_244) AT=840.025n

.meas tran vdout0_245ck1670 FIND v(dout0_245) AT=840.025n

.meas tran vdout0_246ck1670 FIND v(dout0_246) AT=840.025n

.meas tran vdout0_247ck1670 FIND v(dout0_247) AT=840.025n

.meas tran vdout0_248ck1670 FIND v(dout0_248) AT=840.025n

.meas tran vdout0_249ck1670 FIND v(dout0_249) AT=840.025n

.meas tran vdout0_250ck1670 FIND v(dout0_250) AT=840.025n

.meas tran vdout0_251ck1670 FIND v(dout0_251) AT=840.025n

.meas tran vdout0_252ck1670 FIND v(dout0_252) AT=840.025n

.meas tran vdout0_253ck1670 FIND v(dout0_253) AT=840.025n

.meas tran vdout0_254ck1670 FIND v(dout0_254) AT=840.025n

.meas tran vdout0_255ck1670 FIND v(dout0_255) AT=840.025n

.meas tran vdout0_0ck1690 FIND v(dout0_0) AT=850.025n

.meas tran vdout0_1ck1690 FIND v(dout0_1) AT=850.025n

.meas tran vdout0_2ck1690 FIND v(dout0_2) AT=850.025n

.meas tran vdout0_3ck1690 FIND v(dout0_3) AT=850.025n

.meas tran vdout0_4ck1690 FIND v(dout0_4) AT=850.025n

.meas tran vdout0_5ck1690 FIND v(dout0_5) AT=850.025n

.meas tran vdout0_6ck1690 FIND v(dout0_6) AT=850.025n

.meas tran vdout0_7ck1690 FIND v(dout0_7) AT=850.025n

.meas tran vdout0_8ck1690 FIND v(dout0_8) AT=850.025n

.meas tran vdout0_9ck1690 FIND v(dout0_9) AT=850.025n

.meas tran vdout0_10ck1690 FIND v(dout0_10) AT=850.025n

.meas tran vdout0_11ck1690 FIND v(dout0_11) AT=850.025n

.meas tran vdout0_12ck1690 FIND v(dout0_12) AT=850.025n

.meas tran vdout0_13ck1690 FIND v(dout0_13) AT=850.025n

.meas tran vdout0_14ck1690 FIND v(dout0_14) AT=850.025n

.meas tran vdout0_15ck1690 FIND v(dout0_15) AT=850.025n

.meas tran vdout0_16ck1690 FIND v(dout0_16) AT=850.025n

.meas tran vdout0_17ck1690 FIND v(dout0_17) AT=850.025n

.meas tran vdout0_18ck1690 FIND v(dout0_18) AT=850.025n

.meas tran vdout0_19ck1690 FIND v(dout0_19) AT=850.025n

.meas tran vdout0_20ck1690 FIND v(dout0_20) AT=850.025n

.meas tran vdout0_21ck1690 FIND v(dout0_21) AT=850.025n

.meas tran vdout0_22ck1690 FIND v(dout0_22) AT=850.025n

.meas tran vdout0_23ck1690 FIND v(dout0_23) AT=850.025n

.meas tran vdout0_24ck1690 FIND v(dout0_24) AT=850.025n

.meas tran vdout0_25ck1690 FIND v(dout0_25) AT=850.025n

.meas tran vdout0_26ck1690 FIND v(dout0_26) AT=850.025n

.meas tran vdout0_27ck1690 FIND v(dout0_27) AT=850.025n

.meas tran vdout0_28ck1690 FIND v(dout0_28) AT=850.025n

.meas tran vdout0_29ck1690 FIND v(dout0_29) AT=850.025n

.meas tran vdout0_30ck1690 FIND v(dout0_30) AT=850.025n

.meas tran vdout0_31ck1690 FIND v(dout0_31) AT=850.025n

.meas tran vdout0_32ck1690 FIND v(dout0_32) AT=850.025n

.meas tran vdout0_33ck1690 FIND v(dout0_33) AT=850.025n

.meas tran vdout0_34ck1690 FIND v(dout0_34) AT=850.025n

.meas tran vdout0_35ck1690 FIND v(dout0_35) AT=850.025n

.meas tran vdout0_36ck1690 FIND v(dout0_36) AT=850.025n

.meas tran vdout0_37ck1690 FIND v(dout0_37) AT=850.025n

.meas tran vdout0_38ck1690 FIND v(dout0_38) AT=850.025n

.meas tran vdout0_39ck1690 FIND v(dout0_39) AT=850.025n

.meas tran vdout0_40ck1690 FIND v(dout0_40) AT=850.025n

.meas tran vdout0_41ck1690 FIND v(dout0_41) AT=850.025n

.meas tran vdout0_42ck1690 FIND v(dout0_42) AT=850.025n

.meas tran vdout0_43ck1690 FIND v(dout0_43) AT=850.025n

.meas tran vdout0_44ck1690 FIND v(dout0_44) AT=850.025n

.meas tran vdout0_45ck1690 FIND v(dout0_45) AT=850.025n

.meas tran vdout0_46ck1690 FIND v(dout0_46) AT=850.025n

.meas tran vdout0_47ck1690 FIND v(dout0_47) AT=850.025n

.meas tran vdout0_48ck1690 FIND v(dout0_48) AT=850.025n

.meas tran vdout0_49ck1690 FIND v(dout0_49) AT=850.025n

.meas tran vdout0_50ck1690 FIND v(dout0_50) AT=850.025n

.meas tran vdout0_51ck1690 FIND v(dout0_51) AT=850.025n

.meas tran vdout0_52ck1690 FIND v(dout0_52) AT=850.025n

.meas tran vdout0_53ck1690 FIND v(dout0_53) AT=850.025n

.meas tran vdout0_54ck1690 FIND v(dout0_54) AT=850.025n

.meas tran vdout0_55ck1690 FIND v(dout0_55) AT=850.025n

.meas tran vdout0_56ck1690 FIND v(dout0_56) AT=850.025n

.meas tran vdout0_57ck1690 FIND v(dout0_57) AT=850.025n

.meas tran vdout0_58ck1690 FIND v(dout0_58) AT=850.025n

.meas tran vdout0_59ck1690 FIND v(dout0_59) AT=850.025n

.meas tran vdout0_60ck1690 FIND v(dout0_60) AT=850.025n

.meas tran vdout0_61ck1690 FIND v(dout0_61) AT=850.025n

.meas tran vdout0_62ck1690 FIND v(dout0_62) AT=850.025n

.meas tran vdout0_63ck1690 FIND v(dout0_63) AT=850.025n

.meas tran vdout0_64ck1690 FIND v(dout0_64) AT=850.025n

.meas tran vdout0_65ck1690 FIND v(dout0_65) AT=850.025n

.meas tran vdout0_66ck1690 FIND v(dout0_66) AT=850.025n

.meas tran vdout0_67ck1690 FIND v(dout0_67) AT=850.025n

.meas tran vdout0_68ck1690 FIND v(dout0_68) AT=850.025n

.meas tran vdout0_69ck1690 FIND v(dout0_69) AT=850.025n

.meas tran vdout0_70ck1690 FIND v(dout0_70) AT=850.025n

.meas tran vdout0_71ck1690 FIND v(dout0_71) AT=850.025n

.meas tran vdout0_72ck1690 FIND v(dout0_72) AT=850.025n

.meas tran vdout0_73ck1690 FIND v(dout0_73) AT=850.025n

.meas tran vdout0_74ck1690 FIND v(dout0_74) AT=850.025n

.meas tran vdout0_75ck1690 FIND v(dout0_75) AT=850.025n

.meas tran vdout0_76ck1690 FIND v(dout0_76) AT=850.025n

.meas tran vdout0_77ck1690 FIND v(dout0_77) AT=850.025n

.meas tran vdout0_78ck1690 FIND v(dout0_78) AT=850.025n

.meas tran vdout0_79ck1690 FIND v(dout0_79) AT=850.025n

.meas tran vdout0_80ck1690 FIND v(dout0_80) AT=850.025n

.meas tran vdout0_81ck1690 FIND v(dout0_81) AT=850.025n

.meas tran vdout0_82ck1690 FIND v(dout0_82) AT=850.025n

.meas tran vdout0_83ck1690 FIND v(dout0_83) AT=850.025n

.meas tran vdout0_84ck1690 FIND v(dout0_84) AT=850.025n

.meas tran vdout0_85ck1690 FIND v(dout0_85) AT=850.025n

.meas tran vdout0_86ck1690 FIND v(dout0_86) AT=850.025n

.meas tran vdout0_87ck1690 FIND v(dout0_87) AT=850.025n

.meas tran vdout0_88ck1690 FIND v(dout0_88) AT=850.025n

.meas tran vdout0_89ck1690 FIND v(dout0_89) AT=850.025n

.meas tran vdout0_90ck1690 FIND v(dout0_90) AT=850.025n

.meas tran vdout0_91ck1690 FIND v(dout0_91) AT=850.025n

.meas tran vdout0_92ck1690 FIND v(dout0_92) AT=850.025n

.meas tran vdout0_93ck1690 FIND v(dout0_93) AT=850.025n

.meas tran vdout0_94ck1690 FIND v(dout0_94) AT=850.025n

.meas tran vdout0_95ck1690 FIND v(dout0_95) AT=850.025n

.meas tran vdout0_96ck1690 FIND v(dout0_96) AT=850.025n

.meas tran vdout0_97ck1690 FIND v(dout0_97) AT=850.025n

.meas tran vdout0_98ck1690 FIND v(dout0_98) AT=850.025n

.meas tran vdout0_99ck1690 FIND v(dout0_99) AT=850.025n

.meas tran vdout0_100ck1690 FIND v(dout0_100) AT=850.025n

.meas tran vdout0_101ck1690 FIND v(dout0_101) AT=850.025n

.meas tran vdout0_102ck1690 FIND v(dout0_102) AT=850.025n

.meas tran vdout0_103ck1690 FIND v(dout0_103) AT=850.025n

.meas tran vdout0_104ck1690 FIND v(dout0_104) AT=850.025n

.meas tran vdout0_105ck1690 FIND v(dout0_105) AT=850.025n

.meas tran vdout0_106ck1690 FIND v(dout0_106) AT=850.025n

.meas tran vdout0_107ck1690 FIND v(dout0_107) AT=850.025n

.meas tran vdout0_108ck1690 FIND v(dout0_108) AT=850.025n

.meas tran vdout0_109ck1690 FIND v(dout0_109) AT=850.025n

.meas tran vdout0_110ck1690 FIND v(dout0_110) AT=850.025n

.meas tran vdout0_111ck1690 FIND v(dout0_111) AT=850.025n

.meas tran vdout0_112ck1690 FIND v(dout0_112) AT=850.025n

.meas tran vdout0_113ck1690 FIND v(dout0_113) AT=850.025n

.meas tran vdout0_114ck1690 FIND v(dout0_114) AT=850.025n

.meas tran vdout0_115ck1690 FIND v(dout0_115) AT=850.025n

.meas tran vdout0_116ck1690 FIND v(dout0_116) AT=850.025n

.meas tran vdout0_117ck1690 FIND v(dout0_117) AT=850.025n

.meas tran vdout0_118ck1690 FIND v(dout0_118) AT=850.025n

.meas tran vdout0_119ck1690 FIND v(dout0_119) AT=850.025n

.meas tran vdout0_120ck1690 FIND v(dout0_120) AT=850.025n

.meas tran vdout0_121ck1690 FIND v(dout0_121) AT=850.025n

.meas tran vdout0_122ck1690 FIND v(dout0_122) AT=850.025n

.meas tran vdout0_123ck1690 FIND v(dout0_123) AT=850.025n

.meas tran vdout0_124ck1690 FIND v(dout0_124) AT=850.025n

.meas tran vdout0_125ck1690 FIND v(dout0_125) AT=850.025n

.meas tran vdout0_126ck1690 FIND v(dout0_126) AT=850.025n

.meas tran vdout0_127ck1690 FIND v(dout0_127) AT=850.025n

.meas tran vdout0_128ck1690 FIND v(dout0_128) AT=850.025n

.meas tran vdout0_129ck1690 FIND v(dout0_129) AT=850.025n

.meas tran vdout0_130ck1690 FIND v(dout0_130) AT=850.025n

.meas tran vdout0_131ck1690 FIND v(dout0_131) AT=850.025n

.meas tran vdout0_132ck1690 FIND v(dout0_132) AT=850.025n

.meas tran vdout0_133ck1690 FIND v(dout0_133) AT=850.025n

.meas tran vdout0_134ck1690 FIND v(dout0_134) AT=850.025n

.meas tran vdout0_135ck1690 FIND v(dout0_135) AT=850.025n

.meas tran vdout0_136ck1690 FIND v(dout0_136) AT=850.025n

.meas tran vdout0_137ck1690 FIND v(dout0_137) AT=850.025n

.meas tran vdout0_138ck1690 FIND v(dout0_138) AT=850.025n

.meas tran vdout0_139ck1690 FIND v(dout0_139) AT=850.025n

.meas tran vdout0_140ck1690 FIND v(dout0_140) AT=850.025n

.meas tran vdout0_141ck1690 FIND v(dout0_141) AT=850.025n

.meas tran vdout0_142ck1690 FIND v(dout0_142) AT=850.025n

.meas tran vdout0_143ck1690 FIND v(dout0_143) AT=850.025n

.meas tran vdout0_144ck1690 FIND v(dout0_144) AT=850.025n

.meas tran vdout0_145ck1690 FIND v(dout0_145) AT=850.025n

.meas tran vdout0_146ck1690 FIND v(dout0_146) AT=850.025n

.meas tran vdout0_147ck1690 FIND v(dout0_147) AT=850.025n

.meas tran vdout0_148ck1690 FIND v(dout0_148) AT=850.025n

.meas tran vdout0_149ck1690 FIND v(dout0_149) AT=850.025n

.meas tran vdout0_150ck1690 FIND v(dout0_150) AT=850.025n

.meas tran vdout0_151ck1690 FIND v(dout0_151) AT=850.025n

.meas tran vdout0_152ck1690 FIND v(dout0_152) AT=850.025n

.meas tran vdout0_153ck1690 FIND v(dout0_153) AT=850.025n

.meas tran vdout0_154ck1690 FIND v(dout0_154) AT=850.025n

.meas tran vdout0_155ck1690 FIND v(dout0_155) AT=850.025n

.meas tran vdout0_156ck1690 FIND v(dout0_156) AT=850.025n

.meas tran vdout0_157ck1690 FIND v(dout0_157) AT=850.025n

.meas tran vdout0_158ck1690 FIND v(dout0_158) AT=850.025n

.meas tran vdout0_159ck1690 FIND v(dout0_159) AT=850.025n

.meas tran vdout0_160ck1690 FIND v(dout0_160) AT=850.025n

.meas tran vdout0_161ck1690 FIND v(dout0_161) AT=850.025n

.meas tran vdout0_162ck1690 FIND v(dout0_162) AT=850.025n

.meas tran vdout0_163ck1690 FIND v(dout0_163) AT=850.025n

.meas tran vdout0_164ck1690 FIND v(dout0_164) AT=850.025n

.meas tran vdout0_165ck1690 FIND v(dout0_165) AT=850.025n

.meas tran vdout0_166ck1690 FIND v(dout0_166) AT=850.025n

.meas tran vdout0_167ck1690 FIND v(dout0_167) AT=850.025n

.meas tran vdout0_168ck1690 FIND v(dout0_168) AT=850.025n

.meas tran vdout0_169ck1690 FIND v(dout0_169) AT=850.025n

.meas tran vdout0_170ck1690 FIND v(dout0_170) AT=850.025n

.meas tran vdout0_171ck1690 FIND v(dout0_171) AT=850.025n

.meas tran vdout0_172ck1690 FIND v(dout0_172) AT=850.025n

.meas tran vdout0_173ck1690 FIND v(dout0_173) AT=850.025n

.meas tran vdout0_174ck1690 FIND v(dout0_174) AT=850.025n

.meas tran vdout0_175ck1690 FIND v(dout0_175) AT=850.025n

.meas tran vdout0_176ck1690 FIND v(dout0_176) AT=850.025n

.meas tran vdout0_177ck1690 FIND v(dout0_177) AT=850.025n

.meas tran vdout0_178ck1690 FIND v(dout0_178) AT=850.025n

.meas tran vdout0_179ck1690 FIND v(dout0_179) AT=850.025n

.meas tran vdout0_180ck1690 FIND v(dout0_180) AT=850.025n

.meas tran vdout0_181ck1690 FIND v(dout0_181) AT=850.025n

.meas tran vdout0_182ck1690 FIND v(dout0_182) AT=850.025n

.meas tran vdout0_183ck1690 FIND v(dout0_183) AT=850.025n

.meas tran vdout0_184ck1690 FIND v(dout0_184) AT=850.025n

.meas tran vdout0_185ck1690 FIND v(dout0_185) AT=850.025n

.meas tran vdout0_186ck1690 FIND v(dout0_186) AT=850.025n

.meas tran vdout0_187ck1690 FIND v(dout0_187) AT=850.025n

.meas tran vdout0_188ck1690 FIND v(dout0_188) AT=850.025n

.meas tran vdout0_189ck1690 FIND v(dout0_189) AT=850.025n

.meas tran vdout0_190ck1690 FIND v(dout0_190) AT=850.025n

.meas tran vdout0_191ck1690 FIND v(dout0_191) AT=850.025n

.meas tran vdout0_192ck1690 FIND v(dout0_192) AT=850.025n

.meas tran vdout0_193ck1690 FIND v(dout0_193) AT=850.025n

.meas tran vdout0_194ck1690 FIND v(dout0_194) AT=850.025n

.meas tran vdout0_195ck1690 FIND v(dout0_195) AT=850.025n

.meas tran vdout0_196ck1690 FIND v(dout0_196) AT=850.025n

.meas tran vdout0_197ck1690 FIND v(dout0_197) AT=850.025n

.meas tran vdout0_198ck1690 FIND v(dout0_198) AT=850.025n

.meas tran vdout0_199ck1690 FIND v(dout0_199) AT=850.025n

.meas tran vdout0_200ck1690 FIND v(dout0_200) AT=850.025n

.meas tran vdout0_201ck1690 FIND v(dout0_201) AT=850.025n

.meas tran vdout0_202ck1690 FIND v(dout0_202) AT=850.025n

.meas tran vdout0_203ck1690 FIND v(dout0_203) AT=850.025n

.meas tran vdout0_204ck1690 FIND v(dout0_204) AT=850.025n

.meas tran vdout0_205ck1690 FIND v(dout0_205) AT=850.025n

.meas tran vdout0_206ck1690 FIND v(dout0_206) AT=850.025n

.meas tran vdout0_207ck1690 FIND v(dout0_207) AT=850.025n

.meas tran vdout0_208ck1690 FIND v(dout0_208) AT=850.025n

.meas tran vdout0_209ck1690 FIND v(dout0_209) AT=850.025n

.meas tran vdout0_210ck1690 FIND v(dout0_210) AT=850.025n

.meas tran vdout0_211ck1690 FIND v(dout0_211) AT=850.025n

.meas tran vdout0_212ck1690 FIND v(dout0_212) AT=850.025n

.meas tran vdout0_213ck1690 FIND v(dout0_213) AT=850.025n

.meas tran vdout0_214ck1690 FIND v(dout0_214) AT=850.025n

.meas tran vdout0_215ck1690 FIND v(dout0_215) AT=850.025n

.meas tran vdout0_216ck1690 FIND v(dout0_216) AT=850.025n

.meas tran vdout0_217ck1690 FIND v(dout0_217) AT=850.025n

.meas tran vdout0_218ck1690 FIND v(dout0_218) AT=850.025n

.meas tran vdout0_219ck1690 FIND v(dout0_219) AT=850.025n

.meas tran vdout0_220ck1690 FIND v(dout0_220) AT=850.025n

.meas tran vdout0_221ck1690 FIND v(dout0_221) AT=850.025n

.meas tran vdout0_222ck1690 FIND v(dout0_222) AT=850.025n

.meas tran vdout0_223ck1690 FIND v(dout0_223) AT=850.025n

.meas tran vdout0_224ck1690 FIND v(dout0_224) AT=850.025n

.meas tran vdout0_225ck1690 FIND v(dout0_225) AT=850.025n

.meas tran vdout0_226ck1690 FIND v(dout0_226) AT=850.025n

.meas tran vdout0_227ck1690 FIND v(dout0_227) AT=850.025n

.meas tran vdout0_228ck1690 FIND v(dout0_228) AT=850.025n

.meas tran vdout0_229ck1690 FIND v(dout0_229) AT=850.025n

.meas tran vdout0_230ck1690 FIND v(dout0_230) AT=850.025n

.meas tran vdout0_231ck1690 FIND v(dout0_231) AT=850.025n

.meas tran vdout0_232ck1690 FIND v(dout0_232) AT=850.025n

.meas tran vdout0_233ck1690 FIND v(dout0_233) AT=850.025n

.meas tran vdout0_234ck1690 FIND v(dout0_234) AT=850.025n

.meas tran vdout0_235ck1690 FIND v(dout0_235) AT=850.025n

.meas tran vdout0_236ck1690 FIND v(dout0_236) AT=850.025n

.meas tran vdout0_237ck1690 FIND v(dout0_237) AT=850.025n

.meas tran vdout0_238ck1690 FIND v(dout0_238) AT=850.025n

.meas tran vdout0_239ck1690 FIND v(dout0_239) AT=850.025n

.meas tran vdout0_240ck1690 FIND v(dout0_240) AT=850.025n

.meas tran vdout0_241ck1690 FIND v(dout0_241) AT=850.025n

.meas tran vdout0_242ck1690 FIND v(dout0_242) AT=850.025n

.meas tran vdout0_243ck1690 FIND v(dout0_243) AT=850.025n

.meas tran vdout0_244ck1690 FIND v(dout0_244) AT=850.025n

.meas tran vdout0_245ck1690 FIND v(dout0_245) AT=850.025n

.meas tran vdout0_246ck1690 FIND v(dout0_246) AT=850.025n

.meas tran vdout0_247ck1690 FIND v(dout0_247) AT=850.025n

.meas tran vdout0_248ck1690 FIND v(dout0_248) AT=850.025n

.meas tran vdout0_249ck1690 FIND v(dout0_249) AT=850.025n

.meas tran vdout0_250ck1690 FIND v(dout0_250) AT=850.025n

.meas tran vdout0_251ck1690 FIND v(dout0_251) AT=850.025n

.meas tran vdout0_252ck1690 FIND v(dout0_252) AT=850.025n

.meas tran vdout0_253ck1690 FIND v(dout0_253) AT=850.025n

.meas tran vdout0_254ck1690 FIND v(dout0_254) AT=850.025n

.meas tran vdout0_255ck1690 FIND v(dout0_255) AT=850.025n

.meas tran vdout0_0ck1710 FIND v(dout0_0) AT=860.025n

.meas tran vdout0_1ck1710 FIND v(dout0_1) AT=860.025n

.meas tran vdout0_2ck1710 FIND v(dout0_2) AT=860.025n

.meas tran vdout0_3ck1710 FIND v(dout0_3) AT=860.025n

.meas tran vdout0_4ck1710 FIND v(dout0_4) AT=860.025n

.meas tran vdout0_5ck1710 FIND v(dout0_5) AT=860.025n

.meas tran vdout0_6ck1710 FIND v(dout0_6) AT=860.025n

.meas tran vdout0_7ck1710 FIND v(dout0_7) AT=860.025n

.meas tran vdout0_8ck1710 FIND v(dout0_8) AT=860.025n

.meas tran vdout0_9ck1710 FIND v(dout0_9) AT=860.025n

.meas tran vdout0_10ck1710 FIND v(dout0_10) AT=860.025n

.meas tran vdout0_11ck1710 FIND v(dout0_11) AT=860.025n

.meas tran vdout0_12ck1710 FIND v(dout0_12) AT=860.025n

.meas tran vdout0_13ck1710 FIND v(dout0_13) AT=860.025n

.meas tran vdout0_14ck1710 FIND v(dout0_14) AT=860.025n

.meas tran vdout0_15ck1710 FIND v(dout0_15) AT=860.025n

.meas tran vdout0_16ck1710 FIND v(dout0_16) AT=860.025n

.meas tran vdout0_17ck1710 FIND v(dout0_17) AT=860.025n

.meas tran vdout0_18ck1710 FIND v(dout0_18) AT=860.025n

.meas tran vdout0_19ck1710 FIND v(dout0_19) AT=860.025n

.meas tran vdout0_20ck1710 FIND v(dout0_20) AT=860.025n

.meas tran vdout0_21ck1710 FIND v(dout0_21) AT=860.025n

.meas tran vdout0_22ck1710 FIND v(dout0_22) AT=860.025n

.meas tran vdout0_23ck1710 FIND v(dout0_23) AT=860.025n

.meas tran vdout0_24ck1710 FIND v(dout0_24) AT=860.025n

.meas tran vdout0_25ck1710 FIND v(dout0_25) AT=860.025n

.meas tran vdout0_26ck1710 FIND v(dout0_26) AT=860.025n

.meas tran vdout0_27ck1710 FIND v(dout0_27) AT=860.025n

.meas tran vdout0_28ck1710 FIND v(dout0_28) AT=860.025n

.meas tran vdout0_29ck1710 FIND v(dout0_29) AT=860.025n

.meas tran vdout0_30ck1710 FIND v(dout0_30) AT=860.025n

.meas tran vdout0_31ck1710 FIND v(dout0_31) AT=860.025n

.meas tran vdout0_32ck1710 FIND v(dout0_32) AT=860.025n

.meas tran vdout0_33ck1710 FIND v(dout0_33) AT=860.025n

.meas tran vdout0_34ck1710 FIND v(dout0_34) AT=860.025n

.meas tran vdout0_35ck1710 FIND v(dout0_35) AT=860.025n

.meas tran vdout0_36ck1710 FIND v(dout0_36) AT=860.025n

.meas tran vdout0_37ck1710 FIND v(dout0_37) AT=860.025n

.meas tran vdout0_38ck1710 FIND v(dout0_38) AT=860.025n

.meas tran vdout0_39ck1710 FIND v(dout0_39) AT=860.025n

.meas tran vdout0_40ck1710 FIND v(dout0_40) AT=860.025n

.meas tran vdout0_41ck1710 FIND v(dout0_41) AT=860.025n

.meas tran vdout0_42ck1710 FIND v(dout0_42) AT=860.025n

.meas tran vdout0_43ck1710 FIND v(dout0_43) AT=860.025n

.meas tran vdout0_44ck1710 FIND v(dout0_44) AT=860.025n

.meas tran vdout0_45ck1710 FIND v(dout0_45) AT=860.025n

.meas tran vdout0_46ck1710 FIND v(dout0_46) AT=860.025n

.meas tran vdout0_47ck1710 FIND v(dout0_47) AT=860.025n

.meas tran vdout0_48ck1710 FIND v(dout0_48) AT=860.025n

.meas tran vdout0_49ck1710 FIND v(dout0_49) AT=860.025n

.meas tran vdout0_50ck1710 FIND v(dout0_50) AT=860.025n

.meas tran vdout0_51ck1710 FIND v(dout0_51) AT=860.025n

.meas tran vdout0_52ck1710 FIND v(dout0_52) AT=860.025n

.meas tran vdout0_53ck1710 FIND v(dout0_53) AT=860.025n

.meas tran vdout0_54ck1710 FIND v(dout0_54) AT=860.025n

.meas tran vdout0_55ck1710 FIND v(dout0_55) AT=860.025n

.meas tran vdout0_56ck1710 FIND v(dout0_56) AT=860.025n

.meas tran vdout0_57ck1710 FIND v(dout0_57) AT=860.025n

.meas tran vdout0_58ck1710 FIND v(dout0_58) AT=860.025n

.meas tran vdout0_59ck1710 FIND v(dout0_59) AT=860.025n

.meas tran vdout0_60ck1710 FIND v(dout0_60) AT=860.025n

.meas tran vdout0_61ck1710 FIND v(dout0_61) AT=860.025n

.meas tran vdout0_62ck1710 FIND v(dout0_62) AT=860.025n

.meas tran vdout0_63ck1710 FIND v(dout0_63) AT=860.025n

.meas tran vdout0_64ck1710 FIND v(dout0_64) AT=860.025n

.meas tran vdout0_65ck1710 FIND v(dout0_65) AT=860.025n

.meas tran vdout0_66ck1710 FIND v(dout0_66) AT=860.025n

.meas tran vdout0_67ck1710 FIND v(dout0_67) AT=860.025n

.meas tran vdout0_68ck1710 FIND v(dout0_68) AT=860.025n

.meas tran vdout0_69ck1710 FIND v(dout0_69) AT=860.025n

.meas tran vdout0_70ck1710 FIND v(dout0_70) AT=860.025n

.meas tran vdout0_71ck1710 FIND v(dout0_71) AT=860.025n

.meas tran vdout0_72ck1710 FIND v(dout0_72) AT=860.025n

.meas tran vdout0_73ck1710 FIND v(dout0_73) AT=860.025n

.meas tran vdout0_74ck1710 FIND v(dout0_74) AT=860.025n

.meas tran vdout0_75ck1710 FIND v(dout0_75) AT=860.025n

.meas tran vdout0_76ck1710 FIND v(dout0_76) AT=860.025n

.meas tran vdout0_77ck1710 FIND v(dout0_77) AT=860.025n

.meas tran vdout0_78ck1710 FIND v(dout0_78) AT=860.025n

.meas tran vdout0_79ck1710 FIND v(dout0_79) AT=860.025n

.meas tran vdout0_80ck1710 FIND v(dout0_80) AT=860.025n

.meas tran vdout0_81ck1710 FIND v(dout0_81) AT=860.025n

.meas tran vdout0_82ck1710 FIND v(dout0_82) AT=860.025n

.meas tran vdout0_83ck1710 FIND v(dout0_83) AT=860.025n

.meas tran vdout0_84ck1710 FIND v(dout0_84) AT=860.025n

.meas tran vdout0_85ck1710 FIND v(dout0_85) AT=860.025n

.meas tran vdout0_86ck1710 FIND v(dout0_86) AT=860.025n

.meas tran vdout0_87ck1710 FIND v(dout0_87) AT=860.025n

.meas tran vdout0_88ck1710 FIND v(dout0_88) AT=860.025n

.meas tran vdout0_89ck1710 FIND v(dout0_89) AT=860.025n

.meas tran vdout0_90ck1710 FIND v(dout0_90) AT=860.025n

.meas tran vdout0_91ck1710 FIND v(dout0_91) AT=860.025n

.meas tran vdout0_92ck1710 FIND v(dout0_92) AT=860.025n

.meas tran vdout0_93ck1710 FIND v(dout0_93) AT=860.025n

.meas tran vdout0_94ck1710 FIND v(dout0_94) AT=860.025n

.meas tran vdout0_95ck1710 FIND v(dout0_95) AT=860.025n

.meas tran vdout0_96ck1710 FIND v(dout0_96) AT=860.025n

.meas tran vdout0_97ck1710 FIND v(dout0_97) AT=860.025n

.meas tran vdout0_98ck1710 FIND v(dout0_98) AT=860.025n

.meas tran vdout0_99ck1710 FIND v(dout0_99) AT=860.025n

.meas tran vdout0_100ck1710 FIND v(dout0_100) AT=860.025n

.meas tran vdout0_101ck1710 FIND v(dout0_101) AT=860.025n

.meas tran vdout0_102ck1710 FIND v(dout0_102) AT=860.025n

.meas tran vdout0_103ck1710 FIND v(dout0_103) AT=860.025n

.meas tran vdout0_104ck1710 FIND v(dout0_104) AT=860.025n

.meas tran vdout0_105ck1710 FIND v(dout0_105) AT=860.025n

.meas tran vdout0_106ck1710 FIND v(dout0_106) AT=860.025n

.meas tran vdout0_107ck1710 FIND v(dout0_107) AT=860.025n

.meas tran vdout0_108ck1710 FIND v(dout0_108) AT=860.025n

.meas tran vdout0_109ck1710 FIND v(dout0_109) AT=860.025n

.meas tran vdout0_110ck1710 FIND v(dout0_110) AT=860.025n

.meas tran vdout0_111ck1710 FIND v(dout0_111) AT=860.025n

.meas tran vdout0_112ck1710 FIND v(dout0_112) AT=860.025n

.meas tran vdout0_113ck1710 FIND v(dout0_113) AT=860.025n

.meas tran vdout0_114ck1710 FIND v(dout0_114) AT=860.025n

.meas tran vdout0_115ck1710 FIND v(dout0_115) AT=860.025n

.meas tran vdout0_116ck1710 FIND v(dout0_116) AT=860.025n

.meas tran vdout0_117ck1710 FIND v(dout0_117) AT=860.025n

.meas tran vdout0_118ck1710 FIND v(dout0_118) AT=860.025n

.meas tran vdout0_119ck1710 FIND v(dout0_119) AT=860.025n

.meas tran vdout0_120ck1710 FIND v(dout0_120) AT=860.025n

.meas tran vdout0_121ck1710 FIND v(dout0_121) AT=860.025n

.meas tran vdout0_122ck1710 FIND v(dout0_122) AT=860.025n

.meas tran vdout0_123ck1710 FIND v(dout0_123) AT=860.025n

.meas tran vdout0_124ck1710 FIND v(dout0_124) AT=860.025n

.meas tran vdout0_125ck1710 FIND v(dout0_125) AT=860.025n

.meas tran vdout0_126ck1710 FIND v(dout0_126) AT=860.025n

.meas tran vdout0_127ck1710 FIND v(dout0_127) AT=860.025n

.meas tran vdout0_128ck1710 FIND v(dout0_128) AT=860.025n

.meas tran vdout0_129ck1710 FIND v(dout0_129) AT=860.025n

.meas tran vdout0_130ck1710 FIND v(dout0_130) AT=860.025n

.meas tran vdout0_131ck1710 FIND v(dout0_131) AT=860.025n

.meas tran vdout0_132ck1710 FIND v(dout0_132) AT=860.025n

.meas tran vdout0_133ck1710 FIND v(dout0_133) AT=860.025n

.meas tran vdout0_134ck1710 FIND v(dout0_134) AT=860.025n

.meas tran vdout0_135ck1710 FIND v(dout0_135) AT=860.025n

.meas tran vdout0_136ck1710 FIND v(dout0_136) AT=860.025n

.meas tran vdout0_137ck1710 FIND v(dout0_137) AT=860.025n

.meas tran vdout0_138ck1710 FIND v(dout0_138) AT=860.025n

.meas tran vdout0_139ck1710 FIND v(dout0_139) AT=860.025n

.meas tran vdout0_140ck1710 FIND v(dout0_140) AT=860.025n

.meas tran vdout0_141ck1710 FIND v(dout0_141) AT=860.025n

.meas tran vdout0_142ck1710 FIND v(dout0_142) AT=860.025n

.meas tran vdout0_143ck1710 FIND v(dout0_143) AT=860.025n

.meas tran vdout0_144ck1710 FIND v(dout0_144) AT=860.025n

.meas tran vdout0_145ck1710 FIND v(dout0_145) AT=860.025n

.meas tran vdout0_146ck1710 FIND v(dout0_146) AT=860.025n

.meas tran vdout0_147ck1710 FIND v(dout0_147) AT=860.025n

.meas tran vdout0_148ck1710 FIND v(dout0_148) AT=860.025n

.meas tran vdout0_149ck1710 FIND v(dout0_149) AT=860.025n

.meas tran vdout0_150ck1710 FIND v(dout0_150) AT=860.025n

.meas tran vdout0_151ck1710 FIND v(dout0_151) AT=860.025n

.meas tran vdout0_152ck1710 FIND v(dout0_152) AT=860.025n

.meas tran vdout0_153ck1710 FIND v(dout0_153) AT=860.025n

.meas tran vdout0_154ck1710 FIND v(dout0_154) AT=860.025n

.meas tran vdout0_155ck1710 FIND v(dout0_155) AT=860.025n

.meas tran vdout0_156ck1710 FIND v(dout0_156) AT=860.025n

.meas tran vdout0_157ck1710 FIND v(dout0_157) AT=860.025n

.meas tran vdout0_158ck1710 FIND v(dout0_158) AT=860.025n

.meas tran vdout0_159ck1710 FIND v(dout0_159) AT=860.025n

.meas tran vdout0_160ck1710 FIND v(dout0_160) AT=860.025n

.meas tran vdout0_161ck1710 FIND v(dout0_161) AT=860.025n

.meas tran vdout0_162ck1710 FIND v(dout0_162) AT=860.025n

.meas tran vdout0_163ck1710 FIND v(dout0_163) AT=860.025n

.meas tran vdout0_164ck1710 FIND v(dout0_164) AT=860.025n

.meas tran vdout0_165ck1710 FIND v(dout0_165) AT=860.025n

.meas tran vdout0_166ck1710 FIND v(dout0_166) AT=860.025n

.meas tran vdout0_167ck1710 FIND v(dout0_167) AT=860.025n

.meas tran vdout0_168ck1710 FIND v(dout0_168) AT=860.025n

.meas tran vdout0_169ck1710 FIND v(dout0_169) AT=860.025n

.meas tran vdout0_170ck1710 FIND v(dout0_170) AT=860.025n

.meas tran vdout0_171ck1710 FIND v(dout0_171) AT=860.025n

.meas tran vdout0_172ck1710 FIND v(dout0_172) AT=860.025n

.meas tran vdout0_173ck1710 FIND v(dout0_173) AT=860.025n

.meas tran vdout0_174ck1710 FIND v(dout0_174) AT=860.025n

.meas tran vdout0_175ck1710 FIND v(dout0_175) AT=860.025n

.meas tran vdout0_176ck1710 FIND v(dout0_176) AT=860.025n

.meas tran vdout0_177ck1710 FIND v(dout0_177) AT=860.025n

.meas tran vdout0_178ck1710 FIND v(dout0_178) AT=860.025n

.meas tran vdout0_179ck1710 FIND v(dout0_179) AT=860.025n

.meas tran vdout0_180ck1710 FIND v(dout0_180) AT=860.025n

.meas tran vdout0_181ck1710 FIND v(dout0_181) AT=860.025n

.meas tran vdout0_182ck1710 FIND v(dout0_182) AT=860.025n

.meas tran vdout0_183ck1710 FIND v(dout0_183) AT=860.025n

.meas tran vdout0_184ck1710 FIND v(dout0_184) AT=860.025n

.meas tran vdout0_185ck1710 FIND v(dout0_185) AT=860.025n

.meas tran vdout0_186ck1710 FIND v(dout0_186) AT=860.025n

.meas tran vdout0_187ck1710 FIND v(dout0_187) AT=860.025n

.meas tran vdout0_188ck1710 FIND v(dout0_188) AT=860.025n

.meas tran vdout0_189ck1710 FIND v(dout0_189) AT=860.025n

.meas tran vdout0_190ck1710 FIND v(dout0_190) AT=860.025n

.meas tran vdout0_191ck1710 FIND v(dout0_191) AT=860.025n

.meas tran vdout0_192ck1710 FIND v(dout0_192) AT=860.025n

.meas tran vdout0_193ck1710 FIND v(dout0_193) AT=860.025n

.meas tran vdout0_194ck1710 FIND v(dout0_194) AT=860.025n

.meas tran vdout0_195ck1710 FIND v(dout0_195) AT=860.025n

.meas tran vdout0_196ck1710 FIND v(dout0_196) AT=860.025n

.meas tran vdout0_197ck1710 FIND v(dout0_197) AT=860.025n

.meas tran vdout0_198ck1710 FIND v(dout0_198) AT=860.025n

.meas tran vdout0_199ck1710 FIND v(dout0_199) AT=860.025n

.meas tran vdout0_200ck1710 FIND v(dout0_200) AT=860.025n

.meas tran vdout0_201ck1710 FIND v(dout0_201) AT=860.025n

.meas tran vdout0_202ck1710 FIND v(dout0_202) AT=860.025n

.meas tran vdout0_203ck1710 FIND v(dout0_203) AT=860.025n

.meas tran vdout0_204ck1710 FIND v(dout0_204) AT=860.025n

.meas tran vdout0_205ck1710 FIND v(dout0_205) AT=860.025n

.meas tran vdout0_206ck1710 FIND v(dout0_206) AT=860.025n

.meas tran vdout0_207ck1710 FIND v(dout0_207) AT=860.025n

.meas tran vdout0_208ck1710 FIND v(dout0_208) AT=860.025n

.meas tran vdout0_209ck1710 FIND v(dout0_209) AT=860.025n

.meas tran vdout0_210ck1710 FIND v(dout0_210) AT=860.025n

.meas tran vdout0_211ck1710 FIND v(dout0_211) AT=860.025n

.meas tran vdout0_212ck1710 FIND v(dout0_212) AT=860.025n

.meas tran vdout0_213ck1710 FIND v(dout0_213) AT=860.025n

.meas tran vdout0_214ck1710 FIND v(dout0_214) AT=860.025n

.meas tran vdout0_215ck1710 FIND v(dout0_215) AT=860.025n

.meas tran vdout0_216ck1710 FIND v(dout0_216) AT=860.025n

.meas tran vdout0_217ck1710 FIND v(dout0_217) AT=860.025n

.meas tran vdout0_218ck1710 FIND v(dout0_218) AT=860.025n

.meas tran vdout0_219ck1710 FIND v(dout0_219) AT=860.025n

.meas tran vdout0_220ck1710 FIND v(dout0_220) AT=860.025n

.meas tran vdout0_221ck1710 FIND v(dout0_221) AT=860.025n

.meas tran vdout0_222ck1710 FIND v(dout0_222) AT=860.025n

.meas tran vdout0_223ck1710 FIND v(dout0_223) AT=860.025n

.meas tran vdout0_224ck1710 FIND v(dout0_224) AT=860.025n

.meas tran vdout0_225ck1710 FIND v(dout0_225) AT=860.025n

.meas tran vdout0_226ck1710 FIND v(dout0_226) AT=860.025n

.meas tran vdout0_227ck1710 FIND v(dout0_227) AT=860.025n

.meas tran vdout0_228ck1710 FIND v(dout0_228) AT=860.025n

.meas tran vdout0_229ck1710 FIND v(dout0_229) AT=860.025n

.meas tran vdout0_230ck1710 FIND v(dout0_230) AT=860.025n

.meas tran vdout0_231ck1710 FIND v(dout0_231) AT=860.025n

.meas tran vdout0_232ck1710 FIND v(dout0_232) AT=860.025n

.meas tran vdout0_233ck1710 FIND v(dout0_233) AT=860.025n

.meas tran vdout0_234ck1710 FIND v(dout0_234) AT=860.025n

.meas tran vdout0_235ck1710 FIND v(dout0_235) AT=860.025n

.meas tran vdout0_236ck1710 FIND v(dout0_236) AT=860.025n

.meas tran vdout0_237ck1710 FIND v(dout0_237) AT=860.025n

.meas tran vdout0_238ck1710 FIND v(dout0_238) AT=860.025n

.meas tran vdout0_239ck1710 FIND v(dout0_239) AT=860.025n

.meas tran vdout0_240ck1710 FIND v(dout0_240) AT=860.025n

.meas tran vdout0_241ck1710 FIND v(dout0_241) AT=860.025n

.meas tran vdout0_242ck1710 FIND v(dout0_242) AT=860.025n

.meas tran vdout0_243ck1710 FIND v(dout0_243) AT=860.025n

.meas tran vdout0_244ck1710 FIND v(dout0_244) AT=860.025n

.meas tran vdout0_245ck1710 FIND v(dout0_245) AT=860.025n

.meas tran vdout0_246ck1710 FIND v(dout0_246) AT=860.025n

.meas tran vdout0_247ck1710 FIND v(dout0_247) AT=860.025n

.meas tran vdout0_248ck1710 FIND v(dout0_248) AT=860.025n

.meas tran vdout0_249ck1710 FIND v(dout0_249) AT=860.025n

.meas tran vdout0_250ck1710 FIND v(dout0_250) AT=860.025n

.meas tran vdout0_251ck1710 FIND v(dout0_251) AT=860.025n

.meas tran vdout0_252ck1710 FIND v(dout0_252) AT=860.025n

.meas tran vdout0_253ck1710 FIND v(dout0_253) AT=860.025n

.meas tran vdout0_254ck1710 FIND v(dout0_254) AT=860.025n

.meas tran vdout0_255ck1710 FIND v(dout0_255) AT=860.025n

.meas tran vdout0_0ck1720 FIND v(dout0_0) AT=865.025n

.meas tran vdout0_1ck1720 FIND v(dout0_1) AT=865.025n

.meas tran vdout0_2ck1720 FIND v(dout0_2) AT=865.025n

.meas tran vdout0_3ck1720 FIND v(dout0_3) AT=865.025n

.meas tran vdout0_4ck1720 FIND v(dout0_4) AT=865.025n

.meas tran vdout0_5ck1720 FIND v(dout0_5) AT=865.025n

.meas tran vdout0_6ck1720 FIND v(dout0_6) AT=865.025n

.meas tran vdout0_7ck1720 FIND v(dout0_7) AT=865.025n

.meas tran vdout0_8ck1720 FIND v(dout0_8) AT=865.025n

.meas tran vdout0_9ck1720 FIND v(dout0_9) AT=865.025n

.meas tran vdout0_10ck1720 FIND v(dout0_10) AT=865.025n

.meas tran vdout0_11ck1720 FIND v(dout0_11) AT=865.025n

.meas tran vdout0_12ck1720 FIND v(dout0_12) AT=865.025n

.meas tran vdout0_13ck1720 FIND v(dout0_13) AT=865.025n

.meas tran vdout0_14ck1720 FIND v(dout0_14) AT=865.025n

.meas tran vdout0_15ck1720 FIND v(dout0_15) AT=865.025n

.meas tran vdout0_16ck1720 FIND v(dout0_16) AT=865.025n

.meas tran vdout0_17ck1720 FIND v(dout0_17) AT=865.025n

.meas tran vdout0_18ck1720 FIND v(dout0_18) AT=865.025n

.meas tran vdout0_19ck1720 FIND v(dout0_19) AT=865.025n

.meas tran vdout0_20ck1720 FIND v(dout0_20) AT=865.025n

.meas tran vdout0_21ck1720 FIND v(dout0_21) AT=865.025n

.meas tran vdout0_22ck1720 FIND v(dout0_22) AT=865.025n

.meas tran vdout0_23ck1720 FIND v(dout0_23) AT=865.025n

.meas tran vdout0_24ck1720 FIND v(dout0_24) AT=865.025n

.meas tran vdout0_25ck1720 FIND v(dout0_25) AT=865.025n

.meas tran vdout0_26ck1720 FIND v(dout0_26) AT=865.025n

.meas tran vdout0_27ck1720 FIND v(dout0_27) AT=865.025n

.meas tran vdout0_28ck1720 FIND v(dout0_28) AT=865.025n

.meas tran vdout0_29ck1720 FIND v(dout0_29) AT=865.025n

.meas tran vdout0_30ck1720 FIND v(dout0_30) AT=865.025n

.meas tran vdout0_31ck1720 FIND v(dout0_31) AT=865.025n

.meas tran vdout0_32ck1720 FIND v(dout0_32) AT=865.025n

.meas tran vdout0_33ck1720 FIND v(dout0_33) AT=865.025n

.meas tran vdout0_34ck1720 FIND v(dout0_34) AT=865.025n

.meas tran vdout0_35ck1720 FIND v(dout0_35) AT=865.025n

.meas tran vdout0_36ck1720 FIND v(dout0_36) AT=865.025n

.meas tran vdout0_37ck1720 FIND v(dout0_37) AT=865.025n

.meas tran vdout0_38ck1720 FIND v(dout0_38) AT=865.025n

.meas tran vdout0_39ck1720 FIND v(dout0_39) AT=865.025n

.meas tran vdout0_40ck1720 FIND v(dout0_40) AT=865.025n

.meas tran vdout0_41ck1720 FIND v(dout0_41) AT=865.025n

.meas tran vdout0_42ck1720 FIND v(dout0_42) AT=865.025n

.meas tran vdout0_43ck1720 FIND v(dout0_43) AT=865.025n

.meas tran vdout0_44ck1720 FIND v(dout0_44) AT=865.025n

.meas tran vdout0_45ck1720 FIND v(dout0_45) AT=865.025n

.meas tran vdout0_46ck1720 FIND v(dout0_46) AT=865.025n

.meas tran vdout0_47ck1720 FIND v(dout0_47) AT=865.025n

.meas tran vdout0_48ck1720 FIND v(dout0_48) AT=865.025n

.meas tran vdout0_49ck1720 FIND v(dout0_49) AT=865.025n

.meas tran vdout0_50ck1720 FIND v(dout0_50) AT=865.025n

.meas tran vdout0_51ck1720 FIND v(dout0_51) AT=865.025n

.meas tran vdout0_52ck1720 FIND v(dout0_52) AT=865.025n

.meas tran vdout0_53ck1720 FIND v(dout0_53) AT=865.025n

.meas tran vdout0_54ck1720 FIND v(dout0_54) AT=865.025n

.meas tran vdout0_55ck1720 FIND v(dout0_55) AT=865.025n

.meas tran vdout0_56ck1720 FIND v(dout0_56) AT=865.025n

.meas tran vdout0_57ck1720 FIND v(dout0_57) AT=865.025n

.meas tran vdout0_58ck1720 FIND v(dout0_58) AT=865.025n

.meas tran vdout0_59ck1720 FIND v(dout0_59) AT=865.025n

.meas tran vdout0_60ck1720 FIND v(dout0_60) AT=865.025n

.meas tran vdout0_61ck1720 FIND v(dout0_61) AT=865.025n

.meas tran vdout0_62ck1720 FIND v(dout0_62) AT=865.025n

.meas tran vdout0_63ck1720 FIND v(dout0_63) AT=865.025n

.meas tran vdout0_64ck1720 FIND v(dout0_64) AT=865.025n

.meas tran vdout0_65ck1720 FIND v(dout0_65) AT=865.025n

.meas tran vdout0_66ck1720 FIND v(dout0_66) AT=865.025n

.meas tran vdout0_67ck1720 FIND v(dout0_67) AT=865.025n

.meas tran vdout0_68ck1720 FIND v(dout0_68) AT=865.025n

.meas tran vdout0_69ck1720 FIND v(dout0_69) AT=865.025n

.meas tran vdout0_70ck1720 FIND v(dout0_70) AT=865.025n

.meas tran vdout0_71ck1720 FIND v(dout0_71) AT=865.025n

.meas tran vdout0_72ck1720 FIND v(dout0_72) AT=865.025n

.meas tran vdout0_73ck1720 FIND v(dout0_73) AT=865.025n

.meas tran vdout0_74ck1720 FIND v(dout0_74) AT=865.025n

.meas tran vdout0_75ck1720 FIND v(dout0_75) AT=865.025n

.meas tran vdout0_76ck1720 FIND v(dout0_76) AT=865.025n

.meas tran vdout0_77ck1720 FIND v(dout0_77) AT=865.025n

.meas tran vdout0_78ck1720 FIND v(dout0_78) AT=865.025n

.meas tran vdout0_79ck1720 FIND v(dout0_79) AT=865.025n

.meas tran vdout0_80ck1720 FIND v(dout0_80) AT=865.025n

.meas tran vdout0_81ck1720 FIND v(dout0_81) AT=865.025n

.meas tran vdout0_82ck1720 FIND v(dout0_82) AT=865.025n

.meas tran vdout0_83ck1720 FIND v(dout0_83) AT=865.025n

.meas tran vdout0_84ck1720 FIND v(dout0_84) AT=865.025n

.meas tran vdout0_85ck1720 FIND v(dout0_85) AT=865.025n

.meas tran vdout0_86ck1720 FIND v(dout0_86) AT=865.025n

.meas tran vdout0_87ck1720 FIND v(dout0_87) AT=865.025n

.meas tran vdout0_88ck1720 FIND v(dout0_88) AT=865.025n

.meas tran vdout0_89ck1720 FIND v(dout0_89) AT=865.025n

.meas tran vdout0_90ck1720 FIND v(dout0_90) AT=865.025n

.meas tran vdout0_91ck1720 FIND v(dout0_91) AT=865.025n

.meas tran vdout0_92ck1720 FIND v(dout0_92) AT=865.025n

.meas tran vdout0_93ck1720 FIND v(dout0_93) AT=865.025n

.meas tran vdout0_94ck1720 FIND v(dout0_94) AT=865.025n

.meas tran vdout0_95ck1720 FIND v(dout0_95) AT=865.025n

.meas tran vdout0_96ck1720 FIND v(dout0_96) AT=865.025n

.meas tran vdout0_97ck1720 FIND v(dout0_97) AT=865.025n

.meas tran vdout0_98ck1720 FIND v(dout0_98) AT=865.025n

.meas tran vdout0_99ck1720 FIND v(dout0_99) AT=865.025n

.meas tran vdout0_100ck1720 FIND v(dout0_100) AT=865.025n

.meas tran vdout0_101ck1720 FIND v(dout0_101) AT=865.025n

.meas tran vdout0_102ck1720 FIND v(dout0_102) AT=865.025n

.meas tran vdout0_103ck1720 FIND v(dout0_103) AT=865.025n

.meas tran vdout0_104ck1720 FIND v(dout0_104) AT=865.025n

.meas tran vdout0_105ck1720 FIND v(dout0_105) AT=865.025n

.meas tran vdout0_106ck1720 FIND v(dout0_106) AT=865.025n

.meas tran vdout0_107ck1720 FIND v(dout0_107) AT=865.025n

.meas tran vdout0_108ck1720 FIND v(dout0_108) AT=865.025n

.meas tran vdout0_109ck1720 FIND v(dout0_109) AT=865.025n

.meas tran vdout0_110ck1720 FIND v(dout0_110) AT=865.025n

.meas tran vdout0_111ck1720 FIND v(dout0_111) AT=865.025n

.meas tran vdout0_112ck1720 FIND v(dout0_112) AT=865.025n

.meas tran vdout0_113ck1720 FIND v(dout0_113) AT=865.025n

.meas tran vdout0_114ck1720 FIND v(dout0_114) AT=865.025n

.meas tran vdout0_115ck1720 FIND v(dout0_115) AT=865.025n

.meas tran vdout0_116ck1720 FIND v(dout0_116) AT=865.025n

.meas tran vdout0_117ck1720 FIND v(dout0_117) AT=865.025n

.meas tran vdout0_118ck1720 FIND v(dout0_118) AT=865.025n

.meas tran vdout0_119ck1720 FIND v(dout0_119) AT=865.025n

.meas tran vdout0_120ck1720 FIND v(dout0_120) AT=865.025n

.meas tran vdout0_121ck1720 FIND v(dout0_121) AT=865.025n

.meas tran vdout0_122ck1720 FIND v(dout0_122) AT=865.025n

.meas tran vdout0_123ck1720 FIND v(dout0_123) AT=865.025n

.meas tran vdout0_124ck1720 FIND v(dout0_124) AT=865.025n

.meas tran vdout0_125ck1720 FIND v(dout0_125) AT=865.025n

.meas tran vdout0_126ck1720 FIND v(dout0_126) AT=865.025n

.meas tran vdout0_127ck1720 FIND v(dout0_127) AT=865.025n

.meas tran vdout0_128ck1720 FIND v(dout0_128) AT=865.025n

.meas tran vdout0_129ck1720 FIND v(dout0_129) AT=865.025n

.meas tran vdout0_130ck1720 FIND v(dout0_130) AT=865.025n

.meas tran vdout0_131ck1720 FIND v(dout0_131) AT=865.025n

.meas tran vdout0_132ck1720 FIND v(dout0_132) AT=865.025n

.meas tran vdout0_133ck1720 FIND v(dout0_133) AT=865.025n

.meas tran vdout0_134ck1720 FIND v(dout0_134) AT=865.025n

.meas tran vdout0_135ck1720 FIND v(dout0_135) AT=865.025n

.meas tran vdout0_136ck1720 FIND v(dout0_136) AT=865.025n

.meas tran vdout0_137ck1720 FIND v(dout0_137) AT=865.025n

.meas tran vdout0_138ck1720 FIND v(dout0_138) AT=865.025n

.meas tran vdout0_139ck1720 FIND v(dout0_139) AT=865.025n

.meas tran vdout0_140ck1720 FIND v(dout0_140) AT=865.025n

.meas tran vdout0_141ck1720 FIND v(dout0_141) AT=865.025n

.meas tran vdout0_142ck1720 FIND v(dout0_142) AT=865.025n

.meas tran vdout0_143ck1720 FIND v(dout0_143) AT=865.025n

.meas tran vdout0_144ck1720 FIND v(dout0_144) AT=865.025n

.meas tran vdout0_145ck1720 FIND v(dout0_145) AT=865.025n

.meas tran vdout0_146ck1720 FIND v(dout0_146) AT=865.025n

.meas tran vdout0_147ck1720 FIND v(dout0_147) AT=865.025n

.meas tran vdout0_148ck1720 FIND v(dout0_148) AT=865.025n

.meas tran vdout0_149ck1720 FIND v(dout0_149) AT=865.025n

.meas tran vdout0_150ck1720 FIND v(dout0_150) AT=865.025n

.meas tran vdout0_151ck1720 FIND v(dout0_151) AT=865.025n

.meas tran vdout0_152ck1720 FIND v(dout0_152) AT=865.025n

.meas tran vdout0_153ck1720 FIND v(dout0_153) AT=865.025n

.meas tran vdout0_154ck1720 FIND v(dout0_154) AT=865.025n

.meas tran vdout0_155ck1720 FIND v(dout0_155) AT=865.025n

.meas tran vdout0_156ck1720 FIND v(dout0_156) AT=865.025n

.meas tran vdout0_157ck1720 FIND v(dout0_157) AT=865.025n

.meas tran vdout0_158ck1720 FIND v(dout0_158) AT=865.025n

.meas tran vdout0_159ck1720 FIND v(dout0_159) AT=865.025n

.meas tran vdout0_160ck1720 FIND v(dout0_160) AT=865.025n

.meas tran vdout0_161ck1720 FIND v(dout0_161) AT=865.025n

.meas tran vdout0_162ck1720 FIND v(dout0_162) AT=865.025n

.meas tran vdout0_163ck1720 FIND v(dout0_163) AT=865.025n

.meas tran vdout0_164ck1720 FIND v(dout0_164) AT=865.025n

.meas tran vdout0_165ck1720 FIND v(dout0_165) AT=865.025n

.meas tran vdout0_166ck1720 FIND v(dout0_166) AT=865.025n

.meas tran vdout0_167ck1720 FIND v(dout0_167) AT=865.025n

.meas tran vdout0_168ck1720 FIND v(dout0_168) AT=865.025n

.meas tran vdout0_169ck1720 FIND v(dout0_169) AT=865.025n

.meas tran vdout0_170ck1720 FIND v(dout0_170) AT=865.025n

.meas tran vdout0_171ck1720 FIND v(dout0_171) AT=865.025n

.meas tran vdout0_172ck1720 FIND v(dout0_172) AT=865.025n

.meas tran vdout0_173ck1720 FIND v(dout0_173) AT=865.025n

.meas tran vdout0_174ck1720 FIND v(dout0_174) AT=865.025n

.meas tran vdout0_175ck1720 FIND v(dout0_175) AT=865.025n

.meas tran vdout0_176ck1720 FIND v(dout0_176) AT=865.025n

.meas tran vdout0_177ck1720 FIND v(dout0_177) AT=865.025n

.meas tran vdout0_178ck1720 FIND v(dout0_178) AT=865.025n

.meas tran vdout0_179ck1720 FIND v(dout0_179) AT=865.025n

.meas tran vdout0_180ck1720 FIND v(dout0_180) AT=865.025n

.meas tran vdout0_181ck1720 FIND v(dout0_181) AT=865.025n

.meas tran vdout0_182ck1720 FIND v(dout0_182) AT=865.025n

.meas tran vdout0_183ck1720 FIND v(dout0_183) AT=865.025n

.meas tran vdout0_184ck1720 FIND v(dout0_184) AT=865.025n

.meas tran vdout0_185ck1720 FIND v(dout0_185) AT=865.025n

.meas tran vdout0_186ck1720 FIND v(dout0_186) AT=865.025n

.meas tran vdout0_187ck1720 FIND v(dout0_187) AT=865.025n

.meas tran vdout0_188ck1720 FIND v(dout0_188) AT=865.025n

.meas tran vdout0_189ck1720 FIND v(dout0_189) AT=865.025n

.meas tran vdout0_190ck1720 FIND v(dout0_190) AT=865.025n

.meas tran vdout0_191ck1720 FIND v(dout0_191) AT=865.025n

.meas tran vdout0_192ck1720 FIND v(dout0_192) AT=865.025n

.meas tran vdout0_193ck1720 FIND v(dout0_193) AT=865.025n

.meas tran vdout0_194ck1720 FIND v(dout0_194) AT=865.025n

.meas tran vdout0_195ck1720 FIND v(dout0_195) AT=865.025n

.meas tran vdout0_196ck1720 FIND v(dout0_196) AT=865.025n

.meas tran vdout0_197ck1720 FIND v(dout0_197) AT=865.025n

.meas tran vdout0_198ck1720 FIND v(dout0_198) AT=865.025n

.meas tran vdout0_199ck1720 FIND v(dout0_199) AT=865.025n

.meas tran vdout0_200ck1720 FIND v(dout0_200) AT=865.025n

.meas tran vdout0_201ck1720 FIND v(dout0_201) AT=865.025n

.meas tran vdout0_202ck1720 FIND v(dout0_202) AT=865.025n

.meas tran vdout0_203ck1720 FIND v(dout0_203) AT=865.025n

.meas tran vdout0_204ck1720 FIND v(dout0_204) AT=865.025n

.meas tran vdout0_205ck1720 FIND v(dout0_205) AT=865.025n

.meas tran vdout0_206ck1720 FIND v(dout0_206) AT=865.025n

.meas tran vdout0_207ck1720 FIND v(dout0_207) AT=865.025n

.meas tran vdout0_208ck1720 FIND v(dout0_208) AT=865.025n

.meas tran vdout0_209ck1720 FIND v(dout0_209) AT=865.025n

.meas tran vdout0_210ck1720 FIND v(dout0_210) AT=865.025n

.meas tran vdout0_211ck1720 FIND v(dout0_211) AT=865.025n

.meas tran vdout0_212ck1720 FIND v(dout0_212) AT=865.025n

.meas tran vdout0_213ck1720 FIND v(dout0_213) AT=865.025n

.meas tran vdout0_214ck1720 FIND v(dout0_214) AT=865.025n

.meas tran vdout0_215ck1720 FIND v(dout0_215) AT=865.025n

.meas tran vdout0_216ck1720 FIND v(dout0_216) AT=865.025n

.meas tran vdout0_217ck1720 FIND v(dout0_217) AT=865.025n

.meas tran vdout0_218ck1720 FIND v(dout0_218) AT=865.025n

.meas tran vdout0_219ck1720 FIND v(dout0_219) AT=865.025n

.meas tran vdout0_220ck1720 FIND v(dout0_220) AT=865.025n

.meas tran vdout0_221ck1720 FIND v(dout0_221) AT=865.025n

.meas tran vdout0_222ck1720 FIND v(dout0_222) AT=865.025n

.meas tran vdout0_223ck1720 FIND v(dout0_223) AT=865.025n

.meas tran vdout0_224ck1720 FIND v(dout0_224) AT=865.025n

.meas tran vdout0_225ck1720 FIND v(dout0_225) AT=865.025n

.meas tran vdout0_226ck1720 FIND v(dout0_226) AT=865.025n

.meas tran vdout0_227ck1720 FIND v(dout0_227) AT=865.025n

.meas tran vdout0_228ck1720 FIND v(dout0_228) AT=865.025n

.meas tran vdout0_229ck1720 FIND v(dout0_229) AT=865.025n

.meas tran vdout0_230ck1720 FIND v(dout0_230) AT=865.025n

.meas tran vdout0_231ck1720 FIND v(dout0_231) AT=865.025n

.meas tran vdout0_232ck1720 FIND v(dout0_232) AT=865.025n

.meas tran vdout0_233ck1720 FIND v(dout0_233) AT=865.025n

.meas tran vdout0_234ck1720 FIND v(dout0_234) AT=865.025n

.meas tran vdout0_235ck1720 FIND v(dout0_235) AT=865.025n

.meas tran vdout0_236ck1720 FIND v(dout0_236) AT=865.025n

.meas tran vdout0_237ck1720 FIND v(dout0_237) AT=865.025n

.meas tran vdout0_238ck1720 FIND v(dout0_238) AT=865.025n

.meas tran vdout0_239ck1720 FIND v(dout0_239) AT=865.025n

.meas tran vdout0_240ck1720 FIND v(dout0_240) AT=865.025n

.meas tran vdout0_241ck1720 FIND v(dout0_241) AT=865.025n

.meas tran vdout0_242ck1720 FIND v(dout0_242) AT=865.025n

.meas tran vdout0_243ck1720 FIND v(dout0_243) AT=865.025n

.meas tran vdout0_244ck1720 FIND v(dout0_244) AT=865.025n

.meas tran vdout0_245ck1720 FIND v(dout0_245) AT=865.025n

.meas tran vdout0_246ck1720 FIND v(dout0_246) AT=865.025n

.meas tran vdout0_247ck1720 FIND v(dout0_247) AT=865.025n

.meas tran vdout0_248ck1720 FIND v(dout0_248) AT=865.025n

.meas tran vdout0_249ck1720 FIND v(dout0_249) AT=865.025n

.meas tran vdout0_250ck1720 FIND v(dout0_250) AT=865.025n

.meas tran vdout0_251ck1720 FIND v(dout0_251) AT=865.025n

.meas tran vdout0_252ck1720 FIND v(dout0_252) AT=865.025n

.meas tran vdout0_253ck1720 FIND v(dout0_253) AT=865.025n

.meas tran vdout0_254ck1720 FIND v(dout0_254) AT=865.025n

.meas tran vdout0_255ck1720 FIND v(dout0_255) AT=865.025n

.meas tran vdout0_0ck1810 FIND v(dout0_0) AT=910.025n

.meas tran vdout0_1ck1810 FIND v(dout0_1) AT=910.025n

.meas tran vdout0_2ck1810 FIND v(dout0_2) AT=910.025n

.meas tran vdout0_3ck1810 FIND v(dout0_3) AT=910.025n

.meas tran vdout0_4ck1810 FIND v(dout0_4) AT=910.025n

.meas tran vdout0_5ck1810 FIND v(dout0_5) AT=910.025n

.meas tran vdout0_6ck1810 FIND v(dout0_6) AT=910.025n

.meas tran vdout0_7ck1810 FIND v(dout0_7) AT=910.025n

.meas tran vdout0_8ck1810 FIND v(dout0_8) AT=910.025n

.meas tran vdout0_9ck1810 FIND v(dout0_9) AT=910.025n

.meas tran vdout0_10ck1810 FIND v(dout0_10) AT=910.025n

.meas tran vdout0_11ck1810 FIND v(dout0_11) AT=910.025n

.meas tran vdout0_12ck1810 FIND v(dout0_12) AT=910.025n

.meas tran vdout0_13ck1810 FIND v(dout0_13) AT=910.025n

.meas tran vdout0_14ck1810 FIND v(dout0_14) AT=910.025n

.meas tran vdout0_15ck1810 FIND v(dout0_15) AT=910.025n

.meas tran vdout0_16ck1810 FIND v(dout0_16) AT=910.025n

.meas tran vdout0_17ck1810 FIND v(dout0_17) AT=910.025n

.meas tran vdout0_18ck1810 FIND v(dout0_18) AT=910.025n

.meas tran vdout0_19ck1810 FIND v(dout0_19) AT=910.025n

.meas tran vdout0_20ck1810 FIND v(dout0_20) AT=910.025n

.meas tran vdout0_21ck1810 FIND v(dout0_21) AT=910.025n

.meas tran vdout0_22ck1810 FIND v(dout0_22) AT=910.025n

.meas tran vdout0_23ck1810 FIND v(dout0_23) AT=910.025n

.meas tran vdout0_24ck1810 FIND v(dout0_24) AT=910.025n

.meas tran vdout0_25ck1810 FIND v(dout0_25) AT=910.025n

.meas tran vdout0_26ck1810 FIND v(dout0_26) AT=910.025n

.meas tran vdout0_27ck1810 FIND v(dout0_27) AT=910.025n

.meas tran vdout0_28ck1810 FIND v(dout0_28) AT=910.025n

.meas tran vdout0_29ck1810 FIND v(dout0_29) AT=910.025n

.meas tran vdout0_30ck1810 FIND v(dout0_30) AT=910.025n

.meas tran vdout0_31ck1810 FIND v(dout0_31) AT=910.025n

.meas tran vdout0_32ck1810 FIND v(dout0_32) AT=910.025n

.meas tran vdout0_33ck1810 FIND v(dout0_33) AT=910.025n

.meas tran vdout0_34ck1810 FIND v(dout0_34) AT=910.025n

.meas tran vdout0_35ck1810 FIND v(dout0_35) AT=910.025n

.meas tran vdout0_36ck1810 FIND v(dout0_36) AT=910.025n

.meas tran vdout0_37ck1810 FIND v(dout0_37) AT=910.025n

.meas tran vdout0_38ck1810 FIND v(dout0_38) AT=910.025n

.meas tran vdout0_39ck1810 FIND v(dout0_39) AT=910.025n

.meas tran vdout0_40ck1810 FIND v(dout0_40) AT=910.025n

.meas tran vdout0_41ck1810 FIND v(dout0_41) AT=910.025n

.meas tran vdout0_42ck1810 FIND v(dout0_42) AT=910.025n

.meas tran vdout0_43ck1810 FIND v(dout0_43) AT=910.025n

.meas tran vdout0_44ck1810 FIND v(dout0_44) AT=910.025n

.meas tran vdout0_45ck1810 FIND v(dout0_45) AT=910.025n

.meas tran vdout0_46ck1810 FIND v(dout0_46) AT=910.025n

.meas tran vdout0_47ck1810 FIND v(dout0_47) AT=910.025n

.meas tran vdout0_48ck1810 FIND v(dout0_48) AT=910.025n

.meas tran vdout0_49ck1810 FIND v(dout0_49) AT=910.025n

.meas tran vdout0_50ck1810 FIND v(dout0_50) AT=910.025n

.meas tran vdout0_51ck1810 FIND v(dout0_51) AT=910.025n

.meas tran vdout0_52ck1810 FIND v(dout0_52) AT=910.025n

.meas tran vdout0_53ck1810 FIND v(dout0_53) AT=910.025n

.meas tran vdout0_54ck1810 FIND v(dout0_54) AT=910.025n

.meas tran vdout0_55ck1810 FIND v(dout0_55) AT=910.025n

.meas tran vdout0_56ck1810 FIND v(dout0_56) AT=910.025n

.meas tran vdout0_57ck1810 FIND v(dout0_57) AT=910.025n

.meas tran vdout0_58ck1810 FIND v(dout0_58) AT=910.025n

.meas tran vdout0_59ck1810 FIND v(dout0_59) AT=910.025n

.meas tran vdout0_60ck1810 FIND v(dout0_60) AT=910.025n

.meas tran vdout0_61ck1810 FIND v(dout0_61) AT=910.025n

.meas tran vdout0_62ck1810 FIND v(dout0_62) AT=910.025n

.meas tran vdout0_63ck1810 FIND v(dout0_63) AT=910.025n

.meas tran vdout0_64ck1810 FIND v(dout0_64) AT=910.025n

.meas tran vdout0_65ck1810 FIND v(dout0_65) AT=910.025n

.meas tran vdout0_66ck1810 FIND v(dout0_66) AT=910.025n

.meas tran vdout0_67ck1810 FIND v(dout0_67) AT=910.025n

.meas tran vdout0_68ck1810 FIND v(dout0_68) AT=910.025n

.meas tran vdout0_69ck1810 FIND v(dout0_69) AT=910.025n

.meas tran vdout0_70ck1810 FIND v(dout0_70) AT=910.025n

.meas tran vdout0_71ck1810 FIND v(dout0_71) AT=910.025n

.meas tran vdout0_72ck1810 FIND v(dout0_72) AT=910.025n

.meas tran vdout0_73ck1810 FIND v(dout0_73) AT=910.025n

.meas tran vdout0_74ck1810 FIND v(dout0_74) AT=910.025n

.meas tran vdout0_75ck1810 FIND v(dout0_75) AT=910.025n

.meas tran vdout0_76ck1810 FIND v(dout0_76) AT=910.025n

.meas tran vdout0_77ck1810 FIND v(dout0_77) AT=910.025n

.meas tran vdout0_78ck1810 FIND v(dout0_78) AT=910.025n

.meas tran vdout0_79ck1810 FIND v(dout0_79) AT=910.025n

.meas tran vdout0_80ck1810 FIND v(dout0_80) AT=910.025n

.meas tran vdout0_81ck1810 FIND v(dout0_81) AT=910.025n

.meas tran vdout0_82ck1810 FIND v(dout0_82) AT=910.025n

.meas tran vdout0_83ck1810 FIND v(dout0_83) AT=910.025n

.meas tran vdout0_84ck1810 FIND v(dout0_84) AT=910.025n

.meas tran vdout0_85ck1810 FIND v(dout0_85) AT=910.025n

.meas tran vdout0_86ck1810 FIND v(dout0_86) AT=910.025n

.meas tran vdout0_87ck1810 FIND v(dout0_87) AT=910.025n

.meas tran vdout0_88ck1810 FIND v(dout0_88) AT=910.025n

.meas tran vdout0_89ck1810 FIND v(dout0_89) AT=910.025n

.meas tran vdout0_90ck1810 FIND v(dout0_90) AT=910.025n

.meas tran vdout0_91ck1810 FIND v(dout0_91) AT=910.025n

.meas tran vdout0_92ck1810 FIND v(dout0_92) AT=910.025n

.meas tran vdout0_93ck1810 FIND v(dout0_93) AT=910.025n

.meas tran vdout0_94ck1810 FIND v(dout0_94) AT=910.025n

.meas tran vdout0_95ck1810 FIND v(dout0_95) AT=910.025n

.meas tran vdout0_96ck1810 FIND v(dout0_96) AT=910.025n

.meas tran vdout0_97ck1810 FIND v(dout0_97) AT=910.025n

.meas tran vdout0_98ck1810 FIND v(dout0_98) AT=910.025n

.meas tran vdout0_99ck1810 FIND v(dout0_99) AT=910.025n

.meas tran vdout0_100ck1810 FIND v(dout0_100) AT=910.025n

.meas tran vdout0_101ck1810 FIND v(dout0_101) AT=910.025n

.meas tran vdout0_102ck1810 FIND v(dout0_102) AT=910.025n

.meas tran vdout0_103ck1810 FIND v(dout0_103) AT=910.025n

.meas tran vdout0_104ck1810 FIND v(dout0_104) AT=910.025n

.meas tran vdout0_105ck1810 FIND v(dout0_105) AT=910.025n

.meas tran vdout0_106ck1810 FIND v(dout0_106) AT=910.025n

.meas tran vdout0_107ck1810 FIND v(dout0_107) AT=910.025n

.meas tran vdout0_108ck1810 FIND v(dout0_108) AT=910.025n

.meas tran vdout0_109ck1810 FIND v(dout0_109) AT=910.025n

.meas tran vdout0_110ck1810 FIND v(dout0_110) AT=910.025n

.meas tran vdout0_111ck1810 FIND v(dout0_111) AT=910.025n

.meas tran vdout0_112ck1810 FIND v(dout0_112) AT=910.025n

.meas tran vdout0_113ck1810 FIND v(dout0_113) AT=910.025n

.meas tran vdout0_114ck1810 FIND v(dout0_114) AT=910.025n

.meas tran vdout0_115ck1810 FIND v(dout0_115) AT=910.025n

.meas tran vdout0_116ck1810 FIND v(dout0_116) AT=910.025n

.meas tran vdout0_117ck1810 FIND v(dout0_117) AT=910.025n

.meas tran vdout0_118ck1810 FIND v(dout0_118) AT=910.025n

.meas tran vdout0_119ck1810 FIND v(dout0_119) AT=910.025n

.meas tran vdout0_120ck1810 FIND v(dout0_120) AT=910.025n

.meas tran vdout0_121ck1810 FIND v(dout0_121) AT=910.025n

.meas tran vdout0_122ck1810 FIND v(dout0_122) AT=910.025n

.meas tran vdout0_123ck1810 FIND v(dout0_123) AT=910.025n

.meas tran vdout0_124ck1810 FIND v(dout0_124) AT=910.025n

.meas tran vdout0_125ck1810 FIND v(dout0_125) AT=910.025n

.meas tran vdout0_126ck1810 FIND v(dout0_126) AT=910.025n

.meas tran vdout0_127ck1810 FIND v(dout0_127) AT=910.025n

.meas tran vdout0_128ck1810 FIND v(dout0_128) AT=910.025n

.meas tran vdout0_129ck1810 FIND v(dout0_129) AT=910.025n

.meas tran vdout0_130ck1810 FIND v(dout0_130) AT=910.025n

.meas tran vdout0_131ck1810 FIND v(dout0_131) AT=910.025n

.meas tran vdout0_132ck1810 FIND v(dout0_132) AT=910.025n

.meas tran vdout0_133ck1810 FIND v(dout0_133) AT=910.025n

.meas tran vdout0_134ck1810 FIND v(dout0_134) AT=910.025n

.meas tran vdout0_135ck1810 FIND v(dout0_135) AT=910.025n

.meas tran vdout0_136ck1810 FIND v(dout0_136) AT=910.025n

.meas tran vdout0_137ck1810 FIND v(dout0_137) AT=910.025n

.meas tran vdout0_138ck1810 FIND v(dout0_138) AT=910.025n

.meas tran vdout0_139ck1810 FIND v(dout0_139) AT=910.025n

.meas tran vdout0_140ck1810 FIND v(dout0_140) AT=910.025n

.meas tran vdout0_141ck1810 FIND v(dout0_141) AT=910.025n

.meas tran vdout0_142ck1810 FIND v(dout0_142) AT=910.025n

.meas tran vdout0_143ck1810 FIND v(dout0_143) AT=910.025n

.meas tran vdout0_144ck1810 FIND v(dout0_144) AT=910.025n

.meas tran vdout0_145ck1810 FIND v(dout0_145) AT=910.025n

.meas tran vdout0_146ck1810 FIND v(dout0_146) AT=910.025n

.meas tran vdout0_147ck1810 FIND v(dout0_147) AT=910.025n

.meas tran vdout0_148ck1810 FIND v(dout0_148) AT=910.025n

.meas tran vdout0_149ck1810 FIND v(dout0_149) AT=910.025n

.meas tran vdout0_150ck1810 FIND v(dout0_150) AT=910.025n

.meas tran vdout0_151ck1810 FIND v(dout0_151) AT=910.025n

.meas tran vdout0_152ck1810 FIND v(dout0_152) AT=910.025n

.meas tran vdout0_153ck1810 FIND v(dout0_153) AT=910.025n

.meas tran vdout0_154ck1810 FIND v(dout0_154) AT=910.025n

.meas tran vdout0_155ck1810 FIND v(dout0_155) AT=910.025n

.meas tran vdout0_156ck1810 FIND v(dout0_156) AT=910.025n

.meas tran vdout0_157ck1810 FIND v(dout0_157) AT=910.025n

.meas tran vdout0_158ck1810 FIND v(dout0_158) AT=910.025n

.meas tran vdout0_159ck1810 FIND v(dout0_159) AT=910.025n

.meas tran vdout0_160ck1810 FIND v(dout0_160) AT=910.025n

.meas tran vdout0_161ck1810 FIND v(dout0_161) AT=910.025n

.meas tran vdout0_162ck1810 FIND v(dout0_162) AT=910.025n

.meas tran vdout0_163ck1810 FIND v(dout0_163) AT=910.025n

.meas tran vdout0_164ck1810 FIND v(dout0_164) AT=910.025n

.meas tran vdout0_165ck1810 FIND v(dout0_165) AT=910.025n

.meas tran vdout0_166ck1810 FIND v(dout0_166) AT=910.025n

.meas tran vdout0_167ck1810 FIND v(dout0_167) AT=910.025n

.meas tran vdout0_168ck1810 FIND v(dout0_168) AT=910.025n

.meas tran vdout0_169ck1810 FIND v(dout0_169) AT=910.025n

.meas tran vdout0_170ck1810 FIND v(dout0_170) AT=910.025n

.meas tran vdout0_171ck1810 FIND v(dout0_171) AT=910.025n

.meas tran vdout0_172ck1810 FIND v(dout0_172) AT=910.025n

.meas tran vdout0_173ck1810 FIND v(dout0_173) AT=910.025n

.meas tran vdout0_174ck1810 FIND v(dout0_174) AT=910.025n

.meas tran vdout0_175ck1810 FIND v(dout0_175) AT=910.025n

.meas tran vdout0_176ck1810 FIND v(dout0_176) AT=910.025n

.meas tran vdout0_177ck1810 FIND v(dout0_177) AT=910.025n

.meas tran vdout0_178ck1810 FIND v(dout0_178) AT=910.025n

.meas tran vdout0_179ck1810 FIND v(dout0_179) AT=910.025n

.meas tran vdout0_180ck1810 FIND v(dout0_180) AT=910.025n

.meas tran vdout0_181ck1810 FIND v(dout0_181) AT=910.025n

.meas tran vdout0_182ck1810 FIND v(dout0_182) AT=910.025n

.meas tran vdout0_183ck1810 FIND v(dout0_183) AT=910.025n

.meas tran vdout0_184ck1810 FIND v(dout0_184) AT=910.025n

.meas tran vdout0_185ck1810 FIND v(dout0_185) AT=910.025n

.meas tran vdout0_186ck1810 FIND v(dout0_186) AT=910.025n

.meas tran vdout0_187ck1810 FIND v(dout0_187) AT=910.025n

.meas tran vdout0_188ck1810 FIND v(dout0_188) AT=910.025n

.meas tran vdout0_189ck1810 FIND v(dout0_189) AT=910.025n

.meas tran vdout0_190ck1810 FIND v(dout0_190) AT=910.025n

.meas tran vdout0_191ck1810 FIND v(dout0_191) AT=910.025n

.meas tran vdout0_192ck1810 FIND v(dout0_192) AT=910.025n

.meas tran vdout0_193ck1810 FIND v(dout0_193) AT=910.025n

.meas tran vdout0_194ck1810 FIND v(dout0_194) AT=910.025n

.meas tran vdout0_195ck1810 FIND v(dout0_195) AT=910.025n

.meas tran vdout0_196ck1810 FIND v(dout0_196) AT=910.025n

.meas tran vdout0_197ck1810 FIND v(dout0_197) AT=910.025n

.meas tran vdout0_198ck1810 FIND v(dout0_198) AT=910.025n

.meas tran vdout0_199ck1810 FIND v(dout0_199) AT=910.025n

.meas tran vdout0_200ck1810 FIND v(dout0_200) AT=910.025n

.meas tran vdout0_201ck1810 FIND v(dout0_201) AT=910.025n

.meas tran vdout0_202ck1810 FIND v(dout0_202) AT=910.025n

.meas tran vdout0_203ck1810 FIND v(dout0_203) AT=910.025n

.meas tran vdout0_204ck1810 FIND v(dout0_204) AT=910.025n

.meas tran vdout0_205ck1810 FIND v(dout0_205) AT=910.025n

.meas tran vdout0_206ck1810 FIND v(dout0_206) AT=910.025n

.meas tran vdout0_207ck1810 FIND v(dout0_207) AT=910.025n

.meas tran vdout0_208ck1810 FIND v(dout0_208) AT=910.025n

.meas tran vdout0_209ck1810 FIND v(dout0_209) AT=910.025n

.meas tran vdout0_210ck1810 FIND v(dout0_210) AT=910.025n

.meas tran vdout0_211ck1810 FIND v(dout0_211) AT=910.025n

.meas tran vdout0_212ck1810 FIND v(dout0_212) AT=910.025n

.meas tran vdout0_213ck1810 FIND v(dout0_213) AT=910.025n

.meas tran vdout0_214ck1810 FIND v(dout0_214) AT=910.025n

.meas tran vdout0_215ck1810 FIND v(dout0_215) AT=910.025n

.meas tran vdout0_216ck1810 FIND v(dout0_216) AT=910.025n

.meas tran vdout0_217ck1810 FIND v(dout0_217) AT=910.025n

.meas tran vdout0_218ck1810 FIND v(dout0_218) AT=910.025n

.meas tran vdout0_219ck1810 FIND v(dout0_219) AT=910.025n

.meas tran vdout0_220ck1810 FIND v(dout0_220) AT=910.025n

.meas tran vdout0_221ck1810 FIND v(dout0_221) AT=910.025n

.meas tran vdout0_222ck1810 FIND v(dout0_222) AT=910.025n

.meas tran vdout0_223ck1810 FIND v(dout0_223) AT=910.025n

.meas tran vdout0_224ck1810 FIND v(dout0_224) AT=910.025n

.meas tran vdout0_225ck1810 FIND v(dout0_225) AT=910.025n

.meas tran vdout0_226ck1810 FIND v(dout0_226) AT=910.025n

.meas tran vdout0_227ck1810 FIND v(dout0_227) AT=910.025n

.meas tran vdout0_228ck1810 FIND v(dout0_228) AT=910.025n

.meas tran vdout0_229ck1810 FIND v(dout0_229) AT=910.025n

.meas tran vdout0_230ck1810 FIND v(dout0_230) AT=910.025n

.meas tran vdout0_231ck1810 FIND v(dout0_231) AT=910.025n

.meas tran vdout0_232ck1810 FIND v(dout0_232) AT=910.025n

.meas tran vdout0_233ck1810 FIND v(dout0_233) AT=910.025n

.meas tran vdout0_234ck1810 FIND v(dout0_234) AT=910.025n

.meas tran vdout0_235ck1810 FIND v(dout0_235) AT=910.025n

.meas tran vdout0_236ck1810 FIND v(dout0_236) AT=910.025n

.meas tran vdout0_237ck1810 FIND v(dout0_237) AT=910.025n

.meas tran vdout0_238ck1810 FIND v(dout0_238) AT=910.025n

.meas tran vdout0_239ck1810 FIND v(dout0_239) AT=910.025n

.meas tran vdout0_240ck1810 FIND v(dout0_240) AT=910.025n

.meas tran vdout0_241ck1810 FIND v(dout0_241) AT=910.025n

.meas tran vdout0_242ck1810 FIND v(dout0_242) AT=910.025n

.meas tran vdout0_243ck1810 FIND v(dout0_243) AT=910.025n

.meas tran vdout0_244ck1810 FIND v(dout0_244) AT=910.025n

.meas tran vdout0_245ck1810 FIND v(dout0_245) AT=910.025n

.meas tran vdout0_246ck1810 FIND v(dout0_246) AT=910.025n

.meas tran vdout0_247ck1810 FIND v(dout0_247) AT=910.025n

.meas tran vdout0_248ck1810 FIND v(dout0_248) AT=910.025n

.meas tran vdout0_249ck1810 FIND v(dout0_249) AT=910.025n

.meas tran vdout0_250ck1810 FIND v(dout0_250) AT=910.025n

.meas tran vdout0_251ck1810 FIND v(dout0_251) AT=910.025n

.meas tran vdout0_252ck1810 FIND v(dout0_252) AT=910.025n

.meas tran vdout0_253ck1810 FIND v(dout0_253) AT=910.025n

.meas tran vdout0_254ck1810 FIND v(dout0_254) AT=910.025n

.meas tran vdout0_255ck1810 FIND v(dout0_255) AT=910.025n

.meas tran vdout0_0ck1830 FIND v(dout0_0) AT=920.025n

.meas tran vdout0_1ck1830 FIND v(dout0_1) AT=920.025n

.meas tran vdout0_2ck1830 FIND v(dout0_2) AT=920.025n

.meas tran vdout0_3ck1830 FIND v(dout0_3) AT=920.025n

.meas tran vdout0_4ck1830 FIND v(dout0_4) AT=920.025n

.meas tran vdout0_5ck1830 FIND v(dout0_5) AT=920.025n

.meas tran vdout0_6ck1830 FIND v(dout0_6) AT=920.025n

.meas tran vdout0_7ck1830 FIND v(dout0_7) AT=920.025n

.meas tran vdout0_8ck1830 FIND v(dout0_8) AT=920.025n

.meas tran vdout0_9ck1830 FIND v(dout0_9) AT=920.025n

.meas tran vdout0_10ck1830 FIND v(dout0_10) AT=920.025n

.meas tran vdout0_11ck1830 FIND v(dout0_11) AT=920.025n

.meas tran vdout0_12ck1830 FIND v(dout0_12) AT=920.025n

.meas tran vdout0_13ck1830 FIND v(dout0_13) AT=920.025n

.meas tran vdout0_14ck1830 FIND v(dout0_14) AT=920.025n

.meas tran vdout0_15ck1830 FIND v(dout0_15) AT=920.025n

.meas tran vdout0_16ck1830 FIND v(dout0_16) AT=920.025n

.meas tran vdout0_17ck1830 FIND v(dout0_17) AT=920.025n

.meas tran vdout0_18ck1830 FIND v(dout0_18) AT=920.025n

.meas tran vdout0_19ck1830 FIND v(dout0_19) AT=920.025n

.meas tran vdout0_20ck1830 FIND v(dout0_20) AT=920.025n

.meas tran vdout0_21ck1830 FIND v(dout0_21) AT=920.025n

.meas tran vdout0_22ck1830 FIND v(dout0_22) AT=920.025n

.meas tran vdout0_23ck1830 FIND v(dout0_23) AT=920.025n

.meas tran vdout0_24ck1830 FIND v(dout0_24) AT=920.025n

.meas tran vdout0_25ck1830 FIND v(dout0_25) AT=920.025n

.meas tran vdout0_26ck1830 FIND v(dout0_26) AT=920.025n

.meas tran vdout0_27ck1830 FIND v(dout0_27) AT=920.025n

.meas tran vdout0_28ck1830 FIND v(dout0_28) AT=920.025n

.meas tran vdout0_29ck1830 FIND v(dout0_29) AT=920.025n

.meas tran vdout0_30ck1830 FIND v(dout0_30) AT=920.025n

.meas tran vdout0_31ck1830 FIND v(dout0_31) AT=920.025n

.meas tran vdout0_32ck1830 FIND v(dout0_32) AT=920.025n

.meas tran vdout0_33ck1830 FIND v(dout0_33) AT=920.025n

.meas tran vdout0_34ck1830 FIND v(dout0_34) AT=920.025n

.meas tran vdout0_35ck1830 FIND v(dout0_35) AT=920.025n

.meas tran vdout0_36ck1830 FIND v(dout0_36) AT=920.025n

.meas tran vdout0_37ck1830 FIND v(dout0_37) AT=920.025n

.meas tran vdout0_38ck1830 FIND v(dout0_38) AT=920.025n

.meas tran vdout0_39ck1830 FIND v(dout0_39) AT=920.025n

.meas tran vdout0_40ck1830 FIND v(dout0_40) AT=920.025n

.meas tran vdout0_41ck1830 FIND v(dout0_41) AT=920.025n

.meas tran vdout0_42ck1830 FIND v(dout0_42) AT=920.025n

.meas tran vdout0_43ck1830 FIND v(dout0_43) AT=920.025n

.meas tran vdout0_44ck1830 FIND v(dout0_44) AT=920.025n

.meas tran vdout0_45ck1830 FIND v(dout0_45) AT=920.025n

.meas tran vdout0_46ck1830 FIND v(dout0_46) AT=920.025n

.meas tran vdout0_47ck1830 FIND v(dout0_47) AT=920.025n

.meas tran vdout0_48ck1830 FIND v(dout0_48) AT=920.025n

.meas tran vdout0_49ck1830 FIND v(dout0_49) AT=920.025n

.meas tran vdout0_50ck1830 FIND v(dout0_50) AT=920.025n

.meas tran vdout0_51ck1830 FIND v(dout0_51) AT=920.025n

.meas tran vdout0_52ck1830 FIND v(dout0_52) AT=920.025n

.meas tran vdout0_53ck1830 FIND v(dout0_53) AT=920.025n

.meas tran vdout0_54ck1830 FIND v(dout0_54) AT=920.025n

.meas tran vdout0_55ck1830 FIND v(dout0_55) AT=920.025n

.meas tran vdout0_56ck1830 FIND v(dout0_56) AT=920.025n

.meas tran vdout0_57ck1830 FIND v(dout0_57) AT=920.025n

.meas tran vdout0_58ck1830 FIND v(dout0_58) AT=920.025n

.meas tran vdout0_59ck1830 FIND v(dout0_59) AT=920.025n

.meas tran vdout0_60ck1830 FIND v(dout0_60) AT=920.025n

.meas tran vdout0_61ck1830 FIND v(dout0_61) AT=920.025n

.meas tran vdout0_62ck1830 FIND v(dout0_62) AT=920.025n

.meas tran vdout0_63ck1830 FIND v(dout0_63) AT=920.025n

.meas tran vdout0_64ck1830 FIND v(dout0_64) AT=920.025n

.meas tran vdout0_65ck1830 FIND v(dout0_65) AT=920.025n

.meas tran vdout0_66ck1830 FIND v(dout0_66) AT=920.025n

.meas tran vdout0_67ck1830 FIND v(dout0_67) AT=920.025n

.meas tran vdout0_68ck1830 FIND v(dout0_68) AT=920.025n

.meas tran vdout0_69ck1830 FIND v(dout0_69) AT=920.025n

.meas tran vdout0_70ck1830 FIND v(dout0_70) AT=920.025n

.meas tran vdout0_71ck1830 FIND v(dout0_71) AT=920.025n

.meas tran vdout0_72ck1830 FIND v(dout0_72) AT=920.025n

.meas tran vdout0_73ck1830 FIND v(dout0_73) AT=920.025n

.meas tran vdout0_74ck1830 FIND v(dout0_74) AT=920.025n

.meas tran vdout0_75ck1830 FIND v(dout0_75) AT=920.025n

.meas tran vdout0_76ck1830 FIND v(dout0_76) AT=920.025n

.meas tran vdout0_77ck1830 FIND v(dout0_77) AT=920.025n

.meas tran vdout0_78ck1830 FIND v(dout0_78) AT=920.025n

.meas tran vdout0_79ck1830 FIND v(dout0_79) AT=920.025n

.meas tran vdout0_80ck1830 FIND v(dout0_80) AT=920.025n

.meas tran vdout0_81ck1830 FIND v(dout0_81) AT=920.025n

.meas tran vdout0_82ck1830 FIND v(dout0_82) AT=920.025n

.meas tran vdout0_83ck1830 FIND v(dout0_83) AT=920.025n

.meas tran vdout0_84ck1830 FIND v(dout0_84) AT=920.025n

.meas tran vdout0_85ck1830 FIND v(dout0_85) AT=920.025n

.meas tran vdout0_86ck1830 FIND v(dout0_86) AT=920.025n

.meas tran vdout0_87ck1830 FIND v(dout0_87) AT=920.025n

.meas tran vdout0_88ck1830 FIND v(dout0_88) AT=920.025n

.meas tran vdout0_89ck1830 FIND v(dout0_89) AT=920.025n

.meas tran vdout0_90ck1830 FIND v(dout0_90) AT=920.025n

.meas tran vdout0_91ck1830 FIND v(dout0_91) AT=920.025n

.meas tran vdout0_92ck1830 FIND v(dout0_92) AT=920.025n

.meas tran vdout0_93ck1830 FIND v(dout0_93) AT=920.025n

.meas tran vdout0_94ck1830 FIND v(dout0_94) AT=920.025n

.meas tran vdout0_95ck1830 FIND v(dout0_95) AT=920.025n

.meas tran vdout0_96ck1830 FIND v(dout0_96) AT=920.025n

.meas tran vdout0_97ck1830 FIND v(dout0_97) AT=920.025n

.meas tran vdout0_98ck1830 FIND v(dout0_98) AT=920.025n

.meas tran vdout0_99ck1830 FIND v(dout0_99) AT=920.025n

.meas tran vdout0_100ck1830 FIND v(dout0_100) AT=920.025n

.meas tran vdout0_101ck1830 FIND v(dout0_101) AT=920.025n

.meas tran vdout0_102ck1830 FIND v(dout0_102) AT=920.025n

.meas tran vdout0_103ck1830 FIND v(dout0_103) AT=920.025n

.meas tran vdout0_104ck1830 FIND v(dout0_104) AT=920.025n

.meas tran vdout0_105ck1830 FIND v(dout0_105) AT=920.025n

.meas tran vdout0_106ck1830 FIND v(dout0_106) AT=920.025n

.meas tran vdout0_107ck1830 FIND v(dout0_107) AT=920.025n

.meas tran vdout0_108ck1830 FIND v(dout0_108) AT=920.025n

.meas tran vdout0_109ck1830 FIND v(dout0_109) AT=920.025n

.meas tran vdout0_110ck1830 FIND v(dout0_110) AT=920.025n

.meas tran vdout0_111ck1830 FIND v(dout0_111) AT=920.025n

.meas tran vdout0_112ck1830 FIND v(dout0_112) AT=920.025n

.meas tran vdout0_113ck1830 FIND v(dout0_113) AT=920.025n

.meas tran vdout0_114ck1830 FIND v(dout0_114) AT=920.025n

.meas tran vdout0_115ck1830 FIND v(dout0_115) AT=920.025n

.meas tran vdout0_116ck1830 FIND v(dout0_116) AT=920.025n

.meas tran vdout0_117ck1830 FIND v(dout0_117) AT=920.025n

.meas tran vdout0_118ck1830 FIND v(dout0_118) AT=920.025n

.meas tran vdout0_119ck1830 FIND v(dout0_119) AT=920.025n

.meas tran vdout0_120ck1830 FIND v(dout0_120) AT=920.025n

.meas tran vdout0_121ck1830 FIND v(dout0_121) AT=920.025n

.meas tran vdout0_122ck1830 FIND v(dout0_122) AT=920.025n

.meas tran vdout0_123ck1830 FIND v(dout0_123) AT=920.025n

.meas tran vdout0_124ck1830 FIND v(dout0_124) AT=920.025n

.meas tran vdout0_125ck1830 FIND v(dout0_125) AT=920.025n

.meas tran vdout0_126ck1830 FIND v(dout0_126) AT=920.025n

.meas tran vdout0_127ck1830 FIND v(dout0_127) AT=920.025n

.meas tran vdout0_128ck1830 FIND v(dout0_128) AT=920.025n

.meas tran vdout0_129ck1830 FIND v(dout0_129) AT=920.025n

.meas tran vdout0_130ck1830 FIND v(dout0_130) AT=920.025n

.meas tran vdout0_131ck1830 FIND v(dout0_131) AT=920.025n

.meas tran vdout0_132ck1830 FIND v(dout0_132) AT=920.025n

.meas tran vdout0_133ck1830 FIND v(dout0_133) AT=920.025n

.meas tran vdout0_134ck1830 FIND v(dout0_134) AT=920.025n

.meas tran vdout0_135ck1830 FIND v(dout0_135) AT=920.025n

.meas tran vdout0_136ck1830 FIND v(dout0_136) AT=920.025n

.meas tran vdout0_137ck1830 FIND v(dout0_137) AT=920.025n

.meas tran vdout0_138ck1830 FIND v(dout0_138) AT=920.025n

.meas tran vdout0_139ck1830 FIND v(dout0_139) AT=920.025n

.meas tran vdout0_140ck1830 FIND v(dout0_140) AT=920.025n

.meas tran vdout0_141ck1830 FIND v(dout0_141) AT=920.025n

.meas tran vdout0_142ck1830 FIND v(dout0_142) AT=920.025n

.meas tran vdout0_143ck1830 FIND v(dout0_143) AT=920.025n

.meas tran vdout0_144ck1830 FIND v(dout0_144) AT=920.025n

.meas tran vdout0_145ck1830 FIND v(dout0_145) AT=920.025n

.meas tran vdout0_146ck1830 FIND v(dout0_146) AT=920.025n

.meas tran vdout0_147ck1830 FIND v(dout0_147) AT=920.025n

.meas tran vdout0_148ck1830 FIND v(dout0_148) AT=920.025n

.meas tran vdout0_149ck1830 FIND v(dout0_149) AT=920.025n

.meas tran vdout0_150ck1830 FIND v(dout0_150) AT=920.025n

.meas tran vdout0_151ck1830 FIND v(dout0_151) AT=920.025n

.meas tran vdout0_152ck1830 FIND v(dout0_152) AT=920.025n

.meas tran vdout0_153ck1830 FIND v(dout0_153) AT=920.025n

.meas tran vdout0_154ck1830 FIND v(dout0_154) AT=920.025n

.meas tran vdout0_155ck1830 FIND v(dout0_155) AT=920.025n

.meas tran vdout0_156ck1830 FIND v(dout0_156) AT=920.025n

.meas tran vdout0_157ck1830 FIND v(dout0_157) AT=920.025n

.meas tran vdout0_158ck1830 FIND v(dout0_158) AT=920.025n

.meas tran vdout0_159ck1830 FIND v(dout0_159) AT=920.025n

.meas tran vdout0_160ck1830 FIND v(dout0_160) AT=920.025n

.meas tran vdout0_161ck1830 FIND v(dout0_161) AT=920.025n

.meas tran vdout0_162ck1830 FIND v(dout0_162) AT=920.025n

.meas tran vdout0_163ck1830 FIND v(dout0_163) AT=920.025n

.meas tran vdout0_164ck1830 FIND v(dout0_164) AT=920.025n

.meas tran vdout0_165ck1830 FIND v(dout0_165) AT=920.025n

.meas tran vdout0_166ck1830 FIND v(dout0_166) AT=920.025n

.meas tran vdout0_167ck1830 FIND v(dout0_167) AT=920.025n

.meas tran vdout0_168ck1830 FIND v(dout0_168) AT=920.025n

.meas tran vdout0_169ck1830 FIND v(dout0_169) AT=920.025n

.meas tran vdout0_170ck1830 FIND v(dout0_170) AT=920.025n

.meas tran vdout0_171ck1830 FIND v(dout0_171) AT=920.025n

.meas tran vdout0_172ck1830 FIND v(dout0_172) AT=920.025n

.meas tran vdout0_173ck1830 FIND v(dout0_173) AT=920.025n

.meas tran vdout0_174ck1830 FIND v(dout0_174) AT=920.025n

.meas tran vdout0_175ck1830 FIND v(dout0_175) AT=920.025n

.meas tran vdout0_176ck1830 FIND v(dout0_176) AT=920.025n

.meas tran vdout0_177ck1830 FIND v(dout0_177) AT=920.025n

.meas tran vdout0_178ck1830 FIND v(dout0_178) AT=920.025n

.meas tran vdout0_179ck1830 FIND v(dout0_179) AT=920.025n

.meas tran vdout0_180ck1830 FIND v(dout0_180) AT=920.025n

.meas tran vdout0_181ck1830 FIND v(dout0_181) AT=920.025n

.meas tran vdout0_182ck1830 FIND v(dout0_182) AT=920.025n

.meas tran vdout0_183ck1830 FIND v(dout0_183) AT=920.025n

.meas tran vdout0_184ck1830 FIND v(dout0_184) AT=920.025n

.meas tran vdout0_185ck1830 FIND v(dout0_185) AT=920.025n

.meas tran vdout0_186ck1830 FIND v(dout0_186) AT=920.025n

.meas tran vdout0_187ck1830 FIND v(dout0_187) AT=920.025n

.meas tran vdout0_188ck1830 FIND v(dout0_188) AT=920.025n

.meas tran vdout0_189ck1830 FIND v(dout0_189) AT=920.025n

.meas tran vdout0_190ck1830 FIND v(dout0_190) AT=920.025n

.meas tran vdout0_191ck1830 FIND v(dout0_191) AT=920.025n

.meas tran vdout0_192ck1830 FIND v(dout0_192) AT=920.025n

.meas tran vdout0_193ck1830 FIND v(dout0_193) AT=920.025n

.meas tran vdout0_194ck1830 FIND v(dout0_194) AT=920.025n

.meas tran vdout0_195ck1830 FIND v(dout0_195) AT=920.025n

.meas tran vdout0_196ck1830 FIND v(dout0_196) AT=920.025n

.meas tran vdout0_197ck1830 FIND v(dout0_197) AT=920.025n

.meas tran vdout0_198ck1830 FIND v(dout0_198) AT=920.025n

.meas tran vdout0_199ck1830 FIND v(dout0_199) AT=920.025n

.meas tran vdout0_200ck1830 FIND v(dout0_200) AT=920.025n

.meas tran vdout0_201ck1830 FIND v(dout0_201) AT=920.025n

.meas tran vdout0_202ck1830 FIND v(dout0_202) AT=920.025n

.meas tran vdout0_203ck1830 FIND v(dout0_203) AT=920.025n

.meas tran vdout0_204ck1830 FIND v(dout0_204) AT=920.025n

.meas tran vdout0_205ck1830 FIND v(dout0_205) AT=920.025n

.meas tran vdout0_206ck1830 FIND v(dout0_206) AT=920.025n

.meas tran vdout0_207ck1830 FIND v(dout0_207) AT=920.025n

.meas tran vdout0_208ck1830 FIND v(dout0_208) AT=920.025n

.meas tran vdout0_209ck1830 FIND v(dout0_209) AT=920.025n

.meas tran vdout0_210ck1830 FIND v(dout0_210) AT=920.025n

.meas tran vdout0_211ck1830 FIND v(dout0_211) AT=920.025n

.meas tran vdout0_212ck1830 FIND v(dout0_212) AT=920.025n

.meas tran vdout0_213ck1830 FIND v(dout0_213) AT=920.025n

.meas tran vdout0_214ck1830 FIND v(dout0_214) AT=920.025n

.meas tran vdout0_215ck1830 FIND v(dout0_215) AT=920.025n

.meas tran vdout0_216ck1830 FIND v(dout0_216) AT=920.025n

.meas tran vdout0_217ck1830 FIND v(dout0_217) AT=920.025n

.meas tran vdout0_218ck1830 FIND v(dout0_218) AT=920.025n

.meas tran vdout0_219ck1830 FIND v(dout0_219) AT=920.025n

.meas tran vdout0_220ck1830 FIND v(dout0_220) AT=920.025n

.meas tran vdout0_221ck1830 FIND v(dout0_221) AT=920.025n

.meas tran vdout0_222ck1830 FIND v(dout0_222) AT=920.025n

.meas tran vdout0_223ck1830 FIND v(dout0_223) AT=920.025n

.meas tran vdout0_224ck1830 FIND v(dout0_224) AT=920.025n

.meas tran vdout0_225ck1830 FIND v(dout0_225) AT=920.025n

.meas tran vdout0_226ck1830 FIND v(dout0_226) AT=920.025n

.meas tran vdout0_227ck1830 FIND v(dout0_227) AT=920.025n

.meas tran vdout0_228ck1830 FIND v(dout0_228) AT=920.025n

.meas tran vdout0_229ck1830 FIND v(dout0_229) AT=920.025n

.meas tran vdout0_230ck1830 FIND v(dout0_230) AT=920.025n

.meas tran vdout0_231ck1830 FIND v(dout0_231) AT=920.025n

.meas tran vdout0_232ck1830 FIND v(dout0_232) AT=920.025n

.meas tran vdout0_233ck1830 FIND v(dout0_233) AT=920.025n

.meas tran vdout0_234ck1830 FIND v(dout0_234) AT=920.025n

.meas tran vdout0_235ck1830 FIND v(dout0_235) AT=920.025n

.meas tran vdout0_236ck1830 FIND v(dout0_236) AT=920.025n

.meas tran vdout0_237ck1830 FIND v(dout0_237) AT=920.025n

.meas tran vdout0_238ck1830 FIND v(dout0_238) AT=920.025n

.meas tran vdout0_239ck1830 FIND v(dout0_239) AT=920.025n

.meas tran vdout0_240ck1830 FIND v(dout0_240) AT=920.025n

.meas tran vdout0_241ck1830 FIND v(dout0_241) AT=920.025n

.meas tran vdout0_242ck1830 FIND v(dout0_242) AT=920.025n

.meas tran vdout0_243ck1830 FIND v(dout0_243) AT=920.025n

.meas tran vdout0_244ck1830 FIND v(dout0_244) AT=920.025n

.meas tran vdout0_245ck1830 FIND v(dout0_245) AT=920.025n

.meas tran vdout0_246ck1830 FIND v(dout0_246) AT=920.025n

.meas tran vdout0_247ck1830 FIND v(dout0_247) AT=920.025n

.meas tran vdout0_248ck1830 FIND v(dout0_248) AT=920.025n

.meas tran vdout0_249ck1830 FIND v(dout0_249) AT=920.025n

.meas tran vdout0_250ck1830 FIND v(dout0_250) AT=920.025n

.meas tran vdout0_251ck1830 FIND v(dout0_251) AT=920.025n

.meas tran vdout0_252ck1830 FIND v(dout0_252) AT=920.025n

.meas tran vdout0_253ck1830 FIND v(dout0_253) AT=920.025n

.meas tran vdout0_254ck1830 FIND v(dout0_254) AT=920.025n

.meas tran vdout0_255ck1830 FIND v(dout0_255) AT=920.025n

.meas tran vdout0_0ck1860 FIND v(dout0_0) AT=935.025n

.meas tran vdout0_1ck1860 FIND v(dout0_1) AT=935.025n

.meas tran vdout0_2ck1860 FIND v(dout0_2) AT=935.025n

.meas tran vdout0_3ck1860 FIND v(dout0_3) AT=935.025n

.meas tran vdout0_4ck1860 FIND v(dout0_4) AT=935.025n

.meas tran vdout0_5ck1860 FIND v(dout0_5) AT=935.025n

.meas tran vdout0_6ck1860 FIND v(dout0_6) AT=935.025n

.meas tran vdout0_7ck1860 FIND v(dout0_7) AT=935.025n

.meas tran vdout0_8ck1860 FIND v(dout0_8) AT=935.025n

.meas tran vdout0_9ck1860 FIND v(dout0_9) AT=935.025n

.meas tran vdout0_10ck1860 FIND v(dout0_10) AT=935.025n

.meas tran vdout0_11ck1860 FIND v(dout0_11) AT=935.025n

.meas tran vdout0_12ck1860 FIND v(dout0_12) AT=935.025n

.meas tran vdout0_13ck1860 FIND v(dout0_13) AT=935.025n

.meas tran vdout0_14ck1860 FIND v(dout0_14) AT=935.025n

.meas tran vdout0_15ck1860 FIND v(dout0_15) AT=935.025n

.meas tran vdout0_16ck1860 FIND v(dout0_16) AT=935.025n

.meas tran vdout0_17ck1860 FIND v(dout0_17) AT=935.025n

.meas tran vdout0_18ck1860 FIND v(dout0_18) AT=935.025n

.meas tran vdout0_19ck1860 FIND v(dout0_19) AT=935.025n

.meas tran vdout0_20ck1860 FIND v(dout0_20) AT=935.025n

.meas tran vdout0_21ck1860 FIND v(dout0_21) AT=935.025n

.meas tran vdout0_22ck1860 FIND v(dout0_22) AT=935.025n

.meas tran vdout0_23ck1860 FIND v(dout0_23) AT=935.025n

.meas tran vdout0_24ck1860 FIND v(dout0_24) AT=935.025n

.meas tran vdout0_25ck1860 FIND v(dout0_25) AT=935.025n

.meas tran vdout0_26ck1860 FIND v(dout0_26) AT=935.025n

.meas tran vdout0_27ck1860 FIND v(dout0_27) AT=935.025n

.meas tran vdout0_28ck1860 FIND v(dout0_28) AT=935.025n

.meas tran vdout0_29ck1860 FIND v(dout0_29) AT=935.025n

.meas tran vdout0_30ck1860 FIND v(dout0_30) AT=935.025n

.meas tran vdout0_31ck1860 FIND v(dout0_31) AT=935.025n

.meas tran vdout0_32ck1860 FIND v(dout0_32) AT=935.025n

.meas tran vdout0_33ck1860 FIND v(dout0_33) AT=935.025n

.meas tran vdout0_34ck1860 FIND v(dout0_34) AT=935.025n

.meas tran vdout0_35ck1860 FIND v(dout0_35) AT=935.025n

.meas tran vdout0_36ck1860 FIND v(dout0_36) AT=935.025n

.meas tran vdout0_37ck1860 FIND v(dout0_37) AT=935.025n

.meas tran vdout0_38ck1860 FIND v(dout0_38) AT=935.025n

.meas tran vdout0_39ck1860 FIND v(dout0_39) AT=935.025n

.meas tran vdout0_40ck1860 FIND v(dout0_40) AT=935.025n

.meas tran vdout0_41ck1860 FIND v(dout0_41) AT=935.025n

.meas tran vdout0_42ck1860 FIND v(dout0_42) AT=935.025n

.meas tran vdout0_43ck1860 FIND v(dout0_43) AT=935.025n

.meas tran vdout0_44ck1860 FIND v(dout0_44) AT=935.025n

.meas tran vdout0_45ck1860 FIND v(dout0_45) AT=935.025n

.meas tran vdout0_46ck1860 FIND v(dout0_46) AT=935.025n

.meas tran vdout0_47ck1860 FIND v(dout0_47) AT=935.025n

.meas tran vdout0_48ck1860 FIND v(dout0_48) AT=935.025n

.meas tran vdout0_49ck1860 FIND v(dout0_49) AT=935.025n

.meas tran vdout0_50ck1860 FIND v(dout0_50) AT=935.025n

.meas tran vdout0_51ck1860 FIND v(dout0_51) AT=935.025n

.meas tran vdout0_52ck1860 FIND v(dout0_52) AT=935.025n

.meas tran vdout0_53ck1860 FIND v(dout0_53) AT=935.025n

.meas tran vdout0_54ck1860 FIND v(dout0_54) AT=935.025n

.meas tran vdout0_55ck1860 FIND v(dout0_55) AT=935.025n

.meas tran vdout0_56ck1860 FIND v(dout0_56) AT=935.025n

.meas tran vdout0_57ck1860 FIND v(dout0_57) AT=935.025n

.meas tran vdout0_58ck1860 FIND v(dout0_58) AT=935.025n

.meas tran vdout0_59ck1860 FIND v(dout0_59) AT=935.025n

.meas tran vdout0_60ck1860 FIND v(dout0_60) AT=935.025n

.meas tran vdout0_61ck1860 FIND v(dout0_61) AT=935.025n

.meas tran vdout0_62ck1860 FIND v(dout0_62) AT=935.025n

.meas tran vdout0_63ck1860 FIND v(dout0_63) AT=935.025n

.meas tran vdout0_64ck1860 FIND v(dout0_64) AT=935.025n

.meas tran vdout0_65ck1860 FIND v(dout0_65) AT=935.025n

.meas tran vdout0_66ck1860 FIND v(dout0_66) AT=935.025n

.meas tran vdout0_67ck1860 FIND v(dout0_67) AT=935.025n

.meas tran vdout0_68ck1860 FIND v(dout0_68) AT=935.025n

.meas tran vdout0_69ck1860 FIND v(dout0_69) AT=935.025n

.meas tran vdout0_70ck1860 FIND v(dout0_70) AT=935.025n

.meas tran vdout0_71ck1860 FIND v(dout0_71) AT=935.025n

.meas tran vdout0_72ck1860 FIND v(dout0_72) AT=935.025n

.meas tran vdout0_73ck1860 FIND v(dout0_73) AT=935.025n

.meas tran vdout0_74ck1860 FIND v(dout0_74) AT=935.025n

.meas tran vdout0_75ck1860 FIND v(dout0_75) AT=935.025n

.meas tran vdout0_76ck1860 FIND v(dout0_76) AT=935.025n

.meas tran vdout0_77ck1860 FIND v(dout0_77) AT=935.025n

.meas tran vdout0_78ck1860 FIND v(dout0_78) AT=935.025n

.meas tran vdout0_79ck1860 FIND v(dout0_79) AT=935.025n

.meas tran vdout0_80ck1860 FIND v(dout0_80) AT=935.025n

.meas tran vdout0_81ck1860 FIND v(dout0_81) AT=935.025n

.meas tran vdout0_82ck1860 FIND v(dout0_82) AT=935.025n

.meas tran vdout0_83ck1860 FIND v(dout0_83) AT=935.025n

.meas tran vdout0_84ck1860 FIND v(dout0_84) AT=935.025n

.meas tran vdout0_85ck1860 FIND v(dout0_85) AT=935.025n

.meas tran vdout0_86ck1860 FIND v(dout0_86) AT=935.025n

.meas tran vdout0_87ck1860 FIND v(dout0_87) AT=935.025n

.meas tran vdout0_88ck1860 FIND v(dout0_88) AT=935.025n

.meas tran vdout0_89ck1860 FIND v(dout0_89) AT=935.025n

.meas tran vdout0_90ck1860 FIND v(dout0_90) AT=935.025n

.meas tran vdout0_91ck1860 FIND v(dout0_91) AT=935.025n

.meas tran vdout0_92ck1860 FIND v(dout0_92) AT=935.025n

.meas tran vdout0_93ck1860 FIND v(dout0_93) AT=935.025n

.meas tran vdout0_94ck1860 FIND v(dout0_94) AT=935.025n

.meas tran vdout0_95ck1860 FIND v(dout0_95) AT=935.025n

.meas tran vdout0_96ck1860 FIND v(dout0_96) AT=935.025n

.meas tran vdout0_97ck1860 FIND v(dout0_97) AT=935.025n

.meas tran vdout0_98ck1860 FIND v(dout0_98) AT=935.025n

.meas tran vdout0_99ck1860 FIND v(dout0_99) AT=935.025n

.meas tran vdout0_100ck1860 FIND v(dout0_100) AT=935.025n

.meas tran vdout0_101ck1860 FIND v(dout0_101) AT=935.025n

.meas tran vdout0_102ck1860 FIND v(dout0_102) AT=935.025n

.meas tran vdout0_103ck1860 FIND v(dout0_103) AT=935.025n

.meas tran vdout0_104ck1860 FIND v(dout0_104) AT=935.025n

.meas tran vdout0_105ck1860 FIND v(dout0_105) AT=935.025n

.meas tran vdout0_106ck1860 FIND v(dout0_106) AT=935.025n

.meas tran vdout0_107ck1860 FIND v(dout0_107) AT=935.025n

.meas tran vdout0_108ck1860 FIND v(dout0_108) AT=935.025n

.meas tran vdout0_109ck1860 FIND v(dout0_109) AT=935.025n

.meas tran vdout0_110ck1860 FIND v(dout0_110) AT=935.025n

.meas tran vdout0_111ck1860 FIND v(dout0_111) AT=935.025n

.meas tran vdout0_112ck1860 FIND v(dout0_112) AT=935.025n

.meas tran vdout0_113ck1860 FIND v(dout0_113) AT=935.025n

.meas tran vdout0_114ck1860 FIND v(dout0_114) AT=935.025n

.meas tran vdout0_115ck1860 FIND v(dout0_115) AT=935.025n

.meas tran vdout0_116ck1860 FIND v(dout0_116) AT=935.025n

.meas tran vdout0_117ck1860 FIND v(dout0_117) AT=935.025n

.meas tran vdout0_118ck1860 FIND v(dout0_118) AT=935.025n

.meas tran vdout0_119ck1860 FIND v(dout0_119) AT=935.025n

.meas tran vdout0_120ck1860 FIND v(dout0_120) AT=935.025n

.meas tran vdout0_121ck1860 FIND v(dout0_121) AT=935.025n

.meas tran vdout0_122ck1860 FIND v(dout0_122) AT=935.025n

.meas tran vdout0_123ck1860 FIND v(dout0_123) AT=935.025n

.meas tran vdout0_124ck1860 FIND v(dout0_124) AT=935.025n

.meas tran vdout0_125ck1860 FIND v(dout0_125) AT=935.025n

.meas tran vdout0_126ck1860 FIND v(dout0_126) AT=935.025n

.meas tran vdout0_127ck1860 FIND v(dout0_127) AT=935.025n

.meas tran vdout0_128ck1860 FIND v(dout0_128) AT=935.025n

.meas tran vdout0_129ck1860 FIND v(dout0_129) AT=935.025n

.meas tran vdout0_130ck1860 FIND v(dout0_130) AT=935.025n

.meas tran vdout0_131ck1860 FIND v(dout0_131) AT=935.025n

.meas tran vdout0_132ck1860 FIND v(dout0_132) AT=935.025n

.meas tran vdout0_133ck1860 FIND v(dout0_133) AT=935.025n

.meas tran vdout0_134ck1860 FIND v(dout0_134) AT=935.025n

.meas tran vdout0_135ck1860 FIND v(dout0_135) AT=935.025n

.meas tran vdout0_136ck1860 FIND v(dout0_136) AT=935.025n

.meas tran vdout0_137ck1860 FIND v(dout0_137) AT=935.025n

.meas tran vdout0_138ck1860 FIND v(dout0_138) AT=935.025n

.meas tran vdout0_139ck1860 FIND v(dout0_139) AT=935.025n

.meas tran vdout0_140ck1860 FIND v(dout0_140) AT=935.025n

.meas tran vdout0_141ck1860 FIND v(dout0_141) AT=935.025n

.meas tran vdout0_142ck1860 FIND v(dout0_142) AT=935.025n

.meas tran vdout0_143ck1860 FIND v(dout0_143) AT=935.025n

.meas tran vdout0_144ck1860 FIND v(dout0_144) AT=935.025n

.meas tran vdout0_145ck1860 FIND v(dout0_145) AT=935.025n

.meas tran vdout0_146ck1860 FIND v(dout0_146) AT=935.025n

.meas tran vdout0_147ck1860 FIND v(dout0_147) AT=935.025n

.meas tran vdout0_148ck1860 FIND v(dout0_148) AT=935.025n

.meas tran vdout0_149ck1860 FIND v(dout0_149) AT=935.025n

.meas tran vdout0_150ck1860 FIND v(dout0_150) AT=935.025n

.meas tran vdout0_151ck1860 FIND v(dout0_151) AT=935.025n

.meas tran vdout0_152ck1860 FIND v(dout0_152) AT=935.025n

.meas tran vdout0_153ck1860 FIND v(dout0_153) AT=935.025n

.meas tran vdout0_154ck1860 FIND v(dout0_154) AT=935.025n

.meas tran vdout0_155ck1860 FIND v(dout0_155) AT=935.025n

.meas tran vdout0_156ck1860 FIND v(dout0_156) AT=935.025n

.meas tran vdout0_157ck1860 FIND v(dout0_157) AT=935.025n

.meas tran vdout0_158ck1860 FIND v(dout0_158) AT=935.025n

.meas tran vdout0_159ck1860 FIND v(dout0_159) AT=935.025n

.meas tran vdout0_160ck1860 FIND v(dout0_160) AT=935.025n

.meas tran vdout0_161ck1860 FIND v(dout0_161) AT=935.025n

.meas tran vdout0_162ck1860 FIND v(dout0_162) AT=935.025n

.meas tran vdout0_163ck1860 FIND v(dout0_163) AT=935.025n

.meas tran vdout0_164ck1860 FIND v(dout0_164) AT=935.025n

.meas tran vdout0_165ck1860 FIND v(dout0_165) AT=935.025n

.meas tran vdout0_166ck1860 FIND v(dout0_166) AT=935.025n

.meas tran vdout0_167ck1860 FIND v(dout0_167) AT=935.025n

.meas tran vdout0_168ck1860 FIND v(dout0_168) AT=935.025n

.meas tran vdout0_169ck1860 FIND v(dout0_169) AT=935.025n

.meas tran vdout0_170ck1860 FIND v(dout0_170) AT=935.025n

.meas tran vdout0_171ck1860 FIND v(dout0_171) AT=935.025n

.meas tran vdout0_172ck1860 FIND v(dout0_172) AT=935.025n

.meas tran vdout0_173ck1860 FIND v(dout0_173) AT=935.025n

.meas tran vdout0_174ck1860 FIND v(dout0_174) AT=935.025n

.meas tran vdout0_175ck1860 FIND v(dout0_175) AT=935.025n

.meas tran vdout0_176ck1860 FIND v(dout0_176) AT=935.025n

.meas tran vdout0_177ck1860 FIND v(dout0_177) AT=935.025n

.meas tran vdout0_178ck1860 FIND v(dout0_178) AT=935.025n

.meas tran vdout0_179ck1860 FIND v(dout0_179) AT=935.025n

.meas tran vdout0_180ck1860 FIND v(dout0_180) AT=935.025n

.meas tran vdout0_181ck1860 FIND v(dout0_181) AT=935.025n

.meas tran vdout0_182ck1860 FIND v(dout0_182) AT=935.025n

.meas tran vdout0_183ck1860 FIND v(dout0_183) AT=935.025n

.meas tran vdout0_184ck1860 FIND v(dout0_184) AT=935.025n

.meas tran vdout0_185ck1860 FIND v(dout0_185) AT=935.025n

.meas tran vdout0_186ck1860 FIND v(dout0_186) AT=935.025n

.meas tran vdout0_187ck1860 FIND v(dout0_187) AT=935.025n

.meas tran vdout0_188ck1860 FIND v(dout0_188) AT=935.025n

.meas tran vdout0_189ck1860 FIND v(dout0_189) AT=935.025n

.meas tran vdout0_190ck1860 FIND v(dout0_190) AT=935.025n

.meas tran vdout0_191ck1860 FIND v(dout0_191) AT=935.025n

.meas tran vdout0_192ck1860 FIND v(dout0_192) AT=935.025n

.meas tran vdout0_193ck1860 FIND v(dout0_193) AT=935.025n

.meas tran vdout0_194ck1860 FIND v(dout0_194) AT=935.025n

.meas tran vdout0_195ck1860 FIND v(dout0_195) AT=935.025n

.meas tran vdout0_196ck1860 FIND v(dout0_196) AT=935.025n

.meas tran vdout0_197ck1860 FIND v(dout0_197) AT=935.025n

.meas tran vdout0_198ck1860 FIND v(dout0_198) AT=935.025n

.meas tran vdout0_199ck1860 FIND v(dout0_199) AT=935.025n

.meas tran vdout0_200ck1860 FIND v(dout0_200) AT=935.025n

.meas tran vdout0_201ck1860 FIND v(dout0_201) AT=935.025n

.meas tran vdout0_202ck1860 FIND v(dout0_202) AT=935.025n

.meas tran vdout0_203ck1860 FIND v(dout0_203) AT=935.025n

.meas tran vdout0_204ck1860 FIND v(dout0_204) AT=935.025n

.meas tran vdout0_205ck1860 FIND v(dout0_205) AT=935.025n

.meas tran vdout0_206ck1860 FIND v(dout0_206) AT=935.025n

.meas tran vdout0_207ck1860 FIND v(dout0_207) AT=935.025n

.meas tran vdout0_208ck1860 FIND v(dout0_208) AT=935.025n

.meas tran vdout0_209ck1860 FIND v(dout0_209) AT=935.025n

.meas tran vdout0_210ck1860 FIND v(dout0_210) AT=935.025n

.meas tran vdout0_211ck1860 FIND v(dout0_211) AT=935.025n

.meas tran vdout0_212ck1860 FIND v(dout0_212) AT=935.025n

.meas tran vdout0_213ck1860 FIND v(dout0_213) AT=935.025n

.meas tran vdout0_214ck1860 FIND v(dout0_214) AT=935.025n

.meas tran vdout0_215ck1860 FIND v(dout0_215) AT=935.025n

.meas tran vdout0_216ck1860 FIND v(dout0_216) AT=935.025n

.meas tran vdout0_217ck1860 FIND v(dout0_217) AT=935.025n

.meas tran vdout0_218ck1860 FIND v(dout0_218) AT=935.025n

.meas tran vdout0_219ck1860 FIND v(dout0_219) AT=935.025n

.meas tran vdout0_220ck1860 FIND v(dout0_220) AT=935.025n

.meas tran vdout0_221ck1860 FIND v(dout0_221) AT=935.025n

.meas tran vdout0_222ck1860 FIND v(dout0_222) AT=935.025n

.meas tran vdout0_223ck1860 FIND v(dout0_223) AT=935.025n

.meas tran vdout0_224ck1860 FIND v(dout0_224) AT=935.025n

.meas tran vdout0_225ck1860 FIND v(dout0_225) AT=935.025n

.meas tran vdout0_226ck1860 FIND v(dout0_226) AT=935.025n

.meas tran vdout0_227ck1860 FIND v(dout0_227) AT=935.025n

.meas tran vdout0_228ck1860 FIND v(dout0_228) AT=935.025n

.meas tran vdout0_229ck1860 FIND v(dout0_229) AT=935.025n

.meas tran vdout0_230ck1860 FIND v(dout0_230) AT=935.025n

.meas tran vdout0_231ck1860 FIND v(dout0_231) AT=935.025n

.meas tran vdout0_232ck1860 FIND v(dout0_232) AT=935.025n

.meas tran vdout0_233ck1860 FIND v(dout0_233) AT=935.025n

.meas tran vdout0_234ck1860 FIND v(dout0_234) AT=935.025n

.meas tran vdout0_235ck1860 FIND v(dout0_235) AT=935.025n

.meas tran vdout0_236ck1860 FIND v(dout0_236) AT=935.025n

.meas tran vdout0_237ck1860 FIND v(dout0_237) AT=935.025n

.meas tran vdout0_238ck1860 FIND v(dout0_238) AT=935.025n

.meas tran vdout0_239ck1860 FIND v(dout0_239) AT=935.025n

.meas tran vdout0_240ck1860 FIND v(dout0_240) AT=935.025n

.meas tran vdout0_241ck1860 FIND v(dout0_241) AT=935.025n

.meas tran vdout0_242ck1860 FIND v(dout0_242) AT=935.025n

.meas tran vdout0_243ck1860 FIND v(dout0_243) AT=935.025n

.meas tran vdout0_244ck1860 FIND v(dout0_244) AT=935.025n

.meas tran vdout0_245ck1860 FIND v(dout0_245) AT=935.025n

.meas tran vdout0_246ck1860 FIND v(dout0_246) AT=935.025n

.meas tran vdout0_247ck1860 FIND v(dout0_247) AT=935.025n

.meas tran vdout0_248ck1860 FIND v(dout0_248) AT=935.025n

.meas tran vdout0_249ck1860 FIND v(dout0_249) AT=935.025n

.meas tran vdout0_250ck1860 FIND v(dout0_250) AT=935.025n

.meas tran vdout0_251ck1860 FIND v(dout0_251) AT=935.025n

.meas tran vdout0_252ck1860 FIND v(dout0_252) AT=935.025n

.meas tran vdout0_253ck1860 FIND v(dout0_253) AT=935.025n

.meas tran vdout0_254ck1860 FIND v(dout0_254) AT=935.025n

.meas tran vdout0_255ck1860 FIND v(dout0_255) AT=935.025n

.meas tran vdout0_0ck1890 FIND v(dout0_0) AT=950.025n

.meas tran vdout0_1ck1890 FIND v(dout0_1) AT=950.025n

.meas tran vdout0_2ck1890 FIND v(dout0_2) AT=950.025n

.meas tran vdout0_3ck1890 FIND v(dout0_3) AT=950.025n

.meas tran vdout0_4ck1890 FIND v(dout0_4) AT=950.025n

.meas tran vdout0_5ck1890 FIND v(dout0_5) AT=950.025n

.meas tran vdout0_6ck1890 FIND v(dout0_6) AT=950.025n

.meas tran vdout0_7ck1890 FIND v(dout0_7) AT=950.025n

.meas tran vdout0_8ck1890 FIND v(dout0_8) AT=950.025n

.meas tran vdout0_9ck1890 FIND v(dout0_9) AT=950.025n

.meas tran vdout0_10ck1890 FIND v(dout0_10) AT=950.025n

.meas tran vdout0_11ck1890 FIND v(dout0_11) AT=950.025n

.meas tran vdout0_12ck1890 FIND v(dout0_12) AT=950.025n

.meas tran vdout0_13ck1890 FIND v(dout0_13) AT=950.025n

.meas tran vdout0_14ck1890 FIND v(dout0_14) AT=950.025n

.meas tran vdout0_15ck1890 FIND v(dout0_15) AT=950.025n

.meas tran vdout0_16ck1890 FIND v(dout0_16) AT=950.025n

.meas tran vdout0_17ck1890 FIND v(dout0_17) AT=950.025n

.meas tran vdout0_18ck1890 FIND v(dout0_18) AT=950.025n

.meas tran vdout0_19ck1890 FIND v(dout0_19) AT=950.025n

.meas tran vdout0_20ck1890 FIND v(dout0_20) AT=950.025n

.meas tran vdout0_21ck1890 FIND v(dout0_21) AT=950.025n

.meas tran vdout0_22ck1890 FIND v(dout0_22) AT=950.025n

.meas tran vdout0_23ck1890 FIND v(dout0_23) AT=950.025n

.meas tran vdout0_24ck1890 FIND v(dout0_24) AT=950.025n

.meas tran vdout0_25ck1890 FIND v(dout0_25) AT=950.025n

.meas tran vdout0_26ck1890 FIND v(dout0_26) AT=950.025n

.meas tran vdout0_27ck1890 FIND v(dout0_27) AT=950.025n

.meas tran vdout0_28ck1890 FIND v(dout0_28) AT=950.025n

.meas tran vdout0_29ck1890 FIND v(dout0_29) AT=950.025n

.meas tran vdout0_30ck1890 FIND v(dout0_30) AT=950.025n

.meas tran vdout0_31ck1890 FIND v(dout0_31) AT=950.025n

.meas tran vdout0_32ck1890 FIND v(dout0_32) AT=950.025n

.meas tran vdout0_33ck1890 FIND v(dout0_33) AT=950.025n

.meas tran vdout0_34ck1890 FIND v(dout0_34) AT=950.025n

.meas tran vdout0_35ck1890 FIND v(dout0_35) AT=950.025n

.meas tran vdout0_36ck1890 FIND v(dout0_36) AT=950.025n

.meas tran vdout0_37ck1890 FIND v(dout0_37) AT=950.025n

.meas tran vdout0_38ck1890 FIND v(dout0_38) AT=950.025n

.meas tran vdout0_39ck1890 FIND v(dout0_39) AT=950.025n

.meas tran vdout0_40ck1890 FIND v(dout0_40) AT=950.025n

.meas tran vdout0_41ck1890 FIND v(dout0_41) AT=950.025n

.meas tran vdout0_42ck1890 FIND v(dout0_42) AT=950.025n

.meas tran vdout0_43ck1890 FIND v(dout0_43) AT=950.025n

.meas tran vdout0_44ck1890 FIND v(dout0_44) AT=950.025n

.meas tran vdout0_45ck1890 FIND v(dout0_45) AT=950.025n

.meas tran vdout0_46ck1890 FIND v(dout0_46) AT=950.025n

.meas tran vdout0_47ck1890 FIND v(dout0_47) AT=950.025n

.meas tran vdout0_48ck1890 FIND v(dout0_48) AT=950.025n

.meas tran vdout0_49ck1890 FIND v(dout0_49) AT=950.025n

.meas tran vdout0_50ck1890 FIND v(dout0_50) AT=950.025n

.meas tran vdout0_51ck1890 FIND v(dout0_51) AT=950.025n

.meas tran vdout0_52ck1890 FIND v(dout0_52) AT=950.025n

.meas tran vdout0_53ck1890 FIND v(dout0_53) AT=950.025n

.meas tran vdout0_54ck1890 FIND v(dout0_54) AT=950.025n

.meas tran vdout0_55ck1890 FIND v(dout0_55) AT=950.025n

.meas tran vdout0_56ck1890 FIND v(dout0_56) AT=950.025n

.meas tran vdout0_57ck1890 FIND v(dout0_57) AT=950.025n

.meas tran vdout0_58ck1890 FIND v(dout0_58) AT=950.025n

.meas tran vdout0_59ck1890 FIND v(dout0_59) AT=950.025n

.meas tran vdout0_60ck1890 FIND v(dout0_60) AT=950.025n

.meas tran vdout0_61ck1890 FIND v(dout0_61) AT=950.025n

.meas tran vdout0_62ck1890 FIND v(dout0_62) AT=950.025n

.meas tran vdout0_63ck1890 FIND v(dout0_63) AT=950.025n

.meas tran vdout0_64ck1890 FIND v(dout0_64) AT=950.025n

.meas tran vdout0_65ck1890 FIND v(dout0_65) AT=950.025n

.meas tran vdout0_66ck1890 FIND v(dout0_66) AT=950.025n

.meas tran vdout0_67ck1890 FIND v(dout0_67) AT=950.025n

.meas tran vdout0_68ck1890 FIND v(dout0_68) AT=950.025n

.meas tran vdout0_69ck1890 FIND v(dout0_69) AT=950.025n

.meas tran vdout0_70ck1890 FIND v(dout0_70) AT=950.025n

.meas tran vdout0_71ck1890 FIND v(dout0_71) AT=950.025n

.meas tran vdout0_72ck1890 FIND v(dout0_72) AT=950.025n

.meas tran vdout0_73ck1890 FIND v(dout0_73) AT=950.025n

.meas tran vdout0_74ck1890 FIND v(dout0_74) AT=950.025n

.meas tran vdout0_75ck1890 FIND v(dout0_75) AT=950.025n

.meas tran vdout0_76ck1890 FIND v(dout0_76) AT=950.025n

.meas tran vdout0_77ck1890 FIND v(dout0_77) AT=950.025n

.meas tran vdout0_78ck1890 FIND v(dout0_78) AT=950.025n

.meas tran vdout0_79ck1890 FIND v(dout0_79) AT=950.025n

.meas tran vdout0_80ck1890 FIND v(dout0_80) AT=950.025n

.meas tran vdout0_81ck1890 FIND v(dout0_81) AT=950.025n

.meas tran vdout0_82ck1890 FIND v(dout0_82) AT=950.025n

.meas tran vdout0_83ck1890 FIND v(dout0_83) AT=950.025n

.meas tran vdout0_84ck1890 FIND v(dout0_84) AT=950.025n

.meas tran vdout0_85ck1890 FIND v(dout0_85) AT=950.025n

.meas tran vdout0_86ck1890 FIND v(dout0_86) AT=950.025n

.meas tran vdout0_87ck1890 FIND v(dout0_87) AT=950.025n

.meas tran vdout0_88ck1890 FIND v(dout0_88) AT=950.025n

.meas tran vdout0_89ck1890 FIND v(dout0_89) AT=950.025n

.meas tran vdout0_90ck1890 FIND v(dout0_90) AT=950.025n

.meas tran vdout0_91ck1890 FIND v(dout0_91) AT=950.025n

.meas tran vdout0_92ck1890 FIND v(dout0_92) AT=950.025n

.meas tran vdout0_93ck1890 FIND v(dout0_93) AT=950.025n

.meas tran vdout0_94ck1890 FIND v(dout0_94) AT=950.025n

.meas tran vdout0_95ck1890 FIND v(dout0_95) AT=950.025n

.meas tran vdout0_96ck1890 FIND v(dout0_96) AT=950.025n

.meas tran vdout0_97ck1890 FIND v(dout0_97) AT=950.025n

.meas tran vdout0_98ck1890 FIND v(dout0_98) AT=950.025n

.meas tran vdout0_99ck1890 FIND v(dout0_99) AT=950.025n

.meas tran vdout0_100ck1890 FIND v(dout0_100) AT=950.025n

.meas tran vdout0_101ck1890 FIND v(dout0_101) AT=950.025n

.meas tran vdout0_102ck1890 FIND v(dout0_102) AT=950.025n

.meas tran vdout0_103ck1890 FIND v(dout0_103) AT=950.025n

.meas tran vdout0_104ck1890 FIND v(dout0_104) AT=950.025n

.meas tran vdout0_105ck1890 FIND v(dout0_105) AT=950.025n

.meas tran vdout0_106ck1890 FIND v(dout0_106) AT=950.025n

.meas tran vdout0_107ck1890 FIND v(dout0_107) AT=950.025n

.meas tran vdout0_108ck1890 FIND v(dout0_108) AT=950.025n

.meas tran vdout0_109ck1890 FIND v(dout0_109) AT=950.025n

.meas tran vdout0_110ck1890 FIND v(dout0_110) AT=950.025n

.meas tran vdout0_111ck1890 FIND v(dout0_111) AT=950.025n

.meas tran vdout0_112ck1890 FIND v(dout0_112) AT=950.025n

.meas tran vdout0_113ck1890 FIND v(dout0_113) AT=950.025n

.meas tran vdout0_114ck1890 FIND v(dout0_114) AT=950.025n

.meas tran vdout0_115ck1890 FIND v(dout0_115) AT=950.025n

.meas tran vdout0_116ck1890 FIND v(dout0_116) AT=950.025n

.meas tran vdout0_117ck1890 FIND v(dout0_117) AT=950.025n

.meas tran vdout0_118ck1890 FIND v(dout0_118) AT=950.025n

.meas tran vdout0_119ck1890 FIND v(dout0_119) AT=950.025n

.meas tran vdout0_120ck1890 FIND v(dout0_120) AT=950.025n

.meas tran vdout0_121ck1890 FIND v(dout0_121) AT=950.025n

.meas tran vdout0_122ck1890 FIND v(dout0_122) AT=950.025n

.meas tran vdout0_123ck1890 FIND v(dout0_123) AT=950.025n

.meas tran vdout0_124ck1890 FIND v(dout0_124) AT=950.025n

.meas tran vdout0_125ck1890 FIND v(dout0_125) AT=950.025n

.meas tran vdout0_126ck1890 FIND v(dout0_126) AT=950.025n

.meas tran vdout0_127ck1890 FIND v(dout0_127) AT=950.025n

.meas tran vdout0_128ck1890 FIND v(dout0_128) AT=950.025n

.meas tran vdout0_129ck1890 FIND v(dout0_129) AT=950.025n

.meas tran vdout0_130ck1890 FIND v(dout0_130) AT=950.025n

.meas tran vdout0_131ck1890 FIND v(dout0_131) AT=950.025n

.meas tran vdout0_132ck1890 FIND v(dout0_132) AT=950.025n

.meas tran vdout0_133ck1890 FIND v(dout0_133) AT=950.025n

.meas tran vdout0_134ck1890 FIND v(dout0_134) AT=950.025n

.meas tran vdout0_135ck1890 FIND v(dout0_135) AT=950.025n

.meas tran vdout0_136ck1890 FIND v(dout0_136) AT=950.025n

.meas tran vdout0_137ck1890 FIND v(dout0_137) AT=950.025n

.meas tran vdout0_138ck1890 FIND v(dout0_138) AT=950.025n

.meas tran vdout0_139ck1890 FIND v(dout0_139) AT=950.025n

.meas tran vdout0_140ck1890 FIND v(dout0_140) AT=950.025n

.meas tran vdout0_141ck1890 FIND v(dout0_141) AT=950.025n

.meas tran vdout0_142ck1890 FIND v(dout0_142) AT=950.025n

.meas tran vdout0_143ck1890 FIND v(dout0_143) AT=950.025n

.meas tran vdout0_144ck1890 FIND v(dout0_144) AT=950.025n

.meas tran vdout0_145ck1890 FIND v(dout0_145) AT=950.025n

.meas tran vdout0_146ck1890 FIND v(dout0_146) AT=950.025n

.meas tran vdout0_147ck1890 FIND v(dout0_147) AT=950.025n

.meas tran vdout0_148ck1890 FIND v(dout0_148) AT=950.025n

.meas tran vdout0_149ck1890 FIND v(dout0_149) AT=950.025n

.meas tran vdout0_150ck1890 FIND v(dout0_150) AT=950.025n

.meas tran vdout0_151ck1890 FIND v(dout0_151) AT=950.025n

.meas tran vdout0_152ck1890 FIND v(dout0_152) AT=950.025n

.meas tran vdout0_153ck1890 FIND v(dout0_153) AT=950.025n

.meas tran vdout0_154ck1890 FIND v(dout0_154) AT=950.025n

.meas tran vdout0_155ck1890 FIND v(dout0_155) AT=950.025n

.meas tran vdout0_156ck1890 FIND v(dout0_156) AT=950.025n

.meas tran vdout0_157ck1890 FIND v(dout0_157) AT=950.025n

.meas tran vdout0_158ck1890 FIND v(dout0_158) AT=950.025n

.meas tran vdout0_159ck1890 FIND v(dout0_159) AT=950.025n

.meas tran vdout0_160ck1890 FIND v(dout0_160) AT=950.025n

.meas tran vdout0_161ck1890 FIND v(dout0_161) AT=950.025n

.meas tran vdout0_162ck1890 FIND v(dout0_162) AT=950.025n

.meas tran vdout0_163ck1890 FIND v(dout0_163) AT=950.025n

.meas tran vdout0_164ck1890 FIND v(dout0_164) AT=950.025n

.meas tran vdout0_165ck1890 FIND v(dout0_165) AT=950.025n

.meas tran vdout0_166ck1890 FIND v(dout0_166) AT=950.025n

.meas tran vdout0_167ck1890 FIND v(dout0_167) AT=950.025n

.meas tran vdout0_168ck1890 FIND v(dout0_168) AT=950.025n

.meas tran vdout0_169ck1890 FIND v(dout0_169) AT=950.025n

.meas tran vdout0_170ck1890 FIND v(dout0_170) AT=950.025n

.meas tran vdout0_171ck1890 FIND v(dout0_171) AT=950.025n

.meas tran vdout0_172ck1890 FIND v(dout0_172) AT=950.025n

.meas tran vdout0_173ck1890 FIND v(dout0_173) AT=950.025n

.meas tran vdout0_174ck1890 FIND v(dout0_174) AT=950.025n

.meas tran vdout0_175ck1890 FIND v(dout0_175) AT=950.025n

.meas tran vdout0_176ck1890 FIND v(dout0_176) AT=950.025n

.meas tran vdout0_177ck1890 FIND v(dout0_177) AT=950.025n

.meas tran vdout0_178ck1890 FIND v(dout0_178) AT=950.025n

.meas tran vdout0_179ck1890 FIND v(dout0_179) AT=950.025n

.meas tran vdout0_180ck1890 FIND v(dout0_180) AT=950.025n

.meas tran vdout0_181ck1890 FIND v(dout0_181) AT=950.025n

.meas tran vdout0_182ck1890 FIND v(dout0_182) AT=950.025n

.meas tran vdout0_183ck1890 FIND v(dout0_183) AT=950.025n

.meas tran vdout0_184ck1890 FIND v(dout0_184) AT=950.025n

.meas tran vdout0_185ck1890 FIND v(dout0_185) AT=950.025n

.meas tran vdout0_186ck1890 FIND v(dout0_186) AT=950.025n

.meas tran vdout0_187ck1890 FIND v(dout0_187) AT=950.025n

.meas tran vdout0_188ck1890 FIND v(dout0_188) AT=950.025n

.meas tran vdout0_189ck1890 FIND v(dout0_189) AT=950.025n

.meas tran vdout0_190ck1890 FIND v(dout0_190) AT=950.025n

.meas tran vdout0_191ck1890 FIND v(dout0_191) AT=950.025n

.meas tran vdout0_192ck1890 FIND v(dout0_192) AT=950.025n

.meas tran vdout0_193ck1890 FIND v(dout0_193) AT=950.025n

.meas tran vdout0_194ck1890 FIND v(dout0_194) AT=950.025n

.meas tran vdout0_195ck1890 FIND v(dout0_195) AT=950.025n

.meas tran vdout0_196ck1890 FIND v(dout0_196) AT=950.025n

.meas tran vdout0_197ck1890 FIND v(dout0_197) AT=950.025n

.meas tran vdout0_198ck1890 FIND v(dout0_198) AT=950.025n

.meas tran vdout0_199ck1890 FIND v(dout0_199) AT=950.025n

.meas tran vdout0_200ck1890 FIND v(dout0_200) AT=950.025n

.meas tran vdout0_201ck1890 FIND v(dout0_201) AT=950.025n

.meas tran vdout0_202ck1890 FIND v(dout0_202) AT=950.025n

.meas tran vdout0_203ck1890 FIND v(dout0_203) AT=950.025n

.meas tran vdout0_204ck1890 FIND v(dout0_204) AT=950.025n

.meas tran vdout0_205ck1890 FIND v(dout0_205) AT=950.025n

.meas tran vdout0_206ck1890 FIND v(dout0_206) AT=950.025n

.meas tran vdout0_207ck1890 FIND v(dout0_207) AT=950.025n

.meas tran vdout0_208ck1890 FIND v(dout0_208) AT=950.025n

.meas tran vdout0_209ck1890 FIND v(dout0_209) AT=950.025n

.meas tran vdout0_210ck1890 FIND v(dout0_210) AT=950.025n

.meas tran vdout0_211ck1890 FIND v(dout0_211) AT=950.025n

.meas tran vdout0_212ck1890 FIND v(dout0_212) AT=950.025n

.meas tran vdout0_213ck1890 FIND v(dout0_213) AT=950.025n

.meas tran vdout0_214ck1890 FIND v(dout0_214) AT=950.025n

.meas tran vdout0_215ck1890 FIND v(dout0_215) AT=950.025n

.meas tran vdout0_216ck1890 FIND v(dout0_216) AT=950.025n

.meas tran vdout0_217ck1890 FIND v(dout0_217) AT=950.025n

.meas tran vdout0_218ck1890 FIND v(dout0_218) AT=950.025n

.meas tran vdout0_219ck1890 FIND v(dout0_219) AT=950.025n

.meas tran vdout0_220ck1890 FIND v(dout0_220) AT=950.025n

.meas tran vdout0_221ck1890 FIND v(dout0_221) AT=950.025n

.meas tran vdout0_222ck1890 FIND v(dout0_222) AT=950.025n

.meas tran vdout0_223ck1890 FIND v(dout0_223) AT=950.025n

.meas tran vdout0_224ck1890 FIND v(dout0_224) AT=950.025n

.meas tran vdout0_225ck1890 FIND v(dout0_225) AT=950.025n

.meas tran vdout0_226ck1890 FIND v(dout0_226) AT=950.025n

.meas tran vdout0_227ck1890 FIND v(dout0_227) AT=950.025n

.meas tran vdout0_228ck1890 FIND v(dout0_228) AT=950.025n

.meas tran vdout0_229ck1890 FIND v(dout0_229) AT=950.025n

.meas tran vdout0_230ck1890 FIND v(dout0_230) AT=950.025n

.meas tran vdout0_231ck1890 FIND v(dout0_231) AT=950.025n

.meas tran vdout0_232ck1890 FIND v(dout0_232) AT=950.025n

.meas tran vdout0_233ck1890 FIND v(dout0_233) AT=950.025n

.meas tran vdout0_234ck1890 FIND v(dout0_234) AT=950.025n

.meas tran vdout0_235ck1890 FIND v(dout0_235) AT=950.025n

.meas tran vdout0_236ck1890 FIND v(dout0_236) AT=950.025n

.meas tran vdout0_237ck1890 FIND v(dout0_237) AT=950.025n

.meas tran vdout0_238ck1890 FIND v(dout0_238) AT=950.025n

.meas tran vdout0_239ck1890 FIND v(dout0_239) AT=950.025n

.meas tran vdout0_240ck1890 FIND v(dout0_240) AT=950.025n

.meas tran vdout0_241ck1890 FIND v(dout0_241) AT=950.025n

.meas tran vdout0_242ck1890 FIND v(dout0_242) AT=950.025n

.meas tran vdout0_243ck1890 FIND v(dout0_243) AT=950.025n

.meas tran vdout0_244ck1890 FIND v(dout0_244) AT=950.025n

.meas tran vdout0_245ck1890 FIND v(dout0_245) AT=950.025n

.meas tran vdout0_246ck1890 FIND v(dout0_246) AT=950.025n

.meas tran vdout0_247ck1890 FIND v(dout0_247) AT=950.025n

.meas tran vdout0_248ck1890 FIND v(dout0_248) AT=950.025n

.meas tran vdout0_249ck1890 FIND v(dout0_249) AT=950.025n

.meas tran vdout0_250ck1890 FIND v(dout0_250) AT=950.025n

.meas tran vdout0_251ck1890 FIND v(dout0_251) AT=950.025n

.meas tran vdout0_252ck1890 FIND v(dout0_252) AT=950.025n

.meas tran vdout0_253ck1890 FIND v(dout0_253) AT=950.025n

.meas tran vdout0_254ck1890 FIND v(dout0_254) AT=950.025n

.meas tran vdout0_255ck1890 FIND v(dout0_255) AT=950.025n

.meas tran vdout0_0ck1900 FIND v(dout0_0) AT=955.025n

.meas tran vdout0_1ck1900 FIND v(dout0_1) AT=955.025n

.meas tran vdout0_2ck1900 FIND v(dout0_2) AT=955.025n

.meas tran vdout0_3ck1900 FIND v(dout0_3) AT=955.025n

.meas tran vdout0_4ck1900 FIND v(dout0_4) AT=955.025n

.meas tran vdout0_5ck1900 FIND v(dout0_5) AT=955.025n

.meas tran vdout0_6ck1900 FIND v(dout0_6) AT=955.025n

.meas tran vdout0_7ck1900 FIND v(dout0_7) AT=955.025n

.meas tran vdout0_8ck1900 FIND v(dout0_8) AT=955.025n

.meas tran vdout0_9ck1900 FIND v(dout0_9) AT=955.025n

.meas tran vdout0_10ck1900 FIND v(dout0_10) AT=955.025n

.meas tran vdout0_11ck1900 FIND v(dout0_11) AT=955.025n

.meas tran vdout0_12ck1900 FIND v(dout0_12) AT=955.025n

.meas tran vdout0_13ck1900 FIND v(dout0_13) AT=955.025n

.meas tran vdout0_14ck1900 FIND v(dout0_14) AT=955.025n

.meas tran vdout0_15ck1900 FIND v(dout0_15) AT=955.025n

.meas tran vdout0_16ck1900 FIND v(dout0_16) AT=955.025n

.meas tran vdout0_17ck1900 FIND v(dout0_17) AT=955.025n

.meas tran vdout0_18ck1900 FIND v(dout0_18) AT=955.025n

.meas tran vdout0_19ck1900 FIND v(dout0_19) AT=955.025n

.meas tran vdout0_20ck1900 FIND v(dout0_20) AT=955.025n

.meas tran vdout0_21ck1900 FIND v(dout0_21) AT=955.025n

.meas tran vdout0_22ck1900 FIND v(dout0_22) AT=955.025n

.meas tran vdout0_23ck1900 FIND v(dout0_23) AT=955.025n

.meas tran vdout0_24ck1900 FIND v(dout0_24) AT=955.025n

.meas tran vdout0_25ck1900 FIND v(dout0_25) AT=955.025n

.meas tran vdout0_26ck1900 FIND v(dout0_26) AT=955.025n

.meas tran vdout0_27ck1900 FIND v(dout0_27) AT=955.025n

.meas tran vdout0_28ck1900 FIND v(dout0_28) AT=955.025n

.meas tran vdout0_29ck1900 FIND v(dout0_29) AT=955.025n

.meas tran vdout0_30ck1900 FIND v(dout0_30) AT=955.025n

.meas tran vdout0_31ck1900 FIND v(dout0_31) AT=955.025n

.meas tran vdout0_32ck1900 FIND v(dout0_32) AT=955.025n

.meas tran vdout0_33ck1900 FIND v(dout0_33) AT=955.025n

.meas tran vdout0_34ck1900 FIND v(dout0_34) AT=955.025n

.meas tran vdout0_35ck1900 FIND v(dout0_35) AT=955.025n

.meas tran vdout0_36ck1900 FIND v(dout0_36) AT=955.025n

.meas tran vdout0_37ck1900 FIND v(dout0_37) AT=955.025n

.meas tran vdout0_38ck1900 FIND v(dout0_38) AT=955.025n

.meas tran vdout0_39ck1900 FIND v(dout0_39) AT=955.025n

.meas tran vdout0_40ck1900 FIND v(dout0_40) AT=955.025n

.meas tran vdout0_41ck1900 FIND v(dout0_41) AT=955.025n

.meas tran vdout0_42ck1900 FIND v(dout0_42) AT=955.025n

.meas tran vdout0_43ck1900 FIND v(dout0_43) AT=955.025n

.meas tran vdout0_44ck1900 FIND v(dout0_44) AT=955.025n

.meas tran vdout0_45ck1900 FIND v(dout0_45) AT=955.025n

.meas tran vdout0_46ck1900 FIND v(dout0_46) AT=955.025n

.meas tran vdout0_47ck1900 FIND v(dout0_47) AT=955.025n

.meas tran vdout0_48ck1900 FIND v(dout0_48) AT=955.025n

.meas tran vdout0_49ck1900 FIND v(dout0_49) AT=955.025n

.meas tran vdout0_50ck1900 FIND v(dout0_50) AT=955.025n

.meas tran vdout0_51ck1900 FIND v(dout0_51) AT=955.025n

.meas tran vdout0_52ck1900 FIND v(dout0_52) AT=955.025n

.meas tran vdout0_53ck1900 FIND v(dout0_53) AT=955.025n

.meas tran vdout0_54ck1900 FIND v(dout0_54) AT=955.025n

.meas tran vdout0_55ck1900 FIND v(dout0_55) AT=955.025n

.meas tran vdout0_56ck1900 FIND v(dout0_56) AT=955.025n

.meas tran vdout0_57ck1900 FIND v(dout0_57) AT=955.025n

.meas tran vdout0_58ck1900 FIND v(dout0_58) AT=955.025n

.meas tran vdout0_59ck1900 FIND v(dout0_59) AT=955.025n

.meas tran vdout0_60ck1900 FIND v(dout0_60) AT=955.025n

.meas tran vdout0_61ck1900 FIND v(dout0_61) AT=955.025n

.meas tran vdout0_62ck1900 FIND v(dout0_62) AT=955.025n

.meas tran vdout0_63ck1900 FIND v(dout0_63) AT=955.025n

.meas tran vdout0_64ck1900 FIND v(dout0_64) AT=955.025n

.meas tran vdout0_65ck1900 FIND v(dout0_65) AT=955.025n

.meas tran vdout0_66ck1900 FIND v(dout0_66) AT=955.025n

.meas tran vdout0_67ck1900 FIND v(dout0_67) AT=955.025n

.meas tran vdout0_68ck1900 FIND v(dout0_68) AT=955.025n

.meas tran vdout0_69ck1900 FIND v(dout0_69) AT=955.025n

.meas tran vdout0_70ck1900 FIND v(dout0_70) AT=955.025n

.meas tran vdout0_71ck1900 FIND v(dout0_71) AT=955.025n

.meas tran vdout0_72ck1900 FIND v(dout0_72) AT=955.025n

.meas tran vdout0_73ck1900 FIND v(dout0_73) AT=955.025n

.meas tran vdout0_74ck1900 FIND v(dout0_74) AT=955.025n

.meas tran vdout0_75ck1900 FIND v(dout0_75) AT=955.025n

.meas tran vdout0_76ck1900 FIND v(dout0_76) AT=955.025n

.meas tran vdout0_77ck1900 FIND v(dout0_77) AT=955.025n

.meas tran vdout0_78ck1900 FIND v(dout0_78) AT=955.025n

.meas tran vdout0_79ck1900 FIND v(dout0_79) AT=955.025n

.meas tran vdout0_80ck1900 FIND v(dout0_80) AT=955.025n

.meas tran vdout0_81ck1900 FIND v(dout0_81) AT=955.025n

.meas tran vdout0_82ck1900 FIND v(dout0_82) AT=955.025n

.meas tran vdout0_83ck1900 FIND v(dout0_83) AT=955.025n

.meas tran vdout0_84ck1900 FIND v(dout0_84) AT=955.025n

.meas tran vdout0_85ck1900 FIND v(dout0_85) AT=955.025n

.meas tran vdout0_86ck1900 FIND v(dout0_86) AT=955.025n

.meas tran vdout0_87ck1900 FIND v(dout0_87) AT=955.025n

.meas tran vdout0_88ck1900 FIND v(dout0_88) AT=955.025n

.meas tran vdout0_89ck1900 FIND v(dout0_89) AT=955.025n

.meas tran vdout0_90ck1900 FIND v(dout0_90) AT=955.025n

.meas tran vdout0_91ck1900 FIND v(dout0_91) AT=955.025n

.meas tran vdout0_92ck1900 FIND v(dout0_92) AT=955.025n

.meas tran vdout0_93ck1900 FIND v(dout0_93) AT=955.025n

.meas tran vdout0_94ck1900 FIND v(dout0_94) AT=955.025n

.meas tran vdout0_95ck1900 FIND v(dout0_95) AT=955.025n

.meas tran vdout0_96ck1900 FIND v(dout0_96) AT=955.025n

.meas tran vdout0_97ck1900 FIND v(dout0_97) AT=955.025n

.meas tran vdout0_98ck1900 FIND v(dout0_98) AT=955.025n

.meas tran vdout0_99ck1900 FIND v(dout0_99) AT=955.025n

.meas tran vdout0_100ck1900 FIND v(dout0_100) AT=955.025n

.meas tran vdout0_101ck1900 FIND v(dout0_101) AT=955.025n

.meas tran vdout0_102ck1900 FIND v(dout0_102) AT=955.025n

.meas tran vdout0_103ck1900 FIND v(dout0_103) AT=955.025n

.meas tran vdout0_104ck1900 FIND v(dout0_104) AT=955.025n

.meas tran vdout0_105ck1900 FIND v(dout0_105) AT=955.025n

.meas tran vdout0_106ck1900 FIND v(dout0_106) AT=955.025n

.meas tran vdout0_107ck1900 FIND v(dout0_107) AT=955.025n

.meas tran vdout0_108ck1900 FIND v(dout0_108) AT=955.025n

.meas tran vdout0_109ck1900 FIND v(dout0_109) AT=955.025n

.meas tran vdout0_110ck1900 FIND v(dout0_110) AT=955.025n

.meas tran vdout0_111ck1900 FIND v(dout0_111) AT=955.025n

.meas tran vdout0_112ck1900 FIND v(dout0_112) AT=955.025n

.meas tran vdout0_113ck1900 FIND v(dout0_113) AT=955.025n

.meas tran vdout0_114ck1900 FIND v(dout0_114) AT=955.025n

.meas tran vdout0_115ck1900 FIND v(dout0_115) AT=955.025n

.meas tran vdout0_116ck1900 FIND v(dout0_116) AT=955.025n

.meas tran vdout0_117ck1900 FIND v(dout0_117) AT=955.025n

.meas tran vdout0_118ck1900 FIND v(dout0_118) AT=955.025n

.meas tran vdout0_119ck1900 FIND v(dout0_119) AT=955.025n

.meas tran vdout0_120ck1900 FIND v(dout0_120) AT=955.025n

.meas tran vdout0_121ck1900 FIND v(dout0_121) AT=955.025n

.meas tran vdout0_122ck1900 FIND v(dout0_122) AT=955.025n

.meas tran vdout0_123ck1900 FIND v(dout0_123) AT=955.025n

.meas tran vdout0_124ck1900 FIND v(dout0_124) AT=955.025n

.meas tran vdout0_125ck1900 FIND v(dout0_125) AT=955.025n

.meas tran vdout0_126ck1900 FIND v(dout0_126) AT=955.025n

.meas tran vdout0_127ck1900 FIND v(dout0_127) AT=955.025n

.meas tran vdout0_128ck1900 FIND v(dout0_128) AT=955.025n

.meas tran vdout0_129ck1900 FIND v(dout0_129) AT=955.025n

.meas tran vdout0_130ck1900 FIND v(dout0_130) AT=955.025n

.meas tran vdout0_131ck1900 FIND v(dout0_131) AT=955.025n

.meas tran vdout0_132ck1900 FIND v(dout0_132) AT=955.025n

.meas tran vdout0_133ck1900 FIND v(dout0_133) AT=955.025n

.meas tran vdout0_134ck1900 FIND v(dout0_134) AT=955.025n

.meas tran vdout0_135ck1900 FIND v(dout0_135) AT=955.025n

.meas tran vdout0_136ck1900 FIND v(dout0_136) AT=955.025n

.meas tran vdout0_137ck1900 FIND v(dout0_137) AT=955.025n

.meas tran vdout0_138ck1900 FIND v(dout0_138) AT=955.025n

.meas tran vdout0_139ck1900 FIND v(dout0_139) AT=955.025n

.meas tran vdout0_140ck1900 FIND v(dout0_140) AT=955.025n

.meas tran vdout0_141ck1900 FIND v(dout0_141) AT=955.025n

.meas tran vdout0_142ck1900 FIND v(dout0_142) AT=955.025n

.meas tran vdout0_143ck1900 FIND v(dout0_143) AT=955.025n

.meas tran vdout0_144ck1900 FIND v(dout0_144) AT=955.025n

.meas tran vdout0_145ck1900 FIND v(dout0_145) AT=955.025n

.meas tran vdout0_146ck1900 FIND v(dout0_146) AT=955.025n

.meas tran vdout0_147ck1900 FIND v(dout0_147) AT=955.025n

.meas tran vdout0_148ck1900 FIND v(dout0_148) AT=955.025n

.meas tran vdout0_149ck1900 FIND v(dout0_149) AT=955.025n

.meas tran vdout0_150ck1900 FIND v(dout0_150) AT=955.025n

.meas tran vdout0_151ck1900 FIND v(dout0_151) AT=955.025n

.meas tran vdout0_152ck1900 FIND v(dout0_152) AT=955.025n

.meas tran vdout0_153ck1900 FIND v(dout0_153) AT=955.025n

.meas tran vdout0_154ck1900 FIND v(dout0_154) AT=955.025n

.meas tran vdout0_155ck1900 FIND v(dout0_155) AT=955.025n

.meas tran vdout0_156ck1900 FIND v(dout0_156) AT=955.025n

.meas tran vdout0_157ck1900 FIND v(dout0_157) AT=955.025n

.meas tran vdout0_158ck1900 FIND v(dout0_158) AT=955.025n

.meas tran vdout0_159ck1900 FIND v(dout0_159) AT=955.025n

.meas tran vdout0_160ck1900 FIND v(dout0_160) AT=955.025n

.meas tran vdout0_161ck1900 FIND v(dout0_161) AT=955.025n

.meas tran vdout0_162ck1900 FIND v(dout0_162) AT=955.025n

.meas tran vdout0_163ck1900 FIND v(dout0_163) AT=955.025n

.meas tran vdout0_164ck1900 FIND v(dout0_164) AT=955.025n

.meas tran vdout0_165ck1900 FIND v(dout0_165) AT=955.025n

.meas tran vdout0_166ck1900 FIND v(dout0_166) AT=955.025n

.meas tran vdout0_167ck1900 FIND v(dout0_167) AT=955.025n

.meas tran vdout0_168ck1900 FIND v(dout0_168) AT=955.025n

.meas tran vdout0_169ck1900 FIND v(dout0_169) AT=955.025n

.meas tran vdout0_170ck1900 FIND v(dout0_170) AT=955.025n

.meas tran vdout0_171ck1900 FIND v(dout0_171) AT=955.025n

.meas tran vdout0_172ck1900 FIND v(dout0_172) AT=955.025n

.meas tran vdout0_173ck1900 FIND v(dout0_173) AT=955.025n

.meas tran vdout0_174ck1900 FIND v(dout0_174) AT=955.025n

.meas tran vdout0_175ck1900 FIND v(dout0_175) AT=955.025n

.meas tran vdout0_176ck1900 FIND v(dout0_176) AT=955.025n

.meas tran vdout0_177ck1900 FIND v(dout0_177) AT=955.025n

.meas tran vdout0_178ck1900 FIND v(dout0_178) AT=955.025n

.meas tran vdout0_179ck1900 FIND v(dout0_179) AT=955.025n

.meas tran vdout0_180ck1900 FIND v(dout0_180) AT=955.025n

.meas tran vdout0_181ck1900 FIND v(dout0_181) AT=955.025n

.meas tran vdout0_182ck1900 FIND v(dout0_182) AT=955.025n

.meas tran vdout0_183ck1900 FIND v(dout0_183) AT=955.025n

.meas tran vdout0_184ck1900 FIND v(dout0_184) AT=955.025n

.meas tran vdout0_185ck1900 FIND v(dout0_185) AT=955.025n

.meas tran vdout0_186ck1900 FIND v(dout0_186) AT=955.025n

.meas tran vdout0_187ck1900 FIND v(dout0_187) AT=955.025n

.meas tran vdout0_188ck1900 FIND v(dout0_188) AT=955.025n

.meas tran vdout0_189ck1900 FIND v(dout0_189) AT=955.025n

.meas tran vdout0_190ck1900 FIND v(dout0_190) AT=955.025n

.meas tran vdout0_191ck1900 FIND v(dout0_191) AT=955.025n

.meas tran vdout0_192ck1900 FIND v(dout0_192) AT=955.025n

.meas tran vdout0_193ck1900 FIND v(dout0_193) AT=955.025n

.meas tran vdout0_194ck1900 FIND v(dout0_194) AT=955.025n

.meas tran vdout0_195ck1900 FIND v(dout0_195) AT=955.025n

.meas tran vdout0_196ck1900 FIND v(dout0_196) AT=955.025n

.meas tran vdout0_197ck1900 FIND v(dout0_197) AT=955.025n

.meas tran vdout0_198ck1900 FIND v(dout0_198) AT=955.025n

.meas tran vdout0_199ck1900 FIND v(dout0_199) AT=955.025n

.meas tran vdout0_200ck1900 FIND v(dout0_200) AT=955.025n

.meas tran vdout0_201ck1900 FIND v(dout0_201) AT=955.025n

.meas tran vdout0_202ck1900 FIND v(dout0_202) AT=955.025n

.meas tran vdout0_203ck1900 FIND v(dout0_203) AT=955.025n

.meas tran vdout0_204ck1900 FIND v(dout0_204) AT=955.025n

.meas tran vdout0_205ck1900 FIND v(dout0_205) AT=955.025n

.meas tran vdout0_206ck1900 FIND v(dout0_206) AT=955.025n

.meas tran vdout0_207ck1900 FIND v(dout0_207) AT=955.025n

.meas tran vdout0_208ck1900 FIND v(dout0_208) AT=955.025n

.meas tran vdout0_209ck1900 FIND v(dout0_209) AT=955.025n

.meas tran vdout0_210ck1900 FIND v(dout0_210) AT=955.025n

.meas tran vdout0_211ck1900 FIND v(dout0_211) AT=955.025n

.meas tran vdout0_212ck1900 FIND v(dout0_212) AT=955.025n

.meas tran vdout0_213ck1900 FIND v(dout0_213) AT=955.025n

.meas tran vdout0_214ck1900 FIND v(dout0_214) AT=955.025n

.meas tran vdout0_215ck1900 FIND v(dout0_215) AT=955.025n

.meas tran vdout0_216ck1900 FIND v(dout0_216) AT=955.025n

.meas tran vdout0_217ck1900 FIND v(dout0_217) AT=955.025n

.meas tran vdout0_218ck1900 FIND v(dout0_218) AT=955.025n

.meas tran vdout0_219ck1900 FIND v(dout0_219) AT=955.025n

.meas tran vdout0_220ck1900 FIND v(dout0_220) AT=955.025n

.meas tran vdout0_221ck1900 FIND v(dout0_221) AT=955.025n

.meas tran vdout0_222ck1900 FIND v(dout0_222) AT=955.025n

.meas tran vdout0_223ck1900 FIND v(dout0_223) AT=955.025n

.meas tran vdout0_224ck1900 FIND v(dout0_224) AT=955.025n

.meas tran vdout0_225ck1900 FIND v(dout0_225) AT=955.025n

.meas tran vdout0_226ck1900 FIND v(dout0_226) AT=955.025n

.meas tran vdout0_227ck1900 FIND v(dout0_227) AT=955.025n

.meas tran vdout0_228ck1900 FIND v(dout0_228) AT=955.025n

.meas tran vdout0_229ck1900 FIND v(dout0_229) AT=955.025n

.meas tran vdout0_230ck1900 FIND v(dout0_230) AT=955.025n

.meas tran vdout0_231ck1900 FIND v(dout0_231) AT=955.025n

.meas tran vdout0_232ck1900 FIND v(dout0_232) AT=955.025n

.meas tran vdout0_233ck1900 FIND v(dout0_233) AT=955.025n

.meas tran vdout0_234ck1900 FIND v(dout0_234) AT=955.025n

.meas tran vdout0_235ck1900 FIND v(dout0_235) AT=955.025n

.meas tran vdout0_236ck1900 FIND v(dout0_236) AT=955.025n

.meas tran vdout0_237ck1900 FIND v(dout0_237) AT=955.025n

.meas tran vdout0_238ck1900 FIND v(dout0_238) AT=955.025n

.meas tran vdout0_239ck1900 FIND v(dout0_239) AT=955.025n

.meas tran vdout0_240ck1900 FIND v(dout0_240) AT=955.025n

.meas tran vdout0_241ck1900 FIND v(dout0_241) AT=955.025n

.meas tran vdout0_242ck1900 FIND v(dout0_242) AT=955.025n

.meas tran vdout0_243ck1900 FIND v(dout0_243) AT=955.025n

.meas tran vdout0_244ck1900 FIND v(dout0_244) AT=955.025n

.meas tran vdout0_245ck1900 FIND v(dout0_245) AT=955.025n

.meas tran vdout0_246ck1900 FIND v(dout0_246) AT=955.025n

.meas tran vdout0_247ck1900 FIND v(dout0_247) AT=955.025n

.meas tran vdout0_248ck1900 FIND v(dout0_248) AT=955.025n

.meas tran vdout0_249ck1900 FIND v(dout0_249) AT=955.025n

.meas tran vdout0_250ck1900 FIND v(dout0_250) AT=955.025n

.meas tran vdout0_251ck1900 FIND v(dout0_251) AT=955.025n

.meas tran vdout0_252ck1900 FIND v(dout0_252) AT=955.025n

.meas tran vdout0_253ck1900 FIND v(dout0_253) AT=955.025n

.meas tran vdout0_254ck1900 FIND v(dout0_254) AT=955.025n

.meas tran vdout0_255ck1900 FIND v(dout0_255) AT=955.025n

.meas tran vdout0_0ck1930 FIND v(dout0_0) AT=970.025n

.meas tran vdout0_1ck1930 FIND v(dout0_1) AT=970.025n

.meas tran vdout0_2ck1930 FIND v(dout0_2) AT=970.025n

.meas tran vdout0_3ck1930 FIND v(dout0_3) AT=970.025n

.meas tran vdout0_4ck1930 FIND v(dout0_4) AT=970.025n

.meas tran vdout0_5ck1930 FIND v(dout0_5) AT=970.025n

.meas tran vdout0_6ck1930 FIND v(dout0_6) AT=970.025n

.meas tran vdout0_7ck1930 FIND v(dout0_7) AT=970.025n

.meas tran vdout0_8ck1930 FIND v(dout0_8) AT=970.025n

.meas tran vdout0_9ck1930 FIND v(dout0_9) AT=970.025n

.meas tran vdout0_10ck1930 FIND v(dout0_10) AT=970.025n

.meas tran vdout0_11ck1930 FIND v(dout0_11) AT=970.025n

.meas tran vdout0_12ck1930 FIND v(dout0_12) AT=970.025n

.meas tran vdout0_13ck1930 FIND v(dout0_13) AT=970.025n

.meas tran vdout0_14ck1930 FIND v(dout0_14) AT=970.025n

.meas tran vdout0_15ck1930 FIND v(dout0_15) AT=970.025n

.meas tran vdout0_16ck1930 FIND v(dout0_16) AT=970.025n

.meas tran vdout0_17ck1930 FIND v(dout0_17) AT=970.025n

.meas tran vdout0_18ck1930 FIND v(dout0_18) AT=970.025n

.meas tran vdout0_19ck1930 FIND v(dout0_19) AT=970.025n

.meas tran vdout0_20ck1930 FIND v(dout0_20) AT=970.025n

.meas tran vdout0_21ck1930 FIND v(dout0_21) AT=970.025n

.meas tran vdout0_22ck1930 FIND v(dout0_22) AT=970.025n

.meas tran vdout0_23ck1930 FIND v(dout0_23) AT=970.025n

.meas tran vdout0_24ck1930 FIND v(dout0_24) AT=970.025n

.meas tran vdout0_25ck1930 FIND v(dout0_25) AT=970.025n

.meas tran vdout0_26ck1930 FIND v(dout0_26) AT=970.025n

.meas tran vdout0_27ck1930 FIND v(dout0_27) AT=970.025n

.meas tran vdout0_28ck1930 FIND v(dout0_28) AT=970.025n

.meas tran vdout0_29ck1930 FIND v(dout0_29) AT=970.025n

.meas tran vdout0_30ck1930 FIND v(dout0_30) AT=970.025n

.meas tran vdout0_31ck1930 FIND v(dout0_31) AT=970.025n

.meas tran vdout0_32ck1930 FIND v(dout0_32) AT=970.025n

.meas tran vdout0_33ck1930 FIND v(dout0_33) AT=970.025n

.meas tran vdout0_34ck1930 FIND v(dout0_34) AT=970.025n

.meas tran vdout0_35ck1930 FIND v(dout0_35) AT=970.025n

.meas tran vdout0_36ck1930 FIND v(dout0_36) AT=970.025n

.meas tran vdout0_37ck1930 FIND v(dout0_37) AT=970.025n

.meas tran vdout0_38ck1930 FIND v(dout0_38) AT=970.025n

.meas tran vdout0_39ck1930 FIND v(dout0_39) AT=970.025n

.meas tran vdout0_40ck1930 FIND v(dout0_40) AT=970.025n

.meas tran vdout0_41ck1930 FIND v(dout0_41) AT=970.025n

.meas tran vdout0_42ck1930 FIND v(dout0_42) AT=970.025n

.meas tran vdout0_43ck1930 FIND v(dout0_43) AT=970.025n

.meas tran vdout0_44ck1930 FIND v(dout0_44) AT=970.025n

.meas tran vdout0_45ck1930 FIND v(dout0_45) AT=970.025n

.meas tran vdout0_46ck1930 FIND v(dout0_46) AT=970.025n

.meas tran vdout0_47ck1930 FIND v(dout0_47) AT=970.025n

.meas tran vdout0_48ck1930 FIND v(dout0_48) AT=970.025n

.meas tran vdout0_49ck1930 FIND v(dout0_49) AT=970.025n

.meas tran vdout0_50ck1930 FIND v(dout0_50) AT=970.025n

.meas tran vdout0_51ck1930 FIND v(dout0_51) AT=970.025n

.meas tran vdout0_52ck1930 FIND v(dout0_52) AT=970.025n

.meas tran vdout0_53ck1930 FIND v(dout0_53) AT=970.025n

.meas tran vdout0_54ck1930 FIND v(dout0_54) AT=970.025n

.meas tran vdout0_55ck1930 FIND v(dout0_55) AT=970.025n

.meas tran vdout0_56ck1930 FIND v(dout0_56) AT=970.025n

.meas tran vdout0_57ck1930 FIND v(dout0_57) AT=970.025n

.meas tran vdout0_58ck1930 FIND v(dout0_58) AT=970.025n

.meas tran vdout0_59ck1930 FIND v(dout0_59) AT=970.025n

.meas tran vdout0_60ck1930 FIND v(dout0_60) AT=970.025n

.meas tran vdout0_61ck1930 FIND v(dout0_61) AT=970.025n

.meas tran vdout0_62ck1930 FIND v(dout0_62) AT=970.025n

.meas tran vdout0_63ck1930 FIND v(dout0_63) AT=970.025n

.meas tran vdout0_64ck1930 FIND v(dout0_64) AT=970.025n

.meas tran vdout0_65ck1930 FIND v(dout0_65) AT=970.025n

.meas tran vdout0_66ck1930 FIND v(dout0_66) AT=970.025n

.meas tran vdout0_67ck1930 FIND v(dout0_67) AT=970.025n

.meas tran vdout0_68ck1930 FIND v(dout0_68) AT=970.025n

.meas tran vdout0_69ck1930 FIND v(dout0_69) AT=970.025n

.meas tran vdout0_70ck1930 FIND v(dout0_70) AT=970.025n

.meas tran vdout0_71ck1930 FIND v(dout0_71) AT=970.025n

.meas tran vdout0_72ck1930 FIND v(dout0_72) AT=970.025n

.meas tran vdout0_73ck1930 FIND v(dout0_73) AT=970.025n

.meas tran vdout0_74ck1930 FIND v(dout0_74) AT=970.025n

.meas tran vdout0_75ck1930 FIND v(dout0_75) AT=970.025n

.meas tran vdout0_76ck1930 FIND v(dout0_76) AT=970.025n

.meas tran vdout0_77ck1930 FIND v(dout0_77) AT=970.025n

.meas tran vdout0_78ck1930 FIND v(dout0_78) AT=970.025n

.meas tran vdout0_79ck1930 FIND v(dout0_79) AT=970.025n

.meas tran vdout0_80ck1930 FIND v(dout0_80) AT=970.025n

.meas tran vdout0_81ck1930 FIND v(dout0_81) AT=970.025n

.meas tran vdout0_82ck1930 FIND v(dout0_82) AT=970.025n

.meas tran vdout0_83ck1930 FIND v(dout0_83) AT=970.025n

.meas tran vdout0_84ck1930 FIND v(dout0_84) AT=970.025n

.meas tran vdout0_85ck1930 FIND v(dout0_85) AT=970.025n

.meas tran vdout0_86ck1930 FIND v(dout0_86) AT=970.025n

.meas tran vdout0_87ck1930 FIND v(dout0_87) AT=970.025n

.meas tran vdout0_88ck1930 FIND v(dout0_88) AT=970.025n

.meas tran vdout0_89ck1930 FIND v(dout0_89) AT=970.025n

.meas tran vdout0_90ck1930 FIND v(dout0_90) AT=970.025n

.meas tran vdout0_91ck1930 FIND v(dout0_91) AT=970.025n

.meas tran vdout0_92ck1930 FIND v(dout0_92) AT=970.025n

.meas tran vdout0_93ck1930 FIND v(dout0_93) AT=970.025n

.meas tran vdout0_94ck1930 FIND v(dout0_94) AT=970.025n

.meas tran vdout0_95ck1930 FIND v(dout0_95) AT=970.025n

.meas tran vdout0_96ck1930 FIND v(dout0_96) AT=970.025n

.meas tran vdout0_97ck1930 FIND v(dout0_97) AT=970.025n

.meas tran vdout0_98ck1930 FIND v(dout0_98) AT=970.025n

.meas tran vdout0_99ck1930 FIND v(dout0_99) AT=970.025n

.meas tran vdout0_100ck1930 FIND v(dout0_100) AT=970.025n

.meas tran vdout0_101ck1930 FIND v(dout0_101) AT=970.025n

.meas tran vdout0_102ck1930 FIND v(dout0_102) AT=970.025n

.meas tran vdout0_103ck1930 FIND v(dout0_103) AT=970.025n

.meas tran vdout0_104ck1930 FIND v(dout0_104) AT=970.025n

.meas tran vdout0_105ck1930 FIND v(dout0_105) AT=970.025n

.meas tran vdout0_106ck1930 FIND v(dout0_106) AT=970.025n

.meas tran vdout0_107ck1930 FIND v(dout0_107) AT=970.025n

.meas tran vdout0_108ck1930 FIND v(dout0_108) AT=970.025n

.meas tran vdout0_109ck1930 FIND v(dout0_109) AT=970.025n

.meas tran vdout0_110ck1930 FIND v(dout0_110) AT=970.025n

.meas tran vdout0_111ck1930 FIND v(dout0_111) AT=970.025n

.meas tran vdout0_112ck1930 FIND v(dout0_112) AT=970.025n

.meas tran vdout0_113ck1930 FIND v(dout0_113) AT=970.025n

.meas tran vdout0_114ck1930 FIND v(dout0_114) AT=970.025n

.meas tran vdout0_115ck1930 FIND v(dout0_115) AT=970.025n

.meas tran vdout0_116ck1930 FIND v(dout0_116) AT=970.025n

.meas tran vdout0_117ck1930 FIND v(dout0_117) AT=970.025n

.meas tran vdout0_118ck1930 FIND v(dout0_118) AT=970.025n

.meas tran vdout0_119ck1930 FIND v(dout0_119) AT=970.025n

.meas tran vdout0_120ck1930 FIND v(dout0_120) AT=970.025n

.meas tran vdout0_121ck1930 FIND v(dout0_121) AT=970.025n

.meas tran vdout0_122ck1930 FIND v(dout0_122) AT=970.025n

.meas tran vdout0_123ck1930 FIND v(dout0_123) AT=970.025n

.meas tran vdout0_124ck1930 FIND v(dout0_124) AT=970.025n

.meas tran vdout0_125ck1930 FIND v(dout0_125) AT=970.025n

.meas tran vdout0_126ck1930 FIND v(dout0_126) AT=970.025n

.meas tran vdout0_127ck1930 FIND v(dout0_127) AT=970.025n

.meas tran vdout0_128ck1930 FIND v(dout0_128) AT=970.025n

.meas tran vdout0_129ck1930 FIND v(dout0_129) AT=970.025n

.meas tran vdout0_130ck1930 FIND v(dout0_130) AT=970.025n

.meas tran vdout0_131ck1930 FIND v(dout0_131) AT=970.025n

.meas tran vdout0_132ck1930 FIND v(dout0_132) AT=970.025n

.meas tran vdout0_133ck1930 FIND v(dout0_133) AT=970.025n

.meas tran vdout0_134ck1930 FIND v(dout0_134) AT=970.025n

.meas tran vdout0_135ck1930 FIND v(dout0_135) AT=970.025n

.meas tran vdout0_136ck1930 FIND v(dout0_136) AT=970.025n

.meas tran vdout0_137ck1930 FIND v(dout0_137) AT=970.025n

.meas tran vdout0_138ck1930 FIND v(dout0_138) AT=970.025n

.meas tran vdout0_139ck1930 FIND v(dout0_139) AT=970.025n

.meas tran vdout0_140ck1930 FIND v(dout0_140) AT=970.025n

.meas tran vdout0_141ck1930 FIND v(dout0_141) AT=970.025n

.meas tran vdout0_142ck1930 FIND v(dout0_142) AT=970.025n

.meas tran vdout0_143ck1930 FIND v(dout0_143) AT=970.025n

.meas tran vdout0_144ck1930 FIND v(dout0_144) AT=970.025n

.meas tran vdout0_145ck1930 FIND v(dout0_145) AT=970.025n

.meas tran vdout0_146ck1930 FIND v(dout0_146) AT=970.025n

.meas tran vdout0_147ck1930 FIND v(dout0_147) AT=970.025n

.meas tran vdout0_148ck1930 FIND v(dout0_148) AT=970.025n

.meas tran vdout0_149ck1930 FIND v(dout0_149) AT=970.025n

.meas tran vdout0_150ck1930 FIND v(dout0_150) AT=970.025n

.meas tran vdout0_151ck1930 FIND v(dout0_151) AT=970.025n

.meas tran vdout0_152ck1930 FIND v(dout0_152) AT=970.025n

.meas tran vdout0_153ck1930 FIND v(dout0_153) AT=970.025n

.meas tran vdout0_154ck1930 FIND v(dout0_154) AT=970.025n

.meas tran vdout0_155ck1930 FIND v(dout0_155) AT=970.025n

.meas tran vdout0_156ck1930 FIND v(dout0_156) AT=970.025n

.meas tran vdout0_157ck1930 FIND v(dout0_157) AT=970.025n

.meas tran vdout0_158ck1930 FIND v(dout0_158) AT=970.025n

.meas tran vdout0_159ck1930 FIND v(dout0_159) AT=970.025n

.meas tran vdout0_160ck1930 FIND v(dout0_160) AT=970.025n

.meas tran vdout0_161ck1930 FIND v(dout0_161) AT=970.025n

.meas tran vdout0_162ck1930 FIND v(dout0_162) AT=970.025n

.meas tran vdout0_163ck1930 FIND v(dout0_163) AT=970.025n

.meas tran vdout0_164ck1930 FIND v(dout0_164) AT=970.025n

.meas tran vdout0_165ck1930 FIND v(dout0_165) AT=970.025n

.meas tran vdout0_166ck1930 FIND v(dout0_166) AT=970.025n

.meas tran vdout0_167ck1930 FIND v(dout0_167) AT=970.025n

.meas tran vdout0_168ck1930 FIND v(dout0_168) AT=970.025n

.meas tran vdout0_169ck1930 FIND v(dout0_169) AT=970.025n

.meas tran vdout0_170ck1930 FIND v(dout0_170) AT=970.025n

.meas tran vdout0_171ck1930 FIND v(dout0_171) AT=970.025n

.meas tran vdout0_172ck1930 FIND v(dout0_172) AT=970.025n

.meas tran vdout0_173ck1930 FIND v(dout0_173) AT=970.025n

.meas tran vdout0_174ck1930 FIND v(dout0_174) AT=970.025n

.meas tran vdout0_175ck1930 FIND v(dout0_175) AT=970.025n

.meas tran vdout0_176ck1930 FIND v(dout0_176) AT=970.025n

.meas tran vdout0_177ck1930 FIND v(dout0_177) AT=970.025n

.meas tran vdout0_178ck1930 FIND v(dout0_178) AT=970.025n

.meas tran vdout0_179ck1930 FIND v(dout0_179) AT=970.025n

.meas tran vdout0_180ck1930 FIND v(dout0_180) AT=970.025n

.meas tran vdout0_181ck1930 FIND v(dout0_181) AT=970.025n

.meas tran vdout0_182ck1930 FIND v(dout0_182) AT=970.025n

.meas tran vdout0_183ck1930 FIND v(dout0_183) AT=970.025n

.meas tran vdout0_184ck1930 FIND v(dout0_184) AT=970.025n

.meas tran vdout0_185ck1930 FIND v(dout0_185) AT=970.025n

.meas tran vdout0_186ck1930 FIND v(dout0_186) AT=970.025n

.meas tran vdout0_187ck1930 FIND v(dout0_187) AT=970.025n

.meas tran vdout0_188ck1930 FIND v(dout0_188) AT=970.025n

.meas tran vdout0_189ck1930 FIND v(dout0_189) AT=970.025n

.meas tran vdout0_190ck1930 FIND v(dout0_190) AT=970.025n

.meas tran vdout0_191ck1930 FIND v(dout0_191) AT=970.025n

.meas tran vdout0_192ck1930 FIND v(dout0_192) AT=970.025n

.meas tran vdout0_193ck1930 FIND v(dout0_193) AT=970.025n

.meas tran vdout0_194ck1930 FIND v(dout0_194) AT=970.025n

.meas tran vdout0_195ck1930 FIND v(dout0_195) AT=970.025n

.meas tran vdout0_196ck1930 FIND v(dout0_196) AT=970.025n

.meas tran vdout0_197ck1930 FIND v(dout0_197) AT=970.025n

.meas tran vdout0_198ck1930 FIND v(dout0_198) AT=970.025n

.meas tran vdout0_199ck1930 FIND v(dout0_199) AT=970.025n

.meas tran vdout0_200ck1930 FIND v(dout0_200) AT=970.025n

.meas tran vdout0_201ck1930 FIND v(dout0_201) AT=970.025n

.meas tran vdout0_202ck1930 FIND v(dout0_202) AT=970.025n

.meas tran vdout0_203ck1930 FIND v(dout0_203) AT=970.025n

.meas tran vdout0_204ck1930 FIND v(dout0_204) AT=970.025n

.meas tran vdout0_205ck1930 FIND v(dout0_205) AT=970.025n

.meas tran vdout0_206ck1930 FIND v(dout0_206) AT=970.025n

.meas tran vdout0_207ck1930 FIND v(dout0_207) AT=970.025n

.meas tran vdout0_208ck1930 FIND v(dout0_208) AT=970.025n

.meas tran vdout0_209ck1930 FIND v(dout0_209) AT=970.025n

.meas tran vdout0_210ck1930 FIND v(dout0_210) AT=970.025n

.meas tran vdout0_211ck1930 FIND v(dout0_211) AT=970.025n

.meas tran vdout0_212ck1930 FIND v(dout0_212) AT=970.025n

.meas tran vdout0_213ck1930 FIND v(dout0_213) AT=970.025n

.meas tran vdout0_214ck1930 FIND v(dout0_214) AT=970.025n

.meas tran vdout0_215ck1930 FIND v(dout0_215) AT=970.025n

.meas tran vdout0_216ck1930 FIND v(dout0_216) AT=970.025n

.meas tran vdout0_217ck1930 FIND v(dout0_217) AT=970.025n

.meas tran vdout0_218ck1930 FIND v(dout0_218) AT=970.025n

.meas tran vdout0_219ck1930 FIND v(dout0_219) AT=970.025n

.meas tran vdout0_220ck1930 FIND v(dout0_220) AT=970.025n

.meas tran vdout0_221ck1930 FIND v(dout0_221) AT=970.025n

.meas tran vdout0_222ck1930 FIND v(dout0_222) AT=970.025n

.meas tran vdout0_223ck1930 FIND v(dout0_223) AT=970.025n

.meas tran vdout0_224ck1930 FIND v(dout0_224) AT=970.025n

.meas tran vdout0_225ck1930 FIND v(dout0_225) AT=970.025n

.meas tran vdout0_226ck1930 FIND v(dout0_226) AT=970.025n

.meas tran vdout0_227ck1930 FIND v(dout0_227) AT=970.025n

.meas tran vdout0_228ck1930 FIND v(dout0_228) AT=970.025n

.meas tran vdout0_229ck1930 FIND v(dout0_229) AT=970.025n

.meas tran vdout0_230ck1930 FIND v(dout0_230) AT=970.025n

.meas tran vdout0_231ck1930 FIND v(dout0_231) AT=970.025n

.meas tran vdout0_232ck1930 FIND v(dout0_232) AT=970.025n

.meas tran vdout0_233ck1930 FIND v(dout0_233) AT=970.025n

.meas tran vdout0_234ck1930 FIND v(dout0_234) AT=970.025n

.meas tran vdout0_235ck1930 FIND v(dout0_235) AT=970.025n

.meas tran vdout0_236ck1930 FIND v(dout0_236) AT=970.025n

.meas tran vdout0_237ck1930 FIND v(dout0_237) AT=970.025n

.meas tran vdout0_238ck1930 FIND v(dout0_238) AT=970.025n

.meas tran vdout0_239ck1930 FIND v(dout0_239) AT=970.025n

.meas tran vdout0_240ck1930 FIND v(dout0_240) AT=970.025n

.meas tran vdout0_241ck1930 FIND v(dout0_241) AT=970.025n

.meas tran vdout0_242ck1930 FIND v(dout0_242) AT=970.025n

.meas tran vdout0_243ck1930 FIND v(dout0_243) AT=970.025n

.meas tran vdout0_244ck1930 FIND v(dout0_244) AT=970.025n

.meas tran vdout0_245ck1930 FIND v(dout0_245) AT=970.025n

.meas tran vdout0_246ck1930 FIND v(dout0_246) AT=970.025n

.meas tran vdout0_247ck1930 FIND v(dout0_247) AT=970.025n

.meas tran vdout0_248ck1930 FIND v(dout0_248) AT=970.025n

.meas tran vdout0_249ck1930 FIND v(dout0_249) AT=970.025n

.meas tran vdout0_250ck1930 FIND v(dout0_250) AT=970.025n

.meas tran vdout0_251ck1930 FIND v(dout0_251) AT=970.025n

.meas tran vdout0_252ck1930 FIND v(dout0_252) AT=970.025n

.meas tran vdout0_253ck1930 FIND v(dout0_253) AT=970.025n

.meas tran vdout0_254ck1930 FIND v(dout0_254) AT=970.025n

.meas tran vdout0_255ck1930 FIND v(dout0_255) AT=970.025n

.meas tran vdout0_0ck1960 FIND v(dout0_0) AT=985.025n

.meas tran vdout0_1ck1960 FIND v(dout0_1) AT=985.025n

.meas tran vdout0_2ck1960 FIND v(dout0_2) AT=985.025n

.meas tran vdout0_3ck1960 FIND v(dout0_3) AT=985.025n

.meas tran vdout0_4ck1960 FIND v(dout0_4) AT=985.025n

.meas tran vdout0_5ck1960 FIND v(dout0_5) AT=985.025n

.meas tran vdout0_6ck1960 FIND v(dout0_6) AT=985.025n

.meas tran vdout0_7ck1960 FIND v(dout0_7) AT=985.025n

.meas tran vdout0_8ck1960 FIND v(dout0_8) AT=985.025n

.meas tran vdout0_9ck1960 FIND v(dout0_9) AT=985.025n

.meas tran vdout0_10ck1960 FIND v(dout0_10) AT=985.025n

.meas tran vdout0_11ck1960 FIND v(dout0_11) AT=985.025n

.meas tran vdout0_12ck1960 FIND v(dout0_12) AT=985.025n

.meas tran vdout0_13ck1960 FIND v(dout0_13) AT=985.025n

.meas tran vdout0_14ck1960 FIND v(dout0_14) AT=985.025n

.meas tran vdout0_15ck1960 FIND v(dout0_15) AT=985.025n

.meas tran vdout0_16ck1960 FIND v(dout0_16) AT=985.025n

.meas tran vdout0_17ck1960 FIND v(dout0_17) AT=985.025n

.meas tran vdout0_18ck1960 FIND v(dout0_18) AT=985.025n

.meas tran vdout0_19ck1960 FIND v(dout0_19) AT=985.025n

.meas tran vdout0_20ck1960 FIND v(dout0_20) AT=985.025n

.meas tran vdout0_21ck1960 FIND v(dout0_21) AT=985.025n

.meas tran vdout0_22ck1960 FIND v(dout0_22) AT=985.025n

.meas tran vdout0_23ck1960 FIND v(dout0_23) AT=985.025n

.meas tran vdout0_24ck1960 FIND v(dout0_24) AT=985.025n

.meas tran vdout0_25ck1960 FIND v(dout0_25) AT=985.025n

.meas tran vdout0_26ck1960 FIND v(dout0_26) AT=985.025n

.meas tran vdout0_27ck1960 FIND v(dout0_27) AT=985.025n

.meas tran vdout0_28ck1960 FIND v(dout0_28) AT=985.025n

.meas tran vdout0_29ck1960 FIND v(dout0_29) AT=985.025n

.meas tran vdout0_30ck1960 FIND v(dout0_30) AT=985.025n

.meas tran vdout0_31ck1960 FIND v(dout0_31) AT=985.025n

.meas tran vdout0_32ck1960 FIND v(dout0_32) AT=985.025n

.meas tran vdout0_33ck1960 FIND v(dout0_33) AT=985.025n

.meas tran vdout0_34ck1960 FIND v(dout0_34) AT=985.025n

.meas tran vdout0_35ck1960 FIND v(dout0_35) AT=985.025n

.meas tran vdout0_36ck1960 FIND v(dout0_36) AT=985.025n

.meas tran vdout0_37ck1960 FIND v(dout0_37) AT=985.025n

.meas tran vdout0_38ck1960 FIND v(dout0_38) AT=985.025n

.meas tran vdout0_39ck1960 FIND v(dout0_39) AT=985.025n

.meas tran vdout0_40ck1960 FIND v(dout0_40) AT=985.025n

.meas tran vdout0_41ck1960 FIND v(dout0_41) AT=985.025n

.meas tran vdout0_42ck1960 FIND v(dout0_42) AT=985.025n

.meas tran vdout0_43ck1960 FIND v(dout0_43) AT=985.025n

.meas tran vdout0_44ck1960 FIND v(dout0_44) AT=985.025n

.meas tran vdout0_45ck1960 FIND v(dout0_45) AT=985.025n

.meas tran vdout0_46ck1960 FIND v(dout0_46) AT=985.025n

.meas tran vdout0_47ck1960 FIND v(dout0_47) AT=985.025n

.meas tran vdout0_48ck1960 FIND v(dout0_48) AT=985.025n

.meas tran vdout0_49ck1960 FIND v(dout0_49) AT=985.025n

.meas tran vdout0_50ck1960 FIND v(dout0_50) AT=985.025n

.meas tran vdout0_51ck1960 FIND v(dout0_51) AT=985.025n

.meas tran vdout0_52ck1960 FIND v(dout0_52) AT=985.025n

.meas tran vdout0_53ck1960 FIND v(dout0_53) AT=985.025n

.meas tran vdout0_54ck1960 FIND v(dout0_54) AT=985.025n

.meas tran vdout0_55ck1960 FIND v(dout0_55) AT=985.025n

.meas tran vdout0_56ck1960 FIND v(dout0_56) AT=985.025n

.meas tran vdout0_57ck1960 FIND v(dout0_57) AT=985.025n

.meas tran vdout0_58ck1960 FIND v(dout0_58) AT=985.025n

.meas tran vdout0_59ck1960 FIND v(dout0_59) AT=985.025n

.meas tran vdout0_60ck1960 FIND v(dout0_60) AT=985.025n

.meas tran vdout0_61ck1960 FIND v(dout0_61) AT=985.025n

.meas tran vdout0_62ck1960 FIND v(dout0_62) AT=985.025n

.meas tran vdout0_63ck1960 FIND v(dout0_63) AT=985.025n

.meas tran vdout0_64ck1960 FIND v(dout0_64) AT=985.025n

.meas tran vdout0_65ck1960 FIND v(dout0_65) AT=985.025n

.meas tran vdout0_66ck1960 FIND v(dout0_66) AT=985.025n

.meas tran vdout0_67ck1960 FIND v(dout0_67) AT=985.025n

.meas tran vdout0_68ck1960 FIND v(dout0_68) AT=985.025n

.meas tran vdout0_69ck1960 FIND v(dout0_69) AT=985.025n

.meas tran vdout0_70ck1960 FIND v(dout0_70) AT=985.025n

.meas tran vdout0_71ck1960 FIND v(dout0_71) AT=985.025n

.meas tran vdout0_72ck1960 FIND v(dout0_72) AT=985.025n

.meas tran vdout0_73ck1960 FIND v(dout0_73) AT=985.025n

.meas tran vdout0_74ck1960 FIND v(dout0_74) AT=985.025n

.meas tran vdout0_75ck1960 FIND v(dout0_75) AT=985.025n

.meas tran vdout0_76ck1960 FIND v(dout0_76) AT=985.025n

.meas tran vdout0_77ck1960 FIND v(dout0_77) AT=985.025n

.meas tran vdout0_78ck1960 FIND v(dout0_78) AT=985.025n

.meas tran vdout0_79ck1960 FIND v(dout0_79) AT=985.025n

.meas tran vdout0_80ck1960 FIND v(dout0_80) AT=985.025n

.meas tran vdout0_81ck1960 FIND v(dout0_81) AT=985.025n

.meas tran vdout0_82ck1960 FIND v(dout0_82) AT=985.025n

.meas tran vdout0_83ck1960 FIND v(dout0_83) AT=985.025n

.meas tran vdout0_84ck1960 FIND v(dout0_84) AT=985.025n

.meas tran vdout0_85ck1960 FIND v(dout0_85) AT=985.025n

.meas tran vdout0_86ck1960 FIND v(dout0_86) AT=985.025n

.meas tran vdout0_87ck1960 FIND v(dout0_87) AT=985.025n

.meas tran vdout0_88ck1960 FIND v(dout0_88) AT=985.025n

.meas tran vdout0_89ck1960 FIND v(dout0_89) AT=985.025n

.meas tran vdout0_90ck1960 FIND v(dout0_90) AT=985.025n

.meas tran vdout0_91ck1960 FIND v(dout0_91) AT=985.025n

.meas tran vdout0_92ck1960 FIND v(dout0_92) AT=985.025n

.meas tran vdout0_93ck1960 FIND v(dout0_93) AT=985.025n

.meas tran vdout0_94ck1960 FIND v(dout0_94) AT=985.025n

.meas tran vdout0_95ck1960 FIND v(dout0_95) AT=985.025n

.meas tran vdout0_96ck1960 FIND v(dout0_96) AT=985.025n

.meas tran vdout0_97ck1960 FIND v(dout0_97) AT=985.025n

.meas tran vdout0_98ck1960 FIND v(dout0_98) AT=985.025n

.meas tran vdout0_99ck1960 FIND v(dout0_99) AT=985.025n

.meas tran vdout0_100ck1960 FIND v(dout0_100) AT=985.025n

.meas tran vdout0_101ck1960 FIND v(dout0_101) AT=985.025n

.meas tran vdout0_102ck1960 FIND v(dout0_102) AT=985.025n

.meas tran vdout0_103ck1960 FIND v(dout0_103) AT=985.025n

.meas tran vdout0_104ck1960 FIND v(dout0_104) AT=985.025n

.meas tran vdout0_105ck1960 FIND v(dout0_105) AT=985.025n

.meas tran vdout0_106ck1960 FIND v(dout0_106) AT=985.025n

.meas tran vdout0_107ck1960 FIND v(dout0_107) AT=985.025n

.meas tran vdout0_108ck1960 FIND v(dout0_108) AT=985.025n

.meas tran vdout0_109ck1960 FIND v(dout0_109) AT=985.025n

.meas tran vdout0_110ck1960 FIND v(dout0_110) AT=985.025n

.meas tran vdout0_111ck1960 FIND v(dout0_111) AT=985.025n

.meas tran vdout0_112ck1960 FIND v(dout0_112) AT=985.025n

.meas tran vdout0_113ck1960 FIND v(dout0_113) AT=985.025n

.meas tran vdout0_114ck1960 FIND v(dout0_114) AT=985.025n

.meas tran vdout0_115ck1960 FIND v(dout0_115) AT=985.025n

.meas tran vdout0_116ck1960 FIND v(dout0_116) AT=985.025n

.meas tran vdout0_117ck1960 FIND v(dout0_117) AT=985.025n

.meas tran vdout0_118ck1960 FIND v(dout0_118) AT=985.025n

.meas tran vdout0_119ck1960 FIND v(dout0_119) AT=985.025n

.meas tran vdout0_120ck1960 FIND v(dout0_120) AT=985.025n

.meas tran vdout0_121ck1960 FIND v(dout0_121) AT=985.025n

.meas tran vdout0_122ck1960 FIND v(dout0_122) AT=985.025n

.meas tran vdout0_123ck1960 FIND v(dout0_123) AT=985.025n

.meas tran vdout0_124ck1960 FIND v(dout0_124) AT=985.025n

.meas tran vdout0_125ck1960 FIND v(dout0_125) AT=985.025n

.meas tran vdout0_126ck1960 FIND v(dout0_126) AT=985.025n

.meas tran vdout0_127ck1960 FIND v(dout0_127) AT=985.025n

.meas tran vdout0_128ck1960 FIND v(dout0_128) AT=985.025n

.meas tran vdout0_129ck1960 FIND v(dout0_129) AT=985.025n

.meas tran vdout0_130ck1960 FIND v(dout0_130) AT=985.025n

.meas tran vdout0_131ck1960 FIND v(dout0_131) AT=985.025n

.meas tran vdout0_132ck1960 FIND v(dout0_132) AT=985.025n

.meas tran vdout0_133ck1960 FIND v(dout0_133) AT=985.025n

.meas tran vdout0_134ck1960 FIND v(dout0_134) AT=985.025n

.meas tran vdout0_135ck1960 FIND v(dout0_135) AT=985.025n

.meas tran vdout0_136ck1960 FIND v(dout0_136) AT=985.025n

.meas tran vdout0_137ck1960 FIND v(dout0_137) AT=985.025n

.meas tran vdout0_138ck1960 FIND v(dout0_138) AT=985.025n

.meas tran vdout0_139ck1960 FIND v(dout0_139) AT=985.025n

.meas tran vdout0_140ck1960 FIND v(dout0_140) AT=985.025n

.meas tran vdout0_141ck1960 FIND v(dout0_141) AT=985.025n

.meas tran vdout0_142ck1960 FIND v(dout0_142) AT=985.025n

.meas tran vdout0_143ck1960 FIND v(dout0_143) AT=985.025n

.meas tran vdout0_144ck1960 FIND v(dout0_144) AT=985.025n

.meas tran vdout0_145ck1960 FIND v(dout0_145) AT=985.025n

.meas tran vdout0_146ck1960 FIND v(dout0_146) AT=985.025n

.meas tran vdout0_147ck1960 FIND v(dout0_147) AT=985.025n

.meas tran vdout0_148ck1960 FIND v(dout0_148) AT=985.025n

.meas tran vdout0_149ck1960 FIND v(dout0_149) AT=985.025n

.meas tran vdout0_150ck1960 FIND v(dout0_150) AT=985.025n

.meas tran vdout0_151ck1960 FIND v(dout0_151) AT=985.025n

.meas tran vdout0_152ck1960 FIND v(dout0_152) AT=985.025n

.meas tran vdout0_153ck1960 FIND v(dout0_153) AT=985.025n

.meas tran vdout0_154ck1960 FIND v(dout0_154) AT=985.025n

.meas tran vdout0_155ck1960 FIND v(dout0_155) AT=985.025n

.meas tran vdout0_156ck1960 FIND v(dout0_156) AT=985.025n

.meas tran vdout0_157ck1960 FIND v(dout0_157) AT=985.025n

.meas tran vdout0_158ck1960 FIND v(dout0_158) AT=985.025n

.meas tran vdout0_159ck1960 FIND v(dout0_159) AT=985.025n

.meas tran vdout0_160ck1960 FIND v(dout0_160) AT=985.025n

.meas tran vdout0_161ck1960 FIND v(dout0_161) AT=985.025n

.meas tran vdout0_162ck1960 FIND v(dout0_162) AT=985.025n

.meas tran vdout0_163ck1960 FIND v(dout0_163) AT=985.025n

.meas tran vdout0_164ck1960 FIND v(dout0_164) AT=985.025n

.meas tran vdout0_165ck1960 FIND v(dout0_165) AT=985.025n

.meas tran vdout0_166ck1960 FIND v(dout0_166) AT=985.025n

.meas tran vdout0_167ck1960 FIND v(dout0_167) AT=985.025n

.meas tran vdout0_168ck1960 FIND v(dout0_168) AT=985.025n

.meas tran vdout0_169ck1960 FIND v(dout0_169) AT=985.025n

.meas tran vdout0_170ck1960 FIND v(dout0_170) AT=985.025n

.meas tran vdout0_171ck1960 FIND v(dout0_171) AT=985.025n

.meas tran vdout0_172ck1960 FIND v(dout0_172) AT=985.025n

.meas tran vdout0_173ck1960 FIND v(dout0_173) AT=985.025n

.meas tran vdout0_174ck1960 FIND v(dout0_174) AT=985.025n

.meas tran vdout0_175ck1960 FIND v(dout0_175) AT=985.025n

.meas tran vdout0_176ck1960 FIND v(dout0_176) AT=985.025n

.meas tran vdout0_177ck1960 FIND v(dout0_177) AT=985.025n

.meas tran vdout0_178ck1960 FIND v(dout0_178) AT=985.025n

.meas tran vdout0_179ck1960 FIND v(dout0_179) AT=985.025n

.meas tran vdout0_180ck1960 FIND v(dout0_180) AT=985.025n

.meas tran vdout0_181ck1960 FIND v(dout0_181) AT=985.025n

.meas tran vdout0_182ck1960 FIND v(dout0_182) AT=985.025n

.meas tran vdout0_183ck1960 FIND v(dout0_183) AT=985.025n

.meas tran vdout0_184ck1960 FIND v(dout0_184) AT=985.025n

.meas tran vdout0_185ck1960 FIND v(dout0_185) AT=985.025n

.meas tran vdout0_186ck1960 FIND v(dout0_186) AT=985.025n

.meas tran vdout0_187ck1960 FIND v(dout0_187) AT=985.025n

.meas tran vdout0_188ck1960 FIND v(dout0_188) AT=985.025n

.meas tran vdout0_189ck1960 FIND v(dout0_189) AT=985.025n

.meas tran vdout0_190ck1960 FIND v(dout0_190) AT=985.025n

.meas tran vdout0_191ck1960 FIND v(dout0_191) AT=985.025n

.meas tran vdout0_192ck1960 FIND v(dout0_192) AT=985.025n

.meas tran vdout0_193ck1960 FIND v(dout0_193) AT=985.025n

.meas tran vdout0_194ck1960 FIND v(dout0_194) AT=985.025n

.meas tran vdout0_195ck1960 FIND v(dout0_195) AT=985.025n

.meas tran vdout0_196ck1960 FIND v(dout0_196) AT=985.025n

.meas tran vdout0_197ck1960 FIND v(dout0_197) AT=985.025n

.meas tran vdout0_198ck1960 FIND v(dout0_198) AT=985.025n

.meas tran vdout0_199ck1960 FIND v(dout0_199) AT=985.025n

.meas tran vdout0_200ck1960 FIND v(dout0_200) AT=985.025n

.meas tran vdout0_201ck1960 FIND v(dout0_201) AT=985.025n

.meas tran vdout0_202ck1960 FIND v(dout0_202) AT=985.025n

.meas tran vdout0_203ck1960 FIND v(dout0_203) AT=985.025n

.meas tran vdout0_204ck1960 FIND v(dout0_204) AT=985.025n

.meas tran vdout0_205ck1960 FIND v(dout0_205) AT=985.025n

.meas tran vdout0_206ck1960 FIND v(dout0_206) AT=985.025n

.meas tran vdout0_207ck1960 FIND v(dout0_207) AT=985.025n

.meas tran vdout0_208ck1960 FIND v(dout0_208) AT=985.025n

.meas tran vdout0_209ck1960 FIND v(dout0_209) AT=985.025n

.meas tran vdout0_210ck1960 FIND v(dout0_210) AT=985.025n

.meas tran vdout0_211ck1960 FIND v(dout0_211) AT=985.025n

.meas tran vdout0_212ck1960 FIND v(dout0_212) AT=985.025n

.meas tran vdout0_213ck1960 FIND v(dout0_213) AT=985.025n

.meas tran vdout0_214ck1960 FIND v(dout0_214) AT=985.025n

.meas tran vdout0_215ck1960 FIND v(dout0_215) AT=985.025n

.meas tran vdout0_216ck1960 FIND v(dout0_216) AT=985.025n

.meas tran vdout0_217ck1960 FIND v(dout0_217) AT=985.025n

.meas tran vdout0_218ck1960 FIND v(dout0_218) AT=985.025n

.meas tran vdout0_219ck1960 FIND v(dout0_219) AT=985.025n

.meas tran vdout0_220ck1960 FIND v(dout0_220) AT=985.025n

.meas tran vdout0_221ck1960 FIND v(dout0_221) AT=985.025n

.meas tran vdout0_222ck1960 FIND v(dout0_222) AT=985.025n

.meas tran vdout0_223ck1960 FIND v(dout0_223) AT=985.025n

.meas tran vdout0_224ck1960 FIND v(dout0_224) AT=985.025n

.meas tran vdout0_225ck1960 FIND v(dout0_225) AT=985.025n

.meas tran vdout0_226ck1960 FIND v(dout0_226) AT=985.025n

.meas tran vdout0_227ck1960 FIND v(dout0_227) AT=985.025n

.meas tran vdout0_228ck1960 FIND v(dout0_228) AT=985.025n

.meas tran vdout0_229ck1960 FIND v(dout0_229) AT=985.025n

.meas tran vdout0_230ck1960 FIND v(dout0_230) AT=985.025n

.meas tran vdout0_231ck1960 FIND v(dout0_231) AT=985.025n

.meas tran vdout0_232ck1960 FIND v(dout0_232) AT=985.025n

.meas tran vdout0_233ck1960 FIND v(dout0_233) AT=985.025n

.meas tran vdout0_234ck1960 FIND v(dout0_234) AT=985.025n

.meas tran vdout0_235ck1960 FIND v(dout0_235) AT=985.025n

.meas tran vdout0_236ck1960 FIND v(dout0_236) AT=985.025n

.meas tran vdout0_237ck1960 FIND v(dout0_237) AT=985.025n

.meas tran vdout0_238ck1960 FIND v(dout0_238) AT=985.025n

.meas tran vdout0_239ck1960 FIND v(dout0_239) AT=985.025n

.meas tran vdout0_240ck1960 FIND v(dout0_240) AT=985.025n

.meas tran vdout0_241ck1960 FIND v(dout0_241) AT=985.025n

.meas tran vdout0_242ck1960 FIND v(dout0_242) AT=985.025n

.meas tran vdout0_243ck1960 FIND v(dout0_243) AT=985.025n

.meas tran vdout0_244ck1960 FIND v(dout0_244) AT=985.025n

.meas tran vdout0_245ck1960 FIND v(dout0_245) AT=985.025n

.meas tran vdout0_246ck1960 FIND v(dout0_246) AT=985.025n

.meas tran vdout0_247ck1960 FIND v(dout0_247) AT=985.025n

.meas tran vdout0_248ck1960 FIND v(dout0_248) AT=985.025n

.meas tran vdout0_249ck1960 FIND v(dout0_249) AT=985.025n

.meas tran vdout0_250ck1960 FIND v(dout0_250) AT=985.025n

.meas tran vdout0_251ck1960 FIND v(dout0_251) AT=985.025n

.meas tran vdout0_252ck1960 FIND v(dout0_252) AT=985.025n

.meas tran vdout0_253ck1960 FIND v(dout0_253) AT=985.025n

.meas tran vdout0_254ck1960 FIND v(dout0_254) AT=985.025n

.meas tran vdout0_255ck1960 FIND v(dout0_255) AT=985.025n

.meas tran vdout0_0ck1970 FIND v(dout0_0) AT=990.025n

.meas tran vdout0_1ck1970 FIND v(dout0_1) AT=990.025n

.meas tran vdout0_2ck1970 FIND v(dout0_2) AT=990.025n

.meas tran vdout0_3ck1970 FIND v(dout0_3) AT=990.025n

.meas tran vdout0_4ck1970 FIND v(dout0_4) AT=990.025n

.meas tran vdout0_5ck1970 FIND v(dout0_5) AT=990.025n

.meas tran vdout0_6ck1970 FIND v(dout0_6) AT=990.025n

.meas tran vdout0_7ck1970 FIND v(dout0_7) AT=990.025n

.meas tran vdout0_8ck1970 FIND v(dout0_8) AT=990.025n

.meas tran vdout0_9ck1970 FIND v(dout0_9) AT=990.025n

.meas tran vdout0_10ck1970 FIND v(dout0_10) AT=990.025n

.meas tran vdout0_11ck1970 FIND v(dout0_11) AT=990.025n

.meas tran vdout0_12ck1970 FIND v(dout0_12) AT=990.025n

.meas tran vdout0_13ck1970 FIND v(dout0_13) AT=990.025n

.meas tran vdout0_14ck1970 FIND v(dout0_14) AT=990.025n

.meas tran vdout0_15ck1970 FIND v(dout0_15) AT=990.025n

.meas tran vdout0_16ck1970 FIND v(dout0_16) AT=990.025n

.meas tran vdout0_17ck1970 FIND v(dout0_17) AT=990.025n

.meas tran vdout0_18ck1970 FIND v(dout0_18) AT=990.025n

.meas tran vdout0_19ck1970 FIND v(dout0_19) AT=990.025n

.meas tran vdout0_20ck1970 FIND v(dout0_20) AT=990.025n

.meas tran vdout0_21ck1970 FIND v(dout0_21) AT=990.025n

.meas tran vdout0_22ck1970 FIND v(dout0_22) AT=990.025n

.meas tran vdout0_23ck1970 FIND v(dout0_23) AT=990.025n

.meas tran vdout0_24ck1970 FIND v(dout0_24) AT=990.025n

.meas tran vdout0_25ck1970 FIND v(dout0_25) AT=990.025n

.meas tran vdout0_26ck1970 FIND v(dout0_26) AT=990.025n

.meas tran vdout0_27ck1970 FIND v(dout0_27) AT=990.025n

.meas tran vdout0_28ck1970 FIND v(dout0_28) AT=990.025n

.meas tran vdout0_29ck1970 FIND v(dout0_29) AT=990.025n

.meas tran vdout0_30ck1970 FIND v(dout0_30) AT=990.025n

.meas tran vdout0_31ck1970 FIND v(dout0_31) AT=990.025n

.meas tran vdout0_32ck1970 FIND v(dout0_32) AT=990.025n

.meas tran vdout0_33ck1970 FIND v(dout0_33) AT=990.025n

.meas tran vdout0_34ck1970 FIND v(dout0_34) AT=990.025n

.meas tran vdout0_35ck1970 FIND v(dout0_35) AT=990.025n

.meas tran vdout0_36ck1970 FIND v(dout0_36) AT=990.025n

.meas tran vdout0_37ck1970 FIND v(dout0_37) AT=990.025n

.meas tran vdout0_38ck1970 FIND v(dout0_38) AT=990.025n

.meas tran vdout0_39ck1970 FIND v(dout0_39) AT=990.025n

.meas tran vdout0_40ck1970 FIND v(dout0_40) AT=990.025n

.meas tran vdout0_41ck1970 FIND v(dout0_41) AT=990.025n

.meas tran vdout0_42ck1970 FIND v(dout0_42) AT=990.025n

.meas tran vdout0_43ck1970 FIND v(dout0_43) AT=990.025n

.meas tran vdout0_44ck1970 FIND v(dout0_44) AT=990.025n

.meas tran vdout0_45ck1970 FIND v(dout0_45) AT=990.025n

.meas tran vdout0_46ck1970 FIND v(dout0_46) AT=990.025n

.meas tran vdout0_47ck1970 FIND v(dout0_47) AT=990.025n

.meas tran vdout0_48ck1970 FIND v(dout0_48) AT=990.025n

.meas tran vdout0_49ck1970 FIND v(dout0_49) AT=990.025n

.meas tran vdout0_50ck1970 FIND v(dout0_50) AT=990.025n

.meas tran vdout0_51ck1970 FIND v(dout0_51) AT=990.025n

.meas tran vdout0_52ck1970 FIND v(dout0_52) AT=990.025n

.meas tran vdout0_53ck1970 FIND v(dout0_53) AT=990.025n

.meas tran vdout0_54ck1970 FIND v(dout0_54) AT=990.025n

.meas tran vdout0_55ck1970 FIND v(dout0_55) AT=990.025n

.meas tran vdout0_56ck1970 FIND v(dout0_56) AT=990.025n

.meas tran vdout0_57ck1970 FIND v(dout0_57) AT=990.025n

.meas tran vdout0_58ck1970 FIND v(dout0_58) AT=990.025n

.meas tran vdout0_59ck1970 FIND v(dout0_59) AT=990.025n

.meas tran vdout0_60ck1970 FIND v(dout0_60) AT=990.025n

.meas tran vdout0_61ck1970 FIND v(dout0_61) AT=990.025n

.meas tran vdout0_62ck1970 FIND v(dout0_62) AT=990.025n

.meas tran vdout0_63ck1970 FIND v(dout0_63) AT=990.025n

.meas tran vdout0_64ck1970 FIND v(dout0_64) AT=990.025n

.meas tran vdout0_65ck1970 FIND v(dout0_65) AT=990.025n

.meas tran vdout0_66ck1970 FIND v(dout0_66) AT=990.025n

.meas tran vdout0_67ck1970 FIND v(dout0_67) AT=990.025n

.meas tran vdout0_68ck1970 FIND v(dout0_68) AT=990.025n

.meas tran vdout0_69ck1970 FIND v(dout0_69) AT=990.025n

.meas tran vdout0_70ck1970 FIND v(dout0_70) AT=990.025n

.meas tran vdout0_71ck1970 FIND v(dout0_71) AT=990.025n

.meas tran vdout0_72ck1970 FIND v(dout0_72) AT=990.025n

.meas tran vdout0_73ck1970 FIND v(dout0_73) AT=990.025n

.meas tran vdout0_74ck1970 FIND v(dout0_74) AT=990.025n

.meas tran vdout0_75ck1970 FIND v(dout0_75) AT=990.025n

.meas tran vdout0_76ck1970 FIND v(dout0_76) AT=990.025n

.meas tran vdout0_77ck1970 FIND v(dout0_77) AT=990.025n

.meas tran vdout0_78ck1970 FIND v(dout0_78) AT=990.025n

.meas tran vdout0_79ck1970 FIND v(dout0_79) AT=990.025n

.meas tran vdout0_80ck1970 FIND v(dout0_80) AT=990.025n

.meas tran vdout0_81ck1970 FIND v(dout0_81) AT=990.025n

.meas tran vdout0_82ck1970 FIND v(dout0_82) AT=990.025n

.meas tran vdout0_83ck1970 FIND v(dout0_83) AT=990.025n

.meas tran vdout0_84ck1970 FIND v(dout0_84) AT=990.025n

.meas tran vdout0_85ck1970 FIND v(dout0_85) AT=990.025n

.meas tran vdout0_86ck1970 FIND v(dout0_86) AT=990.025n

.meas tran vdout0_87ck1970 FIND v(dout0_87) AT=990.025n

.meas tran vdout0_88ck1970 FIND v(dout0_88) AT=990.025n

.meas tran vdout0_89ck1970 FIND v(dout0_89) AT=990.025n

.meas tran vdout0_90ck1970 FIND v(dout0_90) AT=990.025n

.meas tran vdout0_91ck1970 FIND v(dout0_91) AT=990.025n

.meas tran vdout0_92ck1970 FIND v(dout0_92) AT=990.025n

.meas tran vdout0_93ck1970 FIND v(dout0_93) AT=990.025n

.meas tran vdout0_94ck1970 FIND v(dout0_94) AT=990.025n

.meas tran vdout0_95ck1970 FIND v(dout0_95) AT=990.025n

.meas tran vdout0_96ck1970 FIND v(dout0_96) AT=990.025n

.meas tran vdout0_97ck1970 FIND v(dout0_97) AT=990.025n

.meas tran vdout0_98ck1970 FIND v(dout0_98) AT=990.025n

.meas tran vdout0_99ck1970 FIND v(dout0_99) AT=990.025n

.meas tran vdout0_100ck1970 FIND v(dout0_100) AT=990.025n

.meas tran vdout0_101ck1970 FIND v(dout0_101) AT=990.025n

.meas tran vdout0_102ck1970 FIND v(dout0_102) AT=990.025n

.meas tran vdout0_103ck1970 FIND v(dout0_103) AT=990.025n

.meas tran vdout0_104ck1970 FIND v(dout0_104) AT=990.025n

.meas tran vdout0_105ck1970 FIND v(dout0_105) AT=990.025n

.meas tran vdout0_106ck1970 FIND v(dout0_106) AT=990.025n

.meas tran vdout0_107ck1970 FIND v(dout0_107) AT=990.025n

.meas tran vdout0_108ck1970 FIND v(dout0_108) AT=990.025n

.meas tran vdout0_109ck1970 FIND v(dout0_109) AT=990.025n

.meas tran vdout0_110ck1970 FIND v(dout0_110) AT=990.025n

.meas tran vdout0_111ck1970 FIND v(dout0_111) AT=990.025n

.meas tran vdout0_112ck1970 FIND v(dout0_112) AT=990.025n

.meas tran vdout0_113ck1970 FIND v(dout0_113) AT=990.025n

.meas tran vdout0_114ck1970 FIND v(dout0_114) AT=990.025n

.meas tran vdout0_115ck1970 FIND v(dout0_115) AT=990.025n

.meas tran vdout0_116ck1970 FIND v(dout0_116) AT=990.025n

.meas tran vdout0_117ck1970 FIND v(dout0_117) AT=990.025n

.meas tran vdout0_118ck1970 FIND v(dout0_118) AT=990.025n

.meas tran vdout0_119ck1970 FIND v(dout0_119) AT=990.025n

.meas tran vdout0_120ck1970 FIND v(dout0_120) AT=990.025n

.meas tran vdout0_121ck1970 FIND v(dout0_121) AT=990.025n

.meas tran vdout0_122ck1970 FIND v(dout0_122) AT=990.025n

.meas tran vdout0_123ck1970 FIND v(dout0_123) AT=990.025n

.meas tran vdout0_124ck1970 FIND v(dout0_124) AT=990.025n

.meas tran vdout0_125ck1970 FIND v(dout0_125) AT=990.025n

.meas tran vdout0_126ck1970 FIND v(dout0_126) AT=990.025n

.meas tran vdout0_127ck1970 FIND v(dout0_127) AT=990.025n

.meas tran vdout0_128ck1970 FIND v(dout0_128) AT=990.025n

.meas tran vdout0_129ck1970 FIND v(dout0_129) AT=990.025n

.meas tran vdout0_130ck1970 FIND v(dout0_130) AT=990.025n

.meas tran vdout0_131ck1970 FIND v(dout0_131) AT=990.025n

.meas tran vdout0_132ck1970 FIND v(dout0_132) AT=990.025n

.meas tran vdout0_133ck1970 FIND v(dout0_133) AT=990.025n

.meas tran vdout0_134ck1970 FIND v(dout0_134) AT=990.025n

.meas tran vdout0_135ck1970 FIND v(dout0_135) AT=990.025n

.meas tran vdout0_136ck1970 FIND v(dout0_136) AT=990.025n

.meas tran vdout0_137ck1970 FIND v(dout0_137) AT=990.025n

.meas tran vdout0_138ck1970 FIND v(dout0_138) AT=990.025n

.meas tran vdout0_139ck1970 FIND v(dout0_139) AT=990.025n

.meas tran vdout0_140ck1970 FIND v(dout0_140) AT=990.025n

.meas tran vdout0_141ck1970 FIND v(dout0_141) AT=990.025n

.meas tran vdout0_142ck1970 FIND v(dout0_142) AT=990.025n

.meas tran vdout0_143ck1970 FIND v(dout0_143) AT=990.025n

.meas tran vdout0_144ck1970 FIND v(dout0_144) AT=990.025n

.meas tran vdout0_145ck1970 FIND v(dout0_145) AT=990.025n

.meas tran vdout0_146ck1970 FIND v(dout0_146) AT=990.025n

.meas tran vdout0_147ck1970 FIND v(dout0_147) AT=990.025n

.meas tran vdout0_148ck1970 FIND v(dout0_148) AT=990.025n

.meas tran vdout0_149ck1970 FIND v(dout0_149) AT=990.025n

.meas tran vdout0_150ck1970 FIND v(dout0_150) AT=990.025n

.meas tran vdout0_151ck1970 FIND v(dout0_151) AT=990.025n

.meas tran vdout0_152ck1970 FIND v(dout0_152) AT=990.025n

.meas tran vdout0_153ck1970 FIND v(dout0_153) AT=990.025n

.meas tran vdout0_154ck1970 FIND v(dout0_154) AT=990.025n

.meas tran vdout0_155ck1970 FIND v(dout0_155) AT=990.025n

.meas tran vdout0_156ck1970 FIND v(dout0_156) AT=990.025n

.meas tran vdout0_157ck1970 FIND v(dout0_157) AT=990.025n

.meas tran vdout0_158ck1970 FIND v(dout0_158) AT=990.025n

.meas tran vdout0_159ck1970 FIND v(dout0_159) AT=990.025n

.meas tran vdout0_160ck1970 FIND v(dout0_160) AT=990.025n

.meas tran vdout0_161ck1970 FIND v(dout0_161) AT=990.025n

.meas tran vdout0_162ck1970 FIND v(dout0_162) AT=990.025n

.meas tran vdout0_163ck1970 FIND v(dout0_163) AT=990.025n

.meas tran vdout0_164ck1970 FIND v(dout0_164) AT=990.025n

.meas tran vdout0_165ck1970 FIND v(dout0_165) AT=990.025n

.meas tran vdout0_166ck1970 FIND v(dout0_166) AT=990.025n

.meas tran vdout0_167ck1970 FIND v(dout0_167) AT=990.025n

.meas tran vdout0_168ck1970 FIND v(dout0_168) AT=990.025n

.meas tran vdout0_169ck1970 FIND v(dout0_169) AT=990.025n

.meas tran vdout0_170ck1970 FIND v(dout0_170) AT=990.025n

.meas tran vdout0_171ck1970 FIND v(dout0_171) AT=990.025n

.meas tran vdout0_172ck1970 FIND v(dout0_172) AT=990.025n

.meas tran vdout0_173ck1970 FIND v(dout0_173) AT=990.025n

.meas tran vdout0_174ck1970 FIND v(dout0_174) AT=990.025n

.meas tran vdout0_175ck1970 FIND v(dout0_175) AT=990.025n

.meas tran vdout0_176ck1970 FIND v(dout0_176) AT=990.025n

.meas tran vdout0_177ck1970 FIND v(dout0_177) AT=990.025n

.meas tran vdout0_178ck1970 FIND v(dout0_178) AT=990.025n

.meas tran vdout0_179ck1970 FIND v(dout0_179) AT=990.025n

.meas tran vdout0_180ck1970 FIND v(dout0_180) AT=990.025n

.meas tran vdout0_181ck1970 FIND v(dout0_181) AT=990.025n

.meas tran vdout0_182ck1970 FIND v(dout0_182) AT=990.025n

.meas tran vdout0_183ck1970 FIND v(dout0_183) AT=990.025n

.meas tran vdout0_184ck1970 FIND v(dout0_184) AT=990.025n

.meas tran vdout0_185ck1970 FIND v(dout0_185) AT=990.025n

.meas tran vdout0_186ck1970 FIND v(dout0_186) AT=990.025n

.meas tran vdout0_187ck1970 FIND v(dout0_187) AT=990.025n

.meas tran vdout0_188ck1970 FIND v(dout0_188) AT=990.025n

.meas tran vdout0_189ck1970 FIND v(dout0_189) AT=990.025n

.meas tran vdout0_190ck1970 FIND v(dout0_190) AT=990.025n

.meas tran vdout0_191ck1970 FIND v(dout0_191) AT=990.025n

.meas tran vdout0_192ck1970 FIND v(dout0_192) AT=990.025n

.meas tran vdout0_193ck1970 FIND v(dout0_193) AT=990.025n

.meas tran vdout0_194ck1970 FIND v(dout0_194) AT=990.025n

.meas tran vdout0_195ck1970 FIND v(dout0_195) AT=990.025n

.meas tran vdout0_196ck1970 FIND v(dout0_196) AT=990.025n

.meas tran vdout0_197ck1970 FIND v(dout0_197) AT=990.025n

.meas tran vdout0_198ck1970 FIND v(dout0_198) AT=990.025n

.meas tran vdout0_199ck1970 FIND v(dout0_199) AT=990.025n

.meas tran vdout0_200ck1970 FIND v(dout0_200) AT=990.025n

.meas tran vdout0_201ck1970 FIND v(dout0_201) AT=990.025n

.meas tran vdout0_202ck1970 FIND v(dout0_202) AT=990.025n

.meas tran vdout0_203ck1970 FIND v(dout0_203) AT=990.025n

.meas tran vdout0_204ck1970 FIND v(dout0_204) AT=990.025n

.meas tran vdout0_205ck1970 FIND v(dout0_205) AT=990.025n

.meas tran vdout0_206ck1970 FIND v(dout0_206) AT=990.025n

.meas tran vdout0_207ck1970 FIND v(dout0_207) AT=990.025n

.meas tran vdout0_208ck1970 FIND v(dout0_208) AT=990.025n

.meas tran vdout0_209ck1970 FIND v(dout0_209) AT=990.025n

.meas tran vdout0_210ck1970 FIND v(dout0_210) AT=990.025n

.meas tran vdout0_211ck1970 FIND v(dout0_211) AT=990.025n

.meas tran vdout0_212ck1970 FIND v(dout0_212) AT=990.025n

.meas tran vdout0_213ck1970 FIND v(dout0_213) AT=990.025n

.meas tran vdout0_214ck1970 FIND v(dout0_214) AT=990.025n

.meas tran vdout0_215ck1970 FIND v(dout0_215) AT=990.025n

.meas tran vdout0_216ck1970 FIND v(dout0_216) AT=990.025n

.meas tran vdout0_217ck1970 FIND v(dout0_217) AT=990.025n

.meas tran vdout0_218ck1970 FIND v(dout0_218) AT=990.025n

.meas tran vdout0_219ck1970 FIND v(dout0_219) AT=990.025n

.meas tran vdout0_220ck1970 FIND v(dout0_220) AT=990.025n

.meas tran vdout0_221ck1970 FIND v(dout0_221) AT=990.025n

.meas tran vdout0_222ck1970 FIND v(dout0_222) AT=990.025n

.meas tran vdout0_223ck1970 FIND v(dout0_223) AT=990.025n

.meas tran vdout0_224ck1970 FIND v(dout0_224) AT=990.025n

.meas tran vdout0_225ck1970 FIND v(dout0_225) AT=990.025n

.meas tran vdout0_226ck1970 FIND v(dout0_226) AT=990.025n

.meas tran vdout0_227ck1970 FIND v(dout0_227) AT=990.025n

.meas tran vdout0_228ck1970 FIND v(dout0_228) AT=990.025n

.meas tran vdout0_229ck1970 FIND v(dout0_229) AT=990.025n

.meas tran vdout0_230ck1970 FIND v(dout0_230) AT=990.025n

.meas tran vdout0_231ck1970 FIND v(dout0_231) AT=990.025n

.meas tran vdout0_232ck1970 FIND v(dout0_232) AT=990.025n

.meas tran vdout0_233ck1970 FIND v(dout0_233) AT=990.025n

.meas tran vdout0_234ck1970 FIND v(dout0_234) AT=990.025n

.meas tran vdout0_235ck1970 FIND v(dout0_235) AT=990.025n

.meas tran vdout0_236ck1970 FIND v(dout0_236) AT=990.025n

.meas tran vdout0_237ck1970 FIND v(dout0_237) AT=990.025n

.meas tran vdout0_238ck1970 FIND v(dout0_238) AT=990.025n

.meas tran vdout0_239ck1970 FIND v(dout0_239) AT=990.025n

.meas tran vdout0_240ck1970 FIND v(dout0_240) AT=990.025n

.meas tran vdout0_241ck1970 FIND v(dout0_241) AT=990.025n

.meas tran vdout0_242ck1970 FIND v(dout0_242) AT=990.025n

.meas tran vdout0_243ck1970 FIND v(dout0_243) AT=990.025n

.meas tran vdout0_244ck1970 FIND v(dout0_244) AT=990.025n

.meas tran vdout0_245ck1970 FIND v(dout0_245) AT=990.025n

.meas tran vdout0_246ck1970 FIND v(dout0_246) AT=990.025n

.meas tran vdout0_247ck1970 FIND v(dout0_247) AT=990.025n

.meas tran vdout0_248ck1970 FIND v(dout0_248) AT=990.025n

.meas tran vdout0_249ck1970 FIND v(dout0_249) AT=990.025n

.meas tran vdout0_250ck1970 FIND v(dout0_250) AT=990.025n

.meas tran vdout0_251ck1970 FIND v(dout0_251) AT=990.025n

.meas tran vdout0_252ck1970 FIND v(dout0_252) AT=990.025n

.meas tran vdout0_253ck1970 FIND v(dout0_253) AT=990.025n

.meas tran vdout0_254ck1970 FIND v(dout0_254) AT=990.025n

.meas tran vdout0_255ck1970 FIND v(dout0_255) AT=990.025n

.meas tran vdout0_0ck1980 FIND v(dout0_0) AT=995.025n

.meas tran vdout0_1ck1980 FIND v(dout0_1) AT=995.025n

.meas tran vdout0_2ck1980 FIND v(dout0_2) AT=995.025n

.meas tran vdout0_3ck1980 FIND v(dout0_3) AT=995.025n

.meas tran vdout0_4ck1980 FIND v(dout0_4) AT=995.025n

.meas tran vdout0_5ck1980 FIND v(dout0_5) AT=995.025n

.meas tran vdout0_6ck1980 FIND v(dout0_6) AT=995.025n

.meas tran vdout0_7ck1980 FIND v(dout0_7) AT=995.025n

.meas tran vdout0_8ck1980 FIND v(dout0_8) AT=995.025n

.meas tran vdout0_9ck1980 FIND v(dout0_9) AT=995.025n

.meas tran vdout0_10ck1980 FIND v(dout0_10) AT=995.025n

.meas tran vdout0_11ck1980 FIND v(dout0_11) AT=995.025n

.meas tran vdout0_12ck1980 FIND v(dout0_12) AT=995.025n

.meas tran vdout0_13ck1980 FIND v(dout0_13) AT=995.025n

.meas tran vdout0_14ck1980 FIND v(dout0_14) AT=995.025n

.meas tran vdout0_15ck1980 FIND v(dout0_15) AT=995.025n

.meas tran vdout0_16ck1980 FIND v(dout0_16) AT=995.025n

.meas tran vdout0_17ck1980 FIND v(dout0_17) AT=995.025n

.meas tran vdout0_18ck1980 FIND v(dout0_18) AT=995.025n

.meas tran vdout0_19ck1980 FIND v(dout0_19) AT=995.025n

.meas tran vdout0_20ck1980 FIND v(dout0_20) AT=995.025n

.meas tran vdout0_21ck1980 FIND v(dout0_21) AT=995.025n

.meas tran vdout0_22ck1980 FIND v(dout0_22) AT=995.025n

.meas tran vdout0_23ck1980 FIND v(dout0_23) AT=995.025n

.meas tran vdout0_24ck1980 FIND v(dout0_24) AT=995.025n

.meas tran vdout0_25ck1980 FIND v(dout0_25) AT=995.025n

.meas tran vdout0_26ck1980 FIND v(dout0_26) AT=995.025n

.meas tran vdout0_27ck1980 FIND v(dout0_27) AT=995.025n

.meas tran vdout0_28ck1980 FIND v(dout0_28) AT=995.025n

.meas tran vdout0_29ck1980 FIND v(dout0_29) AT=995.025n

.meas tran vdout0_30ck1980 FIND v(dout0_30) AT=995.025n

.meas tran vdout0_31ck1980 FIND v(dout0_31) AT=995.025n

.meas tran vdout0_32ck1980 FIND v(dout0_32) AT=995.025n

.meas tran vdout0_33ck1980 FIND v(dout0_33) AT=995.025n

.meas tran vdout0_34ck1980 FIND v(dout0_34) AT=995.025n

.meas tran vdout0_35ck1980 FIND v(dout0_35) AT=995.025n

.meas tran vdout0_36ck1980 FIND v(dout0_36) AT=995.025n

.meas tran vdout0_37ck1980 FIND v(dout0_37) AT=995.025n

.meas tran vdout0_38ck1980 FIND v(dout0_38) AT=995.025n

.meas tran vdout0_39ck1980 FIND v(dout0_39) AT=995.025n

.meas tran vdout0_40ck1980 FIND v(dout0_40) AT=995.025n

.meas tran vdout0_41ck1980 FIND v(dout0_41) AT=995.025n

.meas tran vdout0_42ck1980 FIND v(dout0_42) AT=995.025n

.meas tran vdout0_43ck1980 FIND v(dout0_43) AT=995.025n

.meas tran vdout0_44ck1980 FIND v(dout0_44) AT=995.025n

.meas tran vdout0_45ck1980 FIND v(dout0_45) AT=995.025n

.meas tran vdout0_46ck1980 FIND v(dout0_46) AT=995.025n

.meas tran vdout0_47ck1980 FIND v(dout0_47) AT=995.025n

.meas tran vdout0_48ck1980 FIND v(dout0_48) AT=995.025n

.meas tran vdout0_49ck1980 FIND v(dout0_49) AT=995.025n

.meas tran vdout0_50ck1980 FIND v(dout0_50) AT=995.025n

.meas tran vdout0_51ck1980 FIND v(dout0_51) AT=995.025n

.meas tran vdout0_52ck1980 FIND v(dout0_52) AT=995.025n

.meas tran vdout0_53ck1980 FIND v(dout0_53) AT=995.025n

.meas tran vdout0_54ck1980 FIND v(dout0_54) AT=995.025n

.meas tran vdout0_55ck1980 FIND v(dout0_55) AT=995.025n

.meas tran vdout0_56ck1980 FIND v(dout0_56) AT=995.025n

.meas tran vdout0_57ck1980 FIND v(dout0_57) AT=995.025n

.meas tran vdout0_58ck1980 FIND v(dout0_58) AT=995.025n

.meas tran vdout0_59ck1980 FIND v(dout0_59) AT=995.025n

.meas tran vdout0_60ck1980 FIND v(dout0_60) AT=995.025n

.meas tran vdout0_61ck1980 FIND v(dout0_61) AT=995.025n

.meas tran vdout0_62ck1980 FIND v(dout0_62) AT=995.025n

.meas tran vdout0_63ck1980 FIND v(dout0_63) AT=995.025n

.meas tran vdout0_64ck1980 FIND v(dout0_64) AT=995.025n

.meas tran vdout0_65ck1980 FIND v(dout0_65) AT=995.025n

.meas tran vdout0_66ck1980 FIND v(dout0_66) AT=995.025n

.meas tran vdout0_67ck1980 FIND v(dout0_67) AT=995.025n

.meas tran vdout0_68ck1980 FIND v(dout0_68) AT=995.025n

.meas tran vdout0_69ck1980 FIND v(dout0_69) AT=995.025n

.meas tran vdout0_70ck1980 FIND v(dout0_70) AT=995.025n

.meas tran vdout0_71ck1980 FIND v(dout0_71) AT=995.025n

.meas tran vdout0_72ck1980 FIND v(dout0_72) AT=995.025n

.meas tran vdout0_73ck1980 FIND v(dout0_73) AT=995.025n

.meas tran vdout0_74ck1980 FIND v(dout0_74) AT=995.025n

.meas tran vdout0_75ck1980 FIND v(dout0_75) AT=995.025n

.meas tran vdout0_76ck1980 FIND v(dout0_76) AT=995.025n

.meas tran vdout0_77ck1980 FIND v(dout0_77) AT=995.025n

.meas tran vdout0_78ck1980 FIND v(dout0_78) AT=995.025n

.meas tran vdout0_79ck1980 FIND v(dout0_79) AT=995.025n

.meas tran vdout0_80ck1980 FIND v(dout0_80) AT=995.025n

.meas tran vdout0_81ck1980 FIND v(dout0_81) AT=995.025n

.meas tran vdout0_82ck1980 FIND v(dout0_82) AT=995.025n

.meas tran vdout0_83ck1980 FIND v(dout0_83) AT=995.025n

.meas tran vdout0_84ck1980 FIND v(dout0_84) AT=995.025n

.meas tran vdout0_85ck1980 FIND v(dout0_85) AT=995.025n

.meas tran vdout0_86ck1980 FIND v(dout0_86) AT=995.025n

.meas tran vdout0_87ck1980 FIND v(dout0_87) AT=995.025n

.meas tran vdout0_88ck1980 FIND v(dout0_88) AT=995.025n

.meas tran vdout0_89ck1980 FIND v(dout0_89) AT=995.025n

.meas tran vdout0_90ck1980 FIND v(dout0_90) AT=995.025n

.meas tran vdout0_91ck1980 FIND v(dout0_91) AT=995.025n

.meas tran vdout0_92ck1980 FIND v(dout0_92) AT=995.025n

.meas tran vdout0_93ck1980 FIND v(dout0_93) AT=995.025n

.meas tran vdout0_94ck1980 FIND v(dout0_94) AT=995.025n

.meas tran vdout0_95ck1980 FIND v(dout0_95) AT=995.025n

.meas tran vdout0_96ck1980 FIND v(dout0_96) AT=995.025n

.meas tran vdout0_97ck1980 FIND v(dout0_97) AT=995.025n

.meas tran vdout0_98ck1980 FIND v(dout0_98) AT=995.025n

.meas tran vdout0_99ck1980 FIND v(dout0_99) AT=995.025n

.meas tran vdout0_100ck1980 FIND v(dout0_100) AT=995.025n

.meas tran vdout0_101ck1980 FIND v(dout0_101) AT=995.025n

.meas tran vdout0_102ck1980 FIND v(dout0_102) AT=995.025n

.meas tran vdout0_103ck1980 FIND v(dout0_103) AT=995.025n

.meas tran vdout0_104ck1980 FIND v(dout0_104) AT=995.025n

.meas tran vdout0_105ck1980 FIND v(dout0_105) AT=995.025n

.meas tran vdout0_106ck1980 FIND v(dout0_106) AT=995.025n

.meas tran vdout0_107ck1980 FIND v(dout0_107) AT=995.025n

.meas tran vdout0_108ck1980 FIND v(dout0_108) AT=995.025n

.meas tran vdout0_109ck1980 FIND v(dout0_109) AT=995.025n

.meas tran vdout0_110ck1980 FIND v(dout0_110) AT=995.025n

.meas tran vdout0_111ck1980 FIND v(dout0_111) AT=995.025n

.meas tran vdout0_112ck1980 FIND v(dout0_112) AT=995.025n

.meas tran vdout0_113ck1980 FIND v(dout0_113) AT=995.025n

.meas tran vdout0_114ck1980 FIND v(dout0_114) AT=995.025n

.meas tran vdout0_115ck1980 FIND v(dout0_115) AT=995.025n

.meas tran vdout0_116ck1980 FIND v(dout0_116) AT=995.025n

.meas tran vdout0_117ck1980 FIND v(dout0_117) AT=995.025n

.meas tran vdout0_118ck1980 FIND v(dout0_118) AT=995.025n

.meas tran vdout0_119ck1980 FIND v(dout0_119) AT=995.025n

.meas tran vdout0_120ck1980 FIND v(dout0_120) AT=995.025n

.meas tran vdout0_121ck1980 FIND v(dout0_121) AT=995.025n

.meas tran vdout0_122ck1980 FIND v(dout0_122) AT=995.025n

.meas tran vdout0_123ck1980 FIND v(dout0_123) AT=995.025n

.meas tran vdout0_124ck1980 FIND v(dout0_124) AT=995.025n

.meas tran vdout0_125ck1980 FIND v(dout0_125) AT=995.025n

.meas tran vdout0_126ck1980 FIND v(dout0_126) AT=995.025n

.meas tran vdout0_127ck1980 FIND v(dout0_127) AT=995.025n

.meas tran vdout0_128ck1980 FIND v(dout0_128) AT=995.025n

.meas tran vdout0_129ck1980 FIND v(dout0_129) AT=995.025n

.meas tran vdout0_130ck1980 FIND v(dout0_130) AT=995.025n

.meas tran vdout0_131ck1980 FIND v(dout0_131) AT=995.025n

.meas tran vdout0_132ck1980 FIND v(dout0_132) AT=995.025n

.meas tran vdout0_133ck1980 FIND v(dout0_133) AT=995.025n

.meas tran vdout0_134ck1980 FIND v(dout0_134) AT=995.025n

.meas tran vdout0_135ck1980 FIND v(dout0_135) AT=995.025n

.meas tran vdout0_136ck1980 FIND v(dout0_136) AT=995.025n

.meas tran vdout0_137ck1980 FIND v(dout0_137) AT=995.025n

.meas tran vdout0_138ck1980 FIND v(dout0_138) AT=995.025n

.meas tran vdout0_139ck1980 FIND v(dout0_139) AT=995.025n

.meas tran vdout0_140ck1980 FIND v(dout0_140) AT=995.025n

.meas tran vdout0_141ck1980 FIND v(dout0_141) AT=995.025n

.meas tran vdout0_142ck1980 FIND v(dout0_142) AT=995.025n

.meas tran vdout0_143ck1980 FIND v(dout0_143) AT=995.025n

.meas tran vdout0_144ck1980 FIND v(dout0_144) AT=995.025n

.meas tran vdout0_145ck1980 FIND v(dout0_145) AT=995.025n

.meas tran vdout0_146ck1980 FIND v(dout0_146) AT=995.025n

.meas tran vdout0_147ck1980 FIND v(dout0_147) AT=995.025n

.meas tran vdout0_148ck1980 FIND v(dout0_148) AT=995.025n

.meas tran vdout0_149ck1980 FIND v(dout0_149) AT=995.025n

.meas tran vdout0_150ck1980 FIND v(dout0_150) AT=995.025n

.meas tran vdout0_151ck1980 FIND v(dout0_151) AT=995.025n

.meas tran vdout0_152ck1980 FIND v(dout0_152) AT=995.025n

.meas tran vdout0_153ck1980 FIND v(dout0_153) AT=995.025n

.meas tran vdout0_154ck1980 FIND v(dout0_154) AT=995.025n

.meas tran vdout0_155ck1980 FIND v(dout0_155) AT=995.025n

.meas tran vdout0_156ck1980 FIND v(dout0_156) AT=995.025n

.meas tran vdout0_157ck1980 FIND v(dout0_157) AT=995.025n

.meas tran vdout0_158ck1980 FIND v(dout0_158) AT=995.025n

.meas tran vdout0_159ck1980 FIND v(dout0_159) AT=995.025n

.meas tran vdout0_160ck1980 FIND v(dout0_160) AT=995.025n

.meas tran vdout0_161ck1980 FIND v(dout0_161) AT=995.025n

.meas tran vdout0_162ck1980 FIND v(dout0_162) AT=995.025n

.meas tran vdout0_163ck1980 FIND v(dout0_163) AT=995.025n

.meas tran vdout0_164ck1980 FIND v(dout0_164) AT=995.025n

.meas tran vdout0_165ck1980 FIND v(dout0_165) AT=995.025n

.meas tran vdout0_166ck1980 FIND v(dout0_166) AT=995.025n

.meas tran vdout0_167ck1980 FIND v(dout0_167) AT=995.025n

.meas tran vdout0_168ck1980 FIND v(dout0_168) AT=995.025n

.meas tran vdout0_169ck1980 FIND v(dout0_169) AT=995.025n

.meas tran vdout0_170ck1980 FIND v(dout0_170) AT=995.025n

.meas tran vdout0_171ck1980 FIND v(dout0_171) AT=995.025n

.meas tran vdout0_172ck1980 FIND v(dout0_172) AT=995.025n

.meas tran vdout0_173ck1980 FIND v(dout0_173) AT=995.025n

.meas tran vdout0_174ck1980 FIND v(dout0_174) AT=995.025n

.meas tran vdout0_175ck1980 FIND v(dout0_175) AT=995.025n

.meas tran vdout0_176ck1980 FIND v(dout0_176) AT=995.025n

.meas tran vdout0_177ck1980 FIND v(dout0_177) AT=995.025n

.meas tran vdout0_178ck1980 FIND v(dout0_178) AT=995.025n

.meas tran vdout0_179ck1980 FIND v(dout0_179) AT=995.025n

.meas tran vdout0_180ck1980 FIND v(dout0_180) AT=995.025n

.meas tran vdout0_181ck1980 FIND v(dout0_181) AT=995.025n

.meas tran vdout0_182ck1980 FIND v(dout0_182) AT=995.025n

.meas tran vdout0_183ck1980 FIND v(dout0_183) AT=995.025n

.meas tran vdout0_184ck1980 FIND v(dout0_184) AT=995.025n

.meas tran vdout0_185ck1980 FIND v(dout0_185) AT=995.025n

.meas tran vdout0_186ck1980 FIND v(dout0_186) AT=995.025n

.meas tran vdout0_187ck1980 FIND v(dout0_187) AT=995.025n

.meas tran vdout0_188ck1980 FIND v(dout0_188) AT=995.025n

.meas tran vdout0_189ck1980 FIND v(dout0_189) AT=995.025n

.meas tran vdout0_190ck1980 FIND v(dout0_190) AT=995.025n

.meas tran vdout0_191ck1980 FIND v(dout0_191) AT=995.025n

.meas tran vdout0_192ck1980 FIND v(dout0_192) AT=995.025n

.meas tran vdout0_193ck1980 FIND v(dout0_193) AT=995.025n

.meas tran vdout0_194ck1980 FIND v(dout0_194) AT=995.025n

.meas tran vdout0_195ck1980 FIND v(dout0_195) AT=995.025n

.meas tran vdout0_196ck1980 FIND v(dout0_196) AT=995.025n

.meas tran vdout0_197ck1980 FIND v(dout0_197) AT=995.025n

.meas tran vdout0_198ck1980 FIND v(dout0_198) AT=995.025n

.meas tran vdout0_199ck1980 FIND v(dout0_199) AT=995.025n

.meas tran vdout0_200ck1980 FIND v(dout0_200) AT=995.025n

.meas tran vdout0_201ck1980 FIND v(dout0_201) AT=995.025n

.meas tran vdout0_202ck1980 FIND v(dout0_202) AT=995.025n

.meas tran vdout0_203ck1980 FIND v(dout0_203) AT=995.025n

.meas tran vdout0_204ck1980 FIND v(dout0_204) AT=995.025n

.meas tran vdout0_205ck1980 FIND v(dout0_205) AT=995.025n

.meas tran vdout0_206ck1980 FIND v(dout0_206) AT=995.025n

.meas tran vdout0_207ck1980 FIND v(dout0_207) AT=995.025n

.meas tran vdout0_208ck1980 FIND v(dout0_208) AT=995.025n

.meas tran vdout0_209ck1980 FIND v(dout0_209) AT=995.025n

.meas tran vdout0_210ck1980 FIND v(dout0_210) AT=995.025n

.meas tran vdout0_211ck1980 FIND v(dout0_211) AT=995.025n

.meas tran vdout0_212ck1980 FIND v(dout0_212) AT=995.025n

.meas tran vdout0_213ck1980 FIND v(dout0_213) AT=995.025n

.meas tran vdout0_214ck1980 FIND v(dout0_214) AT=995.025n

.meas tran vdout0_215ck1980 FIND v(dout0_215) AT=995.025n

.meas tran vdout0_216ck1980 FIND v(dout0_216) AT=995.025n

.meas tran vdout0_217ck1980 FIND v(dout0_217) AT=995.025n

.meas tran vdout0_218ck1980 FIND v(dout0_218) AT=995.025n

.meas tran vdout0_219ck1980 FIND v(dout0_219) AT=995.025n

.meas tran vdout0_220ck1980 FIND v(dout0_220) AT=995.025n

.meas tran vdout0_221ck1980 FIND v(dout0_221) AT=995.025n

.meas tran vdout0_222ck1980 FIND v(dout0_222) AT=995.025n

.meas tran vdout0_223ck1980 FIND v(dout0_223) AT=995.025n

.meas tran vdout0_224ck1980 FIND v(dout0_224) AT=995.025n

.meas tran vdout0_225ck1980 FIND v(dout0_225) AT=995.025n

.meas tran vdout0_226ck1980 FIND v(dout0_226) AT=995.025n

.meas tran vdout0_227ck1980 FIND v(dout0_227) AT=995.025n

.meas tran vdout0_228ck1980 FIND v(dout0_228) AT=995.025n

.meas tran vdout0_229ck1980 FIND v(dout0_229) AT=995.025n

.meas tran vdout0_230ck1980 FIND v(dout0_230) AT=995.025n

.meas tran vdout0_231ck1980 FIND v(dout0_231) AT=995.025n

.meas tran vdout0_232ck1980 FIND v(dout0_232) AT=995.025n

.meas tran vdout0_233ck1980 FIND v(dout0_233) AT=995.025n

.meas tran vdout0_234ck1980 FIND v(dout0_234) AT=995.025n

.meas tran vdout0_235ck1980 FIND v(dout0_235) AT=995.025n

.meas tran vdout0_236ck1980 FIND v(dout0_236) AT=995.025n

.meas tran vdout0_237ck1980 FIND v(dout0_237) AT=995.025n

.meas tran vdout0_238ck1980 FIND v(dout0_238) AT=995.025n

.meas tran vdout0_239ck1980 FIND v(dout0_239) AT=995.025n

.meas tran vdout0_240ck1980 FIND v(dout0_240) AT=995.025n

.meas tran vdout0_241ck1980 FIND v(dout0_241) AT=995.025n

.meas tran vdout0_242ck1980 FIND v(dout0_242) AT=995.025n

.meas tran vdout0_243ck1980 FIND v(dout0_243) AT=995.025n

.meas tran vdout0_244ck1980 FIND v(dout0_244) AT=995.025n

.meas tran vdout0_245ck1980 FIND v(dout0_245) AT=995.025n

.meas tran vdout0_246ck1980 FIND v(dout0_246) AT=995.025n

.meas tran vdout0_247ck1980 FIND v(dout0_247) AT=995.025n

.meas tran vdout0_248ck1980 FIND v(dout0_248) AT=995.025n

.meas tran vdout0_249ck1980 FIND v(dout0_249) AT=995.025n

.meas tran vdout0_250ck1980 FIND v(dout0_250) AT=995.025n

.meas tran vdout0_251ck1980 FIND v(dout0_251) AT=995.025n

.meas tran vdout0_252ck1980 FIND v(dout0_252) AT=995.025n

.meas tran vdout0_253ck1980 FIND v(dout0_253) AT=995.025n

.meas tran vdout0_254ck1980 FIND v(dout0_254) AT=995.025n

.meas tran vdout0_255ck1980 FIND v(dout0_255) AT=995.025n

.meas tran vdout0_0ck2030 FIND v(dout0_0) AT=1020.025n

.meas tran vdout0_1ck2030 FIND v(dout0_1) AT=1020.025n

.meas tran vdout0_2ck2030 FIND v(dout0_2) AT=1020.025n

.meas tran vdout0_3ck2030 FIND v(dout0_3) AT=1020.025n

.meas tran vdout0_4ck2030 FIND v(dout0_4) AT=1020.025n

.meas tran vdout0_5ck2030 FIND v(dout0_5) AT=1020.025n

.meas tran vdout0_6ck2030 FIND v(dout0_6) AT=1020.025n

.meas tran vdout0_7ck2030 FIND v(dout0_7) AT=1020.025n

.meas tran vdout0_8ck2030 FIND v(dout0_8) AT=1020.025n

.meas tran vdout0_9ck2030 FIND v(dout0_9) AT=1020.025n

.meas tran vdout0_10ck2030 FIND v(dout0_10) AT=1020.025n

.meas tran vdout0_11ck2030 FIND v(dout0_11) AT=1020.025n

.meas tran vdout0_12ck2030 FIND v(dout0_12) AT=1020.025n

.meas tran vdout0_13ck2030 FIND v(dout0_13) AT=1020.025n

.meas tran vdout0_14ck2030 FIND v(dout0_14) AT=1020.025n

.meas tran vdout0_15ck2030 FIND v(dout0_15) AT=1020.025n

.meas tran vdout0_16ck2030 FIND v(dout0_16) AT=1020.025n

.meas tran vdout0_17ck2030 FIND v(dout0_17) AT=1020.025n

.meas tran vdout0_18ck2030 FIND v(dout0_18) AT=1020.025n

.meas tran vdout0_19ck2030 FIND v(dout0_19) AT=1020.025n

.meas tran vdout0_20ck2030 FIND v(dout0_20) AT=1020.025n

.meas tran vdout0_21ck2030 FIND v(dout0_21) AT=1020.025n

.meas tran vdout0_22ck2030 FIND v(dout0_22) AT=1020.025n

.meas tran vdout0_23ck2030 FIND v(dout0_23) AT=1020.025n

.meas tran vdout0_24ck2030 FIND v(dout0_24) AT=1020.025n

.meas tran vdout0_25ck2030 FIND v(dout0_25) AT=1020.025n

.meas tran vdout0_26ck2030 FIND v(dout0_26) AT=1020.025n

.meas tran vdout0_27ck2030 FIND v(dout0_27) AT=1020.025n

.meas tran vdout0_28ck2030 FIND v(dout0_28) AT=1020.025n

.meas tran vdout0_29ck2030 FIND v(dout0_29) AT=1020.025n

.meas tran vdout0_30ck2030 FIND v(dout0_30) AT=1020.025n

.meas tran vdout0_31ck2030 FIND v(dout0_31) AT=1020.025n

.meas tran vdout0_32ck2030 FIND v(dout0_32) AT=1020.025n

.meas tran vdout0_33ck2030 FIND v(dout0_33) AT=1020.025n

.meas tran vdout0_34ck2030 FIND v(dout0_34) AT=1020.025n

.meas tran vdout0_35ck2030 FIND v(dout0_35) AT=1020.025n

.meas tran vdout0_36ck2030 FIND v(dout0_36) AT=1020.025n

.meas tran vdout0_37ck2030 FIND v(dout0_37) AT=1020.025n

.meas tran vdout0_38ck2030 FIND v(dout0_38) AT=1020.025n

.meas tran vdout0_39ck2030 FIND v(dout0_39) AT=1020.025n

.meas tran vdout0_40ck2030 FIND v(dout0_40) AT=1020.025n

.meas tran vdout0_41ck2030 FIND v(dout0_41) AT=1020.025n

.meas tran vdout0_42ck2030 FIND v(dout0_42) AT=1020.025n

.meas tran vdout0_43ck2030 FIND v(dout0_43) AT=1020.025n

.meas tran vdout0_44ck2030 FIND v(dout0_44) AT=1020.025n

.meas tran vdout0_45ck2030 FIND v(dout0_45) AT=1020.025n

.meas tran vdout0_46ck2030 FIND v(dout0_46) AT=1020.025n

.meas tran vdout0_47ck2030 FIND v(dout0_47) AT=1020.025n

.meas tran vdout0_48ck2030 FIND v(dout0_48) AT=1020.025n

.meas tran vdout0_49ck2030 FIND v(dout0_49) AT=1020.025n

.meas tran vdout0_50ck2030 FIND v(dout0_50) AT=1020.025n

.meas tran vdout0_51ck2030 FIND v(dout0_51) AT=1020.025n

.meas tran vdout0_52ck2030 FIND v(dout0_52) AT=1020.025n

.meas tran vdout0_53ck2030 FIND v(dout0_53) AT=1020.025n

.meas tran vdout0_54ck2030 FIND v(dout0_54) AT=1020.025n

.meas tran vdout0_55ck2030 FIND v(dout0_55) AT=1020.025n

.meas tran vdout0_56ck2030 FIND v(dout0_56) AT=1020.025n

.meas tran vdout0_57ck2030 FIND v(dout0_57) AT=1020.025n

.meas tran vdout0_58ck2030 FIND v(dout0_58) AT=1020.025n

.meas tran vdout0_59ck2030 FIND v(dout0_59) AT=1020.025n

.meas tran vdout0_60ck2030 FIND v(dout0_60) AT=1020.025n

.meas tran vdout0_61ck2030 FIND v(dout0_61) AT=1020.025n

.meas tran vdout0_62ck2030 FIND v(dout0_62) AT=1020.025n

.meas tran vdout0_63ck2030 FIND v(dout0_63) AT=1020.025n

.meas tran vdout0_64ck2030 FIND v(dout0_64) AT=1020.025n

.meas tran vdout0_65ck2030 FIND v(dout0_65) AT=1020.025n

.meas tran vdout0_66ck2030 FIND v(dout0_66) AT=1020.025n

.meas tran vdout0_67ck2030 FIND v(dout0_67) AT=1020.025n

.meas tran vdout0_68ck2030 FIND v(dout0_68) AT=1020.025n

.meas tran vdout0_69ck2030 FIND v(dout0_69) AT=1020.025n

.meas tran vdout0_70ck2030 FIND v(dout0_70) AT=1020.025n

.meas tran vdout0_71ck2030 FIND v(dout0_71) AT=1020.025n

.meas tran vdout0_72ck2030 FIND v(dout0_72) AT=1020.025n

.meas tran vdout0_73ck2030 FIND v(dout0_73) AT=1020.025n

.meas tran vdout0_74ck2030 FIND v(dout0_74) AT=1020.025n

.meas tran vdout0_75ck2030 FIND v(dout0_75) AT=1020.025n

.meas tran vdout0_76ck2030 FIND v(dout0_76) AT=1020.025n

.meas tran vdout0_77ck2030 FIND v(dout0_77) AT=1020.025n

.meas tran vdout0_78ck2030 FIND v(dout0_78) AT=1020.025n

.meas tran vdout0_79ck2030 FIND v(dout0_79) AT=1020.025n

.meas tran vdout0_80ck2030 FIND v(dout0_80) AT=1020.025n

.meas tran vdout0_81ck2030 FIND v(dout0_81) AT=1020.025n

.meas tran vdout0_82ck2030 FIND v(dout0_82) AT=1020.025n

.meas tran vdout0_83ck2030 FIND v(dout0_83) AT=1020.025n

.meas tran vdout0_84ck2030 FIND v(dout0_84) AT=1020.025n

.meas tran vdout0_85ck2030 FIND v(dout0_85) AT=1020.025n

.meas tran vdout0_86ck2030 FIND v(dout0_86) AT=1020.025n

.meas tran vdout0_87ck2030 FIND v(dout0_87) AT=1020.025n

.meas tran vdout0_88ck2030 FIND v(dout0_88) AT=1020.025n

.meas tran vdout0_89ck2030 FIND v(dout0_89) AT=1020.025n

.meas tran vdout0_90ck2030 FIND v(dout0_90) AT=1020.025n

.meas tran vdout0_91ck2030 FIND v(dout0_91) AT=1020.025n

.meas tran vdout0_92ck2030 FIND v(dout0_92) AT=1020.025n

.meas tran vdout0_93ck2030 FIND v(dout0_93) AT=1020.025n

.meas tran vdout0_94ck2030 FIND v(dout0_94) AT=1020.025n

.meas tran vdout0_95ck2030 FIND v(dout0_95) AT=1020.025n

.meas tran vdout0_96ck2030 FIND v(dout0_96) AT=1020.025n

.meas tran vdout0_97ck2030 FIND v(dout0_97) AT=1020.025n

.meas tran vdout0_98ck2030 FIND v(dout0_98) AT=1020.025n

.meas tran vdout0_99ck2030 FIND v(dout0_99) AT=1020.025n

.meas tran vdout0_100ck2030 FIND v(dout0_100) AT=1020.025n

.meas tran vdout0_101ck2030 FIND v(dout0_101) AT=1020.025n

.meas tran vdout0_102ck2030 FIND v(dout0_102) AT=1020.025n

.meas tran vdout0_103ck2030 FIND v(dout0_103) AT=1020.025n

.meas tran vdout0_104ck2030 FIND v(dout0_104) AT=1020.025n

.meas tran vdout0_105ck2030 FIND v(dout0_105) AT=1020.025n

.meas tran vdout0_106ck2030 FIND v(dout0_106) AT=1020.025n

.meas tran vdout0_107ck2030 FIND v(dout0_107) AT=1020.025n

.meas tran vdout0_108ck2030 FIND v(dout0_108) AT=1020.025n

.meas tran vdout0_109ck2030 FIND v(dout0_109) AT=1020.025n

.meas tran vdout0_110ck2030 FIND v(dout0_110) AT=1020.025n

.meas tran vdout0_111ck2030 FIND v(dout0_111) AT=1020.025n

.meas tran vdout0_112ck2030 FIND v(dout0_112) AT=1020.025n

.meas tran vdout0_113ck2030 FIND v(dout0_113) AT=1020.025n

.meas tran vdout0_114ck2030 FIND v(dout0_114) AT=1020.025n

.meas tran vdout0_115ck2030 FIND v(dout0_115) AT=1020.025n

.meas tran vdout0_116ck2030 FIND v(dout0_116) AT=1020.025n

.meas tran vdout0_117ck2030 FIND v(dout0_117) AT=1020.025n

.meas tran vdout0_118ck2030 FIND v(dout0_118) AT=1020.025n

.meas tran vdout0_119ck2030 FIND v(dout0_119) AT=1020.025n

.meas tran vdout0_120ck2030 FIND v(dout0_120) AT=1020.025n

.meas tran vdout0_121ck2030 FIND v(dout0_121) AT=1020.025n

.meas tran vdout0_122ck2030 FIND v(dout0_122) AT=1020.025n

.meas tran vdout0_123ck2030 FIND v(dout0_123) AT=1020.025n

.meas tran vdout0_124ck2030 FIND v(dout0_124) AT=1020.025n

.meas tran vdout0_125ck2030 FIND v(dout0_125) AT=1020.025n

.meas tran vdout0_126ck2030 FIND v(dout0_126) AT=1020.025n

.meas tran vdout0_127ck2030 FIND v(dout0_127) AT=1020.025n

.meas tran vdout0_128ck2030 FIND v(dout0_128) AT=1020.025n

.meas tran vdout0_129ck2030 FIND v(dout0_129) AT=1020.025n

.meas tran vdout0_130ck2030 FIND v(dout0_130) AT=1020.025n

.meas tran vdout0_131ck2030 FIND v(dout0_131) AT=1020.025n

.meas tran vdout0_132ck2030 FIND v(dout0_132) AT=1020.025n

.meas tran vdout0_133ck2030 FIND v(dout0_133) AT=1020.025n

.meas tran vdout0_134ck2030 FIND v(dout0_134) AT=1020.025n

.meas tran vdout0_135ck2030 FIND v(dout0_135) AT=1020.025n

.meas tran vdout0_136ck2030 FIND v(dout0_136) AT=1020.025n

.meas tran vdout0_137ck2030 FIND v(dout0_137) AT=1020.025n

.meas tran vdout0_138ck2030 FIND v(dout0_138) AT=1020.025n

.meas tran vdout0_139ck2030 FIND v(dout0_139) AT=1020.025n

.meas tran vdout0_140ck2030 FIND v(dout0_140) AT=1020.025n

.meas tran vdout0_141ck2030 FIND v(dout0_141) AT=1020.025n

.meas tran vdout0_142ck2030 FIND v(dout0_142) AT=1020.025n

.meas tran vdout0_143ck2030 FIND v(dout0_143) AT=1020.025n

.meas tran vdout0_144ck2030 FIND v(dout0_144) AT=1020.025n

.meas tran vdout0_145ck2030 FIND v(dout0_145) AT=1020.025n

.meas tran vdout0_146ck2030 FIND v(dout0_146) AT=1020.025n

.meas tran vdout0_147ck2030 FIND v(dout0_147) AT=1020.025n

.meas tran vdout0_148ck2030 FIND v(dout0_148) AT=1020.025n

.meas tran vdout0_149ck2030 FIND v(dout0_149) AT=1020.025n

.meas tran vdout0_150ck2030 FIND v(dout0_150) AT=1020.025n

.meas tran vdout0_151ck2030 FIND v(dout0_151) AT=1020.025n

.meas tran vdout0_152ck2030 FIND v(dout0_152) AT=1020.025n

.meas tran vdout0_153ck2030 FIND v(dout0_153) AT=1020.025n

.meas tran vdout0_154ck2030 FIND v(dout0_154) AT=1020.025n

.meas tran vdout0_155ck2030 FIND v(dout0_155) AT=1020.025n

.meas tran vdout0_156ck2030 FIND v(dout0_156) AT=1020.025n

.meas tran vdout0_157ck2030 FIND v(dout0_157) AT=1020.025n

.meas tran vdout0_158ck2030 FIND v(dout0_158) AT=1020.025n

.meas tran vdout0_159ck2030 FIND v(dout0_159) AT=1020.025n

.meas tran vdout0_160ck2030 FIND v(dout0_160) AT=1020.025n

.meas tran vdout0_161ck2030 FIND v(dout0_161) AT=1020.025n

.meas tran vdout0_162ck2030 FIND v(dout0_162) AT=1020.025n

.meas tran vdout0_163ck2030 FIND v(dout0_163) AT=1020.025n

.meas tran vdout0_164ck2030 FIND v(dout0_164) AT=1020.025n

.meas tran vdout0_165ck2030 FIND v(dout0_165) AT=1020.025n

.meas tran vdout0_166ck2030 FIND v(dout0_166) AT=1020.025n

.meas tran vdout0_167ck2030 FIND v(dout0_167) AT=1020.025n

.meas tran vdout0_168ck2030 FIND v(dout0_168) AT=1020.025n

.meas tran vdout0_169ck2030 FIND v(dout0_169) AT=1020.025n

.meas tran vdout0_170ck2030 FIND v(dout0_170) AT=1020.025n

.meas tran vdout0_171ck2030 FIND v(dout0_171) AT=1020.025n

.meas tran vdout0_172ck2030 FIND v(dout0_172) AT=1020.025n

.meas tran vdout0_173ck2030 FIND v(dout0_173) AT=1020.025n

.meas tran vdout0_174ck2030 FIND v(dout0_174) AT=1020.025n

.meas tran vdout0_175ck2030 FIND v(dout0_175) AT=1020.025n

.meas tran vdout0_176ck2030 FIND v(dout0_176) AT=1020.025n

.meas tran vdout0_177ck2030 FIND v(dout0_177) AT=1020.025n

.meas tran vdout0_178ck2030 FIND v(dout0_178) AT=1020.025n

.meas tran vdout0_179ck2030 FIND v(dout0_179) AT=1020.025n

.meas tran vdout0_180ck2030 FIND v(dout0_180) AT=1020.025n

.meas tran vdout0_181ck2030 FIND v(dout0_181) AT=1020.025n

.meas tran vdout0_182ck2030 FIND v(dout0_182) AT=1020.025n

.meas tran vdout0_183ck2030 FIND v(dout0_183) AT=1020.025n

.meas tran vdout0_184ck2030 FIND v(dout0_184) AT=1020.025n

.meas tran vdout0_185ck2030 FIND v(dout0_185) AT=1020.025n

.meas tran vdout0_186ck2030 FIND v(dout0_186) AT=1020.025n

.meas tran vdout0_187ck2030 FIND v(dout0_187) AT=1020.025n

.meas tran vdout0_188ck2030 FIND v(dout0_188) AT=1020.025n

.meas tran vdout0_189ck2030 FIND v(dout0_189) AT=1020.025n

.meas tran vdout0_190ck2030 FIND v(dout0_190) AT=1020.025n

.meas tran vdout0_191ck2030 FIND v(dout0_191) AT=1020.025n

.meas tran vdout0_192ck2030 FIND v(dout0_192) AT=1020.025n

.meas tran vdout0_193ck2030 FIND v(dout0_193) AT=1020.025n

.meas tran vdout0_194ck2030 FIND v(dout0_194) AT=1020.025n

.meas tran vdout0_195ck2030 FIND v(dout0_195) AT=1020.025n

.meas tran vdout0_196ck2030 FIND v(dout0_196) AT=1020.025n

.meas tran vdout0_197ck2030 FIND v(dout0_197) AT=1020.025n

.meas tran vdout0_198ck2030 FIND v(dout0_198) AT=1020.025n

.meas tran vdout0_199ck2030 FIND v(dout0_199) AT=1020.025n

.meas tran vdout0_200ck2030 FIND v(dout0_200) AT=1020.025n

.meas tran vdout0_201ck2030 FIND v(dout0_201) AT=1020.025n

.meas tran vdout0_202ck2030 FIND v(dout0_202) AT=1020.025n

.meas tran vdout0_203ck2030 FIND v(dout0_203) AT=1020.025n

.meas tran vdout0_204ck2030 FIND v(dout0_204) AT=1020.025n

.meas tran vdout0_205ck2030 FIND v(dout0_205) AT=1020.025n

.meas tran vdout0_206ck2030 FIND v(dout0_206) AT=1020.025n

.meas tran vdout0_207ck2030 FIND v(dout0_207) AT=1020.025n

.meas tran vdout0_208ck2030 FIND v(dout0_208) AT=1020.025n

.meas tran vdout0_209ck2030 FIND v(dout0_209) AT=1020.025n

.meas tran vdout0_210ck2030 FIND v(dout0_210) AT=1020.025n

.meas tran vdout0_211ck2030 FIND v(dout0_211) AT=1020.025n

.meas tran vdout0_212ck2030 FIND v(dout0_212) AT=1020.025n

.meas tran vdout0_213ck2030 FIND v(dout0_213) AT=1020.025n

.meas tran vdout0_214ck2030 FIND v(dout0_214) AT=1020.025n

.meas tran vdout0_215ck2030 FIND v(dout0_215) AT=1020.025n

.meas tran vdout0_216ck2030 FIND v(dout0_216) AT=1020.025n

.meas tran vdout0_217ck2030 FIND v(dout0_217) AT=1020.025n

.meas tran vdout0_218ck2030 FIND v(dout0_218) AT=1020.025n

.meas tran vdout0_219ck2030 FIND v(dout0_219) AT=1020.025n

.meas tran vdout0_220ck2030 FIND v(dout0_220) AT=1020.025n

.meas tran vdout0_221ck2030 FIND v(dout0_221) AT=1020.025n

.meas tran vdout0_222ck2030 FIND v(dout0_222) AT=1020.025n

.meas tran vdout0_223ck2030 FIND v(dout0_223) AT=1020.025n

.meas tran vdout0_224ck2030 FIND v(dout0_224) AT=1020.025n

.meas tran vdout0_225ck2030 FIND v(dout0_225) AT=1020.025n

.meas tran vdout0_226ck2030 FIND v(dout0_226) AT=1020.025n

.meas tran vdout0_227ck2030 FIND v(dout0_227) AT=1020.025n

.meas tran vdout0_228ck2030 FIND v(dout0_228) AT=1020.025n

.meas tran vdout0_229ck2030 FIND v(dout0_229) AT=1020.025n

.meas tran vdout0_230ck2030 FIND v(dout0_230) AT=1020.025n

.meas tran vdout0_231ck2030 FIND v(dout0_231) AT=1020.025n

.meas tran vdout0_232ck2030 FIND v(dout0_232) AT=1020.025n

.meas tran vdout0_233ck2030 FIND v(dout0_233) AT=1020.025n

.meas tran vdout0_234ck2030 FIND v(dout0_234) AT=1020.025n

.meas tran vdout0_235ck2030 FIND v(dout0_235) AT=1020.025n

.meas tran vdout0_236ck2030 FIND v(dout0_236) AT=1020.025n

.meas tran vdout0_237ck2030 FIND v(dout0_237) AT=1020.025n

.meas tran vdout0_238ck2030 FIND v(dout0_238) AT=1020.025n

.meas tran vdout0_239ck2030 FIND v(dout0_239) AT=1020.025n

.meas tran vdout0_240ck2030 FIND v(dout0_240) AT=1020.025n

.meas tran vdout0_241ck2030 FIND v(dout0_241) AT=1020.025n

.meas tran vdout0_242ck2030 FIND v(dout0_242) AT=1020.025n

.meas tran vdout0_243ck2030 FIND v(dout0_243) AT=1020.025n

.meas tran vdout0_244ck2030 FIND v(dout0_244) AT=1020.025n

.meas tran vdout0_245ck2030 FIND v(dout0_245) AT=1020.025n

.meas tran vdout0_246ck2030 FIND v(dout0_246) AT=1020.025n

.meas tran vdout0_247ck2030 FIND v(dout0_247) AT=1020.025n

.meas tran vdout0_248ck2030 FIND v(dout0_248) AT=1020.025n

.meas tran vdout0_249ck2030 FIND v(dout0_249) AT=1020.025n

.meas tran vdout0_250ck2030 FIND v(dout0_250) AT=1020.025n

.meas tran vdout0_251ck2030 FIND v(dout0_251) AT=1020.025n

.meas tran vdout0_252ck2030 FIND v(dout0_252) AT=1020.025n

.meas tran vdout0_253ck2030 FIND v(dout0_253) AT=1020.025n

.meas tran vdout0_254ck2030 FIND v(dout0_254) AT=1020.025n

.meas tran vdout0_255ck2030 FIND v(dout0_255) AT=1020.025n

.meas tran vdout0_0ck2040 FIND v(dout0_0) AT=1025.025n

.meas tran vdout0_1ck2040 FIND v(dout0_1) AT=1025.025n

.meas tran vdout0_2ck2040 FIND v(dout0_2) AT=1025.025n

.meas tran vdout0_3ck2040 FIND v(dout0_3) AT=1025.025n

.meas tran vdout0_4ck2040 FIND v(dout0_4) AT=1025.025n

.meas tran vdout0_5ck2040 FIND v(dout0_5) AT=1025.025n

.meas tran vdout0_6ck2040 FIND v(dout0_6) AT=1025.025n

.meas tran vdout0_7ck2040 FIND v(dout0_7) AT=1025.025n

.meas tran vdout0_8ck2040 FIND v(dout0_8) AT=1025.025n

.meas tran vdout0_9ck2040 FIND v(dout0_9) AT=1025.025n

.meas tran vdout0_10ck2040 FIND v(dout0_10) AT=1025.025n

.meas tran vdout0_11ck2040 FIND v(dout0_11) AT=1025.025n

.meas tran vdout0_12ck2040 FIND v(dout0_12) AT=1025.025n

.meas tran vdout0_13ck2040 FIND v(dout0_13) AT=1025.025n

.meas tran vdout0_14ck2040 FIND v(dout0_14) AT=1025.025n

.meas tran vdout0_15ck2040 FIND v(dout0_15) AT=1025.025n

.meas tran vdout0_16ck2040 FIND v(dout0_16) AT=1025.025n

.meas tran vdout0_17ck2040 FIND v(dout0_17) AT=1025.025n

.meas tran vdout0_18ck2040 FIND v(dout0_18) AT=1025.025n

.meas tran vdout0_19ck2040 FIND v(dout0_19) AT=1025.025n

.meas tran vdout0_20ck2040 FIND v(dout0_20) AT=1025.025n

.meas tran vdout0_21ck2040 FIND v(dout0_21) AT=1025.025n

.meas tran vdout0_22ck2040 FIND v(dout0_22) AT=1025.025n

.meas tran vdout0_23ck2040 FIND v(dout0_23) AT=1025.025n

.meas tran vdout0_24ck2040 FIND v(dout0_24) AT=1025.025n

.meas tran vdout0_25ck2040 FIND v(dout0_25) AT=1025.025n

.meas tran vdout0_26ck2040 FIND v(dout0_26) AT=1025.025n

.meas tran vdout0_27ck2040 FIND v(dout0_27) AT=1025.025n

.meas tran vdout0_28ck2040 FIND v(dout0_28) AT=1025.025n

.meas tran vdout0_29ck2040 FIND v(dout0_29) AT=1025.025n

.meas tran vdout0_30ck2040 FIND v(dout0_30) AT=1025.025n

.meas tran vdout0_31ck2040 FIND v(dout0_31) AT=1025.025n

.meas tran vdout0_32ck2040 FIND v(dout0_32) AT=1025.025n

.meas tran vdout0_33ck2040 FIND v(dout0_33) AT=1025.025n

.meas tran vdout0_34ck2040 FIND v(dout0_34) AT=1025.025n

.meas tran vdout0_35ck2040 FIND v(dout0_35) AT=1025.025n

.meas tran vdout0_36ck2040 FIND v(dout0_36) AT=1025.025n

.meas tran vdout0_37ck2040 FIND v(dout0_37) AT=1025.025n

.meas tran vdout0_38ck2040 FIND v(dout0_38) AT=1025.025n

.meas tran vdout0_39ck2040 FIND v(dout0_39) AT=1025.025n

.meas tran vdout0_40ck2040 FIND v(dout0_40) AT=1025.025n

.meas tran vdout0_41ck2040 FIND v(dout0_41) AT=1025.025n

.meas tran vdout0_42ck2040 FIND v(dout0_42) AT=1025.025n

.meas tran vdout0_43ck2040 FIND v(dout0_43) AT=1025.025n

.meas tran vdout0_44ck2040 FIND v(dout0_44) AT=1025.025n

.meas tran vdout0_45ck2040 FIND v(dout0_45) AT=1025.025n

.meas tran vdout0_46ck2040 FIND v(dout0_46) AT=1025.025n

.meas tran vdout0_47ck2040 FIND v(dout0_47) AT=1025.025n

.meas tran vdout0_48ck2040 FIND v(dout0_48) AT=1025.025n

.meas tran vdout0_49ck2040 FIND v(dout0_49) AT=1025.025n

.meas tran vdout0_50ck2040 FIND v(dout0_50) AT=1025.025n

.meas tran vdout0_51ck2040 FIND v(dout0_51) AT=1025.025n

.meas tran vdout0_52ck2040 FIND v(dout0_52) AT=1025.025n

.meas tran vdout0_53ck2040 FIND v(dout0_53) AT=1025.025n

.meas tran vdout0_54ck2040 FIND v(dout0_54) AT=1025.025n

.meas tran vdout0_55ck2040 FIND v(dout0_55) AT=1025.025n

.meas tran vdout0_56ck2040 FIND v(dout0_56) AT=1025.025n

.meas tran vdout0_57ck2040 FIND v(dout0_57) AT=1025.025n

.meas tran vdout0_58ck2040 FIND v(dout0_58) AT=1025.025n

.meas tran vdout0_59ck2040 FIND v(dout0_59) AT=1025.025n

.meas tran vdout0_60ck2040 FIND v(dout0_60) AT=1025.025n

.meas tran vdout0_61ck2040 FIND v(dout0_61) AT=1025.025n

.meas tran vdout0_62ck2040 FIND v(dout0_62) AT=1025.025n

.meas tran vdout0_63ck2040 FIND v(dout0_63) AT=1025.025n

.meas tran vdout0_64ck2040 FIND v(dout0_64) AT=1025.025n

.meas tran vdout0_65ck2040 FIND v(dout0_65) AT=1025.025n

.meas tran vdout0_66ck2040 FIND v(dout0_66) AT=1025.025n

.meas tran vdout0_67ck2040 FIND v(dout0_67) AT=1025.025n

.meas tran vdout0_68ck2040 FIND v(dout0_68) AT=1025.025n

.meas tran vdout0_69ck2040 FIND v(dout0_69) AT=1025.025n

.meas tran vdout0_70ck2040 FIND v(dout0_70) AT=1025.025n

.meas tran vdout0_71ck2040 FIND v(dout0_71) AT=1025.025n

.meas tran vdout0_72ck2040 FIND v(dout0_72) AT=1025.025n

.meas tran vdout0_73ck2040 FIND v(dout0_73) AT=1025.025n

.meas tran vdout0_74ck2040 FIND v(dout0_74) AT=1025.025n

.meas tran vdout0_75ck2040 FIND v(dout0_75) AT=1025.025n

.meas tran vdout0_76ck2040 FIND v(dout0_76) AT=1025.025n

.meas tran vdout0_77ck2040 FIND v(dout0_77) AT=1025.025n

.meas tran vdout0_78ck2040 FIND v(dout0_78) AT=1025.025n

.meas tran vdout0_79ck2040 FIND v(dout0_79) AT=1025.025n

.meas tran vdout0_80ck2040 FIND v(dout0_80) AT=1025.025n

.meas tran vdout0_81ck2040 FIND v(dout0_81) AT=1025.025n

.meas tran vdout0_82ck2040 FIND v(dout0_82) AT=1025.025n

.meas tran vdout0_83ck2040 FIND v(dout0_83) AT=1025.025n

.meas tran vdout0_84ck2040 FIND v(dout0_84) AT=1025.025n

.meas tran vdout0_85ck2040 FIND v(dout0_85) AT=1025.025n

.meas tran vdout0_86ck2040 FIND v(dout0_86) AT=1025.025n

.meas tran vdout0_87ck2040 FIND v(dout0_87) AT=1025.025n

.meas tran vdout0_88ck2040 FIND v(dout0_88) AT=1025.025n

.meas tran vdout0_89ck2040 FIND v(dout0_89) AT=1025.025n

.meas tran vdout0_90ck2040 FIND v(dout0_90) AT=1025.025n

.meas tran vdout0_91ck2040 FIND v(dout0_91) AT=1025.025n

.meas tran vdout0_92ck2040 FIND v(dout0_92) AT=1025.025n

.meas tran vdout0_93ck2040 FIND v(dout0_93) AT=1025.025n

.meas tran vdout0_94ck2040 FIND v(dout0_94) AT=1025.025n

.meas tran vdout0_95ck2040 FIND v(dout0_95) AT=1025.025n

.meas tran vdout0_96ck2040 FIND v(dout0_96) AT=1025.025n

.meas tran vdout0_97ck2040 FIND v(dout0_97) AT=1025.025n

.meas tran vdout0_98ck2040 FIND v(dout0_98) AT=1025.025n

.meas tran vdout0_99ck2040 FIND v(dout0_99) AT=1025.025n

.meas tran vdout0_100ck2040 FIND v(dout0_100) AT=1025.025n

.meas tran vdout0_101ck2040 FIND v(dout0_101) AT=1025.025n

.meas tran vdout0_102ck2040 FIND v(dout0_102) AT=1025.025n

.meas tran vdout0_103ck2040 FIND v(dout0_103) AT=1025.025n

.meas tran vdout0_104ck2040 FIND v(dout0_104) AT=1025.025n

.meas tran vdout0_105ck2040 FIND v(dout0_105) AT=1025.025n

.meas tran vdout0_106ck2040 FIND v(dout0_106) AT=1025.025n

.meas tran vdout0_107ck2040 FIND v(dout0_107) AT=1025.025n

.meas tran vdout0_108ck2040 FIND v(dout0_108) AT=1025.025n

.meas tran vdout0_109ck2040 FIND v(dout0_109) AT=1025.025n

.meas tran vdout0_110ck2040 FIND v(dout0_110) AT=1025.025n

.meas tran vdout0_111ck2040 FIND v(dout0_111) AT=1025.025n

.meas tran vdout0_112ck2040 FIND v(dout0_112) AT=1025.025n

.meas tran vdout0_113ck2040 FIND v(dout0_113) AT=1025.025n

.meas tran vdout0_114ck2040 FIND v(dout0_114) AT=1025.025n

.meas tran vdout0_115ck2040 FIND v(dout0_115) AT=1025.025n

.meas tran vdout0_116ck2040 FIND v(dout0_116) AT=1025.025n

.meas tran vdout0_117ck2040 FIND v(dout0_117) AT=1025.025n

.meas tran vdout0_118ck2040 FIND v(dout0_118) AT=1025.025n

.meas tran vdout0_119ck2040 FIND v(dout0_119) AT=1025.025n

.meas tran vdout0_120ck2040 FIND v(dout0_120) AT=1025.025n

.meas tran vdout0_121ck2040 FIND v(dout0_121) AT=1025.025n

.meas tran vdout0_122ck2040 FIND v(dout0_122) AT=1025.025n

.meas tran vdout0_123ck2040 FIND v(dout0_123) AT=1025.025n

.meas tran vdout0_124ck2040 FIND v(dout0_124) AT=1025.025n

.meas tran vdout0_125ck2040 FIND v(dout0_125) AT=1025.025n

.meas tran vdout0_126ck2040 FIND v(dout0_126) AT=1025.025n

.meas tran vdout0_127ck2040 FIND v(dout0_127) AT=1025.025n

.meas tran vdout0_128ck2040 FIND v(dout0_128) AT=1025.025n

.meas tran vdout0_129ck2040 FIND v(dout0_129) AT=1025.025n

.meas tran vdout0_130ck2040 FIND v(dout0_130) AT=1025.025n

.meas tran vdout0_131ck2040 FIND v(dout0_131) AT=1025.025n

.meas tran vdout0_132ck2040 FIND v(dout0_132) AT=1025.025n

.meas tran vdout0_133ck2040 FIND v(dout0_133) AT=1025.025n

.meas tran vdout0_134ck2040 FIND v(dout0_134) AT=1025.025n

.meas tran vdout0_135ck2040 FIND v(dout0_135) AT=1025.025n

.meas tran vdout0_136ck2040 FIND v(dout0_136) AT=1025.025n

.meas tran vdout0_137ck2040 FIND v(dout0_137) AT=1025.025n

.meas tran vdout0_138ck2040 FIND v(dout0_138) AT=1025.025n

.meas tran vdout0_139ck2040 FIND v(dout0_139) AT=1025.025n

.meas tran vdout0_140ck2040 FIND v(dout0_140) AT=1025.025n

.meas tran vdout0_141ck2040 FIND v(dout0_141) AT=1025.025n

.meas tran vdout0_142ck2040 FIND v(dout0_142) AT=1025.025n

.meas tran vdout0_143ck2040 FIND v(dout0_143) AT=1025.025n

.meas tran vdout0_144ck2040 FIND v(dout0_144) AT=1025.025n

.meas tran vdout0_145ck2040 FIND v(dout0_145) AT=1025.025n

.meas tran vdout0_146ck2040 FIND v(dout0_146) AT=1025.025n

.meas tran vdout0_147ck2040 FIND v(dout0_147) AT=1025.025n

.meas tran vdout0_148ck2040 FIND v(dout0_148) AT=1025.025n

.meas tran vdout0_149ck2040 FIND v(dout0_149) AT=1025.025n

.meas tran vdout0_150ck2040 FIND v(dout0_150) AT=1025.025n

.meas tran vdout0_151ck2040 FIND v(dout0_151) AT=1025.025n

.meas tran vdout0_152ck2040 FIND v(dout0_152) AT=1025.025n

.meas tran vdout0_153ck2040 FIND v(dout0_153) AT=1025.025n

.meas tran vdout0_154ck2040 FIND v(dout0_154) AT=1025.025n

.meas tran vdout0_155ck2040 FIND v(dout0_155) AT=1025.025n

.meas tran vdout0_156ck2040 FIND v(dout0_156) AT=1025.025n

.meas tran vdout0_157ck2040 FIND v(dout0_157) AT=1025.025n

.meas tran vdout0_158ck2040 FIND v(dout0_158) AT=1025.025n

.meas tran vdout0_159ck2040 FIND v(dout0_159) AT=1025.025n

.meas tran vdout0_160ck2040 FIND v(dout0_160) AT=1025.025n

.meas tran vdout0_161ck2040 FIND v(dout0_161) AT=1025.025n

.meas tran vdout0_162ck2040 FIND v(dout0_162) AT=1025.025n

.meas tran vdout0_163ck2040 FIND v(dout0_163) AT=1025.025n

.meas tran vdout0_164ck2040 FIND v(dout0_164) AT=1025.025n

.meas tran vdout0_165ck2040 FIND v(dout0_165) AT=1025.025n

.meas tran vdout0_166ck2040 FIND v(dout0_166) AT=1025.025n

.meas tran vdout0_167ck2040 FIND v(dout0_167) AT=1025.025n

.meas tran vdout0_168ck2040 FIND v(dout0_168) AT=1025.025n

.meas tran vdout0_169ck2040 FIND v(dout0_169) AT=1025.025n

.meas tran vdout0_170ck2040 FIND v(dout0_170) AT=1025.025n

.meas tran vdout0_171ck2040 FIND v(dout0_171) AT=1025.025n

.meas tran vdout0_172ck2040 FIND v(dout0_172) AT=1025.025n

.meas tran vdout0_173ck2040 FIND v(dout0_173) AT=1025.025n

.meas tran vdout0_174ck2040 FIND v(dout0_174) AT=1025.025n

.meas tran vdout0_175ck2040 FIND v(dout0_175) AT=1025.025n

.meas tran vdout0_176ck2040 FIND v(dout0_176) AT=1025.025n

.meas tran vdout0_177ck2040 FIND v(dout0_177) AT=1025.025n

.meas tran vdout0_178ck2040 FIND v(dout0_178) AT=1025.025n

.meas tran vdout0_179ck2040 FIND v(dout0_179) AT=1025.025n

.meas tran vdout0_180ck2040 FIND v(dout0_180) AT=1025.025n

.meas tran vdout0_181ck2040 FIND v(dout0_181) AT=1025.025n

.meas tran vdout0_182ck2040 FIND v(dout0_182) AT=1025.025n

.meas tran vdout0_183ck2040 FIND v(dout0_183) AT=1025.025n

.meas tran vdout0_184ck2040 FIND v(dout0_184) AT=1025.025n

.meas tran vdout0_185ck2040 FIND v(dout0_185) AT=1025.025n

.meas tran vdout0_186ck2040 FIND v(dout0_186) AT=1025.025n

.meas tran vdout0_187ck2040 FIND v(dout0_187) AT=1025.025n

.meas tran vdout0_188ck2040 FIND v(dout0_188) AT=1025.025n

.meas tran vdout0_189ck2040 FIND v(dout0_189) AT=1025.025n

.meas tran vdout0_190ck2040 FIND v(dout0_190) AT=1025.025n

.meas tran vdout0_191ck2040 FIND v(dout0_191) AT=1025.025n

.meas tran vdout0_192ck2040 FIND v(dout0_192) AT=1025.025n

.meas tran vdout0_193ck2040 FIND v(dout0_193) AT=1025.025n

.meas tran vdout0_194ck2040 FIND v(dout0_194) AT=1025.025n

.meas tran vdout0_195ck2040 FIND v(dout0_195) AT=1025.025n

.meas tran vdout0_196ck2040 FIND v(dout0_196) AT=1025.025n

.meas tran vdout0_197ck2040 FIND v(dout0_197) AT=1025.025n

.meas tran vdout0_198ck2040 FIND v(dout0_198) AT=1025.025n

.meas tran vdout0_199ck2040 FIND v(dout0_199) AT=1025.025n

.meas tran vdout0_200ck2040 FIND v(dout0_200) AT=1025.025n

.meas tran vdout0_201ck2040 FIND v(dout0_201) AT=1025.025n

.meas tran vdout0_202ck2040 FIND v(dout0_202) AT=1025.025n

.meas tran vdout0_203ck2040 FIND v(dout0_203) AT=1025.025n

.meas tran vdout0_204ck2040 FIND v(dout0_204) AT=1025.025n

.meas tran vdout0_205ck2040 FIND v(dout0_205) AT=1025.025n

.meas tran vdout0_206ck2040 FIND v(dout0_206) AT=1025.025n

.meas tran vdout0_207ck2040 FIND v(dout0_207) AT=1025.025n

.meas tran vdout0_208ck2040 FIND v(dout0_208) AT=1025.025n

.meas tran vdout0_209ck2040 FIND v(dout0_209) AT=1025.025n

.meas tran vdout0_210ck2040 FIND v(dout0_210) AT=1025.025n

.meas tran vdout0_211ck2040 FIND v(dout0_211) AT=1025.025n

.meas tran vdout0_212ck2040 FIND v(dout0_212) AT=1025.025n

.meas tran vdout0_213ck2040 FIND v(dout0_213) AT=1025.025n

.meas tran vdout0_214ck2040 FIND v(dout0_214) AT=1025.025n

.meas tran vdout0_215ck2040 FIND v(dout0_215) AT=1025.025n

.meas tran vdout0_216ck2040 FIND v(dout0_216) AT=1025.025n

.meas tran vdout0_217ck2040 FIND v(dout0_217) AT=1025.025n

.meas tran vdout0_218ck2040 FIND v(dout0_218) AT=1025.025n

.meas tran vdout0_219ck2040 FIND v(dout0_219) AT=1025.025n

.meas tran vdout0_220ck2040 FIND v(dout0_220) AT=1025.025n

.meas tran vdout0_221ck2040 FIND v(dout0_221) AT=1025.025n

.meas tran vdout0_222ck2040 FIND v(dout0_222) AT=1025.025n

.meas tran vdout0_223ck2040 FIND v(dout0_223) AT=1025.025n

.meas tran vdout0_224ck2040 FIND v(dout0_224) AT=1025.025n

.meas tran vdout0_225ck2040 FIND v(dout0_225) AT=1025.025n

.meas tran vdout0_226ck2040 FIND v(dout0_226) AT=1025.025n

.meas tran vdout0_227ck2040 FIND v(dout0_227) AT=1025.025n

.meas tran vdout0_228ck2040 FIND v(dout0_228) AT=1025.025n

.meas tran vdout0_229ck2040 FIND v(dout0_229) AT=1025.025n

.meas tran vdout0_230ck2040 FIND v(dout0_230) AT=1025.025n

.meas tran vdout0_231ck2040 FIND v(dout0_231) AT=1025.025n

.meas tran vdout0_232ck2040 FIND v(dout0_232) AT=1025.025n

.meas tran vdout0_233ck2040 FIND v(dout0_233) AT=1025.025n

.meas tran vdout0_234ck2040 FIND v(dout0_234) AT=1025.025n

.meas tran vdout0_235ck2040 FIND v(dout0_235) AT=1025.025n

.meas tran vdout0_236ck2040 FIND v(dout0_236) AT=1025.025n

.meas tran vdout0_237ck2040 FIND v(dout0_237) AT=1025.025n

.meas tran vdout0_238ck2040 FIND v(dout0_238) AT=1025.025n

.meas tran vdout0_239ck2040 FIND v(dout0_239) AT=1025.025n

.meas tran vdout0_240ck2040 FIND v(dout0_240) AT=1025.025n

.meas tran vdout0_241ck2040 FIND v(dout0_241) AT=1025.025n

.meas tran vdout0_242ck2040 FIND v(dout0_242) AT=1025.025n

.meas tran vdout0_243ck2040 FIND v(dout0_243) AT=1025.025n

.meas tran vdout0_244ck2040 FIND v(dout0_244) AT=1025.025n

.meas tran vdout0_245ck2040 FIND v(dout0_245) AT=1025.025n

.meas tran vdout0_246ck2040 FIND v(dout0_246) AT=1025.025n

.meas tran vdout0_247ck2040 FIND v(dout0_247) AT=1025.025n

.meas tran vdout0_248ck2040 FIND v(dout0_248) AT=1025.025n

.meas tran vdout0_249ck2040 FIND v(dout0_249) AT=1025.025n

.meas tran vdout0_250ck2040 FIND v(dout0_250) AT=1025.025n

.meas tran vdout0_251ck2040 FIND v(dout0_251) AT=1025.025n

.meas tran vdout0_252ck2040 FIND v(dout0_252) AT=1025.025n

.meas tran vdout0_253ck2040 FIND v(dout0_253) AT=1025.025n

.meas tran vdout0_254ck2040 FIND v(dout0_254) AT=1025.025n

.meas tran vdout0_255ck2040 FIND v(dout0_255) AT=1025.025n

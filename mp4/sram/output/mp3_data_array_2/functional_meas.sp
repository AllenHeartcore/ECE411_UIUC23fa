.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_0ck50 FIND v(dout0_0) AT=30.025n

.meas tran vdout0_1ck50 FIND v(dout0_1) AT=30.025n

.meas tran vdout0_2ck50 FIND v(dout0_2) AT=30.025n

.meas tran vdout0_3ck50 FIND v(dout0_3) AT=30.025n

.meas tran vdout0_4ck50 FIND v(dout0_4) AT=30.025n

.meas tran vdout0_5ck50 FIND v(dout0_5) AT=30.025n

.meas tran vdout0_6ck50 FIND v(dout0_6) AT=30.025n

.meas tran vdout0_7ck50 FIND v(dout0_7) AT=30.025n

.meas tran vdout0_8ck50 FIND v(dout0_8) AT=30.025n

.meas tran vdout0_9ck50 FIND v(dout0_9) AT=30.025n

.meas tran vdout0_10ck50 FIND v(dout0_10) AT=30.025n

.meas tran vdout0_11ck50 FIND v(dout0_11) AT=30.025n

.meas tran vdout0_12ck50 FIND v(dout0_12) AT=30.025n

.meas tran vdout0_13ck50 FIND v(dout0_13) AT=30.025n

.meas tran vdout0_14ck50 FIND v(dout0_14) AT=30.025n

.meas tran vdout0_15ck50 FIND v(dout0_15) AT=30.025n

.meas tran vdout0_16ck50 FIND v(dout0_16) AT=30.025n

.meas tran vdout0_17ck50 FIND v(dout0_17) AT=30.025n

.meas tran vdout0_18ck50 FIND v(dout0_18) AT=30.025n

.meas tran vdout0_19ck50 FIND v(dout0_19) AT=30.025n

.meas tran vdout0_20ck50 FIND v(dout0_20) AT=30.025n

.meas tran vdout0_21ck50 FIND v(dout0_21) AT=30.025n

.meas tran vdout0_22ck50 FIND v(dout0_22) AT=30.025n

.meas tran vdout0_23ck50 FIND v(dout0_23) AT=30.025n

.meas tran vdout0_24ck50 FIND v(dout0_24) AT=30.025n

.meas tran vdout0_25ck50 FIND v(dout0_25) AT=30.025n

.meas tran vdout0_26ck50 FIND v(dout0_26) AT=30.025n

.meas tran vdout0_27ck50 FIND v(dout0_27) AT=30.025n

.meas tran vdout0_28ck50 FIND v(dout0_28) AT=30.025n

.meas tran vdout0_29ck50 FIND v(dout0_29) AT=30.025n

.meas tran vdout0_30ck50 FIND v(dout0_30) AT=30.025n

.meas tran vdout0_31ck50 FIND v(dout0_31) AT=30.025n

.meas tran vdout0_32ck50 FIND v(dout0_32) AT=30.025n

.meas tran vdout0_33ck50 FIND v(dout0_33) AT=30.025n

.meas tran vdout0_34ck50 FIND v(dout0_34) AT=30.025n

.meas tran vdout0_35ck50 FIND v(dout0_35) AT=30.025n

.meas tran vdout0_36ck50 FIND v(dout0_36) AT=30.025n

.meas tran vdout0_37ck50 FIND v(dout0_37) AT=30.025n

.meas tran vdout0_38ck50 FIND v(dout0_38) AT=30.025n

.meas tran vdout0_39ck50 FIND v(dout0_39) AT=30.025n

.meas tran vdout0_40ck50 FIND v(dout0_40) AT=30.025n

.meas tran vdout0_41ck50 FIND v(dout0_41) AT=30.025n

.meas tran vdout0_42ck50 FIND v(dout0_42) AT=30.025n

.meas tran vdout0_43ck50 FIND v(dout0_43) AT=30.025n

.meas tran vdout0_44ck50 FIND v(dout0_44) AT=30.025n

.meas tran vdout0_45ck50 FIND v(dout0_45) AT=30.025n

.meas tran vdout0_46ck50 FIND v(dout0_46) AT=30.025n

.meas tran vdout0_47ck50 FIND v(dout0_47) AT=30.025n

.meas tran vdout0_48ck50 FIND v(dout0_48) AT=30.025n

.meas tran vdout0_49ck50 FIND v(dout0_49) AT=30.025n

.meas tran vdout0_50ck50 FIND v(dout0_50) AT=30.025n

.meas tran vdout0_51ck50 FIND v(dout0_51) AT=30.025n

.meas tran vdout0_52ck50 FIND v(dout0_52) AT=30.025n

.meas tran vdout0_53ck50 FIND v(dout0_53) AT=30.025n

.meas tran vdout0_54ck50 FIND v(dout0_54) AT=30.025n

.meas tran vdout0_55ck50 FIND v(dout0_55) AT=30.025n

.meas tran vdout0_56ck50 FIND v(dout0_56) AT=30.025n

.meas tran vdout0_57ck50 FIND v(dout0_57) AT=30.025n

.meas tran vdout0_58ck50 FIND v(dout0_58) AT=30.025n

.meas tran vdout0_59ck50 FIND v(dout0_59) AT=30.025n

.meas tran vdout0_60ck50 FIND v(dout0_60) AT=30.025n

.meas tran vdout0_61ck50 FIND v(dout0_61) AT=30.025n

.meas tran vdout0_62ck50 FIND v(dout0_62) AT=30.025n

.meas tran vdout0_63ck50 FIND v(dout0_63) AT=30.025n

.meas tran vdout0_64ck50 FIND v(dout0_64) AT=30.025n

.meas tran vdout0_65ck50 FIND v(dout0_65) AT=30.025n

.meas tran vdout0_66ck50 FIND v(dout0_66) AT=30.025n

.meas tran vdout0_67ck50 FIND v(dout0_67) AT=30.025n

.meas tran vdout0_68ck50 FIND v(dout0_68) AT=30.025n

.meas tran vdout0_69ck50 FIND v(dout0_69) AT=30.025n

.meas tran vdout0_70ck50 FIND v(dout0_70) AT=30.025n

.meas tran vdout0_71ck50 FIND v(dout0_71) AT=30.025n

.meas tran vdout0_72ck50 FIND v(dout0_72) AT=30.025n

.meas tran vdout0_73ck50 FIND v(dout0_73) AT=30.025n

.meas tran vdout0_74ck50 FIND v(dout0_74) AT=30.025n

.meas tran vdout0_75ck50 FIND v(dout0_75) AT=30.025n

.meas tran vdout0_76ck50 FIND v(dout0_76) AT=30.025n

.meas tran vdout0_77ck50 FIND v(dout0_77) AT=30.025n

.meas tran vdout0_78ck50 FIND v(dout0_78) AT=30.025n

.meas tran vdout0_79ck50 FIND v(dout0_79) AT=30.025n

.meas tran vdout0_80ck50 FIND v(dout0_80) AT=30.025n

.meas tran vdout0_81ck50 FIND v(dout0_81) AT=30.025n

.meas tran vdout0_82ck50 FIND v(dout0_82) AT=30.025n

.meas tran vdout0_83ck50 FIND v(dout0_83) AT=30.025n

.meas tran vdout0_84ck50 FIND v(dout0_84) AT=30.025n

.meas tran vdout0_85ck50 FIND v(dout0_85) AT=30.025n

.meas tran vdout0_86ck50 FIND v(dout0_86) AT=30.025n

.meas tran vdout0_87ck50 FIND v(dout0_87) AT=30.025n

.meas tran vdout0_88ck50 FIND v(dout0_88) AT=30.025n

.meas tran vdout0_89ck50 FIND v(dout0_89) AT=30.025n

.meas tran vdout0_90ck50 FIND v(dout0_90) AT=30.025n

.meas tran vdout0_91ck50 FIND v(dout0_91) AT=30.025n

.meas tran vdout0_92ck50 FIND v(dout0_92) AT=30.025n

.meas tran vdout0_93ck50 FIND v(dout0_93) AT=30.025n

.meas tran vdout0_94ck50 FIND v(dout0_94) AT=30.025n

.meas tran vdout0_95ck50 FIND v(dout0_95) AT=30.025n

.meas tran vdout0_96ck50 FIND v(dout0_96) AT=30.025n

.meas tran vdout0_97ck50 FIND v(dout0_97) AT=30.025n

.meas tran vdout0_98ck50 FIND v(dout0_98) AT=30.025n

.meas tran vdout0_99ck50 FIND v(dout0_99) AT=30.025n

.meas tran vdout0_100ck50 FIND v(dout0_100) AT=30.025n

.meas tran vdout0_101ck50 FIND v(dout0_101) AT=30.025n

.meas tran vdout0_102ck50 FIND v(dout0_102) AT=30.025n

.meas tran vdout0_103ck50 FIND v(dout0_103) AT=30.025n

.meas tran vdout0_104ck50 FIND v(dout0_104) AT=30.025n

.meas tran vdout0_105ck50 FIND v(dout0_105) AT=30.025n

.meas tran vdout0_106ck50 FIND v(dout0_106) AT=30.025n

.meas tran vdout0_107ck50 FIND v(dout0_107) AT=30.025n

.meas tran vdout0_108ck50 FIND v(dout0_108) AT=30.025n

.meas tran vdout0_109ck50 FIND v(dout0_109) AT=30.025n

.meas tran vdout0_110ck50 FIND v(dout0_110) AT=30.025n

.meas tran vdout0_111ck50 FIND v(dout0_111) AT=30.025n

.meas tran vdout0_112ck50 FIND v(dout0_112) AT=30.025n

.meas tran vdout0_113ck50 FIND v(dout0_113) AT=30.025n

.meas tran vdout0_114ck50 FIND v(dout0_114) AT=30.025n

.meas tran vdout0_115ck50 FIND v(dout0_115) AT=30.025n

.meas tran vdout0_116ck50 FIND v(dout0_116) AT=30.025n

.meas tran vdout0_117ck50 FIND v(dout0_117) AT=30.025n

.meas tran vdout0_118ck50 FIND v(dout0_118) AT=30.025n

.meas tran vdout0_119ck50 FIND v(dout0_119) AT=30.025n

.meas tran vdout0_120ck50 FIND v(dout0_120) AT=30.025n

.meas tran vdout0_121ck50 FIND v(dout0_121) AT=30.025n

.meas tran vdout0_122ck50 FIND v(dout0_122) AT=30.025n

.meas tran vdout0_123ck50 FIND v(dout0_123) AT=30.025n

.meas tran vdout0_124ck50 FIND v(dout0_124) AT=30.025n

.meas tran vdout0_125ck50 FIND v(dout0_125) AT=30.025n

.meas tran vdout0_126ck50 FIND v(dout0_126) AT=30.025n

.meas tran vdout0_127ck50 FIND v(dout0_127) AT=30.025n

.meas tran vdout0_0ck120 FIND v(dout0_0) AT=65.025n

.meas tran vdout0_1ck120 FIND v(dout0_1) AT=65.025n

.meas tran vdout0_2ck120 FIND v(dout0_2) AT=65.025n

.meas tran vdout0_3ck120 FIND v(dout0_3) AT=65.025n

.meas tran vdout0_4ck120 FIND v(dout0_4) AT=65.025n

.meas tran vdout0_5ck120 FIND v(dout0_5) AT=65.025n

.meas tran vdout0_6ck120 FIND v(dout0_6) AT=65.025n

.meas tran vdout0_7ck120 FIND v(dout0_7) AT=65.025n

.meas tran vdout0_8ck120 FIND v(dout0_8) AT=65.025n

.meas tran vdout0_9ck120 FIND v(dout0_9) AT=65.025n

.meas tran vdout0_10ck120 FIND v(dout0_10) AT=65.025n

.meas tran vdout0_11ck120 FIND v(dout0_11) AT=65.025n

.meas tran vdout0_12ck120 FIND v(dout0_12) AT=65.025n

.meas tran vdout0_13ck120 FIND v(dout0_13) AT=65.025n

.meas tran vdout0_14ck120 FIND v(dout0_14) AT=65.025n

.meas tran vdout0_15ck120 FIND v(dout0_15) AT=65.025n

.meas tran vdout0_16ck120 FIND v(dout0_16) AT=65.025n

.meas tran vdout0_17ck120 FIND v(dout0_17) AT=65.025n

.meas tran vdout0_18ck120 FIND v(dout0_18) AT=65.025n

.meas tran vdout0_19ck120 FIND v(dout0_19) AT=65.025n

.meas tran vdout0_20ck120 FIND v(dout0_20) AT=65.025n

.meas tran vdout0_21ck120 FIND v(dout0_21) AT=65.025n

.meas tran vdout0_22ck120 FIND v(dout0_22) AT=65.025n

.meas tran vdout0_23ck120 FIND v(dout0_23) AT=65.025n

.meas tran vdout0_24ck120 FIND v(dout0_24) AT=65.025n

.meas tran vdout0_25ck120 FIND v(dout0_25) AT=65.025n

.meas tran vdout0_26ck120 FIND v(dout0_26) AT=65.025n

.meas tran vdout0_27ck120 FIND v(dout0_27) AT=65.025n

.meas tran vdout0_28ck120 FIND v(dout0_28) AT=65.025n

.meas tran vdout0_29ck120 FIND v(dout0_29) AT=65.025n

.meas tran vdout0_30ck120 FIND v(dout0_30) AT=65.025n

.meas tran vdout0_31ck120 FIND v(dout0_31) AT=65.025n

.meas tran vdout0_32ck120 FIND v(dout0_32) AT=65.025n

.meas tran vdout0_33ck120 FIND v(dout0_33) AT=65.025n

.meas tran vdout0_34ck120 FIND v(dout0_34) AT=65.025n

.meas tran vdout0_35ck120 FIND v(dout0_35) AT=65.025n

.meas tran vdout0_36ck120 FIND v(dout0_36) AT=65.025n

.meas tran vdout0_37ck120 FIND v(dout0_37) AT=65.025n

.meas tran vdout0_38ck120 FIND v(dout0_38) AT=65.025n

.meas tran vdout0_39ck120 FIND v(dout0_39) AT=65.025n

.meas tran vdout0_40ck120 FIND v(dout0_40) AT=65.025n

.meas tran vdout0_41ck120 FIND v(dout0_41) AT=65.025n

.meas tran vdout0_42ck120 FIND v(dout0_42) AT=65.025n

.meas tran vdout0_43ck120 FIND v(dout0_43) AT=65.025n

.meas tran vdout0_44ck120 FIND v(dout0_44) AT=65.025n

.meas tran vdout0_45ck120 FIND v(dout0_45) AT=65.025n

.meas tran vdout0_46ck120 FIND v(dout0_46) AT=65.025n

.meas tran vdout0_47ck120 FIND v(dout0_47) AT=65.025n

.meas tran vdout0_48ck120 FIND v(dout0_48) AT=65.025n

.meas tran vdout0_49ck120 FIND v(dout0_49) AT=65.025n

.meas tran vdout0_50ck120 FIND v(dout0_50) AT=65.025n

.meas tran vdout0_51ck120 FIND v(dout0_51) AT=65.025n

.meas tran vdout0_52ck120 FIND v(dout0_52) AT=65.025n

.meas tran vdout0_53ck120 FIND v(dout0_53) AT=65.025n

.meas tran vdout0_54ck120 FIND v(dout0_54) AT=65.025n

.meas tran vdout0_55ck120 FIND v(dout0_55) AT=65.025n

.meas tran vdout0_56ck120 FIND v(dout0_56) AT=65.025n

.meas tran vdout0_57ck120 FIND v(dout0_57) AT=65.025n

.meas tran vdout0_58ck120 FIND v(dout0_58) AT=65.025n

.meas tran vdout0_59ck120 FIND v(dout0_59) AT=65.025n

.meas tran vdout0_60ck120 FIND v(dout0_60) AT=65.025n

.meas tran vdout0_61ck120 FIND v(dout0_61) AT=65.025n

.meas tran vdout0_62ck120 FIND v(dout0_62) AT=65.025n

.meas tran vdout0_63ck120 FIND v(dout0_63) AT=65.025n

.meas tran vdout0_64ck120 FIND v(dout0_64) AT=65.025n

.meas tran vdout0_65ck120 FIND v(dout0_65) AT=65.025n

.meas tran vdout0_66ck120 FIND v(dout0_66) AT=65.025n

.meas tran vdout0_67ck120 FIND v(dout0_67) AT=65.025n

.meas tran vdout0_68ck120 FIND v(dout0_68) AT=65.025n

.meas tran vdout0_69ck120 FIND v(dout0_69) AT=65.025n

.meas tran vdout0_70ck120 FIND v(dout0_70) AT=65.025n

.meas tran vdout0_71ck120 FIND v(dout0_71) AT=65.025n

.meas tran vdout0_72ck120 FIND v(dout0_72) AT=65.025n

.meas tran vdout0_73ck120 FIND v(dout0_73) AT=65.025n

.meas tran vdout0_74ck120 FIND v(dout0_74) AT=65.025n

.meas tran vdout0_75ck120 FIND v(dout0_75) AT=65.025n

.meas tran vdout0_76ck120 FIND v(dout0_76) AT=65.025n

.meas tran vdout0_77ck120 FIND v(dout0_77) AT=65.025n

.meas tran vdout0_78ck120 FIND v(dout0_78) AT=65.025n

.meas tran vdout0_79ck120 FIND v(dout0_79) AT=65.025n

.meas tran vdout0_80ck120 FIND v(dout0_80) AT=65.025n

.meas tran vdout0_81ck120 FIND v(dout0_81) AT=65.025n

.meas tran vdout0_82ck120 FIND v(dout0_82) AT=65.025n

.meas tran vdout0_83ck120 FIND v(dout0_83) AT=65.025n

.meas tran vdout0_84ck120 FIND v(dout0_84) AT=65.025n

.meas tran vdout0_85ck120 FIND v(dout0_85) AT=65.025n

.meas tran vdout0_86ck120 FIND v(dout0_86) AT=65.025n

.meas tran vdout0_87ck120 FIND v(dout0_87) AT=65.025n

.meas tran vdout0_88ck120 FIND v(dout0_88) AT=65.025n

.meas tran vdout0_89ck120 FIND v(dout0_89) AT=65.025n

.meas tran vdout0_90ck120 FIND v(dout0_90) AT=65.025n

.meas tran vdout0_91ck120 FIND v(dout0_91) AT=65.025n

.meas tran vdout0_92ck120 FIND v(dout0_92) AT=65.025n

.meas tran vdout0_93ck120 FIND v(dout0_93) AT=65.025n

.meas tran vdout0_94ck120 FIND v(dout0_94) AT=65.025n

.meas tran vdout0_95ck120 FIND v(dout0_95) AT=65.025n

.meas tran vdout0_96ck120 FIND v(dout0_96) AT=65.025n

.meas tran vdout0_97ck120 FIND v(dout0_97) AT=65.025n

.meas tran vdout0_98ck120 FIND v(dout0_98) AT=65.025n

.meas tran vdout0_99ck120 FIND v(dout0_99) AT=65.025n

.meas tran vdout0_100ck120 FIND v(dout0_100) AT=65.025n

.meas tran vdout0_101ck120 FIND v(dout0_101) AT=65.025n

.meas tran vdout0_102ck120 FIND v(dout0_102) AT=65.025n

.meas tran vdout0_103ck120 FIND v(dout0_103) AT=65.025n

.meas tran vdout0_104ck120 FIND v(dout0_104) AT=65.025n

.meas tran vdout0_105ck120 FIND v(dout0_105) AT=65.025n

.meas tran vdout0_106ck120 FIND v(dout0_106) AT=65.025n

.meas tran vdout0_107ck120 FIND v(dout0_107) AT=65.025n

.meas tran vdout0_108ck120 FIND v(dout0_108) AT=65.025n

.meas tran vdout0_109ck120 FIND v(dout0_109) AT=65.025n

.meas tran vdout0_110ck120 FIND v(dout0_110) AT=65.025n

.meas tran vdout0_111ck120 FIND v(dout0_111) AT=65.025n

.meas tran vdout0_112ck120 FIND v(dout0_112) AT=65.025n

.meas tran vdout0_113ck120 FIND v(dout0_113) AT=65.025n

.meas tran vdout0_114ck120 FIND v(dout0_114) AT=65.025n

.meas tran vdout0_115ck120 FIND v(dout0_115) AT=65.025n

.meas tran vdout0_116ck120 FIND v(dout0_116) AT=65.025n

.meas tran vdout0_117ck120 FIND v(dout0_117) AT=65.025n

.meas tran vdout0_118ck120 FIND v(dout0_118) AT=65.025n

.meas tran vdout0_119ck120 FIND v(dout0_119) AT=65.025n

.meas tran vdout0_120ck120 FIND v(dout0_120) AT=65.025n

.meas tran vdout0_121ck120 FIND v(dout0_121) AT=65.025n

.meas tran vdout0_122ck120 FIND v(dout0_122) AT=65.025n

.meas tran vdout0_123ck120 FIND v(dout0_123) AT=65.025n

.meas tran vdout0_124ck120 FIND v(dout0_124) AT=65.025n

.meas tran vdout0_125ck120 FIND v(dout0_125) AT=65.025n

.meas tran vdout0_126ck120 FIND v(dout0_126) AT=65.025n

.meas tran vdout0_127ck120 FIND v(dout0_127) AT=65.025n

.meas tran vdout0_0ck150 FIND v(dout0_0) AT=80.025n

.meas tran vdout0_1ck150 FIND v(dout0_1) AT=80.025n

.meas tran vdout0_2ck150 FIND v(dout0_2) AT=80.025n

.meas tran vdout0_3ck150 FIND v(dout0_3) AT=80.025n

.meas tran vdout0_4ck150 FIND v(dout0_4) AT=80.025n

.meas tran vdout0_5ck150 FIND v(dout0_5) AT=80.025n

.meas tran vdout0_6ck150 FIND v(dout0_6) AT=80.025n

.meas tran vdout0_7ck150 FIND v(dout0_7) AT=80.025n

.meas tran vdout0_8ck150 FIND v(dout0_8) AT=80.025n

.meas tran vdout0_9ck150 FIND v(dout0_9) AT=80.025n

.meas tran vdout0_10ck150 FIND v(dout0_10) AT=80.025n

.meas tran vdout0_11ck150 FIND v(dout0_11) AT=80.025n

.meas tran vdout0_12ck150 FIND v(dout0_12) AT=80.025n

.meas tran vdout0_13ck150 FIND v(dout0_13) AT=80.025n

.meas tran vdout0_14ck150 FIND v(dout0_14) AT=80.025n

.meas tran vdout0_15ck150 FIND v(dout0_15) AT=80.025n

.meas tran vdout0_16ck150 FIND v(dout0_16) AT=80.025n

.meas tran vdout0_17ck150 FIND v(dout0_17) AT=80.025n

.meas tran vdout0_18ck150 FIND v(dout0_18) AT=80.025n

.meas tran vdout0_19ck150 FIND v(dout0_19) AT=80.025n

.meas tran vdout0_20ck150 FIND v(dout0_20) AT=80.025n

.meas tran vdout0_21ck150 FIND v(dout0_21) AT=80.025n

.meas tran vdout0_22ck150 FIND v(dout0_22) AT=80.025n

.meas tran vdout0_23ck150 FIND v(dout0_23) AT=80.025n

.meas tran vdout0_24ck150 FIND v(dout0_24) AT=80.025n

.meas tran vdout0_25ck150 FIND v(dout0_25) AT=80.025n

.meas tran vdout0_26ck150 FIND v(dout0_26) AT=80.025n

.meas tran vdout0_27ck150 FIND v(dout0_27) AT=80.025n

.meas tran vdout0_28ck150 FIND v(dout0_28) AT=80.025n

.meas tran vdout0_29ck150 FIND v(dout0_29) AT=80.025n

.meas tran vdout0_30ck150 FIND v(dout0_30) AT=80.025n

.meas tran vdout0_31ck150 FIND v(dout0_31) AT=80.025n

.meas tran vdout0_32ck150 FIND v(dout0_32) AT=80.025n

.meas tran vdout0_33ck150 FIND v(dout0_33) AT=80.025n

.meas tran vdout0_34ck150 FIND v(dout0_34) AT=80.025n

.meas tran vdout0_35ck150 FIND v(dout0_35) AT=80.025n

.meas tran vdout0_36ck150 FIND v(dout0_36) AT=80.025n

.meas tran vdout0_37ck150 FIND v(dout0_37) AT=80.025n

.meas tran vdout0_38ck150 FIND v(dout0_38) AT=80.025n

.meas tran vdout0_39ck150 FIND v(dout0_39) AT=80.025n

.meas tran vdout0_40ck150 FIND v(dout0_40) AT=80.025n

.meas tran vdout0_41ck150 FIND v(dout0_41) AT=80.025n

.meas tran vdout0_42ck150 FIND v(dout0_42) AT=80.025n

.meas tran vdout0_43ck150 FIND v(dout0_43) AT=80.025n

.meas tran vdout0_44ck150 FIND v(dout0_44) AT=80.025n

.meas tran vdout0_45ck150 FIND v(dout0_45) AT=80.025n

.meas tran vdout0_46ck150 FIND v(dout0_46) AT=80.025n

.meas tran vdout0_47ck150 FIND v(dout0_47) AT=80.025n

.meas tran vdout0_48ck150 FIND v(dout0_48) AT=80.025n

.meas tran vdout0_49ck150 FIND v(dout0_49) AT=80.025n

.meas tran vdout0_50ck150 FIND v(dout0_50) AT=80.025n

.meas tran vdout0_51ck150 FIND v(dout0_51) AT=80.025n

.meas tran vdout0_52ck150 FIND v(dout0_52) AT=80.025n

.meas tran vdout0_53ck150 FIND v(dout0_53) AT=80.025n

.meas tran vdout0_54ck150 FIND v(dout0_54) AT=80.025n

.meas tran vdout0_55ck150 FIND v(dout0_55) AT=80.025n

.meas tran vdout0_56ck150 FIND v(dout0_56) AT=80.025n

.meas tran vdout0_57ck150 FIND v(dout0_57) AT=80.025n

.meas tran vdout0_58ck150 FIND v(dout0_58) AT=80.025n

.meas tran vdout0_59ck150 FIND v(dout0_59) AT=80.025n

.meas tran vdout0_60ck150 FIND v(dout0_60) AT=80.025n

.meas tran vdout0_61ck150 FIND v(dout0_61) AT=80.025n

.meas tran vdout0_62ck150 FIND v(dout0_62) AT=80.025n

.meas tran vdout0_63ck150 FIND v(dout0_63) AT=80.025n

.meas tran vdout0_64ck150 FIND v(dout0_64) AT=80.025n

.meas tran vdout0_65ck150 FIND v(dout0_65) AT=80.025n

.meas tran vdout0_66ck150 FIND v(dout0_66) AT=80.025n

.meas tran vdout0_67ck150 FIND v(dout0_67) AT=80.025n

.meas tran vdout0_68ck150 FIND v(dout0_68) AT=80.025n

.meas tran vdout0_69ck150 FIND v(dout0_69) AT=80.025n

.meas tran vdout0_70ck150 FIND v(dout0_70) AT=80.025n

.meas tran vdout0_71ck150 FIND v(dout0_71) AT=80.025n

.meas tran vdout0_72ck150 FIND v(dout0_72) AT=80.025n

.meas tran vdout0_73ck150 FIND v(dout0_73) AT=80.025n

.meas tran vdout0_74ck150 FIND v(dout0_74) AT=80.025n

.meas tran vdout0_75ck150 FIND v(dout0_75) AT=80.025n

.meas tran vdout0_76ck150 FIND v(dout0_76) AT=80.025n

.meas tran vdout0_77ck150 FIND v(dout0_77) AT=80.025n

.meas tran vdout0_78ck150 FIND v(dout0_78) AT=80.025n

.meas tran vdout0_79ck150 FIND v(dout0_79) AT=80.025n

.meas tran vdout0_80ck150 FIND v(dout0_80) AT=80.025n

.meas tran vdout0_81ck150 FIND v(dout0_81) AT=80.025n

.meas tran vdout0_82ck150 FIND v(dout0_82) AT=80.025n

.meas tran vdout0_83ck150 FIND v(dout0_83) AT=80.025n

.meas tran vdout0_84ck150 FIND v(dout0_84) AT=80.025n

.meas tran vdout0_85ck150 FIND v(dout0_85) AT=80.025n

.meas tran vdout0_86ck150 FIND v(dout0_86) AT=80.025n

.meas tran vdout0_87ck150 FIND v(dout0_87) AT=80.025n

.meas tran vdout0_88ck150 FIND v(dout0_88) AT=80.025n

.meas tran vdout0_89ck150 FIND v(dout0_89) AT=80.025n

.meas tran vdout0_90ck150 FIND v(dout0_90) AT=80.025n

.meas tran vdout0_91ck150 FIND v(dout0_91) AT=80.025n

.meas tran vdout0_92ck150 FIND v(dout0_92) AT=80.025n

.meas tran vdout0_93ck150 FIND v(dout0_93) AT=80.025n

.meas tran vdout0_94ck150 FIND v(dout0_94) AT=80.025n

.meas tran vdout0_95ck150 FIND v(dout0_95) AT=80.025n

.meas tran vdout0_96ck150 FIND v(dout0_96) AT=80.025n

.meas tran vdout0_97ck150 FIND v(dout0_97) AT=80.025n

.meas tran vdout0_98ck150 FIND v(dout0_98) AT=80.025n

.meas tran vdout0_99ck150 FIND v(dout0_99) AT=80.025n

.meas tran vdout0_100ck150 FIND v(dout0_100) AT=80.025n

.meas tran vdout0_101ck150 FIND v(dout0_101) AT=80.025n

.meas tran vdout0_102ck150 FIND v(dout0_102) AT=80.025n

.meas tran vdout0_103ck150 FIND v(dout0_103) AT=80.025n

.meas tran vdout0_104ck150 FIND v(dout0_104) AT=80.025n

.meas tran vdout0_105ck150 FIND v(dout0_105) AT=80.025n

.meas tran vdout0_106ck150 FIND v(dout0_106) AT=80.025n

.meas tran vdout0_107ck150 FIND v(dout0_107) AT=80.025n

.meas tran vdout0_108ck150 FIND v(dout0_108) AT=80.025n

.meas tran vdout0_109ck150 FIND v(dout0_109) AT=80.025n

.meas tran vdout0_110ck150 FIND v(dout0_110) AT=80.025n

.meas tran vdout0_111ck150 FIND v(dout0_111) AT=80.025n

.meas tran vdout0_112ck150 FIND v(dout0_112) AT=80.025n

.meas tran vdout0_113ck150 FIND v(dout0_113) AT=80.025n

.meas tran vdout0_114ck150 FIND v(dout0_114) AT=80.025n

.meas tran vdout0_115ck150 FIND v(dout0_115) AT=80.025n

.meas tran vdout0_116ck150 FIND v(dout0_116) AT=80.025n

.meas tran vdout0_117ck150 FIND v(dout0_117) AT=80.025n

.meas tran vdout0_118ck150 FIND v(dout0_118) AT=80.025n

.meas tran vdout0_119ck150 FIND v(dout0_119) AT=80.025n

.meas tran vdout0_120ck150 FIND v(dout0_120) AT=80.025n

.meas tran vdout0_121ck150 FIND v(dout0_121) AT=80.025n

.meas tran vdout0_122ck150 FIND v(dout0_122) AT=80.025n

.meas tran vdout0_123ck150 FIND v(dout0_123) AT=80.025n

.meas tran vdout0_124ck150 FIND v(dout0_124) AT=80.025n

.meas tran vdout0_125ck150 FIND v(dout0_125) AT=80.025n

.meas tran vdout0_126ck150 FIND v(dout0_126) AT=80.025n

.meas tran vdout0_127ck150 FIND v(dout0_127) AT=80.025n

.meas tran vdout0_0ck160 FIND v(dout0_0) AT=85.025n

.meas tran vdout0_1ck160 FIND v(dout0_1) AT=85.025n

.meas tran vdout0_2ck160 FIND v(dout0_2) AT=85.025n

.meas tran vdout0_3ck160 FIND v(dout0_3) AT=85.025n

.meas tran vdout0_4ck160 FIND v(dout0_4) AT=85.025n

.meas tran vdout0_5ck160 FIND v(dout0_5) AT=85.025n

.meas tran vdout0_6ck160 FIND v(dout0_6) AT=85.025n

.meas tran vdout0_7ck160 FIND v(dout0_7) AT=85.025n

.meas tran vdout0_8ck160 FIND v(dout0_8) AT=85.025n

.meas tran vdout0_9ck160 FIND v(dout0_9) AT=85.025n

.meas tran vdout0_10ck160 FIND v(dout0_10) AT=85.025n

.meas tran vdout0_11ck160 FIND v(dout0_11) AT=85.025n

.meas tran vdout0_12ck160 FIND v(dout0_12) AT=85.025n

.meas tran vdout0_13ck160 FIND v(dout0_13) AT=85.025n

.meas tran vdout0_14ck160 FIND v(dout0_14) AT=85.025n

.meas tran vdout0_15ck160 FIND v(dout0_15) AT=85.025n

.meas tran vdout0_16ck160 FIND v(dout0_16) AT=85.025n

.meas tran vdout0_17ck160 FIND v(dout0_17) AT=85.025n

.meas tran vdout0_18ck160 FIND v(dout0_18) AT=85.025n

.meas tran vdout0_19ck160 FIND v(dout0_19) AT=85.025n

.meas tran vdout0_20ck160 FIND v(dout0_20) AT=85.025n

.meas tran vdout0_21ck160 FIND v(dout0_21) AT=85.025n

.meas tran vdout0_22ck160 FIND v(dout0_22) AT=85.025n

.meas tran vdout0_23ck160 FIND v(dout0_23) AT=85.025n

.meas tran vdout0_24ck160 FIND v(dout0_24) AT=85.025n

.meas tran vdout0_25ck160 FIND v(dout0_25) AT=85.025n

.meas tran vdout0_26ck160 FIND v(dout0_26) AT=85.025n

.meas tran vdout0_27ck160 FIND v(dout0_27) AT=85.025n

.meas tran vdout0_28ck160 FIND v(dout0_28) AT=85.025n

.meas tran vdout0_29ck160 FIND v(dout0_29) AT=85.025n

.meas tran vdout0_30ck160 FIND v(dout0_30) AT=85.025n

.meas tran vdout0_31ck160 FIND v(dout0_31) AT=85.025n

.meas tran vdout0_32ck160 FIND v(dout0_32) AT=85.025n

.meas tran vdout0_33ck160 FIND v(dout0_33) AT=85.025n

.meas tran vdout0_34ck160 FIND v(dout0_34) AT=85.025n

.meas tran vdout0_35ck160 FIND v(dout0_35) AT=85.025n

.meas tran vdout0_36ck160 FIND v(dout0_36) AT=85.025n

.meas tran vdout0_37ck160 FIND v(dout0_37) AT=85.025n

.meas tran vdout0_38ck160 FIND v(dout0_38) AT=85.025n

.meas tran vdout0_39ck160 FIND v(dout0_39) AT=85.025n

.meas tran vdout0_40ck160 FIND v(dout0_40) AT=85.025n

.meas tran vdout0_41ck160 FIND v(dout0_41) AT=85.025n

.meas tran vdout0_42ck160 FIND v(dout0_42) AT=85.025n

.meas tran vdout0_43ck160 FIND v(dout0_43) AT=85.025n

.meas tran vdout0_44ck160 FIND v(dout0_44) AT=85.025n

.meas tran vdout0_45ck160 FIND v(dout0_45) AT=85.025n

.meas tran vdout0_46ck160 FIND v(dout0_46) AT=85.025n

.meas tran vdout0_47ck160 FIND v(dout0_47) AT=85.025n

.meas tran vdout0_48ck160 FIND v(dout0_48) AT=85.025n

.meas tran vdout0_49ck160 FIND v(dout0_49) AT=85.025n

.meas tran vdout0_50ck160 FIND v(dout0_50) AT=85.025n

.meas tran vdout0_51ck160 FIND v(dout0_51) AT=85.025n

.meas tran vdout0_52ck160 FIND v(dout0_52) AT=85.025n

.meas tran vdout0_53ck160 FIND v(dout0_53) AT=85.025n

.meas tran vdout0_54ck160 FIND v(dout0_54) AT=85.025n

.meas tran vdout0_55ck160 FIND v(dout0_55) AT=85.025n

.meas tran vdout0_56ck160 FIND v(dout0_56) AT=85.025n

.meas tran vdout0_57ck160 FIND v(dout0_57) AT=85.025n

.meas tran vdout0_58ck160 FIND v(dout0_58) AT=85.025n

.meas tran vdout0_59ck160 FIND v(dout0_59) AT=85.025n

.meas tran vdout0_60ck160 FIND v(dout0_60) AT=85.025n

.meas tran vdout0_61ck160 FIND v(dout0_61) AT=85.025n

.meas tran vdout0_62ck160 FIND v(dout0_62) AT=85.025n

.meas tran vdout0_63ck160 FIND v(dout0_63) AT=85.025n

.meas tran vdout0_64ck160 FIND v(dout0_64) AT=85.025n

.meas tran vdout0_65ck160 FIND v(dout0_65) AT=85.025n

.meas tran vdout0_66ck160 FIND v(dout0_66) AT=85.025n

.meas tran vdout0_67ck160 FIND v(dout0_67) AT=85.025n

.meas tran vdout0_68ck160 FIND v(dout0_68) AT=85.025n

.meas tran vdout0_69ck160 FIND v(dout0_69) AT=85.025n

.meas tran vdout0_70ck160 FIND v(dout0_70) AT=85.025n

.meas tran vdout0_71ck160 FIND v(dout0_71) AT=85.025n

.meas tran vdout0_72ck160 FIND v(dout0_72) AT=85.025n

.meas tran vdout0_73ck160 FIND v(dout0_73) AT=85.025n

.meas tran vdout0_74ck160 FIND v(dout0_74) AT=85.025n

.meas tran vdout0_75ck160 FIND v(dout0_75) AT=85.025n

.meas tran vdout0_76ck160 FIND v(dout0_76) AT=85.025n

.meas tran vdout0_77ck160 FIND v(dout0_77) AT=85.025n

.meas tran vdout0_78ck160 FIND v(dout0_78) AT=85.025n

.meas tran vdout0_79ck160 FIND v(dout0_79) AT=85.025n

.meas tran vdout0_80ck160 FIND v(dout0_80) AT=85.025n

.meas tran vdout0_81ck160 FIND v(dout0_81) AT=85.025n

.meas tran vdout0_82ck160 FIND v(dout0_82) AT=85.025n

.meas tran vdout0_83ck160 FIND v(dout0_83) AT=85.025n

.meas tran vdout0_84ck160 FIND v(dout0_84) AT=85.025n

.meas tran vdout0_85ck160 FIND v(dout0_85) AT=85.025n

.meas tran vdout0_86ck160 FIND v(dout0_86) AT=85.025n

.meas tran vdout0_87ck160 FIND v(dout0_87) AT=85.025n

.meas tran vdout0_88ck160 FIND v(dout0_88) AT=85.025n

.meas tran vdout0_89ck160 FIND v(dout0_89) AT=85.025n

.meas tran vdout0_90ck160 FIND v(dout0_90) AT=85.025n

.meas tran vdout0_91ck160 FIND v(dout0_91) AT=85.025n

.meas tran vdout0_92ck160 FIND v(dout0_92) AT=85.025n

.meas tran vdout0_93ck160 FIND v(dout0_93) AT=85.025n

.meas tran vdout0_94ck160 FIND v(dout0_94) AT=85.025n

.meas tran vdout0_95ck160 FIND v(dout0_95) AT=85.025n

.meas tran vdout0_96ck160 FIND v(dout0_96) AT=85.025n

.meas tran vdout0_97ck160 FIND v(dout0_97) AT=85.025n

.meas tran vdout0_98ck160 FIND v(dout0_98) AT=85.025n

.meas tran vdout0_99ck160 FIND v(dout0_99) AT=85.025n

.meas tran vdout0_100ck160 FIND v(dout0_100) AT=85.025n

.meas tran vdout0_101ck160 FIND v(dout0_101) AT=85.025n

.meas tran vdout0_102ck160 FIND v(dout0_102) AT=85.025n

.meas tran vdout0_103ck160 FIND v(dout0_103) AT=85.025n

.meas tran vdout0_104ck160 FIND v(dout0_104) AT=85.025n

.meas tran vdout0_105ck160 FIND v(dout0_105) AT=85.025n

.meas tran vdout0_106ck160 FIND v(dout0_106) AT=85.025n

.meas tran vdout0_107ck160 FIND v(dout0_107) AT=85.025n

.meas tran vdout0_108ck160 FIND v(dout0_108) AT=85.025n

.meas tran vdout0_109ck160 FIND v(dout0_109) AT=85.025n

.meas tran vdout0_110ck160 FIND v(dout0_110) AT=85.025n

.meas tran vdout0_111ck160 FIND v(dout0_111) AT=85.025n

.meas tran vdout0_112ck160 FIND v(dout0_112) AT=85.025n

.meas tran vdout0_113ck160 FIND v(dout0_113) AT=85.025n

.meas tran vdout0_114ck160 FIND v(dout0_114) AT=85.025n

.meas tran vdout0_115ck160 FIND v(dout0_115) AT=85.025n

.meas tran vdout0_116ck160 FIND v(dout0_116) AT=85.025n

.meas tran vdout0_117ck160 FIND v(dout0_117) AT=85.025n

.meas tran vdout0_118ck160 FIND v(dout0_118) AT=85.025n

.meas tran vdout0_119ck160 FIND v(dout0_119) AT=85.025n

.meas tran vdout0_120ck160 FIND v(dout0_120) AT=85.025n

.meas tran vdout0_121ck160 FIND v(dout0_121) AT=85.025n

.meas tran vdout0_122ck160 FIND v(dout0_122) AT=85.025n

.meas tran vdout0_123ck160 FIND v(dout0_123) AT=85.025n

.meas tran vdout0_124ck160 FIND v(dout0_124) AT=85.025n

.meas tran vdout0_125ck160 FIND v(dout0_125) AT=85.025n

.meas tran vdout0_126ck160 FIND v(dout0_126) AT=85.025n

.meas tran vdout0_127ck160 FIND v(dout0_127) AT=85.025n

.meas tran vdout0_0ck170 FIND v(dout0_0) AT=90.025n

.meas tran vdout0_1ck170 FIND v(dout0_1) AT=90.025n

.meas tran vdout0_2ck170 FIND v(dout0_2) AT=90.025n

.meas tran vdout0_3ck170 FIND v(dout0_3) AT=90.025n

.meas tran vdout0_4ck170 FIND v(dout0_4) AT=90.025n

.meas tran vdout0_5ck170 FIND v(dout0_5) AT=90.025n

.meas tran vdout0_6ck170 FIND v(dout0_6) AT=90.025n

.meas tran vdout0_7ck170 FIND v(dout0_7) AT=90.025n

.meas tran vdout0_8ck170 FIND v(dout0_8) AT=90.025n

.meas tran vdout0_9ck170 FIND v(dout0_9) AT=90.025n

.meas tran vdout0_10ck170 FIND v(dout0_10) AT=90.025n

.meas tran vdout0_11ck170 FIND v(dout0_11) AT=90.025n

.meas tran vdout0_12ck170 FIND v(dout0_12) AT=90.025n

.meas tran vdout0_13ck170 FIND v(dout0_13) AT=90.025n

.meas tran vdout0_14ck170 FIND v(dout0_14) AT=90.025n

.meas tran vdout0_15ck170 FIND v(dout0_15) AT=90.025n

.meas tran vdout0_16ck170 FIND v(dout0_16) AT=90.025n

.meas tran vdout0_17ck170 FIND v(dout0_17) AT=90.025n

.meas tran vdout0_18ck170 FIND v(dout0_18) AT=90.025n

.meas tran vdout0_19ck170 FIND v(dout0_19) AT=90.025n

.meas tran vdout0_20ck170 FIND v(dout0_20) AT=90.025n

.meas tran vdout0_21ck170 FIND v(dout0_21) AT=90.025n

.meas tran vdout0_22ck170 FIND v(dout0_22) AT=90.025n

.meas tran vdout0_23ck170 FIND v(dout0_23) AT=90.025n

.meas tran vdout0_24ck170 FIND v(dout0_24) AT=90.025n

.meas tran vdout0_25ck170 FIND v(dout0_25) AT=90.025n

.meas tran vdout0_26ck170 FIND v(dout0_26) AT=90.025n

.meas tran vdout0_27ck170 FIND v(dout0_27) AT=90.025n

.meas tran vdout0_28ck170 FIND v(dout0_28) AT=90.025n

.meas tran vdout0_29ck170 FIND v(dout0_29) AT=90.025n

.meas tran vdout0_30ck170 FIND v(dout0_30) AT=90.025n

.meas tran vdout0_31ck170 FIND v(dout0_31) AT=90.025n

.meas tran vdout0_32ck170 FIND v(dout0_32) AT=90.025n

.meas tran vdout0_33ck170 FIND v(dout0_33) AT=90.025n

.meas tran vdout0_34ck170 FIND v(dout0_34) AT=90.025n

.meas tran vdout0_35ck170 FIND v(dout0_35) AT=90.025n

.meas tran vdout0_36ck170 FIND v(dout0_36) AT=90.025n

.meas tran vdout0_37ck170 FIND v(dout0_37) AT=90.025n

.meas tran vdout0_38ck170 FIND v(dout0_38) AT=90.025n

.meas tran vdout0_39ck170 FIND v(dout0_39) AT=90.025n

.meas tran vdout0_40ck170 FIND v(dout0_40) AT=90.025n

.meas tran vdout0_41ck170 FIND v(dout0_41) AT=90.025n

.meas tran vdout0_42ck170 FIND v(dout0_42) AT=90.025n

.meas tran vdout0_43ck170 FIND v(dout0_43) AT=90.025n

.meas tran vdout0_44ck170 FIND v(dout0_44) AT=90.025n

.meas tran vdout0_45ck170 FIND v(dout0_45) AT=90.025n

.meas tran vdout0_46ck170 FIND v(dout0_46) AT=90.025n

.meas tran vdout0_47ck170 FIND v(dout0_47) AT=90.025n

.meas tran vdout0_48ck170 FIND v(dout0_48) AT=90.025n

.meas tran vdout0_49ck170 FIND v(dout0_49) AT=90.025n

.meas tran vdout0_50ck170 FIND v(dout0_50) AT=90.025n

.meas tran vdout0_51ck170 FIND v(dout0_51) AT=90.025n

.meas tran vdout0_52ck170 FIND v(dout0_52) AT=90.025n

.meas tran vdout0_53ck170 FIND v(dout0_53) AT=90.025n

.meas tran vdout0_54ck170 FIND v(dout0_54) AT=90.025n

.meas tran vdout0_55ck170 FIND v(dout0_55) AT=90.025n

.meas tran vdout0_56ck170 FIND v(dout0_56) AT=90.025n

.meas tran vdout0_57ck170 FIND v(dout0_57) AT=90.025n

.meas tran vdout0_58ck170 FIND v(dout0_58) AT=90.025n

.meas tran vdout0_59ck170 FIND v(dout0_59) AT=90.025n

.meas tran vdout0_60ck170 FIND v(dout0_60) AT=90.025n

.meas tran vdout0_61ck170 FIND v(dout0_61) AT=90.025n

.meas tran vdout0_62ck170 FIND v(dout0_62) AT=90.025n

.meas tran vdout0_63ck170 FIND v(dout0_63) AT=90.025n

.meas tran vdout0_64ck170 FIND v(dout0_64) AT=90.025n

.meas tran vdout0_65ck170 FIND v(dout0_65) AT=90.025n

.meas tran vdout0_66ck170 FIND v(dout0_66) AT=90.025n

.meas tran vdout0_67ck170 FIND v(dout0_67) AT=90.025n

.meas tran vdout0_68ck170 FIND v(dout0_68) AT=90.025n

.meas tran vdout0_69ck170 FIND v(dout0_69) AT=90.025n

.meas tran vdout0_70ck170 FIND v(dout0_70) AT=90.025n

.meas tran vdout0_71ck170 FIND v(dout0_71) AT=90.025n

.meas tran vdout0_72ck170 FIND v(dout0_72) AT=90.025n

.meas tran vdout0_73ck170 FIND v(dout0_73) AT=90.025n

.meas tran vdout0_74ck170 FIND v(dout0_74) AT=90.025n

.meas tran vdout0_75ck170 FIND v(dout0_75) AT=90.025n

.meas tran vdout0_76ck170 FIND v(dout0_76) AT=90.025n

.meas tran vdout0_77ck170 FIND v(dout0_77) AT=90.025n

.meas tran vdout0_78ck170 FIND v(dout0_78) AT=90.025n

.meas tran vdout0_79ck170 FIND v(dout0_79) AT=90.025n

.meas tran vdout0_80ck170 FIND v(dout0_80) AT=90.025n

.meas tran vdout0_81ck170 FIND v(dout0_81) AT=90.025n

.meas tran vdout0_82ck170 FIND v(dout0_82) AT=90.025n

.meas tran vdout0_83ck170 FIND v(dout0_83) AT=90.025n

.meas tran vdout0_84ck170 FIND v(dout0_84) AT=90.025n

.meas tran vdout0_85ck170 FIND v(dout0_85) AT=90.025n

.meas tran vdout0_86ck170 FIND v(dout0_86) AT=90.025n

.meas tran vdout0_87ck170 FIND v(dout0_87) AT=90.025n

.meas tran vdout0_88ck170 FIND v(dout0_88) AT=90.025n

.meas tran vdout0_89ck170 FIND v(dout0_89) AT=90.025n

.meas tran vdout0_90ck170 FIND v(dout0_90) AT=90.025n

.meas tran vdout0_91ck170 FIND v(dout0_91) AT=90.025n

.meas tran vdout0_92ck170 FIND v(dout0_92) AT=90.025n

.meas tran vdout0_93ck170 FIND v(dout0_93) AT=90.025n

.meas tran vdout0_94ck170 FIND v(dout0_94) AT=90.025n

.meas tran vdout0_95ck170 FIND v(dout0_95) AT=90.025n

.meas tran vdout0_96ck170 FIND v(dout0_96) AT=90.025n

.meas tran vdout0_97ck170 FIND v(dout0_97) AT=90.025n

.meas tran vdout0_98ck170 FIND v(dout0_98) AT=90.025n

.meas tran vdout0_99ck170 FIND v(dout0_99) AT=90.025n

.meas tran vdout0_100ck170 FIND v(dout0_100) AT=90.025n

.meas tran vdout0_101ck170 FIND v(dout0_101) AT=90.025n

.meas tran vdout0_102ck170 FIND v(dout0_102) AT=90.025n

.meas tran vdout0_103ck170 FIND v(dout0_103) AT=90.025n

.meas tran vdout0_104ck170 FIND v(dout0_104) AT=90.025n

.meas tran vdout0_105ck170 FIND v(dout0_105) AT=90.025n

.meas tran vdout0_106ck170 FIND v(dout0_106) AT=90.025n

.meas tran vdout0_107ck170 FIND v(dout0_107) AT=90.025n

.meas tran vdout0_108ck170 FIND v(dout0_108) AT=90.025n

.meas tran vdout0_109ck170 FIND v(dout0_109) AT=90.025n

.meas tran vdout0_110ck170 FIND v(dout0_110) AT=90.025n

.meas tran vdout0_111ck170 FIND v(dout0_111) AT=90.025n

.meas tran vdout0_112ck170 FIND v(dout0_112) AT=90.025n

.meas tran vdout0_113ck170 FIND v(dout0_113) AT=90.025n

.meas tran vdout0_114ck170 FIND v(dout0_114) AT=90.025n

.meas tran vdout0_115ck170 FIND v(dout0_115) AT=90.025n

.meas tran vdout0_116ck170 FIND v(dout0_116) AT=90.025n

.meas tran vdout0_117ck170 FIND v(dout0_117) AT=90.025n

.meas tran vdout0_118ck170 FIND v(dout0_118) AT=90.025n

.meas tran vdout0_119ck170 FIND v(dout0_119) AT=90.025n

.meas tran vdout0_120ck170 FIND v(dout0_120) AT=90.025n

.meas tran vdout0_121ck170 FIND v(dout0_121) AT=90.025n

.meas tran vdout0_122ck170 FIND v(dout0_122) AT=90.025n

.meas tran vdout0_123ck170 FIND v(dout0_123) AT=90.025n

.meas tran vdout0_124ck170 FIND v(dout0_124) AT=90.025n

.meas tran vdout0_125ck170 FIND v(dout0_125) AT=90.025n

.meas tran vdout0_126ck170 FIND v(dout0_126) AT=90.025n

.meas tran vdout0_127ck170 FIND v(dout0_127) AT=90.025n

.meas tran vdout0_0ck230 FIND v(dout0_0) AT=120.025n

.meas tran vdout0_1ck230 FIND v(dout0_1) AT=120.025n

.meas tran vdout0_2ck230 FIND v(dout0_2) AT=120.025n

.meas tran vdout0_3ck230 FIND v(dout0_3) AT=120.025n

.meas tran vdout0_4ck230 FIND v(dout0_4) AT=120.025n

.meas tran vdout0_5ck230 FIND v(dout0_5) AT=120.025n

.meas tran vdout0_6ck230 FIND v(dout0_6) AT=120.025n

.meas tran vdout0_7ck230 FIND v(dout0_7) AT=120.025n

.meas tran vdout0_8ck230 FIND v(dout0_8) AT=120.025n

.meas tran vdout0_9ck230 FIND v(dout0_9) AT=120.025n

.meas tran vdout0_10ck230 FIND v(dout0_10) AT=120.025n

.meas tran vdout0_11ck230 FIND v(dout0_11) AT=120.025n

.meas tran vdout0_12ck230 FIND v(dout0_12) AT=120.025n

.meas tran vdout0_13ck230 FIND v(dout0_13) AT=120.025n

.meas tran vdout0_14ck230 FIND v(dout0_14) AT=120.025n

.meas tran vdout0_15ck230 FIND v(dout0_15) AT=120.025n

.meas tran vdout0_16ck230 FIND v(dout0_16) AT=120.025n

.meas tran vdout0_17ck230 FIND v(dout0_17) AT=120.025n

.meas tran vdout0_18ck230 FIND v(dout0_18) AT=120.025n

.meas tran vdout0_19ck230 FIND v(dout0_19) AT=120.025n

.meas tran vdout0_20ck230 FIND v(dout0_20) AT=120.025n

.meas tran vdout0_21ck230 FIND v(dout0_21) AT=120.025n

.meas tran vdout0_22ck230 FIND v(dout0_22) AT=120.025n

.meas tran vdout0_23ck230 FIND v(dout0_23) AT=120.025n

.meas tran vdout0_24ck230 FIND v(dout0_24) AT=120.025n

.meas tran vdout0_25ck230 FIND v(dout0_25) AT=120.025n

.meas tran vdout0_26ck230 FIND v(dout0_26) AT=120.025n

.meas tran vdout0_27ck230 FIND v(dout0_27) AT=120.025n

.meas tran vdout0_28ck230 FIND v(dout0_28) AT=120.025n

.meas tran vdout0_29ck230 FIND v(dout0_29) AT=120.025n

.meas tran vdout0_30ck230 FIND v(dout0_30) AT=120.025n

.meas tran vdout0_31ck230 FIND v(dout0_31) AT=120.025n

.meas tran vdout0_32ck230 FIND v(dout0_32) AT=120.025n

.meas tran vdout0_33ck230 FIND v(dout0_33) AT=120.025n

.meas tran vdout0_34ck230 FIND v(dout0_34) AT=120.025n

.meas tran vdout0_35ck230 FIND v(dout0_35) AT=120.025n

.meas tran vdout0_36ck230 FIND v(dout0_36) AT=120.025n

.meas tran vdout0_37ck230 FIND v(dout0_37) AT=120.025n

.meas tran vdout0_38ck230 FIND v(dout0_38) AT=120.025n

.meas tran vdout0_39ck230 FIND v(dout0_39) AT=120.025n

.meas tran vdout0_40ck230 FIND v(dout0_40) AT=120.025n

.meas tran vdout0_41ck230 FIND v(dout0_41) AT=120.025n

.meas tran vdout0_42ck230 FIND v(dout0_42) AT=120.025n

.meas tran vdout0_43ck230 FIND v(dout0_43) AT=120.025n

.meas tran vdout0_44ck230 FIND v(dout0_44) AT=120.025n

.meas tran vdout0_45ck230 FIND v(dout0_45) AT=120.025n

.meas tran vdout0_46ck230 FIND v(dout0_46) AT=120.025n

.meas tran vdout0_47ck230 FIND v(dout0_47) AT=120.025n

.meas tran vdout0_48ck230 FIND v(dout0_48) AT=120.025n

.meas tran vdout0_49ck230 FIND v(dout0_49) AT=120.025n

.meas tran vdout0_50ck230 FIND v(dout0_50) AT=120.025n

.meas tran vdout0_51ck230 FIND v(dout0_51) AT=120.025n

.meas tran vdout0_52ck230 FIND v(dout0_52) AT=120.025n

.meas tran vdout0_53ck230 FIND v(dout0_53) AT=120.025n

.meas tran vdout0_54ck230 FIND v(dout0_54) AT=120.025n

.meas tran vdout0_55ck230 FIND v(dout0_55) AT=120.025n

.meas tran vdout0_56ck230 FIND v(dout0_56) AT=120.025n

.meas tran vdout0_57ck230 FIND v(dout0_57) AT=120.025n

.meas tran vdout0_58ck230 FIND v(dout0_58) AT=120.025n

.meas tran vdout0_59ck230 FIND v(dout0_59) AT=120.025n

.meas tran vdout0_60ck230 FIND v(dout0_60) AT=120.025n

.meas tran vdout0_61ck230 FIND v(dout0_61) AT=120.025n

.meas tran vdout0_62ck230 FIND v(dout0_62) AT=120.025n

.meas tran vdout0_63ck230 FIND v(dout0_63) AT=120.025n

.meas tran vdout0_64ck230 FIND v(dout0_64) AT=120.025n

.meas tran vdout0_65ck230 FIND v(dout0_65) AT=120.025n

.meas tran vdout0_66ck230 FIND v(dout0_66) AT=120.025n

.meas tran vdout0_67ck230 FIND v(dout0_67) AT=120.025n

.meas tran vdout0_68ck230 FIND v(dout0_68) AT=120.025n

.meas tran vdout0_69ck230 FIND v(dout0_69) AT=120.025n

.meas tran vdout0_70ck230 FIND v(dout0_70) AT=120.025n

.meas tran vdout0_71ck230 FIND v(dout0_71) AT=120.025n

.meas tran vdout0_72ck230 FIND v(dout0_72) AT=120.025n

.meas tran vdout0_73ck230 FIND v(dout0_73) AT=120.025n

.meas tran vdout0_74ck230 FIND v(dout0_74) AT=120.025n

.meas tran vdout0_75ck230 FIND v(dout0_75) AT=120.025n

.meas tran vdout0_76ck230 FIND v(dout0_76) AT=120.025n

.meas tran vdout0_77ck230 FIND v(dout0_77) AT=120.025n

.meas tran vdout0_78ck230 FIND v(dout0_78) AT=120.025n

.meas tran vdout0_79ck230 FIND v(dout0_79) AT=120.025n

.meas tran vdout0_80ck230 FIND v(dout0_80) AT=120.025n

.meas tran vdout0_81ck230 FIND v(dout0_81) AT=120.025n

.meas tran vdout0_82ck230 FIND v(dout0_82) AT=120.025n

.meas tran vdout0_83ck230 FIND v(dout0_83) AT=120.025n

.meas tran vdout0_84ck230 FIND v(dout0_84) AT=120.025n

.meas tran vdout0_85ck230 FIND v(dout0_85) AT=120.025n

.meas tran vdout0_86ck230 FIND v(dout0_86) AT=120.025n

.meas tran vdout0_87ck230 FIND v(dout0_87) AT=120.025n

.meas tran vdout0_88ck230 FIND v(dout0_88) AT=120.025n

.meas tran vdout0_89ck230 FIND v(dout0_89) AT=120.025n

.meas tran vdout0_90ck230 FIND v(dout0_90) AT=120.025n

.meas tran vdout0_91ck230 FIND v(dout0_91) AT=120.025n

.meas tran vdout0_92ck230 FIND v(dout0_92) AT=120.025n

.meas tran vdout0_93ck230 FIND v(dout0_93) AT=120.025n

.meas tran vdout0_94ck230 FIND v(dout0_94) AT=120.025n

.meas tran vdout0_95ck230 FIND v(dout0_95) AT=120.025n

.meas tran vdout0_96ck230 FIND v(dout0_96) AT=120.025n

.meas tran vdout0_97ck230 FIND v(dout0_97) AT=120.025n

.meas tran vdout0_98ck230 FIND v(dout0_98) AT=120.025n

.meas tran vdout0_99ck230 FIND v(dout0_99) AT=120.025n

.meas tran vdout0_100ck230 FIND v(dout0_100) AT=120.025n

.meas tran vdout0_101ck230 FIND v(dout0_101) AT=120.025n

.meas tran vdout0_102ck230 FIND v(dout0_102) AT=120.025n

.meas tran vdout0_103ck230 FIND v(dout0_103) AT=120.025n

.meas tran vdout0_104ck230 FIND v(dout0_104) AT=120.025n

.meas tran vdout0_105ck230 FIND v(dout0_105) AT=120.025n

.meas tran vdout0_106ck230 FIND v(dout0_106) AT=120.025n

.meas tran vdout0_107ck230 FIND v(dout0_107) AT=120.025n

.meas tran vdout0_108ck230 FIND v(dout0_108) AT=120.025n

.meas tran vdout0_109ck230 FIND v(dout0_109) AT=120.025n

.meas tran vdout0_110ck230 FIND v(dout0_110) AT=120.025n

.meas tran vdout0_111ck230 FIND v(dout0_111) AT=120.025n

.meas tran vdout0_112ck230 FIND v(dout0_112) AT=120.025n

.meas tran vdout0_113ck230 FIND v(dout0_113) AT=120.025n

.meas tran vdout0_114ck230 FIND v(dout0_114) AT=120.025n

.meas tran vdout0_115ck230 FIND v(dout0_115) AT=120.025n

.meas tran vdout0_116ck230 FIND v(dout0_116) AT=120.025n

.meas tran vdout0_117ck230 FIND v(dout0_117) AT=120.025n

.meas tran vdout0_118ck230 FIND v(dout0_118) AT=120.025n

.meas tran vdout0_119ck230 FIND v(dout0_119) AT=120.025n

.meas tran vdout0_120ck230 FIND v(dout0_120) AT=120.025n

.meas tran vdout0_121ck230 FIND v(dout0_121) AT=120.025n

.meas tran vdout0_122ck230 FIND v(dout0_122) AT=120.025n

.meas tran vdout0_123ck230 FIND v(dout0_123) AT=120.025n

.meas tran vdout0_124ck230 FIND v(dout0_124) AT=120.025n

.meas tran vdout0_125ck230 FIND v(dout0_125) AT=120.025n

.meas tran vdout0_126ck230 FIND v(dout0_126) AT=120.025n

.meas tran vdout0_127ck230 FIND v(dout0_127) AT=120.025n

.meas tran vdout0_0ck240 FIND v(dout0_0) AT=125.025n

.meas tran vdout0_1ck240 FIND v(dout0_1) AT=125.025n

.meas tran vdout0_2ck240 FIND v(dout0_2) AT=125.025n

.meas tran vdout0_3ck240 FIND v(dout0_3) AT=125.025n

.meas tran vdout0_4ck240 FIND v(dout0_4) AT=125.025n

.meas tran vdout0_5ck240 FIND v(dout0_5) AT=125.025n

.meas tran vdout0_6ck240 FIND v(dout0_6) AT=125.025n

.meas tran vdout0_7ck240 FIND v(dout0_7) AT=125.025n

.meas tran vdout0_8ck240 FIND v(dout0_8) AT=125.025n

.meas tran vdout0_9ck240 FIND v(dout0_9) AT=125.025n

.meas tran vdout0_10ck240 FIND v(dout0_10) AT=125.025n

.meas tran vdout0_11ck240 FIND v(dout0_11) AT=125.025n

.meas tran vdout0_12ck240 FIND v(dout0_12) AT=125.025n

.meas tran vdout0_13ck240 FIND v(dout0_13) AT=125.025n

.meas tran vdout0_14ck240 FIND v(dout0_14) AT=125.025n

.meas tran vdout0_15ck240 FIND v(dout0_15) AT=125.025n

.meas tran vdout0_16ck240 FIND v(dout0_16) AT=125.025n

.meas tran vdout0_17ck240 FIND v(dout0_17) AT=125.025n

.meas tran vdout0_18ck240 FIND v(dout0_18) AT=125.025n

.meas tran vdout0_19ck240 FIND v(dout0_19) AT=125.025n

.meas tran vdout0_20ck240 FIND v(dout0_20) AT=125.025n

.meas tran vdout0_21ck240 FIND v(dout0_21) AT=125.025n

.meas tran vdout0_22ck240 FIND v(dout0_22) AT=125.025n

.meas tran vdout0_23ck240 FIND v(dout0_23) AT=125.025n

.meas tran vdout0_24ck240 FIND v(dout0_24) AT=125.025n

.meas tran vdout0_25ck240 FIND v(dout0_25) AT=125.025n

.meas tran vdout0_26ck240 FIND v(dout0_26) AT=125.025n

.meas tran vdout0_27ck240 FIND v(dout0_27) AT=125.025n

.meas tran vdout0_28ck240 FIND v(dout0_28) AT=125.025n

.meas tran vdout0_29ck240 FIND v(dout0_29) AT=125.025n

.meas tran vdout0_30ck240 FIND v(dout0_30) AT=125.025n

.meas tran vdout0_31ck240 FIND v(dout0_31) AT=125.025n

.meas tran vdout0_32ck240 FIND v(dout0_32) AT=125.025n

.meas tran vdout0_33ck240 FIND v(dout0_33) AT=125.025n

.meas tran vdout0_34ck240 FIND v(dout0_34) AT=125.025n

.meas tran vdout0_35ck240 FIND v(dout0_35) AT=125.025n

.meas tran vdout0_36ck240 FIND v(dout0_36) AT=125.025n

.meas tran vdout0_37ck240 FIND v(dout0_37) AT=125.025n

.meas tran vdout0_38ck240 FIND v(dout0_38) AT=125.025n

.meas tran vdout0_39ck240 FIND v(dout0_39) AT=125.025n

.meas tran vdout0_40ck240 FIND v(dout0_40) AT=125.025n

.meas tran vdout0_41ck240 FIND v(dout0_41) AT=125.025n

.meas tran vdout0_42ck240 FIND v(dout0_42) AT=125.025n

.meas tran vdout0_43ck240 FIND v(dout0_43) AT=125.025n

.meas tran vdout0_44ck240 FIND v(dout0_44) AT=125.025n

.meas tran vdout0_45ck240 FIND v(dout0_45) AT=125.025n

.meas tran vdout0_46ck240 FIND v(dout0_46) AT=125.025n

.meas tran vdout0_47ck240 FIND v(dout0_47) AT=125.025n

.meas tran vdout0_48ck240 FIND v(dout0_48) AT=125.025n

.meas tran vdout0_49ck240 FIND v(dout0_49) AT=125.025n

.meas tran vdout0_50ck240 FIND v(dout0_50) AT=125.025n

.meas tran vdout0_51ck240 FIND v(dout0_51) AT=125.025n

.meas tran vdout0_52ck240 FIND v(dout0_52) AT=125.025n

.meas tran vdout0_53ck240 FIND v(dout0_53) AT=125.025n

.meas tran vdout0_54ck240 FIND v(dout0_54) AT=125.025n

.meas tran vdout0_55ck240 FIND v(dout0_55) AT=125.025n

.meas tran vdout0_56ck240 FIND v(dout0_56) AT=125.025n

.meas tran vdout0_57ck240 FIND v(dout0_57) AT=125.025n

.meas tran vdout0_58ck240 FIND v(dout0_58) AT=125.025n

.meas tran vdout0_59ck240 FIND v(dout0_59) AT=125.025n

.meas tran vdout0_60ck240 FIND v(dout0_60) AT=125.025n

.meas tran vdout0_61ck240 FIND v(dout0_61) AT=125.025n

.meas tran vdout0_62ck240 FIND v(dout0_62) AT=125.025n

.meas tran vdout0_63ck240 FIND v(dout0_63) AT=125.025n

.meas tran vdout0_64ck240 FIND v(dout0_64) AT=125.025n

.meas tran vdout0_65ck240 FIND v(dout0_65) AT=125.025n

.meas tran vdout0_66ck240 FIND v(dout0_66) AT=125.025n

.meas tran vdout0_67ck240 FIND v(dout0_67) AT=125.025n

.meas tran vdout0_68ck240 FIND v(dout0_68) AT=125.025n

.meas tran vdout0_69ck240 FIND v(dout0_69) AT=125.025n

.meas tran vdout0_70ck240 FIND v(dout0_70) AT=125.025n

.meas tran vdout0_71ck240 FIND v(dout0_71) AT=125.025n

.meas tran vdout0_72ck240 FIND v(dout0_72) AT=125.025n

.meas tran vdout0_73ck240 FIND v(dout0_73) AT=125.025n

.meas tran vdout0_74ck240 FIND v(dout0_74) AT=125.025n

.meas tran vdout0_75ck240 FIND v(dout0_75) AT=125.025n

.meas tran vdout0_76ck240 FIND v(dout0_76) AT=125.025n

.meas tran vdout0_77ck240 FIND v(dout0_77) AT=125.025n

.meas tran vdout0_78ck240 FIND v(dout0_78) AT=125.025n

.meas tran vdout0_79ck240 FIND v(dout0_79) AT=125.025n

.meas tran vdout0_80ck240 FIND v(dout0_80) AT=125.025n

.meas tran vdout0_81ck240 FIND v(dout0_81) AT=125.025n

.meas tran vdout0_82ck240 FIND v(dout0_82) AT=125.025n

.meas tran vdout0_83ck240 FIND v(dout0_83) AT=125.025n

.meas tran vdout0_84ck240 FIND v(dout0_84) AT=125.025n

.meas tran vdout0_85ck240 FIND v(dout0_85) AT=125.025n

.meas tran vdout0_86ck240 FIND v(dout0_86) AT=125.025n

.meas tran vdout0_87ck240 FIND v(dout0_87) AT=125.025n

.meas tran vdout0_88ck240 FIND v(dout0_88) AT=125.025n

.meas tran vdout0_89ck240 FIND v(dout0_89) AT=125.025n

.meas tran vdout0_90ck240 FIND v(dout0_90) AT=125.025n

.meas tran vdout0_91ck240 FIND v(dout0_91) AT=125.025n

.meas tran vdout0_92ck240 FIND v(dout0_92) AT=125.025n

.meas tran vdout0_93ck240 FIND v(dout0_93) AT=125.025n

.meas tran vdout0_94ck240 FIND v(dout0_94) AT=125.025n

.meas tran vdout0_95ck240 FIND v(dout0_95) AT=125.025n

.meas tran vdout0_96ck240 FIND v(dout0_96) AT=125.025n

.meas tran vdout0_97ck240 FIND v(dout0_97) AT=125.025n

.meas tran vdout0_98ck240 FIND v(dout0_98) AT=125.025n

.meas tran vdout0_99ck240 FIND v(dout0_99) AT=125.025n

.meas tran vdout0_100ck240 FIND v(dout0_100) AT=125.025n

.meas tran vdout0_101ck240 FIND v(dout0_101) AT=125.025n

.meas tran vdout0_102ck240 FIND v(dout0_102) AT=125.025n

.meas tran vdout0_103ck240 FIND v(dout0_103) AT=125.025n

.meas tran vdout0_104ck240 FIND v(dout0_104) AT=125.025n

.meas tran vdout0_105ck240 FIND v(dout0_105) AT=125.025n

.meas tran vdout0_106ck240 FIND v(dout0_106) AT=125.025n

.meas tran vdout0_107ck240 FIND v(dout0_107) AT=125.025n

.meas tran vdout0_108ck240 FIND v(dout0_108) AT=125.025n

.meas tran vdout0_109ck240 FIND v(dout0_109) AT=125.025n

.meas tran vdout0_110ck240 FIND v(dout0_110) AT=125.025n

.meas tran vdout0_111ck240 FIND v(dout0_111) AT=125.025n

.meas tran vdout0_112ck240 FIND v(dout0_112) AT=125.025n

.meas tran vdout0_113ck240 FIND v(dout0_113) AT=125.025n

.meas tran vdout0_114ck240 FIND v(dout0_114) AT=125.025n

.meas tran vdout0_115ck240 FIND v(dout0_115) AT=125.025n

.meas tran vdout0_116ck240 FIND v(dout0_116) AT=125.025n

.meas tran vdout0_117ck240 FIND v(dout0_117) AT=125.025n

.meas tran vdout0_118ck240 FIND v(dout0_118) AT=125.025n

.meas tran vdout0_119ck240 FIND v(dout0_119) AT=125.025n

.meas tran vdout0_120ck240 FIND v(dout0_120) AT=125.025n

.meas tran vdout0_121ck240 FIND v(dout0_121) AT=125.025n

.meas tran vdout0_122ck240 FIND v(dout0_122) AT=125.025n

.meas tran vdout0_123ck240 FIND v(dout0_123) AT=125.025n

.meas tran vdout0_124ck240 FIND v(dout0_124) AT=125.025n

.meas tran vdout0_125ck240 FIND v(dout0_125) AT=125.025n

.meas tran vdout0_126ck240 FIND v(dout0_126) AT=125.025n

.meas tran vdout0_127ck240 FIND v(dout0_127) AT=125.025n

.meas tran vdout0_0ck280 FIND v(dout0_0) AT=145.025n

.meas tran vdout0_1ck280 FIND v(dout0_1) AT=145.025n

.meas tran vdout0_2ck280 FIND v(dout0_2) AT=145.025n

.meas tran vdout0_3ck280 FIND v(dout0_3) AT=145.025n

.meas tran vdout0_4ck280 FIND v(dout0_4) AT=145.025n

.meas tran vdout0_5ck280 FIND v(dout0_5) AT=145.025n

.meas tran vdout0_6ck280 FIND v(dout0_6) AT=145.025n

.meas tran vdout0_7ck280 FIND v(dout0_7) AT=145.025n

.meas tran vdout0_8ck280 FIND v(dout0_8) AT=145.025n

.meas tran vdout0_9ck280 FIND v(dout0_9) AT=145.025n

.meas tran vdout0_10ck280 FIND v(dout0_10) AT=145.025n

.meas tran vdout0_11ck280 FIND v(dout0_11) AT=145.025n

.meas tran vdout0_12ck280 FIND v(dout0_12) AT=145.025n

.meas tran vdout0_13ck280 FIND v(dout0_13) AT=145.025n

.meas tran vdout0_14ck280 FIND v(dout0_14) AT=145.025n

.meas tran vdout0_15ck280 FIND v(dout0_15) AT=145.025n

.meas tran vdout0_16ck280 FIND v(dout0_16) AT=145.025n

.meas tran vdout0_17ck280 FIND v(dout0_17) AT=145.025n

.meas tran vdout0_18ck280 FIND v(dout0_18) AT=145.025n

.meas tran vdout0_19ck280 FIND v(dout0_19) AT=145.025n

.meas tran vdout0_20ck280 FIND v(dout0_20) AT=145.025n

.meas tran vdout0_21ck280 FIND v(dout0_21) AT=145.025n

.meas tran vdout0_22ck280 FIND v(dout0_22) AT=145.025n

.meas tran vdout0_23ck280 FIND v(dout0_23) AT=145.025n

.meas tran vdout0_24ck280 FIND v(dout0_24) AT=145.025n

.meas tran vdout0_25ck280 FIND v(dout0_25) AT=145.025n

.meas tran vdout0_26ck280 FIND v(dout0_26) AT=145.025n

.meas tran vdout0_27ck280 FIND v(dout0_27) AT=145.025n

.meas tran vdout0_28ck280 FIND v(dout0_28) AT=145.025n

.meas tran vdout0_29ck280 FIND v(dout0_29) AT=145.025n

.meas tran vdout0_30ck280 FIND v(dout0_30) AT=145.025n

.meas tran vdout0_31ck280 FIND v(dout0_31) AT=145.025n

.meas tran vdout0_32ck280 FIND v(dout0_32) AT=145.025n

.meas tran vdout0_33ck280 FIND v(dout0_33) AT=145.025n

.meas tran vdout0_34ck280 FIND v(dout0_34) AT=145.025n

.meas tran vdout0_35ck280 FIND v(dout0_35) AT=145.025n

.meas tran vdout0_36ck280 FIND v(dout0_36) AT=145.025n

.meas tran vdout0_37ck280 FIND v(dout0_37) AT=145.025n

.meas tran vdout0_38ck280 FIND v(dout0_38) AT=145.025n

.meas tran vdout0_39ck280 FIND v(dout0_39) AT=145.025n

.meas tran vdout0_40ck280 FIND v(dout0_40) AT=145.025n

.meas tran vdout0_41ck280 FIND v(dout0_41) AT=145.025n

.meas tran vdout0_42ck280 FIND v(dout0_42) AT=145.025n

.meas tran vdout0_43ck280 FIND v(dout0_43) AT=145.025n

.meas tran vdout0_44ck280 FIND v(dout0_44) AT=145.025n

.meas tran vdout0_45ck280 FIND v(dout0_45) AT=145.025n

.meas tran vdout0_46ck280 FIND v(dout0_46) AT=145.025n

.meas tran vdout0_47ck280 FIND v(dout0_47) AT=145.025n

.meas tran vdout0_48ck280 FIND v(dout0_48) AT=145.025n

.meas tran vdout0_49ck280 FIND v(dout0_49) AT=145.025n

.meas tran vdout0_50ck280 FIND v(dout0_50) AT=145.025n

.meas tran vdout0_51ck280 FIND v(dout0_51) AT=145.025n

.meas tran vdout0_52ck280 FIND v(dout0_52) AT=145.025n

.meas tran vdout0_53ck280 FIND v(dout0_53) AT=145.025n

.meas tran vdout0_54ck280 FIND v(dout0_54) AT=145.025n

.meas tran vdout0_55ck280 FIND v(dout0_55) AT=145.025n

.meas tran vdout0_56ck280 FIND v(dout0_56) AT=145.025n

.meas tran vdout0_57ck280 FIND v(dout0_57) AT=145.025n

.meas tran vdout0_58ck280 FIND v(dout0_58) AT=145.025n

.meas tran vdout0_59ck280 FIND v(dout0_59) AT=145.025n

.meas tran vdout0_60ck280 FIND v(dout0_60) AT=145.025n

.meas tran vdout0_61ck280 FIND v(dout0_61) AT=145.025n

.meas tran vdout0_62ck280 FIND v(dout0_62) AT=145.025n

.meas tran vdout0_63ck280 FIND v(dout0_63) AT=145.025n

.meas tran vdout0_64ck280 FIND v(dout0_64) AT=145.025n

.meas tran vdout0_65ck280 FIND v(dout0_65) AT=145.025n

.meas tran vdout0_66ck280 FIND v(dout0_66) AT=145.025n

.meas tran vdout0_67ck280 FIND v(dout0_67) AT=145.025n

.meas tran vdout0_68ck280 FIND v(dout0_68) AT=145.025n

.meas tran vdout0_69ck280 FIND v(dout0_69) AT=145.025n

.meas tran vdout0_70ck280 FIND v(dout0_70) AT=145.025n

.meas tran vdout0_71ck280 FIND v(dout0_71) AT=145.025n

.meas tran vdout0_72ck280 FIND v(dout0_72) AT=145.025n

.meas tran vdout0_73ck280 FIND v(dout0_73) AT=145.025n

.meas tran vdout0_74ck280 FIND v(dout0_74) AT=145.025n

.meas tran vdout0_75ck280 FIND v(dout0_75) AT=145.025n

.meas tran vdout0_76ck280 FIND v(dout0_76) AT=145.025n

.meas tran vdout0_77ck280 FIND v(dout0_77) AT=145.025n

.meas tran vdout0_78ck280 FIND v(dout0_78) AT=145.025n

.meas tran vdout0_79ck280 FIND v(dout0_79) AT=145.025n

.meas tran vdout0_80ck280 FIND v(dout0_80) AT=145.025n

.meas tran vdout0_81ck280 FIND v(dout0_81) AT=145.025n

.meas tran vdout0_82ck280 FIND v(dout0_82) AT=145.025n

.meas tran vdout0_83ck280 FIND v(dout0_83) AT=145.025n

.meas tran vdout0_84ck280 FIND v(dout0_84) AT=145.025n

.meas tran vdout0_85ck280 FIND v(dout0_85) AT=145.025n

.meas tran vdout0_86ck280 FIND v(dout0_86) AT=145.025n

.meas tran vdout0_87ck280 FIND v(dout0_87) AT=145.025n

.meas tran vdout0_88ck280 FIND v(dout0_88) AT=145.025n

.meas tran vdout0_89ck280 FIND v(dout0_89) AT=145.025n

.meas tran vdout0_90ck280 FIND v(dout0_90) AT=145.025n

.meas tran vdout0_91ck280 FIND v(dout0_91) AT=145.025n

.meas tran vdout0_92ck280 FIND v(dout0_92) AT=145.025n

.meas tran vdout0_93ck280 FIND v(dout0_93) AT=145.025n

.meas tran vdout0_94ck280 FIND v(dout0_94) AT=145.025n

.meas tran vdout0_95ck280 FIND v(dout0_95) AT=145.025n

.meas tran vdout0_96ck280 FIND v(dout0_96) AT=145.025n

.meas tran vdout0_97ck280 FIND v(dout0_97) AT=145.025n

.meas tran vdout0_98ck280 FIND v(dout0_98) AT=145.025n

.meas tran vdout0_99ck280 FIND v(dout0_99) AT=145.025n

.meas tran vdout0_100ck280 FIND v(dout0_100) AT=145.025n

.meas tran vdout0_101ck280 FIND v(dout0_101) AT=145.025n

.meas tran vdout0_102ck280 FIND v(dout0_102) AT=145.025n

.meas tran vdout0_103ck280 FIND v(dout0_103) AT=145.025n

.meas tran vdout0_104ck280 FIND v(dout0_104) AT=145.025n

.meas tran vdout0_105ck280 FIND v(dout0_105) AT=145.025n

.meas tran vdout0_106ck280 FIND v(dout0_106) AT=145.025n

.meas tran vdout0_107ck280 FIND v(dout0_107) AT=145.025n

.meas tran vdout0_108ck280 FIND v(dout0_108) AT=145.025n

.meas tran vdout0_109ck280 FIND v(dout0_109) AT=145.025n

.meas tran vdout0_110ck280 FIND v(dout0_110) AT=145.025n

.meas tran vdout0_111ck280 FIND v(dout0_111) AT=145.025n

.meas tran vdout0_112ck280 FIND v(dout0_112) AT=145.025n

.meas tran vdout0_113ck280 FIND v(dout0_113) AT=145.025n

.meas tran vdout0_114ck280 FIND v(dout0_114) AT=145.025n

.meas tran vdout0_115ck280 FIND v(dout0_115) AT=145.025n

.meas tran vdout0_116ck280 FIND v(dout0_116) AT=145.025n

.meas tran vdout0_117ck280 FIND v(dout0_117) AT=145.025n

.meas tran vdout0_118ck280 FIND v(dout0_118) AT=145.025n

.meas tran vdout0_119ck280 FIND v(dout0_119) AT=145.025n

.meas tran vdout0_120ck280 FIND v(dout0_120) AT=145.025n

.meas tran vdout0_121ck280 FIND v(dout0_121) AT=145.025n

.meas tran vdout0_122ck280 FIND v(dout0_122) AT=145.025n

.meas tran vdout0_123ck280 FIND v(dout0_123) AT=145.025n

.meas tran vdout0_124ck280 FIND v(dout0_124) AT=145.025n

.meas tran vdout0_125ck280 FIND v(dout0_125) AT=145.025n

.meas tran vdout0_126ck280 FIND v(dout0_126) AT=145.025n

.meas tran vdout0_127ck280 FIND v(dout0_127) AT=145.025n

.meas tran vdout0_0ck300 FIND v(dout0_0) AT=155.025n

.meas tran vdout0_1ck300 FIND v(dout0_1) AT=155.025n

.meas tran vdout0_2ck300 FIND v(dout0_2) AT=155.025n

.meas tran vdout0_3ck300 FIND v(dout0_3) AT=155.025n

.meas tran vdout0_4ck300 FIND v(dout0_4) AT=155.025n

.meas tran vdout0_5ck300 FIND v(dout0_5) AT=155.025n

.meas tran vdout0_6ck300 FIND v(dout0_6) AT=155.025n

.meas tran vdout0_7ck300 FIND v(dout0_7) AT=155.025n

.meas tran vdout0_8ck300 FIND v(dout0_8) AT=155.025n

.meas tran vdout0_9ck300 FIND v(dout0_9) AT=155.025n

.meas tran vdout0_10ck300 FIND v(dout0_10) AT=155.025n

.meas tran vdout0_11ck300 FIND v(dout0_11) AT=155.025n

.meas tran vdout0_12ck300 FIND v(dout0_12) AT=155.025n

.meas tran vdout0_13ck300 FIND v(dout0_13) AT=155.025n

.meas tran vdout0_14ck300 FIND v(dout0_14) AT=155.025n

.meas tran vdout0_15ck300 FIND v(dout0_15) AT=155.025n

.meas tran vdout0_16ck300 FIND v(dout0_16) AT=155.025n

.meas tran vdout0_17ck300 FIND v(dout0_17) AT=155.025n

.meas tran vdout0_18ck300 FIND v(dout0_18) AT=155.025n

.meas tran vdout0_19ck300 FIND v(dout0_19) AT=155.025n

.meas tran vdout0_20ck300 FIND v(dout0_20) AT=155.025n

.meas tran vdout0_21ck300 FIND v(dout0_21) AT=155.025n

.meas tran vdout0_22ck300 FIND v(dout0_22) AT=155.025n

.meas tran vdout0_23ck300 FIND v(dout0_23) AT=155.025n

.meas tran vdout0_24ck300 FIND v(dout0_24) AT=155.025n

.meas tran vdout0_25ck300 FIND v(dout0_25) AT=155.025n

.meas tran vdout0_26ck300 FIND v(dout0_26) AT=155.025n

.meas tran vdout0_27ck300 FIND v(dout0_27) AT=155.025n

.meas tran vdout0_28ck300 FIND v(dout0_28) AT=155.025n

.meas tran vdout0_29ck300 FIND v(dout0_29) AT=155.025n

.meas tran vdout0_30ck300 FIND v(dout0_30) AT=155.025n

.meas tran vdout0_31ck300 FIND v(dout0_31) AT=155.025n

.meas tran vdout0_32ck300 FIND v(dout0_32) AT=155.025n

.meas tran vdout0_33ck300 FIND v(dout0_33) AT=155.025n

.meas tran vdout0_34ck300 FIND v(dout0_34) AT=155.025n

.meas tran vdout0_35ck300 FIND v(dout0_35) AT=155.025n

.meas tran vdout0_36ck300 FIND v(dout0_36) AT=155.025n

.meas tran vdout0_37ck300 FIND v(dout0_37) AT=155.025n

.meas tran vdout0_38ck300 FIND v(dout0_38) AT=155.025n

.meas tran vdout0_39ck300 FIND v(dout0_39) AT=155.025n

.meas tran vdout0_40ck300 FIND v(dout0_40) AT=155.025n

.meas tran vdout0_41ck300 FIND v(dout0_41) AT=155.025n

.meas tran vdout0_42ck300 FIND v(dout0_42) AT=155.025n

.meas tran vdout0_43ck300 FIND v(dout0_43) AT=155.025n

.meas tran vdout0_44ck300 FIND v(dout0_44) AT=155.025n

.meas tran vdout0_45ck300 FIND v(dout0_45) AT=155.025n

.meas tran vdout0_46ck300 FIND v(dout0_46) AT=155.025n

.meas tran vdout0_47ck300 FIND v(dout0_47) AT=155.025n

.meas tran vdout0_48ck300 FIND v(dout0_48) AT=155.025n

.meas tran vdout0_49ck300 FIND v(dout0_49) AT=155.025n

.meas tran vdout0_50ck300 FIND v(dout0_50) AT=155.025n

.meas tran vdout0_51ck300 FIND v(dout0_51) AT=155.025n

.meas tran vdout0_52ck300 FIND v(dout0_52) AT=155.025n

.meas tran vdout0_53ck300 FIND v(dout0_53) AT=155.025n

.meas tran vdout0_54ck300 FIND v(dout0_54) AT=155.025n

.meas tran vdout0_55ck300 FIND v(dout0_55) AT=155.025n

.meas tran vdout0_56ck300 FIND v(dout0_56) AT=155.025n

.meas tran vdout0_57ck300 FIND v(dout0_57) AT=155.025n

.meas tran vdout0_58ck300 FIND v(dout0_58) AT=155.025n

.meas tran vdout0_59ck300 FIND v(dout0_59) AT=155.025n

.meas tran vdout0_60ck300 FIND v(dout0_60) AT=155.025n

.meas tran vdout0_61ck300 FIND v(dout0_61) AT=155.025n

.meas tran vdout0_62ck300 FIND v(dout0_62) AT=155.025n

.meas tran vdout0_63ck300 FIND v(dout0_63) AT=155.025n

.meas tran vdout0_64ck300 FIND v(dout0_64) AT=155.025n

.meas tran vdout0_65ck300 FIND v(dout0_65) AT=155.025n

.meas tran vdout0_66ck300 FIND v(dout0_66) AT=155.025n

.meas tran vdout0_67ck300 FIND v(dout0_67) AT=155.025n

.meas tran vdout0_68ck300 FIND v(dout0_68) AT=155.025n

.meas tran vdout0_69ck300 FIND v(dout0_69) AT=155.025n

.meas tran vdout0_70ck300 FIND v(dout0_70) AT=155.025n

.meas tran vdout0_71ck300 FIND v(dout0_71) AT=155.025n

.meas tran vdout0_72ck300 FIND v(dout0_72) AT=155.025n

.meas tran vdout0_73ck300 FIND v(dout0_73) AT=155.025n

.meas tran vdout0_74ck300 FIND v(dout0_74) AT=155.025n

.meas tran vdout0_75ck300 FIND v(dout0_75) AT=155.025n

.meas tran vdout0_76ck300 FIND v(dout0_76) AT=155.025n

.meas tran vdout0_77ck300 FIND v(dout0_77) AT=155.025n

.meas tran vdout0_78ck300 FIND v(dout0_78) AT=155.025n

.meas tran vdout0_79ck300 FIND v(dout0_79) AT=155.025n

.meas tran vdout0_80ck300 FIND v(dout0_80) AT=155.025n

.meas tran vdout0_81ck300 FIND v(dout0_81) AT=155.025n

.meas tran vdout0_82ck300 FIND v(dout0_82) AT=155.025n

.meas tran vdout0_83ck300 FIND v(dout0_83) AT=155.025n

.meas tran vdout0_84ck300 FIND v(dout0_84) AT=155.025n

.meas tran vdout0_85ck300 FIND v(dout0_85) AT=155.025n

.meas tran vdout0_86ck300 FIND v(dout0_86) AT=155.025n

.meas tran vdout0_87ck300 FIND v(dout0_87) AT=155.025n

.meas tran vdout0_88ck300 FIND v(dout0_88) AT=155.025n

.meas tran vdout0_89ck300 FIND v(dout0_89) AT=155.025n

.meas tran vdout0_90ck300 FIND v(dout0_90) AT=155.025n

.meas tran vdout0_91ck300 FIND v(dout0_91) AT=155.025n

.meas tran vdout0_92ck300 FIND v(dout0_92) AT=155.025n

.meas tran vdout0_93ck300 FIND v(dout0_93) AT=155.025n

.meas tran vdout0_94ck300 FIND v(dout0_94) AT=155.025n

.meas tran vdout0_95ck300 FIND v(dout0_95) AT=155.025n

.meas tran vdout0_96ck300 FIND v(dout0_96) AT=155.025n

.meas tran vdout0_97ck300 FIND v(dout0_97) AT=155.025n

.meas tran vdout0_98ck300 FIND v(dout0_98) AT=155.025n

.meas tran vdout0_99ck300 FIND v(dout0_99) AT=155.025n

.meas tran vdout0_100ck300 FIND v(dout0_100) AT=155.025n

.meas tran vdout0_101ck300 FIND v(dout0_101) AT=155.025n

.meas tran vdout0_102ck300 FIND v(dout0_102) AT=155.025n

.meas tran vdout0_103ck300 FIND v(dout0_103) AT=155.025n

.meas tran vdout0_104ck300 FIND v(dout0_104) AT=155.025n

.meas tran vdout0_105ck300 FIND v(dout0_105) AT=155.025n

.meas tran vdout0_106ck300 FIND v(dout0_106) AT=155.025n

.meas tran vdout0_107ck300 FIND v(dout0_107) AT=155.025n

.meas tran vdout0_108ck300 FIND v(dout0_108) AT=155.025n

.meas tran vdout0_109ck300 FIND v(dout0_109) AT=155.025n

.meas tran vdout0_110ck300 FIND v(dout0_110) AT=155.025n

.meas tran vdout0_111ck300 FIND v(dout0_111) AT=155.025n

.meas tran vdout0_112ck300 FIND v(dout0_112) AT=155.025n

.meas tran vdout0_113ck300 FIND v(dout0_113) AT=155.025n

.meas tran vdout0_114ck300 FIND v(dout0_114) AT=155.025n

.meas tran vdout0_115ck300 FIND v(dout0_115) AT=155.025n

.meas tran vdout0_116ck300 FIND v(dout0_116) AT=155.025n

.meas tran vdout0_117ck300 FIND v(dout0_117) AT=155.025n

.meas tran vdout0_118ck300 FIND v(dout0_118) AT=155.025n

.meas tran vdout0_119ck300 FIND v(dout0_119) AT=155.025n

.meas tran vdout0_120ck300 FIND v(dout0_120) AT=155.025n

.meas tran vdout0_121ck300 FIND v(dout0_121) AT=155.025n

.meas tran vdout0_122ck300 FIND v(dout0_122) AT=155.025n

.meas tran vdout0_123ck300 FIND v(dout0_123) AT=155.025n

.meas tran vdout0_124ck300 FIND v(dout0_124) AT=155.025n

.meas tran vdout0_125ck300 FIND v(dout0_125) AT=155.025n

.meas tran vdout0_126ck300 FIND v(dout0_126) AT=155.025n

.meas tran vdout0_127ck300 FIND v(dout0_127) AT=155.025n

.meas tran vdout0_0ck310 FIND v(dout0_0) AT=160.025n

.meas tran vdout0_1ck310 FIND v(dout0_1) AT=160.025n

.meas tran vdout0_2ck310 FIND v(dout0_2) AT=160.025n

.meas tran vdout0_3ck310 FIND v(dout0_3) AT=160.025n

.meas tran vdout0_4ck310 FIND v(dout0_4) AT=160.025n

.meas tran vdout0_5ck310 FIND v(dout0_5) AT=160.025n

.meas tran vdout0_6ck310 FIND v(dout0_6) AT=160.025n

.meas tran vdout0_7ck310 FIND v(dout0_7) AT=160.025n

.meas tran vdout0_8ck310 FIND v(dout0_8) AT=160.025n

.meas tran vdout0_9ck310 FIND v(dout0_9) AT=160.025n

.meas tran vdout0_10ck310 FIND v(dout0_10) AT=160.025n

.meas tran vdout0_11ck310 FIND v(dout0_11) AT=160.025n

.meas tran vdout0_12ck310 FIND v(dout0_12) AT=160.025n

.meas tran vdout0_13ck310 FIND v(dout0_13) AT=160.025n

.meas tran vdout0_14ck310 FIND v(dout0_14) AT=160.025n

.meas tran vdout0_15ck310 FIND v(dout0_15) AT=160.025n

.meas tran vdout0_16ck310 FIND v(dout0_16) AT=160.025n

.meas tran vdout0_17ck310 FIND v(dout0_17) AT=160.025n

.meas tran vdout0_18ck310 FIND v(dout0_18) AT=160.025n

.meas tran vdout0_19ck310 FIND v(dout0_19) AT=160.025n

.meas tran vdout0_20ck310 FIND v(dout0_20) AT=160.025n

.meas tran vdout0_21ck310 FIND v(dout0_21) AT=160.025n

.meas tran vdout0_22ck310 FIND v(dout0_22) AT=160.025n

.meas tran vdout0_23ck310 FIND v(dout0_23) AT=160.025n

.meas tran vdout0_24ck310 FIND v(dout0_24) AT=160.025n

.meas tran vdout0_25ck310 FIND v(dout0_25) AT=160.025n

.meas tran vdout0_26ck310 FIND v(dout0_26) AT=160.025n

.meas tran vdout0_27ck310 FIND v(dout0_27) AT=160.025n

.meas tran vdout0_28ck310 FIND v(dout0_28) AT=160.025n

.meas tran vdout0_29ck310 FIND v(dout0_29) AT=160.025n

.meas tran vdout0_30ck310 FIND v(dout0_30) AT=160.025n

.meas tran vdout0_31ck310 FIND v(dout0_31) AT=160.025n

.meas tran vdout0_32ck310 FIND v(dout0_32) AT=160.025n

.meas tran vdout0_33ck310 FIND v(dout0_33) AT=160.025n

.meas tran vdout0_34ck310 FIND v(dout0_34) AT=160.025n

.meas tran vdout0_35ck310 FIND v(dout0_35) AT=160.025n

.meas tran vdout0_36ck310 FIND v(dout0_36) AT=160.025n

.meas tran vdout0_37ck310 FIND v(dout0_37) AT=160.025n

.meas tran vdout0_38ck310 FIND v(dout0_38) AT=160.025n

.meas tran vdout0_39ck310 FIND v(dout0_39) AT=160.025n

.meas tran vdout0_40ck310 FIND v(dout0_40) AT=160.025n

.meas tran vdout0_41ck310 FIND v(dout0_41) AT=160.025n

.meas tran vdout0_42ck310 FIND v(dout0_42) AT=160.025n

.meas tran vdout0_43ck310 FIND v(dout0_43) AT=160.025n

.meas tran vdout0_44ck310 FIND v(dout0_44) AT=160.025n

.meas tran vdout0_45ck310 FIND v(dout0_45) AT=160.025n

.meas tran vdout0_46ck310 FIND v(dout0_46) AT=160.025n

.meas tran vdout0_47ck310 FIND v(dout0_47) AT=160.025n

.meas tran vdout0_48ck310 FIND v(dout0_48) AT=160.025n

.meas tran vdout0_49ck310 FIND v(dout0_49) AT=160.025n

.meas tran vdout0_50ck310 FIND v(dout0_50) AT=160.025n

.meas tran vdout0_51ck310 FIND v(dout0_51) AT=160.025n

.meas tran vdout0_52ck310 FIND v(dout0_52) AT=160.025n

.meas tran vdout0_53ck310 FIND v(dout0_53) AT=160.025n

.meas tran vdout0_54ck310 FIND v(dout0_54) AT=160.025n

.meas tran vdout0_55ck310 FIND v(dout0_55) AT=160.025n

.meas tran vdout0_56ck310 FIND v(dout0_56) AT=160.025n

.meas tran vdout0_57ck310 FIND v(dout0_57) AT=160.025n

.meas tran vdout0_58ck310 FIND v(dout0_58) AT=160.025n

.meas tran vdout0_59ck310 FIND v(dout0_59) AT=160.025n

.meas tran vdout0_60ck310 FIND v(dout0_60) AT=160.025n

.meas tran vdout0_61ck310 FIND v(dout0_61) AT=160.025n

.meas tran vdout0_62ck310 FIND v(dout0_62) AT=160.025n

.meas tran vdout0_63ck310 FIND v(dout0_63) AT=160.025n

.meas tran vdout0_64ck310 FIND v(dout0_64) AT=160.025n

.meas tran vdout0_65ck310 FIND v(dout0_65) AT=160.025n

.meas tran vdout0_66ck310 FIND v(dout0_66) AT=160.025n

.meas tran vdout0_67ck310 FIND v(dout0_67) AT=160.025n

.meas tran vdout0_68ck310 FIND v(dout0_68) AT=160.025n

.meas tran vdout0_69ck310 FIND v(dout0_69) AT=160.025n

.meas tran vdout0_70ck310 FIND v(dout0_70) AT=160.025n

.meas tran vdout0_71ck310 FIND v(dout0_71) AT=160.025n

.meas tran vdout0_72ck310 FIND v(dout0_72) AT=160.025n

.meas tran vdout0_73ck310 FIND v(dout0_73) AT=160.025n

.meas tran vdout0_74ck310 FIND v(dout0_74) AT=160.025n

.meas tran vdout0_75ck310 FIND v(dout0_75) AT=160.025n

.meas tran vdout0_76ck310 FIND v(dout0_76) AT=160.025n

.meas tran vdout0_77ck310 FIND v(dout0_77) AT=160.025n

.meas tran vdout0_78ck310 FIND v(dout0_78) AT=160.025n

.meas tran vdout0_79ck310 FIND v(dout0_79) AT=160.025n

.meas tran vdout0_80ck310 FIND v(dout0_80) AT=160.025n

.meas tran vdout0_81ck310 FIND v(dout0_81) AT=160.025n

.meas tran vdout0_82ck310 FIND v(dout0_82) AT=160.025n

.meas tran vdout0_83ck310 FIND v(dout0_83) AT=160.025n

.meas tran vdout0_84ck310 FIND v(dout0_84) AT=160.025n

.meas tran vdout0_85ck310 FIND v(dout0_85) AT=160.025n

.meas tran vdout0_86ck310 FIND v(dout0_86) AT=160.025n

.meas tran vdout0_87ck310 FIND v(dout0_87) AT=160.025n

.meas tran vdout0_88ck310 FIND v(dout0_88) AT=160.025n

.meas tran vdout0_89ck310 FIND v(dout0_89) AT=160.025n

.meas tran vdout0_90ck310 FIND v(dout0_90) AT=160.025n

.meas tran vdout0_91ck310 FIND v(dout0_91) AT=160.025n

.meas tran vdout0_92ck310 FIND v(dout0_92) AT=160.025n

.meas tran vdout0_93ck310 FIND v(dout0_93) AT=160.025n

.meas tran vdout0_94ck310 FIND v(dout0_94) AT=160.025n

.meas tran vdout0_95ck310 FIND v(dout0_95) AT=160.025n

.meas tran vdout0_96ck310 FIND v(dout0_96) AT=160.025n

.meas tran vdout0_97ck310 FIND v(dout0_97) AT=160.025n

.meas tran vdout0_98ck310 FIND v(dout0_98) AT=160.025n

.meas tran vdout0_99ck310 FIND v(dout0_99) AT=160.025n

.meas tran vdout0_100ck310 FIND v(dout0_100) AT=160.025n

.meas tran vdout0_101ck310 FIND v(dout0_101) AT=160.025n

.meas tran vdout0_102ck310 FIND v(dout0_102) AT=160.025n

.meas tran vdout0_103ck310 FIND v(dout0_103) AT=160.025n

.meas tran vdout0_104ck310 FIND v(dout0_104) AT=160.025n

.meas tran vdout0_105ck310 FIND v(dout0_105) AT=160.025n

.meas tran vdout0_106ck310 FIND v(dout0_106) AT=160.025n

.meas tran vdout0_107ck310 FIND v(dout0_107) AT=160.025n

.meas tran vdout0_108ck310 FIND v(dout0_108) AT=160.025n

.meas tran vdout0_109ck310 FIND v(dout0_109) AT=160.025n

.meas tran vdout0_110ck310 FIND v(dout0_110) AT=160.025n

.meas tran vdout0_111ck310 FIND v(dout0_111) AT=160.025n

.meas tran vdout0_112ck310 FIND v(dout0_112) AT=160.025n

.meas tran vdout0_113ck310 FIND v(dout0_113) AT=160.025n

.meas tran vdout0_114ck310 FIND v(dout0_114) AT=160.025n

.meas tran vdout0_115ck310 FIND v(dout0_115) AT=160.025n

.meas tran vdout0_116ck310 FIND v(dout0_116) AT=160.025n

.meas tran vdout0_117ck310 FIND v(dout0_117) AT=160.025n

.meas tran vdout0_118ck310 FIND v(dout0_118) AT=160.025n

.meas tran vdout0_119ck310 FIND v(dout0_119) AT=160.025n

.meas tran vdout0_120ck310 FIND v(dout0_120) AT=160.025n

.meas tran vdout0_121ck310 FIND v(dout0_121) AT=160.025n

.meas tran vdout0_122ck310 FIND v(dout0_122) AT=160.025n

.meas tran vdout0_123ck310 FIND v(dout0_123) AT=160.025n

.meas tran vdout0_124ck310 FIND v(dout0_124) AT=160.025n

.meas tran vdout0_125ck310 FIND v(dout0_125) AT=160.025n

.meas tran vdout0_126ck310 FIND v(dout0_126) AT=160.025n

.meas tran vdout0_127ck310 FIND v(dout0_127) AT=160.025n

.meas tran vdout0_0ck350 FIND v(dout0_0) AT=180.025n

.meas tran vdout0_1ck350 FIND v(dout0_1) AT=180.025n

.meas tran vdout0_2ck350 FIND v(dout0_2) AT=180.025n

.meas tran vdout0_3ck350 FIND v(dout0_3) AT=180.025n

.meas tran vdout0_4ck350 FIND v(dout0_4) AT=180.025n

.meas tran vdout0_5ck350 FIND v(dout0_5) AT=180.025n

.meas tran vdout0_6ck350 FIND v(dout0_6) AT=180.025n

.meas tran vdout0_7ck350 FIND v(dout0_7) AT=180.025n

.meas tran vdout0_8ck350 FIND v(dout0_8) AT=180.025n

.meas tran vdout0_9ck350 FIND v(dout0_9) AT=180.025n

.meas tran vdout0_10ck350 FIND v(dout0_10) AT=180.025n

.meas tran vdout0_11ck350 FIND v(dout0_11) AT=180.025n

.meas tran vdout0_12ck350 FIND v(dout0_12) AT=180.025n

.meas tran vdout0_13ck350 FIND v(dout0_13) AT=180.025n

.meas tran vdout0_14ck350 FIND v(dout0_14) AT=180.025n

.meas tran vdout0_15ck350 FIND v(dout0_15) AT=180.025n

.meas tran vdout0_16ck350 FIND v(dout0_16) AT=180.025n

.meas tran vdout0_17ck350 FIND v(dout0_17) AT=180.025n

.meas tran vdout0_18ck350 FIND v(dout0_18) AT=180.025n

.meas tran vdout0_19ck350 FIND v(dout0_19) AT=180.025n

.meas tran vdout0_20ck350 FIND v(dout0_20) AT=180.025n

.meas tran vdout0_21ck350 FIND v(dout0_21) AT=180.025n

.meas tran vdout0_22ck350 FIND v(dout0_22) AT=180.025n

.meas tran vdout0_23ck350 FIND v(dout0_23) AT=180.025n

.meas tran vdout0_24ck350 FIND v(dout0_24) AT=180.025n

.meas tran vdout0_25ck350 FIND v(dout0_25) AT=180.025n

.meas tran vdout0_26ck350 FIND v(dout0_26) AT=180.025n

.meas tran vdout0_27ck350 FIND v(dout0_27) AT=180.025n

.meas tran vdout0_28ck350 FIND v(dout0_28) AT=180.025n

.meas tran vdout0_29ck350 FIND v(dout0_29) AT=180.025n

.meas tran vdout0_30ck350 FIND v(dout0_30) AT=180.025n

.meas tran vdout0_31ck350 FIND v(dout0_31) AT=180.025n

.meas tran vdout0_32ck350 FIND v(dout0_32) AT=180.025n

.meas tran vdout0_33ck350 FIND v(dout0_33) AT=180.025n

.meas tran vdout0_34ck350 FIND v(dout0_34) AT=180.025n

.meas tran vdout0_35ck350 FIND v(dout0_35) AT=180.025n

.meas tran vdout0_36ck350 FIND v(dout0_36) AT=180.025n

.meas tran vdout0_37ck350 FIND v(dout0_37) AT=180.025n

.meas tran vdout0_38ck350 FIND v(dout0_38) AT=180.025n

.meas tran vdout0_39ck350 FIND v(dout0_39) AT=180.025n

.meas tran vdout0_40ck350 FIND v(dout0_40) AT=180.025n

.meas tran vdout0_41ck350 FIND v(dout0_41) AT=180.025n

.meas tran vdout0_42ck350 FIND v(dout0_42) AT=180.025n

.meas tran vdout0_43ck350 FIND v(dout0_43) AT=180.025n

.meas tran vdout0_44ck350 FIND v(dout0_44) AT=180.025n

.meas tran vdout0_45ck350 FIND v(dout0_45) AT=180.025n

.meas tran vdout0_46ck350 FIND v(dout0_46) AT=180.025n

.meas tran vdout0_47ck350 FIND v(dout0_47) AT=180.025n

.meas tran vdout0_48ck350 FIND v(dout0_48) AT=180.025n

.meas tran vdout0_49ck350 FIND v(dout0_49) AT=180.025n

.meas tran vdout0_50ck350 FIND v(dout0_50) AT=180.025n

.meas tran vdout0_51ck350 FIND v(dout0_51) AT=180.025n

.meas tran vdout0_52ck350 FIND v(dout0_52) AT=180.025n

.meas tran vdout0_53ck350 FIND v(dout0_53) AT=180.025n

.meas tran vdout0_54ck350 FIND v(dout0_54) AT=180.025n

.meas tran vdout0_55ck350 FIND v(dout0_55) AT=180.025n

.meas tran vdout0_56ck350 FIND v(dout0_56) AT=180.025n

.meas tran vdout0_57ck350 FIND v(dout0_57) AT=180.025n

.meas tran vdout0_58ck350 FIND v(dout0_58) AT=180.025n

.meas tran vdout0_59ck350 FIND v(dout0_59) AT=180.025n

.meas tran vdout0_60ck350 FIND v(dout0_60) AT=180.025n

.meas tran vdout0_61ck350 FIND v(dout0_61) AT=180.025n

.meas tran vdout0_62ck350 FIND v(dout0_62) AT=180.025n

.meas tran vdout0_63ck350 FIND v(dout0_63) AT=180.025n

.meas tran vdout0_64ck350 FIND v(dout0_64) AT=180.025n

.meas tran vdout0_65ck350 FIND v(dout0_65) AT=180.025n

.meas tran vdout0_66ck350 FIND v(dout0_66) AT=180.025n

.meas tran vdout0_67ck350 FIND v(dout0_67) AT=180.025n

.meas tran vdout0_68ck350 FIND v(dout0_68) AT=180.025n

.meas tran vdout0_69ck350 FIND v(dout0_69) AT=180.025n

.meas tran vdout0_70ck350 FIND v(dout0_70) AT=180.025n

.meas tran vdout0_71ck350 FIND v(dout0_71) AT=180.025n

.meas tran vdout0_72ck350 FIND v(dout0_72) AT=180.025n

.meas tran vdout0_73ck350 FIND v(dout0_73) AT=180.025n

.meas tran vdout0_74ck350 FIND v(dout0_74) AT=180.025n

.meas tran vdout0_75ck350 FIND v(dout0_75) AT=180.025n

.meas tran vdout0_76ck350 FIND v(dout0_76) AT=180.025n

.meas tran vdout0_77ck350 FIND v(dout0_77) AT=180.025n

.meas tran vdout0_78ck350 FIND v(dout0_78) AT=180.025n

.meas tran vdout0_79ck350 FIND v(dout0_79) AT=180.025n

.meas tran vdout0_80ck350 FIND v(dout0_80) AT=180.025n

.meas tran vdout0_81ck350 FIND v(dout0_81) AT=180.025n

.meas tran vdout0_82ck350 FIND v(dout0_82) AT=180.025n

.meas tran vdout0_83ck350 FIND v(dout0_83) AT=180.025n

.meas tran vdout0_84ck350 FIND v(dout0_84) AT=180.025n

.meas tran vdout0_85ck350 FIND v(dout0_85) AT=180.025n

.meas tran vdout0_86ck350 FIND v(dout0_86) AT=180.025n

.meas tran vdout0_87ck350 FIND v(dout0_87) AT=180.025n

.meas tran vdout0_88ck350 FIND v(dout0_88) AT=180.025n

.meas tran vdout0_89ck350 FIND v(dout0_89) AT=180.025n

.meas tran vdout0_90ck350 FIND v(dout0_90) AT=180.025n

.meas tran vdout0_91ck350 FIND v(dout0_91) AT=180.025n

.meas tran vdout0_92ck350 FIND v(dout0_92) AT=180.025n

.meas tran vdout0_93ck350 FIND v(dout0_93) AT=180.025n

.meas tran vdout0_94ck350 FIND v(dout0_94) AT=180.025n

.meas tran vdout0_95ck350 FIND v(dout0_95) AT=180.025n

.meas tran vdout0_96ck350 FIND v(dout0_96) AT=180.025n

.meas tran vdout0_97ck350 FIND v(dout0_97) AT=180.025n

.meas tran vdout0_98ck350 FIND v(dout0_98) AT=180.025n

.meas tran vdout0_99ck350 FIND v(dout0_99) AT=180.025n

.meas tran vdout0_100ck350 FIND v(dout0_100) AT=180.025n

.meas tran vdout0_101ck350 FIND v(dout0_101) AT=180.025n

.meas tran vdout0_102ck350 FIND v(dout0_102) AT=180.025n

.meas tran vdout0_103ck350 FIND v(dout0_103) AT=180.025n

.meas tran vdout0_104ck350 FIND v(dout0_104) AT=180.025n

.meas tran vdout0_105ck350 FIND v(dout0_105) AT=180.025n

.meas tran vdout0_106ck350 FIND v(dout0_106) AT=180.025n

.meas tran vdout0_107ck350 FIND v(dout0_107) AT=180.025n

.meas tran vdout0_108ck350 FIND v(dout0_108) AT=180.025n

.meas tran vdout0_109ck350 FIND v(dout0_109) AT=180.025n

.meas tran vdout0_110ck350 FIND v(dout0_110) AT=180.025n

.meas tran vdout0_111ck350 FIND v(dout0_111) AT=180.025n

.meas tran vdout0_112ck350 FIND v(dout0_112) AT=180.025n

.meas tran vdout0_113ck350 FIND v(dout0_113) AT=180.025n

.meas tran vdout0_114ck350 FIND v(dout0_114) AT=180.025n

.meas tran vdout0_115ck350 FIND v(dout0_115) AT=180.025n

.meas tran vdout0_116ck350 FIND v(dout0_116) AT=180.025n

.meas tran vdout0_117ck350 FIND v(dout0_117) AT=180.025n

.meas tran vdout0_118ck350 FIND v(dout0_118) AT=180.025n

.meas tran vdout0_119ck350 FIND v(dout0_119) AT=180.025n

.meas tran vdout0_120ck350 FIND v(dout0_120) AT=180.025n

.meas tran vdout0_121ck350 FIND v(dout0_121) AT=180.025n

.meas tran vdout0_122ck350 FIND v(dout0_122) AT=180.025n

.meas tran vdout0_123ck350 FIND v(dout0_123) AT=180.025n

.meas tran vdout0_124ck350 FIND v(dout0_124) AT=180.025n

.meas tran vdout0_125ck350 FIND v(dout0_125) AT=180.025n

.meas tran vdout0_126ck350 FIND v(dout0_126) AT=180.025n

.meas tran vdout0_127ck350 FIND v(dout0_127) AT=180.025n

.meas tran vdout0_0ck360 FIND v(dout0_0) AT=185.025n

.meas tran vdout0_1ck360 FIND v(dout0_1) AT=185.025n

.meas tran vdout0_2ck360 FIND v(dout0_2) AT=185.025n

.meas tran vdout0_3ck360 FIND v(dout0_3) AT=185.025n

.meas tran vdout0_4ck360 FIND v(dout0_4) AT=185.025n

.meas tran vdout0_5ck360 FIND v(dout0_5) AT=185.025n

.meas tran vdout0_6ck360 FIND v(dout0_6) AT=185.025n

.meas tran vdout0_7ck360 FIND v(dout0_7) AT=185.025n

.meas tran vdout0_8ck360 FIND v(dout0_8) AT=185.025n

.meas tran vdout0_9ck360 FIND v(dout0_9) AT=185.025n

.meas tran vdout0_10ck360 FIND v(dout0_10) AT=185.025n

.meas tran vdout0_11ck360 FIND v(dout0_11) AT=185.025n

.meas tran vdout0_12ck360 FIND v(dout0_12) AT=185.025n

.meas tran vdout0_13ck360 FIND v(dout0_13) AT=185.025n

.meas tran vdout0_14ck360 FIND v(dout0_14) AT=185.025n

.meas tran vdout0_15ck360 FIND v(dout0_15) AT=185.025n

.meas tran vdout0_16ck360 FIND v(dout0_16) AT=185.025n

.meas tran vdout0_17ck360 FIND v(dout0_17) AT=185.025n

.meas tran vdout0_18ck360 FIND v(dout0_18) AT=185.025n

.meas tran vdout0_19ck360 FIND v(dout0_19) AT=185.025n

.meas tran vdout0_20ck360 FIND v(dout0_20) AT=185.025n

.meas tran vdout0_21ck360 FIND v(dout0_21) AT=185.025n

.meas tran vdout0_22ck360 FIND v(dout0_22) AT=185.025n

.meas tran vdout0_23ck360 FIND v(dout0_23) AT=185.025n

.meas tran vdout0_24ck360 FIND v(dout0_24) AT=185.025n

.meas tran vdout0_25ck360 FIND v(dout0_25) AT=185.025n

.meas tran vdout0_26ck360 FIND v(dout0_26) AT=185.025n

.meas tran vdout0_27ck360 FIND v(dout0_27) AT=185.025n

.meas tran vdout0_28ck360 FIND v(dout0_28) AT=185.025n

.meas tran vdout0_29ck360 FIND v(dout0_29) AT=185.025n

.meas tran vdout0_30ck360 FIND v(dout0_30) AT=185.025n

.meas tran vdout0_31ck360 FIND v(dout0_31) AT=185.025n

.meas tran vdout0_32ck360 FIND v(dout0_32) AT=185.025n

.meas tran vdout0_33ck360 FIND v(dout0_33) AT=185.025n

.meas tran vdout0_34ck360 FIND v(dout0_34) AT=185.025n

.meas tran vdout0_35ck360 FIND v(dout0_35) AT=185.025n

.meas tran vdout0_36ck360 FIND v(dout0_36) AT=185.025n

.meas tran vdout0_37ck360 FIND v(dout0_37) AT=185.025n

.meas tran vdout0_38ck360 FIND v(dout0_38) AT=185.025n

.meas tran vdout0_39ck360 FIND v(dout0_39) AT=185.025n

.meas tran vdout0_40ck360 FIND v(dout0_40) AT=185.025n

.meas tran vdout0_41ck360 FIND v(dout0_41) AT=185.025n

.meas tran vdout0_42ck360 FIND v(dout0_42) AT=185.025n

.meas tran vdout0_43ck360 FIND v(dout0_43) AT=185.025n

.meas tran vdout0_44ck360 FIND v(dout0_44) AT=185.025n

.meas tran vdout0_45ck360 FIND v(dout0_45) AT=185.025n

.meas tran vdout0_46ck360 FIND v(dout0_46) AT=185.025n

.meas tran vdout0_47ck360 FIND v(dout0_47) AT=185.025n

.meas tran vdout0_48ck360 FIND v(dout0_48) AT=185.025n

.meas tran vdout0_49ck360 FIND v(dout0_49) AT=185.025n

.meas tran vdout0_50ck360 FIND v(dout0_50) AT=185.025n

.meas tran vdout0_51ck360 FIND v(dout0_51) AT=185.025n

.meas tran vdout0_52ck360 FIND v(dout0_52) AT=185.025n

.meas tran vdout0_53ck360 FIND v(dout0_53) AT=185.025n

.meas tran vdout0_54ck360 FIND v(dout0_54) AT=185.025n

.meas tran vdout0_55ck360 FIND v(dout0_55) AT=185.025n

.meas tran vdout0_56ck360 FIND v(dout0_56) AT=185.025n

.meas tran vdout0_57ck360 FIND v(dout0_57) AT=185.025n

.meas tran vdout0_58ck360 FIND v(dout0_58) AT=185.025n

.meas tran vdout0_59ck360 FIND v(dout0_59) AT=185.025n

.meas tran vdout0_60ck360 FIND v(dout0_60) AT=185.025n

.meas tran vdout0_61ck360 FIND v(dout0_61) AT=185.025n

.meas tran vdout0_62ck360 FIND v(dout0_62) AT=185.025n

.meas tran vdout0_63ck360 FIND v(dout0_63) AT=185.025n

.meas tran vdout0_64ck360 FIND v(dout0_64) AT=185.025n

.meas tran vdout0_65ck360 FIND v(dout0_65) AT=185.025n

.meas tran vdout0_66ck360 FIND v(dout0_66) AT=185.025n

.meas tran vdout0_67ck360 FIND v(dout0_67) AT=185.025n

.meas tran vdout0_68ck360 FIND v(dout0_68) AT=185.025n

.meas tran vdout0_69ck360 FIND v(dout0_69) AT=185.025n

.meas tran vdout0_70ck360 FIND v(dout0_70) AT=185.025n

.meas tran vdout0_71ck360 FIND v(dout0_71) AT=185.025n

.meas tran vdout0_72ck360 FIND v(dout0_72) AT=185.025n

.meas tran vdout0_73ck360 FIND v(dout0_73) AT=185.025n

.meas tran vdout0_74ck360 FIND v(dout0_74) AT=185.025n

.meas tran vdout0_75ck360 FIND v(dout0_75) AT=185.025n

.meas tran vdout0_76ck360 FIND v(dout0_76) AT=185.025n

.meas tran vdout0_77ck360 FIND v(dout0_77) AT=185.025n

.meas tran vdout0_78ck360 FIND v(dout0_78) AT=185.025n

.meas tran vdout0_79ck360 FIND v(dout0_79) AT=185.025n

.meas tran vdout0_80ck360 FIND v(dout0_80) AT=185.025n

.meas tran vdout0_81ck360 FIND v(dout0_81) AT=185.025n

.meas tran vdout0_82ck360 FIND v(dout0_82) AT=185.025n

.meas tran vdout0_83ck360 FIND v(dout0_83) AT=185.025n

.meas tran vdout0_84ck360 FIND v(dout0_84) AT=185.025n

.meas tran vdout0_85ck360 FIND v(dout0_85) AT=185.025n

.meas tran vdout0_86ck360 FIND v(dout0_86) AT=185.025n

.meas tran vdout0_87ck360 FIND v(dout0_87) AT=185.025n

.meas tran vdout0_88ck360 FIND v(dout0_88) AT=185.025n

.meas tran vdout0_89ck360 FIND v(dout0_89) AT=185.025n

.meas tran vdout0_90ck360 FIND v(dout0_90) AT=185.025n

.meas tran vdout0_91ck360 FIND v(dout0_91) AT=185.025n

.meas tran vdout0_92ck360 FIND v(dout0_92) AT=185.025n

.meas tran vdout0_93ck360 FIND v(dout0_93) AT=185.025n

.meas tran vdout0_94ck360 FIND v(dout0_94) AT=185.025n

.meas tran vdout0_95ck360 FIND v(dout0_95) AT=185.025n

.meas tran vdout0_96ck360 FIND v(dout0_96) AT=185.025n

.meas tran vdout0_97ck360 FIND v(dout0_97) AT=185.025n

.meas tran vdout0_98ck360 FIND v(dout0_98) AT=185.025n

.meas tran vdout0_99ck360 FIND v(dout0_99) AT=185.025n

.meas tran vdout0_100ck360 FIND v(dout0_100) AT=185.025n

.meas tran vdout0_101ck360 FIND v(dout0_101) AT=185.025n

.meas tran vdout0_102ck360 FIND v(dout0_102) AT=185.025n

.meas tran vdout0_103ck360 FIND v(dout0_103) AT=185.025n

.meas tran vdout0_104ck360 FIND v(dout0_104) AT=185.025n

.meas tran vdout0_105ck360 FIND v(dout0_105) AT=185.025n

.meas tran vdout0_106ck360 FIND v(dout0_106) AT=185.025n

.meas tran vdout0_107ck360 FIND v(dout0_107) AT=185.025n

.meas tran vdout0_108ck360 FIND v(dout0_108) AT=185.025n

.meas tran vdout0_109ck360 FIND v(dout0_109) AT=185.025n

.meas tran vdout0_110ck360 FIND v(dout0_110) AT=185.025n

.meas tran vdout0_111ck360 FIND v(dout0_111) AT=185.025n

.meas tran vdout0_112ck360 FIND v(dout0_112) AT=185.025n

.meas tran vdout0_113ck360 FIND v(dout0_113) AT=185.025n

.meas tran vdout0_114ck360 FIND v(dout0_114) AT=185.025n

.meas tran vdout0_115ck360 FIND v(dout0_115) AT=185.025n

.meas tran vdout0_116ck360 FIND v(dout0_116) AT=185.025n

.meas tran vdout0_117ck360 FIND v(dout0_117) AT=185.025n

.meas tran vdout0_118ck360 FIND v(dout0_118) AT=185.025n

.meas tran vdout0_119ck360 FIND v(dout0_119) AT=185.025n

.meas tran vdout0_120ck360 FIND v(dout0_120) AT=185.025n

.meas tran vdout0_121ck360 FIND v(dout0_121) AT=185.025n

.meas tran vdout0_122ck360 FIND v(dout0_122) AT=185.025n

.meas tran vdout0_123ck360 FIND v(dout0_123) AT=185.025n

.meas tran vdout0_124ck360 FIND v(dout0_124) AT=185.025n

.meas tran vdout0_125ck360 FIND v(dout0_125) AT=185.025n

.meas tran vdout0_126ck360 FIND v(dout0_126) AT=185.025n

.meas tran vdout0_127ck360 FIND v(dout0_127) AT=185.025n

.meas tran vdout0_0ck380 FIND v(dout0_0) AT=195.025n

.meas tran vdout0_1ck380 FIND v(dout0_1) AT=195.025n

.meas tran vdout0_2ck380 FIND v(dout0_2) AT=195.025n

.meas tran vdout0_3ck380 FIND v(dout0_3) AT=195.025n

.meas tran vdout0_4ck380 FIND v(dout0_4) AT=195.025n

.meas tran vdout0_5ck380 FIND v(dout0_5) AT=195.025n

.meas tran vdout0_6ck380 FIND v(dout0_6) AT=195.025n

.meas tran vdout0_7ck380 FIND v(dout0_7) AT=195.025n

.meas tran vdout0_8ck380 FIND v(dout0_8) AT=195.025n

.meas tran vdout0_9ck380 FIND v(dout0_9) AT=195.025n

.meas tran vdout0_10ck380 FIND v(dout0_10) AT=195.025n

.meas tran vdout0_11ck380 FIND v(dout0_11) AT=195.025n

.meas tran vdout0_12ck380 FIND v(dout0_12) AT=195.025n

.meas tran vdout0_13ck380 FIND v(dout0_13) AT=195.025n

.meas tran vdout0_14ck380 FIND v(dout0_14) AT=195.025n

.meas tran vdout0_15ck380 FIND v(dout0_15) AT=195.025n

.meas tran vdout0_16ck380 FIND v(dout0_16) AT=195.025n

.meas tran vdout0_17ck380 FIND v(dout0_17) AT=195.025n

.meas tran vdout0_18ck380 FIND v(dout0_18) AT=195.025n

.meas tran vdout0_19ck380 FIND v(dout0_19) AT=195.025n

.meas tran vdout0_20ck380 FIND v(dout0_20) AT=195.025n

.meas tran vdout0_21ck380 FIND v(dout0_21) AT=195.025n

.meas tran vdout0_22ck380 FIND v(dout0_22) AT=195.025n

.meas tran vdout0_23ck380 FIND v(dout0_23) AT=195.025n

.meas tran vdout0_24ck380 FIND v(dout0_24) AT=195.025n

.meas tran vdout0_25ck380 FIND v(dout0_25) AT=195.025n

.meas tran vdout0_26ck380 FIND v(dout0_26) AT=195.025n

.meas tran vdout0_27ck380 FIND v(dout0_27) AT=195.025n

.meas tran vdout0_28ck380 FIND v(dout0_28) AT=195.025n

.meas tran vdout0_29ck380 FIND v(dout0_29) AT=195.025n

.meas tran vdout0_30ck380 FIND v(dout0_30) AT=195.025n

.meas tran vdout0_31ck380 FIND v(dout0_31) AT=195.025n

.meas tran vdout0_32ck380 FIND v(dout0_32) AT=195.025n

.meas tran vdout0_33ck380 FIND v(dout0_33) AT=195.025n

.meas tran vdout0_34ck380 FIND v(dout0_34) AT=195.025n

.meas tran vdout0_35ck380 FIND v(dout0_35) AT=195.025n

.meas tran vdout0_36ck380 FIND v(dout0_36) AT=195.025n

.meas tran vdout0_37ck380 FIND v(dout0_37) AT=195.025n

.meas tran vdout0_38ck380 FIND v(dout0_38) AT=195.025n

.meas tran vdout0_39ck380 FIND v(dout0_39) AT=195.025n

.meas tran vdout0_40ck380 FIND v(dout0_40) AT=195.025n

.meas tran vdout0_41ck380 FIND v(dout0_41) AT=195.025n

.meas tran vdout0_42ck380 FIND v(dout0_42) AT=195.025n

.meas tran vdout0_43ck380 FIND v(dout0_43) AT=195.025n

.meas tran vdout0_44ck380 FIND v(dout0_44) AT=195.025n

.meas tran vdout0_45ck380 FIND v(dout0_45) AT=195.025n

.meas tran vdout0_46ck380 FIND v(dout0_46) AT=195.025n

.meas tran vdout0_47ck380 FIND v(dout0_47) AT=195.025n

.meas tran vdout0_48ck380 FIND v(dout0_48) AT=195.025n

.meas tran vdout0_49ck380 FIND v(dout0_49) AT=195.025n

.meas tran vdout0_50ck380 FIND v(dout0_50) AT=195.025n

.meas tran vdout0_51ck380 FIND v(dout0_51) AT=195.025n

.meas tran vdout0_52ck380 FIND v(dout0_52) AT=195.025n

.meas tran vdout0_53ck380 FIND v(dout0_53) AT=195.025n

.meas tran vdout0_54ck380 FIND v(dout0_54) AT=195.025n

.meas tran vdout0_55ck380 FIND v(dout0_55) AT=195.025n

.meas tran vdout0_56ck380 FIND v(dout0_56) AT=195.025n

.meas tran vdout0_57ck380 FIND v(dout0_57) AT=195.025n

.meas tran vdout0_58ck380 FIND v(dout0_58) AT=195.025n

.meas tran vdout0_59ck380 FIND v(dout0_59) AT=195.025n

.meas tran vdout0_60ck380 FIND v(dout0_60) AT=195.025n

.meas tran vdout0_61ck380 FIND v(dout0_61) AT=195.025n

.meas tran vdout0_62ck380 FIND v(dout0_62) AT=195.025n

.meas tran vdout0_63ck380 FIND v(dout0_63) AT=195.025n

.meas tran vdout0_64ck380 FIND v(dout0_64) AT=195.025n

.meas tran vdout0_65ck380 FIND v(dout0_65) AT=195.025n

.meas tran vdout0_66ck380 FIND v(dout0_66) AT=195.025n

.meas tran vdout0_67ck380 FIND v(dout0_67) AT=195.025n

.meas tran vdout0_68ck380 FIND v(dout0_68) AT=195.025n

.meas tran vdout0_69ck380 FIND v(dout0_69) AT=195.025n

.meas tran vdout0_70ck380 FIND v(dout0_70) AT=195.025n

.meas tran vdout0_71ck380 FIND v(dout0_71) AT=195.025n

.meas tran vdout0_72ck380 FIND v(dout0_72) AT=195.025n

.meas tran vdout0_73ck380 FIND v(dout0_73) AT=195.025n

.meas tran vdout0_74ck380 FIND v(dout0_74) AT=195.025n

.meas tran vdout0_75ck380 FIND v(dout0_75) AT=195.025n

.meas tran vdout0_76ck380 FIND v(dout0_76) AT=195.025n

.meas tran vdout0_77ck380 FIND v(dout0_77) AT=195.025n

.meas tran vdout0_78ck380 FIND v(dout0_78) AT=195.025n

.meas tran vdout0_79ck380 FIND v(dout0_79) AT=195.025n

.meas tran vdout0_80ck380 FIND v(dout0_80) AT=195.025n

.meas tran vdout0_81ck380 FIND v(dout0_81) AT=195.025n

.meas tran vdout0_82ck380 FIND v(dout0_82) AT=195.025n

.meas tran vdout0_83ck380 FIND v(dout0_83) AT=195.025n

.meas tran vdout0_84ck380 FIND v(dout0_84) AT=195.025n

.meas tran vdout0_85ck380 FIND v(dout0_85) AT=195.025n

.meas tran vdout0_86ck380 FIND v(dout0_86) AT=195.025n

.meas tran vdout0_87ck380 FIND v(dout0_87) AT=195.025n

.meas tran vdout0_88ck380 FIND v(dout0_88) AT=195.025n

.meas tran vdout0_89ck380 FIND v(dout0_89) AT=195.025n

.meas tran vdout0_90ck380 FIND v(dout0_90) AT=195.025n

.meas tran vdout0_91ck380 FIND v(dout0_91) AT=195.025n

.meas tran vdout0_92ck380 FIND v(dout0_92) AT=195.025n

.meas tran vdout0_93ck380 FIND v(dout0_93) AT=195.025n

.meas tran vdout0_94ck380 FIND v(dout0_94) AT=195.025n

.meas tran vdout0_95ck380 FIND v(dout0_95) AT=195.025n

.meas tran vdout0_96ck380 FIND v(dout0_96) AT=195.025n

.meas tran vdout0_97ck380 FIND v(dout0_97) AT=195.025n

.meas tran vdout0_98ck380 FIND v(dout0_98) AT=195.025n

.meas tran vdout0_99ck380 FIND v(dout0_99) AT=195.025n

.meas tran vdout0_100ck380 FIND v(dout0_100) AT=195.025n

.meas tran vdout0_101ck380 FIND v(dout0_101) AT=195.025n

.meas tran vdout0_102ck380 FIND v(dout0_102) AT=195.025n

.meas tran vdout0_103ck380 FIND v(dout0_103) AT=195.025n

.meas tran vdout0_104ck380 FIND v(dout0_104) AT=195.025n

.meas tran vdout0_105ck380 FIND v(dout0_105) AT=195.025n

.meas tran vdout0_106ck380 FIND v(dout0_106) AT=195.025n

.meas tran vdout0_107ck380 FIND v(dout0_107) AT=195.025n

.meas tran vdout0_108ck380 FIND v(dout0_108) AT=195.025n

.meas tran vdout0_109ck380 FIND v(dout0_109) AT=195.025n

.meas tran vdout0_110ck380 FIND v(dout0_110) AT=195.025n

.meas tran vdout0_111ck380 FIND v(dout0_111) AT=195.025n

.meas tran vdout0_112ck380 FIND v(dout0_112) AT=195.025n

.meas tran vdout0_113ck380 FIND v(dout0_113) AT=195.025n

.meas tran vdout0_114ck380 FIND v(dout0_114) AT=195.025n

.meas tran vdout0_115ck380 FIND v(dout0_115) AT=195.025n

.meas tran vdout0_116ck380 FIND v(dout0_116) AT=195.025n

.meas tran vdout0_117ck380 FIND v(dout0_117) AT=195.025n

.meas tran vdout0_118ck380 FIND v(dout0_118) AT=195.025n

.meas tran vdout0_119ck380 FIND v(dout0_119) AT=195.025n

.meas tran vdout0_120ck380 FIND v(dout0_120) AT=195.025n

.meas tran vdout0_121ck380 FIND v(dout0_121) AT=195.025n

.meas tran vdout0_122ck380 FIND v(dout0_122) AT=195.025n

.meas tran vdout0_123ck380 FIND v(dout0_123) AT=195.025n

.meas tran vdout0_124ck380 FIND v(dout0_124) AT=195.025n

.meas tran vdout0_125ck380 FIND v(dout0_125) AT=195.025n

.meas tran vdout0_126ck380 FIND v(dout0_126) AT=195.025n

.meas tran vdout0_127ck380 FIND v(dout0_127) AT=195.025n

.meas tran vdout0_0ck400 FIND v(dout0_0) AT=205.025n

.meas tran vdout0_1ck400 FIND v(dout0_1) AT=205.025n

.meas tran vdout0_2ck400 FIND v(dout0_2) AT=205.025n

.meas tran vdout0_3ck400 FIND v(dout0_3) AT=205.025n

.meas tran vdout0_4ck400 FIND v(dout0_4) AT=205.025n

.meas tran vdout0_5ck400 FIND v(dout0_5) AT=205.025n

.meas tran vdout0_6ck400 FIND v(dout0_6) AT=205.025n

.meas tran vdout0_7ck400 FIND v(dout0_7) AT=205.025n

.meas tran vdout0_8ck400 FIND v(dout0_8) AT=205.025n

.meas tran vdout0_9ck400 FIND v(dout0_9) AT=205.025n

.meas tran vdout0_10ck400 FIND v(dout0_10) AT=205.025n

.meas tran vdout0_11ck400 FIND v(dout0_11) AT=205.025n

.meas tran vdout0_12ck400 FIND v(dout0_12) AT=205.025n

.meas tran vdout0_13ck400 FIND v(dout0_13) AT=205.025n

.meas tran vdout0_14ck400 FIND v(dout0_14) AT=205.025n

.meas tran vdout0_15ck400 FIND v(dout0_15) AT=205.025n

.meas tran vdout0_16ck400 FIND v(dout0_16) AT=205.025n

.meas tran vdout0_17ck400 FIND v(dout0_17) AT=205.025n

.meas tran vdout0_18ck400 FIND v(dout0_18) AT=205.025n

.meas tran vdout0_19ck400 FIND v(dout0_19) AT=205.025n

.meas tran vdout0_20ck400 FIND v(dout0_20) AT=205.025n

.meas tran vdout0_21ck400 FIND v(dout0_21) AT=205.025n

.meas tran vdout0_22ck400 FIND v(dout0_22) AT=205.025n

.meas tran vdout0_23ck400 FIND v(dout0_23) AT=205.025n

.meas tran vdout0_24ck400 FIND v(dout0_24) AT=205.025n

.meas tran vdout0_25ck400 FIND v(dout0_25) AT=205.025n

.meas tran vdout0_26ck400 FIND v(dout0_26) AT=205.025n

.meas tran vdout0_27ck400 FIND v(dout0_27) AT=205.025n

.meas tran vdout0_28ck400 FIND v(dout0_28) AT=205.025n

.meas tran vdout0_29ck400 FIND v(dout0_29) AT=205.025n

.meas tran vdout0_30ck400 FIND v(dout0_30) AT=205.025n

.meas tran vdout0_31ck400 FIND v(dout0_31) AT=205.025n

.meas tran vdout0_32ck400 FIND v(dout0_32) AT=205.025n

.meas tran vdout0_33ck400 FIND v(dout0_33) AT=205.025n

.meas tran vdout0_34ck400 FIND v(dout0_34) AT=205.025n

.meas tran vdout0_35ck400 FIND v(dout0_35) AT=205.025n

.meas tran vdout0_36ck400 FIND v(dout0_36) AT=205.025n

.meas tran vdout0_37ck400 FIND v(dout0_37) AT=205.025n

.meas tran vdout0_38ck400 FIND v(dout0_38) AT=205.025n

.meas tran vdout0_39ck400 FIND v(dout0_39) AT=205.025n

.meas tran vdout0_40ck400 FIND v(dout0_40) AT=205.025n

.meas tran vdout0_41ck400 FIND v(dout0_41) AT=205.025n

.meas tran vdout0_42ck400 FIND v(dout0_42) AT=205.025n

.meas tran vdout0_43ck400 FIND v(dout0_43) AT=205.025n

.meas tran vdout0_44ck400 FIND v(dout0_44) AT=205.025n

.meas tran vdout0_45ck400 FIND v(dout0_45) AT=205.025n

.meas tran vdout0_46ck400 FIND v(dout0_46) AT=205.025n

.meas tran vdout0_47ck400 FIND v(dout0_47) AT=205.025n

.meas tran vdout0_48ck400 FIND v(dout0_48) AT=205.025n

.meas tran vdout0_49ck400 FIND v(dout0_49) AT=205.025n

.meas tran vdout0_50ck400 FIND v(dout0_50) AT=205.025n

.meas tran vdout0_51ck400 FIND v(dout0_51) AT=205.025n

.meas tran vdout0_52ck400 FIND v(dout0_52) AT=205.025n

.meas tran vdout0_53ck400 FIND v(dout0_53) AT=205.025n

.meas tran vdout0_54ck400 FIND v(dout0_54) AT=205.025n

.meas tran vdout0_55ck400 FIND v(dout0_55) AT=205.025n

.meas tran vdout0_56ck400 FIND v(dout0_56) AT=205.025n

.meas tran vdout0_57ck400 FIND v(dout0_57) AT=205.025n

.meas tran vdout0_58ck400 FIND v(dout0_58) AT=205.025n

.meas tran vdout0_59ck400 FIND v(dout0_59) AT=205.025n

.meas tran vdout0_60ck400 FIND v(dout0_60) AT=205.025n

.meas tran vdout0_61ck400 FIND v(dout0_61) AT=205.025n

.meas tran vdout0_62ck400 FIND v(dout0_62) AT=205.025n

.meas tran vdout0_63ck400 FIND v(dout0_63) AT=205.025n

.meas tran vdout0_64ck400 FIND v(dout0_64) AT=205.025n

.meas tran vdout0_65ck400 FIND v(dout0_65) AT=205.025n

.meas tran vdout0_66ck400 FIND v(dout0_66) AT=205.025n

.meas tran vdout0_67ck400 FIND v(dout0_67) AT=205.025n

.meas tran vdout0_68ck400 FIND v(dout0_68) AT=205.025n

.meas tran vdout0_69ck400 FIND v(dout0_69) AT=205.025n

.meas tran vdout0_70ck400 FIND v(dout0_70) AT=205.025n

.meas tran vdout0_71ck400 FIND v(dout0_71) AT=205.025n

.meas tran vdout0_72ck400 FIND v(dout0_72) AT=205.025n

.meas tran vdout0_73ck400 FIND v(dout0_73) AT=205.025n

.meas tran vdout0_74ck400 FIND v(dout0_74) AT=205.025n

.meas tran vdout0_75ck400 FIND v(dout0_75) AT=205.025n

.meas tran vdout0_76ck400 FIND v(dout0_76) AT=205.025n

.meas tran vdout0_77ck400 FIND v(dout0_77) AT=205.025n

.meas tran vdout0_78ck400 FIND v(dout0_78) AT=205.025n

.meas tran vdout0_79ck400 FIND v(dout0_79) AT=205.025n

.meas tran vdout0_80ck400 FIND v(dout0_80) AT=205.025n

.meas tran vdout0_81ck400 FIND v(dout0_81) AT=205.025n

.meas tran vdout0_82ck400 FIND v(dout0_82) AT=205.025n

.meas tran vdout0_83ck400 FIND v(dout0_83) AT=205.025n

.meas tran vdout0_84ck400 FIND v(dout0_84) AT=205.025n

.meas tran vdout0_85ck400 FIND v(dout0_85) AT=205.025n

.meas tran vdout0_86ck400 FIND v(dout0_86) AT=205.025n

.meas tran vdout0_87ck400 FIND v(dout0_87) AT=205.025n

.meas tran vdout0_88ck400 FIND v(dout0_88) AT=205.025n

.meas tran vdout0_89ck400 FIND v(dout0_89) AT=205.025n

.meas tran vdout0_90ck400 FIND v(dout0_90) AT=205.025n

.meas tran vdout0_91ck400 FIND v(dout0_91) AT=205.025n

.meas tran vdout0_92ck400 FIND v(dout0_92) AT=205.025n

.meas tran vdout0_93ck400 FIND v(dout0_93) AT=205.025n

.meas tran vdout0_94ck400 FIND v(dout0_94) AT=205.025n

.meas tran vdout0_95ck400 FIND v(dout0_95) AT=205.025n

.meas tran vdout0_96ck400 FIND v(dout0_96) AT=205.025n

.meas tran vdout0_97ck400 FIND v(dout0_97) AT=205.025n

.meas tran vdout0_98ck400 FIND v(dout0_98) AT=205.025n

.meas tran vdout0_99ck400 FIND v(dout0_99) AT=205.025n

.meas tran vdout0_100ck400 FIND v(dout0_100) AT=205.025n

.meas tran vdout0_101ck400 FIND v(dout0_101) AT=205.025n

.meas tran vdout0_102ck400 FIND v(dout0_102) AT=205.025n

.meas tran vdout0_103ck400 FIND v(dout0_103) AT=205.025n

.meas tran vdout0_104ck400 FIND v(dout0_104) AT=205.025n

.meas tran vdout0_105ck400 FIND v(dout0_105) AT=205.025n

.meas tran vdout0_106ck400 FIND v(dout0_106) AT=205.025n

.meas tran vdout0_107ck400 FIND v(dout0_107) AT=205.025n

.meas tran vdout0_108ck400 FIND v(dout0_108) AT=205.025n

.meas tran vdout0_109ck400 FIND v(dout0_109) AT=205.025n

.meas tran vdout0_110ck400 FIND v(dout0_110) AT=205.025n

.meas tran vdout0_111ck400 FIND v(dout0_111) AT=205.025n

.meas tran vdout0_112ck400 FIND v(dout0_112) AT=205.025n

.meas tran vdout0_113ck400 FIND v(dout0_113) AT=205.025n

.meas tran vdout0_114ck400 FIND v(dout0_114) AT=205.025n

.meas tran vdout0_115ck400 FIND v(dout0_115) AT=205.025n

.meas tran vdout0_116ck400 FIND v(dout0_116) AT=205.025n

.meas tran vdout0_117ck400 FIND v(dout0_117) AT=205.025n

.meas tran vdout0_118ck400 FIND v(dout0_118) AT=205.025n

.meas tran vdout0_119ck400 FIND v(dout0_119) AT=205.025n

.meas tran vdout0_120ck400 FIND v(dout0_120) AT=205.025n

.meas tran vdout0_121ck400 FIND v(dout0_121) AT=205.025n

.meas tran vdout0_122ck400 FIND v(dout0_122) AT=205.025n

.meas tran vdout0_123ck400 FIND v(dout0_123) AT=205.025n

.meas tran vdout0_124ck400 FIND v(dout0_124) AT=205.025n

.meas tran vdout0_125ck400 FIND v(dout0_125) AT=205.025n

.meas tran vdout0_126ck400 FIND v(dout0_126) AT=205.025n

.meas tran vdout0_127ck400 FIND v(dout0_127) AT=205.025n

.meas tran vdout0_0ck410 FIND v(dout0_0) AT=210.025n

.meas tran vdout0_1ck410 FIND v(dout0_1) AT=210.025n

.meas tran vdout0_2ck410 FIND v(dout0_2) AT=210.025n

.meas tran vdout0_3ck410 FIND v(dout0_3) AT=210.025n

.meas tran vdout0_4ck410 FIND v(dout0_4) AT=210.025n

.meas tran vdout0_5ck410 FIND v(dout0_5) AT=210.025n

.meas tran vdout0_6ck410 FIND v(dout0_6) AT=210.025n

.meas tran vdout0_7ck410 FIND v(dout0_7) AT=210.025n

.meas tran vdout0_8ck410 FIND v(dout0_8) AT=210.025n

.meas tran vdout0_9ck410 FIND v(dout0_9) AT=210.025n

.meas tran vdout0_10ck410 FIND v(dout0_10) AT=210.025n

.meas tran vdout0_11ck410 FIND v(dout0_11) AT=210.025n

.meas tran vdout0_12ck410 FIND v(dout0_12) AT=210.025n

.meas tran vdout0_13ck410 FIND v(dout0_13) AT=210.025n

.meas tran vdout0_14ck410 FIND v(dout0_14) AT=210.025n

.meas tran vdout0_15ck410 FIND v(dout0_15) AT=210.025n

.meas tran vdout0_16ck410 FIND v(dout0_16) AT=210.025n

.meas tran vdout0_17ck410 FIND v(dout0_17) AT=210.025n

.meas tran vdout0_18ck410 FIND v(dout0_18) AT=210.025n

.meas tran vdout0_19ck410 FIND v(dout0_19) AT=210.025n

.meas tran vdout0_20ck410 FIND v(dout0_20) AT=210.025n

.meas tran vdout0_21ck410 FIND v(dout0_21) AT=210.025n

.meas tran vdout0_22ck410 FIND v(dout0_22) AT=210.025n

.meas tran vdout0_23ck410 FIND v(dout0_23) AT=210.025n

.meas tran vdout0_24ck410 FIND v(dout0_24) AT=210.025n

.meas tran vdout0_25ck410 FIND v(dout0_25) AT=210.025n

.meas tran vdout0_26ck410 FIND v(dout0_26) AT=210.025n

.meas tran vdout0_27ck410 FIND v(dout0_27) AT=210.025n

.meas tran vdout0_28ck410 FIND v(dout0_28) AT=210.025n

.meas tran vdout0_29ck410 FIND v(dout0_29) AT=210.025n

.meas tran vdout0_30ck410 FIND v(dout0_30) AT=210.025n

.meas tran vdout0_31ck410 FIND v(dout0_31) AT=210.025n

.meas tran vdout0_32ck410 FIND v(dout0_32) AT=210.025n

.meas tran vdout0_33ck410 FIND v(dout0_33) AT=210.025n

.meas tran vdout0_34ck410 FIND v(dout0_34) AT=210.025n

.meas tran vdout0_35ck410 FIND v(dout0_35) AT=210.025n

.meas tran vdout0_36ck410 FIND v(dout0_36) AT=210.025n

.meas tran vdout0_37ck410 FIND v(dout0_37) AT=210.025n

.meas tran vdout0_38ck410 FIND v(dout0_38) AT=210.025n

.meas tran vdout0_39ck410 FIND v(dout0_39) AT=210.025n

.meas tran vdout0_40ck410 FIND v(dout0_40) AT=210.025n

.meas tran vdout0_41ck410 FIND v(dout0_41) AT=210.025n

.meas tran vdout0_42ck410 FIND v(dout0_42) AT=210.025n

.meas tran vdout0_43ck410 FIND v(dout0_43) AT=210.025n

.meas tran vdout0_44ck410 FIND v(dout0_44) AT=210.025n

.meas tran vdout0_45ck410 FIND v(dout0_45) AT=210.025n

.meas tran vdout0_46ck410 FIND v(dout0_46) AT=210.025n

.meas tran vdout0_47ck410 FIND v(dout0_47) AT=210.025n

.meas tran vdout0_48ck410 FIND v(dout0_48) AT=210.025n

.meas tran vdout0_49ck410 FIND v(dout0_49) AT=210.025n

.meas tran vdout0_50ck410 FIND v(dout0_50) AT=210.025n

.meas tran vdout0_51ck410 FIND v(dout0_51) AT=210.025n

.meas tran vdout0_52ck410 FIND v(dout0_52) AT=210.025n

.meas tran vdout0_53ck410 FIND v(dout0_53) AT=210.025n

.meas tran vdout0_54ck410 FIND v(dout0_54) AT=210.025n

.meas tran vdout0_55ck410 FIND v(dout0_55) AT=210.025n

.meas tran vdout0_56ck410 FIND v(dout0_56) AT=210.025n

.meas tran vdout0_57ck410 FIND v(dout0_57) AT=210.025n

.meas tran vdout0_58ck410 FIND v(dout0_58) AT=210.025n

.meas tran vdout0_59ck410 FIND v(dout0_59) AT=210.025n

.meas tran vdout0_60ck410 FIND v(dout0_60) AT=210.025n

.meas tran vdout0_61ck410 FIND v(dout0_61) AT=210.025n

.meas tran vdout0_62ck410 FIND v(dout0_62) AT=210.025n

.meas tran vdout0_63ck410 FIND v(dout0_63) AT=210.025n

.meas tran vdout0_64ck410 FIND v(dout0_64) AT=210.025n

.meas tran vdout0_65ck410 FIND v(dout0_65) AT=210.025n

.meas tran vdout0_66ck410 FIND v(dout0_66) AT=210.025n

.meas tran vdout0_67ck410 FIND v(dout0_67) AT=210.025n

.meas tran vdout0_68ck410 FIND v(dout0_68) AT=210.025n

.meas tran vdout0_69ck410 FIND v(dout0_69) AT=210.025n

.meas tran vdout0_70ck410 FIND v(dout0_70) AT=210.025n

.meas tran vdout0_71ck410 FIND v(dout0_71) AT=210.025n

.meas tran vdout0_72ck410 FIND v(dout0_72) AT=210.025n

.meas tran vdout0_73ck410 FIND v(dout0_73) AT=210.025n

.meas tran vdout0_74ck410 FIND v(dout0_74) AT=210.025n

.meas tran vdout0_75ck410 FIND v(dout0_75) AT=210.025n

.meas tran vdout0_76ck410 FIND v(dout0_76) AT=210.025n

.meas tran vdout0_77ck410 FIND v(dout0_77) AT=210.025n

.meas tran vdout0_78ck410 FIND v(dout0_78) AT=210.025n

.meas tran vdout0_79ck410 FIND v(dout0_79) AT=210.025n

.meas tran vdout0_80ck410 FIND v(dout0_80) AT=210.025n

.meas tran vdout0_81ck410 FIND v(dout0_81) AT=210.025n

.meas tran vdout0_82ck410 FIND v(dout0_82) AT=210.025n

.meas tran vdout0_83ck410 FIND v(dout0_83) AT=210.025n

.meas tran vdout0_84ck410 FIND v(dout0_84) AT=210.025n

.meas tran vdout0_85ck410 FIND v(dout0_85) AT=210.025n

.meas tran vdout0_86ck410 FIND v(dout0_86) AT=210.025n

.meas tran vdout0_87ck410 FIND v(dout0_87) AT=210.025n

.meas tran vdout0_88ck410 FIND v(dout0_88) AT=210.025n

.meas tran vdout0_89ck410 FIND v(dout0_89) AT=210.025n

.meas tran vdout0_90ck410 FIND v(dout0_90) AT=210.025n

.meas tran vdout0_91ck410 FIND v(dout0_91) AT=210.025n

.meas tran vdout0_92ck410 FIND v(dout0_92) AT=210.025n

.meas tran vdout0_93ck410 FIND v(dout0_93) AT=210.025n

.meas tran vdout0_94ck410 FIND v(dout0_94) AT=210.025n

.meas tran vdout0_95ck410 FIND v(dout0_95) AT=210.025n

.meas tran vdout0_96ck410 FIND v(dout0_96) AT=210.025n

.meas tran vdout0_97ck410 FIND v(dout0_97) AT=210.025n

.meas tran vdout0_98ck410 FIND v(dout0_98) AT=210.025n

.meas tran vdout0_99ck410 FIND v(dout0_99) AT=210.025n

.meas tran vdout0_100ck410 FIND v(dout0_100) AT=210.025n

.meas tran vdout0_101ck410 FIND v(dout0_101) AT=210.025n

.meas tran vdout0_102ck410 FIND v(dout0_102) AT=210.025n

.meas tran vdout0_103ck410 FIND v(dout0_103) AT=210.025n

.meas tran vdout0_104ck410 FIND v(dout0_104) AT=210.025n

.meas tran vdout0_105ck410 FIND v(dout0_105) AT=210.025n

.meas tran vdout0_106ck410 FIND v(dout0_106) AT=210.025n

.meas tran vdout0_107ck410 FIND v(dout0_107) AT=210.025n

.meas tran vdout0_108ck410 FIND v(dout0_108) AT=210.025n

.meas tran vdout0_109ck410 FIND v(dout0_109) AT=210.025n

.meas tran vdout0_110ck410 FIND v(dout0_110) AT=210.025n

.meas tran vdout0_111ck410 FIND v(dout0_111) AT=210.025n

.meas tran vdout0_112ck410 FIND v(dout0_112) AT=210.025n

.meas tran vdout0_113ck410 FIND v(dout0_113) AT=210.025n

.meas tran vdout0_114ck410 FIND v(dout0_114) AT=210.025n

.meas tran vdout0_115ck410 FIND v(dout0_115) AT=210.025n

.meas tran vdout0_116ck410 FIND v(dout0_116) AT=210.025n

.meas tran vdout0_117ck410 FIND v(dout0_117) AT=210.025n

.meas tran vdout0_118ck410 FIND v(dout0_118) AT=210.025n

.meas tran vdout0_119ck410 FIND v(dout0_119) AT=210.025n

.meas tran vdout0_120ck410 FIND v(dout0_120) AT=210.025n

.meas tran vdout0_121ck410 FIND v(dout0_121) AT=210.025n

.meas tran vdout0_122ck410 FIND v(dout0_122) AT=210.025n

.meas tran vdout0_123ck410 FIND v(dout0_123) AT=210.025n

.meas tran vdout0_124ck410 FIND v(dout0_124) AT=210.025n

.meas tran vdout0_125ck410 FIND v(dout0_125) AT=210.025n

.meas tran vdout0_126ck410 FIND v(dout0_126) AT=210.025n

.meas tran vdout0_127ck410 FIND v(dout0_127) AT=210.025n

.meas tran vdout0_0ck420 FIND v(dout0_0) AT=215.025n

.meas tran vdout0_1ck420 FIND v(dout0_1) AT=215.025n

.meas tran vdout0_2ck420 FIND v(dout0_2) AT=215.025n

.meas tran vdout0_3ck420 FIND v(dout0_3) AT=215.025n

.meas tran vdout0_4ck420 FIND v(dout0_4) AT=215.025n

.meas tran vdout0_5ck420 FIND v(dout0_5) AT=215.025n

.meas tran vdout0_6ck420 FIND v(dout0_6) AT=215.025n

.meas tran vdout0_7ck420 FIND v(dout0_7) AT=215.025n

.meas tran vdout0_8ck420 FIND v(dout0_8) AT=215.025n

.meas tran vdout0_9ck420 FIND v(dout0_9) AT=215.025n

.meas tran vdout0_10ck420 FIND v(dout0_10) AT=215.025n

.meas tran vdout0_11ck420 FIND v(dout0_11) AT=215.025n

.meas tran vdout0_12ck420 FIND v(dout0_12) AT=215.025n

.meas tran vdout0_13ck420 FIND v(dout0_13) AT=215.025n

.meas tran vdout0_14ck420 FIND v(dout0_14) AT=215.025n

.meas tran vdout0_15ck420 FIND v(dout0_15) AT=215.025n

.meas tran vdout0_16ck420 FIND v(dout0_16) AT=215.025n

.meas tran vdout0_17ck420 FIND v(dout0_17) AT=215.025n

.meas tran vdout0_18ck420 FIND v(dout0_18) AT=215.025n

.meas tran vdout0_19ck420 FIND v(dout0_19) AT=215.025n

.meas tran vdout0_20ck420 FIND v(dout0_20) AT=215.025n

.meas tran vdout0_21ck420 FIND v(dout0_21) AT=215.025n

.meas tran vdout0_22ck420 FIND v(dout0_22) AT=215.025n

.meas tran vdout0_23ck420 FIND v(dout0_23) AT=215.025n

.meas tran vdout0_24ck420 FIND v(dout0_24) AT=215.025n

.meas tran vdout0_25ck420 FIND v(dout0_25) AT=215.025n

.meas tran vdout0_26ck420 FIND v(dout0_26) AT=215.025n

.meas tran vdout0_27ck420 FIND v(dout0_27) AT=215.025n

.meas tran vdout0_28ck420 FIND v(dout0_28) AT=215.025n

.meas tran vdout0_29ck420 FIND v(dout0_29) AT=215.025n

.meas tran vdout0_30ck420 FIND v(dout0_30) AT=215.025n

.meas tran vdout0_31ck420 FIND v(dout0_31) AT=215.025n

.meas tran vdout0_32ck420 FIND v(dout0_32) AT=215.025n

.meas tran vdout0_33ck420 FIND v(dout0_33) AT=215.025n

.meas tran vdout0_34ck420 FIND v(dout0_34) AT=215.025n

.meas tran vdout0_35ck420 FIND v(dout0_35) AT=215.025n

.meas tran vdout0_36ck420 FIND v(dout0_36) AT=215.025n

.meas tran vdout0_37ck420 FIND v(dout0_37) AT=215.025n

.meas tran vdout0_38ck420 FIND v(dout0_38) AT=215.025n

.meas tran vdout0_39ck420 FIND v(dout0_39) AT=215.025n

.meas tran vdout0_40ck420 FIND v(dout0_40) AT=215.025n

.meas tran vdout0_41ck420 FIND v(dout0_41) AT=215.025n

.meas tran vdout0_42ck420 FIND v(dout0_42) AT=215.025n

.meas tran vdout0_43ck420 FIND v(dout0_43) AT=215.025n

.meas tran vdout0_44ck420 FIND v(dout0_44) AT=215.025n

.meas tran vdout0_45ck420 FIND v(dout0_45) AT=215.025n

.meas tran vdout0_46ck420 FIND v(dout0_46) AT=215.025n

.meas tran vdout0_47ck420 FIND v(dout0_47) AT=215.025n

.meas tran vdout0_48ck420 FIND v(dout0_48) AT=215.025n

.meas tran vdout0_49ck420 FIND v(dout0_49) AT=215.025n

.meas tran vdout0_50ck420 FIND v(dout0_50) AT=215.025n

.meas tran vdout0_51ck420 FIND v(dout0_51) AT=215.025n

.meas tran vdout0_52ck420 FIND v(dout0_52) AT=215.025n

.meas tran vdout0_53ck420 FIND v(dout0_53) AT=215.025n

.meas tran vdout0_54ck420 FIND v(dout0_54) AT=215.025n

.meas tran vdout0_55ck420 FIND v(dout0_55) AT=215.025n

.meas tran vdout0_56ck420 FIND v(dout0_56) AT=215.025n

.meas tran vdout0_57ck420 FIND v(dout0_57) AT=215.025n

.meas tran vdout0_58ck420 FIND v(dout0_58) AT=215.025n

.meas tran vdout0_59ck420 FIND v(dout0_59) AT=215.025n

.meas tran vdout0_60ck420 FIND v(dout0_60) AT=215.025n

.meas tran vdout0_61ck420 FIND v(dout0_61) AT=215.025n

.meas tran vdout0_62ck420 FIND v(dout0_62) AT=215.025n

.meas tran vdout0_63ck420 FIND v(dout0_63) AT=215.025n

.meas tran vdout0_64ck420 FIND v(dout0_64) AT=215.025n

.meas tran vdout0_65ck420 FIND v(dout0_65) AT=215.025n

.meas tran vdout0_66ck420 FIND v(dout0_66) AT=215.025n

.meas tran vdout0_67ck420 FIND v(dout0_67) AT=215.025n

.meas tran vdout0_68ck420 FIND v(dout0_68) AT=215.025n

.meas tran vdout0_69ck420 FIND v(dout0_69) AT=215.025n

.meas tran vdout0_70ck420 FIND v(dout0_70) AT=215.025n

.meas tran vdout0_71ck420 FIND v(dout0_71) AT=215.025n

.meas tran vdout0_72ck420 FIND v(dout0_72) AT=215.025n

.meas tran vdout0_73ck420 FIND v(dout0_73) AT=215.025n

.meas tran vdout0_74ck420 FIND v(dout0_74) AT=215.025n

.meas tran vdout0_75ck420 FIND v(dout0_75) AT=215.025n

.meas tran vdout0_76ck420 FIND v(dout0_76) AT=215.025n

.meas tran vdout0_77ck420 FIND v(dout0_77) AT=215.025n

.meas tran vdout0_78ck420 FIND v(dout0_78) AT=215.025n

.meas tran vdout0_79ck420 FIND v(dout0_79) AT=215.025n

.meas tran vdout0_80ck420 FIND v(dout0_80) AT=215.025n

.meas tran vdout0_81ck420 FIND v(dout0_81) AT=215.025n

.meas tran vdout0_82ck420 FIND v(dout0_82) AT=215.025n

.meas tran vdout0_83ck420 FIND v(dout0_83) AT=215.025n

.meas tran vdout0_84ck420 FIND v(dout0_84) AT=215.025n

.meas tran vdout0_85ck420 FIND v(dout0_85) AT=215.025n

.meas tran vdout0_86ck420 FIND v(dout0_86) AT=215.025n

.meas tran vdout0_87ck420 FIND v(dout0_87) AT=215.025n

.meas tran vdout0_88ck420 FIND v(dout0_88) AT=215.025n

.meas tran vdout0_89ck420 FIND v(dout0_89) AT=215.025n

.meas tran vdout0_90ck420 FIND v(dout0_90) AT=215.025n

.meas tran vdout0_91ck420 FIND v(dout0_91) AT=215.025n

.meas tran vdout0_92ck420 FIND v(dout0_92) AT=215.025n

.meas tran vdout0_93ck420 FIND v(dout0_93) AT=215.025n

.meas tran vdout0_94ck420 FIND v(dout0_94) AT=215.025n

.meas tran vdout0_95ck420 FIND v(dout0_95) AT=215.025n

.meas tran vdout0_96ck420 FIND v(dout0_96) AT=215.025n

.meas tran vdout0_97ck420 FIND v(dout0_97) AT=215.025n

.meas tran vdout0_98ck420 FIND v(dout0_98) AT=215.025n

.meas tran vdout0_99ck420 FIND v(dout0_99) AT=215.025n

.meas tran vdout0_100ck420 FIND v(dout0_100) AT=215.025n

.meas tran vdout0_101ck420 FIND v(dout0_101) AT=215.025n

.meas tran vdout0_102ck420 FIND v(dout0_102) AT=215.025n

.meas tran vdout0_103ck420 FIND v(dout0_103) AT=215.025n

.meas tran vdout0_104ck420 FIND v(dout0_104) AT=215.025n

.meas tran vdout0_105ck420 FIND v(dout0_105) AT=215.025n

.meas tran vdout0_106ck420 FIND v(dout0_106) AT=215.025n

.meas tran vdout0_107ck420 FIND v(dout0_107) AT=215.025n

.meas tran vdout0_108ck420 FIND v(dout0_108) AT=215.025n

.meas tran vdout0_109ck420 FIND v(dout0_109) AT=215.025n

.meas tran vdout0_110ck420 FIND v(dout0_110) AT=215.025n

.meas tran vdout0_111ck420 FIND v(dout0_111) AT=215.025n

.meas tran vdout0_112ck420 FIND v(dout0_112) AT=215.025n

.meas tran vdout0_113ck420 FIND v(dout0_113) AT=215.025n

.meas tran vdout0_114ck420 FIND v(dout0_114) AT=215.025n

.meas tran vdout0_115ck420 FIND v(dout0_115) AT=215.025n

.meas tran vdout0_116ck420 FIND v(dout0_116) AT=215.025n

.meas tran vdout0_117ck420 FIND v(dout0_117) AT=215.025n

.meas tran vdout0_118ck420 FIND v(dout0_118) AT=215.025n

.meas tran vdout0_119ck420 FIND v(dout0_119) AT=215.025n

.meas tran vdout0_120ck420 FIND v(dout0_120) AT=215.025n

.meas tran vdout0_121ck420 FIND v(dout0_121) AT=215.025n

.meas tran vdout0_122ck420 FIND v(dout0_122) AT=215.025n

.meas tran vdout0_123ck420 FIND v(dout0_123) AT=215.025n

.meas tran vdout0_124ck420 FIND v(dout0_124) AT=215.025n

.meas tran vdout0_125ck420 FIND v(dout0_125) AT=215.025n

.meas tran vdout0_126ck420 FIND v(dout0_126) AT=215.025n

.meas tran vdout0_127ck420 FIND v(dout0_127) AT=215.025n

.meas tran vdout0_0ck440 FIND v(dout0_0) AT=225.025n

.meas tran vdout0_1ck440 FIND v(dout0_1) AT=225.025n

.meas tran vdout0_2ck440 FIND v(dout0_2) AT=225.025n

.meas tran vdout0_3ck440 FIND v(dout0_3) AT=225.025n

.meas tran vdout0_4ck440 FIND v(dout0_4) AT=225.025n

.meas tran vdout0_5ck440 FIND v(dout0_5) AT=225.025n

.meas tran vdout0_6ck440 FIND v(dout0_6) AT=225.025n

.meas tran vdout0_7ck440 FIND v(dout0_7) AT=225.025n

.meas tran vdout0_8ck440 FIND v(dout0_8) AT=225.025n

.meas tran vdout0_9ck440 FIND v(dout0_9) AT=225.025n

.meas tran vdout0_10ck440 FIND v(dout0_10) AT=225.025n

.meas tran vdout0_11ck440 FIND v(dout0_11) AT=225.025n

.meas tran vdout0_12ck440 FIND v(dout0_12) AT=225.025n

.meas tran vdout0_13ck440 FIND v(dout0_13) AT=225.025n

.meas tran vdout0_14ck440 FIND v(dout0_14) AT=225.025n

.meas tran vdout0_15ck440 FIND v(dout0_15) AT=225.025n

.meas tran vdout0_16ck440 FIND v(dout0_16) AT=225.025n

.meas tran vdout0_17ck440 FIND v(dout0_17) AT=225.025n

.meas tran vdout0_18ck440 FIND v(dout0_18) AT=225.025n

.meas tran vdout0_19ck440 FIND v(dout0_19) AT=225.025n

.meas tran vdout0_20ck440 FIND v(dout0_20) AT=225.025n

.meas tran vdout0_21ck440 FIND v(dout0_21) AT=225.025n

.meas tran vdout0_22ck440 FIND v(dout0_22) AT=225.025n

.meas tran vdout0_23ck440 FIND v(dout0_23) AT=225.025n

.meas tran vdout0_24ck440 FIND v(dout0_24) AT=225.025n

.meas tran vdout0_25ck440 FIND v(dout0_25) AT=225.025n

.meas tran vdout0_26ck440 FIND v(dout0_26) AT=225.025n

.meas tran vdout0_27ck440 FIND v(dout0_27) AT=225.025n

.meas tran vdout0_28ck440 FIND v(dout0_28) AT=225.025n

.meas tran vdout0_29ck440 FIND v(dout0_29) AT=225.025n

.meas tran vdout0_30ck440 FIND v(dout0_30) AT=225.025n

.meas tran vdout0_31ck440 FIND v(dout0_31) AT=225.025n

.meas tran vdout0_32ck440 FIND v(dout0_32) AT=225.025n

.meas tran vdout0_33ck440 FIND v(dout0_33) AT=225.025n

.meas tran vdout0_34ck440 FIND v(dout0_34) AT=225.025n

.meas tran vdout0_35ck440 FIND v(dout0_35) AT=225.025n

.meas tran vdout0_36ck440 FIND v(dout0_36) AT=225.025n

.meas tran vdout0_37ck440 FIND v(dout0_37) AT=225.025n

.meas tran vdout0_38ck440 FIND v(dout0_38) AT=225.025n

.meas tran vdout0_39ck440 FIND v(dout0_39) AT=225.025n

.meas tran vdout0_40ck440 FIND v(dout0_40) AT=225.025n

.meas tran vdout0_41ck440 FIND v(dout0_41) AT=225.025n

.meas tran vdout0_42ck440 FIND v(dout0_42) AT=225.025n

.meas tran vdout0_43ck440 FIND v(dout0_43) AT=225.025n

.meas tran vdout0_44ck440 FIND v(dout0_44) AT=225.025n

.meas tran vdout0_45ck440 FIND v(dout0_45) AT=225.025n

.meas tran vdout0_46ck440 FIND v(dout0_46) AT=225.025n

.meas tran vdout0_47ck440 FIND v(dout0_47) AT=225.025n

.meas tran vdout0_48ck440 FIND v(dout0_48) AT=225.025n

.meas tran vdout0_49ck440 FIND v(dout0_49) AT=225.025n

.meas tran vdout0_50ck440 FIND v(dout0_50) AT=225.025n

.meas tran vdout0_51ck440 FIND v(dout0_51) AT=225.025n

.meas tran vdout0_52ck440 FIND v(dout0_52) AT=225.025n

.meas tran vdout0_53ck440 FIND v(dout0_53) AT=225.025n

.meas tran vdout0_54ck440 FIND v(dout0_54) AT=225.025n

.meas tran vdout0_55ck440 FIND v(dout0_55) AT=225.025n

.meas tran vdout0_56ck440 FIND v(dout0_56) AT=225.025n

.meas tran vdout0_57ck440 FIND v(dout0_57) AT=225.025n

.meas tran vdout0_58ck440 FIND v(dout0_58) AT=225.025n

.meas tran vdout0_59ck440 FIND v(dout0_59) AT=225.025n

.meas tran vdout0_60ck440 FIND v(dout0_60) AT=225.025n

.meas tran vdout0_61ck440 FIND v(dout0_61) AT=225.025n

.meas tran vdout0_62ck440 FIND v(dout0_62) AT=225.025n

.meas tran vdout0_63ck440 FIND v(dout0_63) AT=225.025n

.meas tran vdout0_64ck440 FIND v(dout0_64) AT=225.025n

.meas tran vdout0_65ck440 FIND v(dout0_65) AT=225.025n

.meas tran vdout0_66ck440 FIND v(dout0_66) AT=225.025n

.meas tran vdout0_67ck440 FIND v(dout0_67) AT=225.025n

.meas tran vdout0_68ck440 FIND v(dout0_68) AT=225.025n

.meas tran vdout0_69ck440 FIND v(dout0_69) AT=225.025n

.meas tran vdout0_70ck440 FIND v(dout0_70) AT=225.025n

.meas tran vdout0_71ck440 FIND v(dout0_71) AT=225.025n

.meas tran vdout0_72ck440 FIND v(dout0_72) AT=225.025n

.meas tran vdout0_73ck440 FIND v(dout0_73) AT=225.025n

.meas tran vdout0_74ck440 FIND v(dout0_74) AT=225.025n

.meas tran vdout0_75ck440 FIND v(dout0_75) AT=225.025n

.meas tran vdout0_76ck440 FIND v(dout0_76) AT=225.025n

.meas tran vdout0_77ck440 FIND v(dout0_77) AT=225.025n

.meas tran vdout0_78ck440 FIND v(dout0_78) AT=225.025n

.meas tran vdout0_79ck440 FIND v(dout0_79) AT=225.025n

.meas tran vdout0_80ck440 FIND v(dout0_80) AT=225.025n

.meas tran vdout0_81ck440 FIND v(dout0_81) AT=225.025n

.meas tran vdout0_82ck440 FIND v(dout0_82) AT=225.025n

.meas tran vdout0_83ck440 FIND v(dout0_83) AT=225.025n

.meas tran vdout0_84ck440 FIND v(dout0_84) AT=225.025n

.meas tran vdout0_85ck440 FIND v(dout0_85) AT=225.025n

.meas tran vdout0_86ck440 FIND v(dout0_86) AT=225.025n

.meas tran vdout0_87ck440 FIND v(dout0_87) AT=225.025n

.meas tran vdout0_88ck440 FIND v(dout0_88) AT=225.025n

.meas tran vdout0_89ck440 FIND v(dout0_89) AT=225.025n

.meas tran vdout0_90ck440 FIND v(dout0_90) AT=225.025n

.meas tran vdout0_91ck440 FIND v(dout0_91) AT=225.025n

.meas tran vdout0_92ck440 FIND v(dout0_92) AT=225.025n

.meas tran vdout0_93ck440 FIND v(dout0_93) AT=225.025n

.meas tran vdout0_94ck440 FIND v(dout0_94) AT=225.025n

.meas tran vdout0_95ck440 FIND v(dout0_95) AT=225.025n

.meas tran vdout0_96ck440 FIND v(dout0_96) AT=225.025n

.meas tran vdout0_97ck440 FIND v(dout0_97) AT=225.025n

.meas tran vdout0_98ck440 FIND v(dout0_98) AT=225.025n

.meas tran vdout0_99ck440 FIND v(dout0_99) AT=225.025n

.meas tran vdout0_100ck440 FIND v(dout0_100) AT=225.025n

.meas tran vdout0_101ck440 FIND v(dout0_101) AT=225.025n

.meas tran vdout0_102ck440 FIND v(dout0_102) AT=225.025n

.meas tran vdout0_103ck440 FIND v(dout0_103) AT=225.025n

.meas tran vdout0_104ck440 FIND v(dout0_104) AT=225.025n

.meas tran vdout0_105ck440 FIND v(dout0_105) AT=225.025n

.meas tran vdout0_106ck440 FIND v(dout0_106) AT=225.025n

.meas tran vdout0_107ck440 FIND v(dout0_107) AT=225.025n

.meas tran vdout0_108ck440 FIND v(dout0_108) AT=225.025n

.meas tran vdout0_109ck440 FIND v(dout0_109) AT=225.025n

.meas tran vdout0_110ck440 FIND v(dout0_110) AT=225.025n

.meas tran vdout0_111ck440 FIND v(dout0_111) AT=225.025n

.meas tran vdout0_112ck440 FIND v(dout0_112) AT=225.025n

.meas tran vdout0_113ck440 FIND v(dout0_113) AT=225.025n

.meas tran vdout0_114ck440 FIND v(dout0_114) AT=225.025n

.meas tran vdout0_115ck440 FIND v(dout0_115) AT=225.025n

.meas tran vdout0_116ck440 FIND v(dout0_116) AT=225.025n

.meas tran vdout0_117ck440 FIND v(dout0_117) AT=225.025n

.meas tran vdout0_118ck440 FIND v(dout0_118) AT=225.025n

.meas tran vdout0_119ck440 FIND v(dout0_119) AT=225.025n

.meas tran vdout0_120ck440 FIND v(dout0_120) AT=225.025n

.meas tran vdout0_121ck440 FIND v(dout0_121) AT=225.025n

.meas tran vdout0_122ck440 FIND v(dout0_122) AT=225.025n

.meas tran vdout0_123ck440 FIND v(dout0_123) AT=225.025n

.meas tran vdout0_124ck440 FIND v(dout0_124) AT=225.025n

.meas tran vdout0_125ck440 FIND v(dout0_125) AT=225.025n

.meas tran vdout0_126ck440 FIND v(dout0_126) AT=225.025n

.meas tran vdout0_127ck440 FIND v(dout0_127) AT=225.025n

.meas tran vdout0_0ck450 FIND v(dout0_0) AT=230.025n

.meas tran vdout0_1ck450 FIND v(dout0_1) AT=230.025n

.meas tran vdout0_2ck450 FIND v(dout0_2) AT=230.025n

.meas tran vdout0_3ck450 FIND v(dout0_3) AT=230.025n

.meas tran vdout0_4ck450 FIND v(dout0_4) AT=230.025n

.meas tran vdout0_5ck450 FIND v(dout0_5) AT=230.025n

.meas tran vdout0_6ck450 FIND v(dout0_6) AT=230.025n

.meas tran vdout0_7ck450 FIND v(dout0_7) AT=230.025n

.meas tran vdout0_8ck450 FIND v(dout0_8) AT=230.025n

.meas tran vdout0_9ck450 FIND v(dout0_9) AT=230.025n

.meas tran vdout0_10ck450 FIND v(dout0_10) AT=230.025n

.meas tran vdout0_11ck450 FIND v(dout0_11) AT=230.025n

.meas tran vdout0_12ck450 FIND v(dout0_12) AT=230.025n

.meas tran vdout0_13ck450 FIND v(dout0_13) AT=230.025n

.meas tran vdout0_14ck450 FIND v(dout0_14) AT=230.025n

.meas tran vdout0_15ck450 FIND v(dout0_15) AT=230.025n

.meas tran vdout0_16ck450 FIND v(dout0_16) AT=230.025n

.meas tran vdout0_17ck450 FIND v(dout0_17) AT=230.025n

.meas tran vdout0_18ck450 FIND v(dout0_18) AT=230.025n

.meas tran vdout0_19ck450 FIND v(dout0_19) AT=230.025n

.meas tran vdout0_20ck450 FIND v(dout0_20) AT=230.025n

.meas tran vdout0_21ck450 FIND v(dout0_21) AT=230.025n

.meas tran vdout0_22ck450 FIND v(dout0_22) AT=230.025n

.meas tran vdout0_23ck450 FIND v(dout0_23) AT=230.025n

.meas tran vdout0_24ck450 FIND v(dout0_24) AT=230.025n

.meas tran vdout0_25ck450 FIND v(dout0_25) AT=230.025n

.meas tran vdout0_26ck450 FIND v(dout0_26) AT=230.025n

.meas tran vdout0_27ck450 FIND v(dout0_27) AT=230.025n

.meas tran vdout0_28ck450 FIND v(dout0_28) AT=230.025n

.meas tran vdout0_29ck450 FIND v(dout0_29) AT=230.025n

.meas tran vdout0_30ck450 FIND v(dout0_30) AT=230.025n

.meas tran vdout0_31ck450 FIND v(dout0_31) AT=230.025n

.meas tran vdout0_32ck450 FIND v(dout0_32) AT=230.025n

.meas tran vdout0_33ck450 FIND v(dout0_33) AT=230.025n

.meas tran vdout0_34ck450 FIND v(dout0_34) AT=230.025n

.meas tran vdout0_35ck450 FIND v(dout0_35) AT=230.025n

.meas tran vdout0_36ck450 FIND v(dout0_36) AT=230.025n

.meas tran vdout0_37ck450 FIND v(dout0_37) AT=230.025n

.meas tran vdout0_38ck450 FIND v(dout0_38) AT=230.025n

.meas tran vdout0_39ck450 FIND v(dout0_39) AT=230.025n

.meas tran vdout0_40ck450 FIND v(dout0_40) AT=230.025n

.meas tran vdout0_41ck450 FIND v(dout0_41) AT=230.025n

.meas tran vdout0_42ck450 FIND v(dout0_42) AT=230.025n

.meas tran vdout0_43ck450 FIND v(dout0_43) AT=230.025n

.meas tran vdout0_44ck450 FIND v(dout0_44) AT=230.025n

.meas tran vdout0_45ck450 FIND v(dout0_45) AT=230.025n

.meas tran vdout0_46ck450 FIND v(dout0_46) AT=230.025n

.meas tran vdout0_47ck450 FIND v(dout0_47) AT=230.025n

.meas tran vdout0_48ck450 FIND v(dout0_48) AT=230.025n

.meas tran vdout0_49ck450 FIND v(dout0_49) AT=230.025n

.meas tran vdout0_50ck450 FIND v(dout0_50) AT=230.025n

.meas tran vdout0_51ck450 FIND v(dout0_51) AT=230.025n

.meas tran vdout0_52ck450 FIND v(dout0_52) AT=230.025n

.meas tran vdout0_53ck450 FIND v(dout0_53) AT=230.025n

.meas tran vdout0_54ck450 FIND v(dout0_54) AT=230.025n

.meas tran vdout0_55ck450 FIND v(dout0_55) AT=230.025n

.meas tran vdout0_56ck450 FIND v(dout0_56) AT=230.025n

.meas tran vdout0_57ck450 FIND v(dout0_57) AT=230.025n

.meas tran vdout0_58ck450 FIND v(dout0_58) AT=230.025n

.meas tran vdout0_59ck450 FIND v(dout0_59) AT=230.025n

.meas tran vdout0_60ck450 FIND v(dout0_60) AT=230.025n

.meas tran vdout0_61ck450 FIND v(dout0_61) AT=230.025n

.meas tran vdout0_62ck450 FIND v(dout0_62) AT=230.025n

.meas tran vdout0_63ck450 FIND v(dout0_63) AT=230.025n

.meas tran vdout0_64ck450 FIND v(dout0_64) AT=230.025n

.meas tran vdout0_65ck450 FIND v(dout0_65) AT=230.025n

.meas tran vdout0_66ck450 FIND v(dout0_66) AT=230.025n

.meas tran vdout0_67ck450 FIND v(dout0_67) AT=230.025n

.meas tran vdout0_68ck450 FIND v(dout0_68) AT=230.025n

.meas tran vdout0_69ck450 FIND v(dout0_69) AT=230.025n

.meas tran vdout0_70ck450 FIND v(dout0_70) AT=230.025n

.meas tran vdout0_71ck450 FIND v(dout0_71) AT=230.025n

.meas tran vdout0_72ck450 FIND v(dout0_72) AT=230.025n

.meas tran vdout0_73ck450 FIND v(dout0_73) AT=230.025n

.meas tran vdout0_74ck450 FIND v(dout0_74) AT=230.025n

.meas tran vdout0_75ck450 FIND v(dout0_75) AT=230.025n

.meas tran vdout0_76ck450 FIND v(dout0_76) AT=230.025n

.meas tran vdout0_77ck450 FIND v(dout0_77) AT=230.025n

.meas tran vdout0_78ck450 FIND v(dout0_78) AT=230.025n

.meas tran vdout0_79ck450 FIND v(dout0_79) AT=230.025n

.meas tran vdout0_80ck450 FIND v(dout0_80) AT=230.025n

.meas tran vdout0_81ck450 FIND v(dout0_81) AT=230.025n

.meas tran vdout0_82ck450 FIND v(dout0_82) AT=230.025n

.meas tran vdout0_83ck450 FIND v(dout0_83) AT=230.025n

.meas tran vdout0_84ck450 FIND v(dout0_84) AT=230.025n

.meas tran vdout0_85ck450 FIND v(dout0_85) AT=230.025n

.meas tran vdout0_86ck450 FIND v(dout0_86) AT=230.025n

.meas tran vdout0_87ck450 FIND v(dout0_87) AT=230.025n

.meas tran vdout0_88ck450 FIND v(dout0_88) AT=230.025n

.meas tran vdout0_89ck450 FIND v(dout0_89) AT=230.025n

.meas tran vdout0_90ck450 FIND v(dout0_90) AT=230.025n

.meas tran vdout0_91ck450 FIND v(dout0_91) AT=230.025n

.meas tran vdout0_92ck450 FIND v(dout0_92) AT=230.025n

.meas tran vdout0_93ck450 FIND v(dout0_93) AT=230.025n

.meas tran vdout0_94ck450 FIND v(dout0_94) AT=230.025n

.meas tran vdout0_95ck450 FIND v(dout0_95) AT=230.025n

.meas tran vdout0_96ck450 FIND v(dout0_96) AT=230.025n

.meas tran vdout0_97ck450 FIND v(dout0_97) AT=230.025n

.meas tran vdout0_98ck450 FIND v(dout0_98) AT=230.025n

.meas tran vdout0_99ck450 FIND v(dout0_99) AT=230.025n

.meas tran vdout0_100ck450 FIND v(dout0_100) AT=230.025n

.meas tran vdout0_101ck450 FIND v(dout0_101) AT=230.025n

.meas tran vdout0_102ck450 FIND v(dout0_102) AT=230.025n

.meas tran vdout0_103ck450 FIND v(dout0_103) AT=230.025n

.meas tran vdout0_104ck450 FIND v(dout0_104) AT=230.025n

.meas tran vdout0_105ck450 FIND v(dout0_105) AT=230.025n

.meas tran vdout0_106ck450 FIND v(dout0_106) AT=230.025n

.meas tran vdout0_107ck450 FIND v(dout0_107) AT=230.025n

.meas tran vdout0_108ck450 FIND v(dout0_108) AT=230.025n

.meas tran vdout0_109ck450 FIND v(dout0_109) AT=230.025n

.meas tran vdout0_110ck450 FIND v(dout0_110) AT=230.025n

.meas tran vdout0_111ck450 FIND v(dout0_111) AT=230.025n

.meas tran vdout0_112ck450 FIND v(dout0_112) AT=230.025n

.meas tran vdout0_113ck450 FIND v(dout0_113) AT=230.025n

.meas tran vdout0_114ck450 FIND v(dout0_114) AT=230.025n

.meas tran vdout0_115ck450 FIND v(dout0_115) AT=230.025n

.meas tran vdout0_116ck450 FIND v(dout0_116) AT=230.025n

.meas tran vdout0_117ck450 FIND v(dout0_117) AT=230.025n

.meas tran vdout0_118ck450 FIND v(dout0_118) AT=230.025n

.meas tran vdout0_119ck450 FIND v(dout0_119) AT=230.025n

.meas tran vdout0_120ck450 FIND v(dout0_120) AT=230.025n

.meas tran vdout0_121ck450 FIND v(dout0_121) AT=230.025n

.meas tran vdout0_122ck450 FIND v(dout0_122) AT=230.025n

.meas tran vdout0_123ck450 FIND v(dout0_123) AT=230.025n

.meas tran vdout0_124ck450 FIND v(dout0_124) AT=230.025n

.meas tran vdout0_125ck450 FIND v(dout0_125) AT=230.025n

.meas tran vdout0_126ck450 FIND v(dout0_126) AT=230.025n

.meas tran vdout0_127ck450 FIND v(dout0_127) AT=230.025n

.meas tran vdout0_0ck460 FIND v(dout0_0) AT=235.025n

.meas tran vdout0_1ck460 FIND v(dout0_1) AT=235.025n

.meas tran vdout0_2ck460 FIND v(dout0_2) AT=235.025n

.meas tran vdout0_3ck460 FIND v(dout0_3) AT=235.025n

.meas tran vdout0_4ck460 FIND v(dout0_4) AT=235.025n

.meas tran vdout0_5ck460 FIND v(dout0_5) AT=235.025n

.meas tran vdout0_6ck460 FIND v(dout0_6) AT=235.025n

.meas tran vdout0_7ck460 FIND v(dout0_7) AT=235.025n

.meas tran vdout0_8ck460 FIND v(dout0_8) AT=235.025n

.meas tran vdout0_9ck460 FIND v(dout0_9) AT=235.025n

.meas tran vdout0_10ck460 FIND v(dout0_10) AT=235.025n

.meas tran vdout0_11ck460 FIND v(dout0_11) AT=235.025n

.meas tran vdout0_12ck460 FIND v(dout0_12) AT=235.025n

.meas tran vdout0_13ck460 FIND v(dout0_13) AT=235.025n

.meas tran vdout0_14ck460 FIND v(dout0_14) AT=235.025n

.meas tran vdout0_15ck460 FIND v(dout0_15) AT=235.025n

.meas tran vdout0_16ck460 FIND v(dout0_16) AT=235.025n

.meas tran vdout0_17ck460 FIND v(dout0_17) AT=235.025n

.meas tran vdout0_18ck460 FIND v(dout0_18) AT=235.025n

.meas tran vdout0_19ck460 FIND v(dout0_19) AT=235.025n

.meas tran vdout0_20ck460 FIND v(dout0_20) AT=235.025n

.meas tran vdout0_21ck460 FIND v(dout0_21) AT=235.025n

.meas tran vdout0_22ck460 FIND v(dout0_22) AT=235.025n

.meas tran vdout0_23ck460 FIND v(dout0_23) AT=235.025n

.meas tran vdout0_24ck460 FIND v(dout0_24) AT=235.025n

.meas tran vdout0_25ck460 FIND v(dout0_25) AT=235.025n

.meas tran vdout0_26ck460 FIND v(dout0_26) AT=235.025n

.meas tran vdout0_27ck460 FIND v(dout0_27) AT=235.025n

.meas tran vdout0_28ck460 FIND v(dout0_28) AT=235.025n

.meas tran vdout0_29ck460 FIND v(dout0_29) AT=235.025n

.meas tran vdout0_30ck460 FIND v(dout0_30) AT=235.025n

.meas tran vdout0_31ck460 FIND v(dout0_31) AT=235.025n

.meas tran vdout0_32ck460 FIND v(dout0_32) AT=235.025n

.meas tran vdout0_33ck460 FIND v(dout0_33) AT=235.025n

.meas tran vdout0_34ck460 FIND v(dout0_34) AT=235.025n

.meas tran vdout0_35ck460 FIND v(dout0_35) AT=235.025n

.meas tran vdout0_36ck460 FIND v(dout0_36) AT=235.025n

.meas tran vdout0_37ck460 FIND v(dout0_37) AT=235.025n

.meas tran vdout0_38ck460 FIND v(dout0_38) AT=235.025n

.meas tran vdout0_39ck460 FIND v(dout0_39) AT=235.025n

.meas tran vdout0_40ck460 FIND v(dout0_40) AT=235.025n

.meas tran vdout0_41ck460 FIND v(dout0_41) AT=235.025n

.meas tran vdout0_42ck460 FIND v(dout0_42) AT=235.025n

.meas tran vdout0_43ck460 FIND v(dout0_43) AT=235.025n

.meas tran vdout0_44ck460 FIND v(dout0_44) AT=235.025n

.meas tran vdout0_45ck460 FIND v(dout0_45) AT=235.025n

.meas tran vdout0_46ck460 FIND v(dout0_46) AT=235.025n

.meas tran vdout0_47ck460 FIND v(dout0_47) AT=235.025n

.meas tran vdout0_48ck460 FIND v(dout0_48) AT=235.025n

.meas tran vdout0_49ck460 FIND v(dout0_49) AT=235.025n

.meas tran vdout0_50ck460 FIND v(dout0_50) AT=235.025n

.meas tran vdout0_51ck460 FIND v(dout0_51) AT=235.025n

.meas tran vdout0_52ck460 FIND v(dout0_52) AT=235.025n

.meas tran vdout0_53ck460 FIND v(dout0_53) AT=235.025n

.meas tran vdout0_54ck460 FIND v(dout0_54) AT=235.025n

.meas tran vdout0_55ck460 FIND v(dout0_55) AT=235.025n

.meas tran vdout0_56ck460 FIND v(dout0_56) AT=235.025n

.meas tran vdout0_57ck460 FIND v(dout0_57) AT=235.025n

.meas tran vdout0_58ck460 FIND v(dout0_58) AT=235.025n

.meas tran vdout0_59ck460 FIND v(dout0_59) AT=235.025n

.meas tran vdout0_60ck460 FIND v(dout0_60) AT=235.025n

.meas tran vdout0_61ck460 FIND v(dout0_61) AT=235.025n

.meas tran vdout0_62ck460 FIND v(dout0_62) AT=235.025n

.meas tran vdout0_63ck460 FIND v(dout0_63) AT=235.025n

.meas tran vdout0_64ck460 FIND v(dout0_64) AT=235.025n

.meas tran vdout0_65ck460 FIND v(dout0_65) AT=235.025n

.meas tran vdout0_66ck460 FIND v(dout0_66) AT=235.025n

.meas tran vdout0_67ck460 FIND v(dout0_67) AT=235.025n

.meas tran vdout0_68ck460 FIND v(dout0_68) AT=235.025n

.meas tran vdout0_69ck460 FIND v(dout0_69) AT=235.025n

.meas tran vdout0_70ck460 FIND v(dout0_70) AT=235.025n

.meas tran vdout0_71ck460 FIND v(dout0_71) AT=235.025n

.meas tran vdout0_72ck460 FIND v(dout0_72) AT=235.025n

.meas tran vdout0_73ck460 FIND v(dout0_73) AT=235.025n

.meas tran vdout0_74ck460 FIND v(dout0_74) AT=235.025n

.meas tran vdout0_75ck460 FIND v(dout0_75) AT=235.025n

.meas tran vdout0_76ck460 FIND v(dout0_76) AT=235.025n

.meas tran vdout0_77ck460 FIND v(dout0_77) AT=235.025n

.meas tran vdout0_78ck460 FIND v(dout0_78) AT=235.025n

.meas tran vdout0_79ck460 FIND v(dout0_79) AT=235.025n

.meas tran vdout0_80ck460 FIND v(dout0_80) AT=235.025n

.meas tran vdout0_81ck460 FIND v(dout0_81) AT=235.025n

.meas tran vdout0_82ck460 FIND v(dout0_82) AT=235.025n

.meas tran vdout0_83ck460 FIND v(dout0_83) AT=235.025n

.meas tran vdout0_84ck460 FIND v(dout0_84) AT=235.025n

.meas tran vdout0_85ck460 FIND v(dout0_85) AT=235.025n

.meas tran vdout0_86ck460 FIND v(dout0_86) AT=235.025n

.meas tran vdout0_87ck460 FIND v(dout0_87) AT=235.025n

.meas tran vdout0_88ck460 FIND v(dout0_88) AT=235.025n

.meas tran vdout0_89ck460 FIND v(dout0_89) AT=235.025n

.meas tran vdout0_90ck460 FIND v(dout0_90) AT=235.025n

.meas tran vdout0_91ck460 FIND v(dout0_91) AT=235.025n

.meas tran vdout0_92ck460 FIND v(dout0_92) AT=235.025n

.meas tran vdout0_93ck460 FIND v(dout0_93) AT=235.025n

.meas tran vdout0_94ck460 FIND v(dout0_94) AT=235.025n

.meas tran vdout0_95ck460 FIND v(dout0_95) AT=235.025n

.meas tran vdout0_96ck460 FIND v(dout0_96) AT=235.025n

.meas tran vdout0_97ck460 FIND v(dout0_97) AT=235.025n

.meas tran vdout0_98ck460 FIND v(dout0_98) AT=235.025n

.meas tran vdout0_99ck460 FIND v(dout0_99) AT=235.025n

.meas tran vdout0_100ck460 FIND v(dout0_100) AT=235.025n

.meas tran vdout0_101ck460 FIND v(dout0_101) AT=235.025n

.meas tran vdout0_102ck460 FIND v(dout0_102) AT=235.025n

.meas tran vdout0_103ck460 FIND v(dout0_103) AT=235.025n

.meas tran vdout0_104ck460 FIND v(dout0_104) AT=235.025n

.meas tran vdout0_105ck460 FIND v(dout0_105) AT=235.025n

.meas tran vdout0_106ck460 FIND v(dout0_106) AT=235.025n

.meas tran vdout0_107ck460 FIND v(dout0_107) AT=235.025n

.meas tran vdout0_108ck460 FIND v(dout0_108) AT=235.025n

.meas tran vdout0_109ck460 FIND v(dout0_109) AT=235.025n

.meas tran vdout0_110ck460 FIND v(dout0_110) AT=235.025n

.meas tran vdout0_111ck460 FIND v(dout0_111) AT=235.025n

.meas tran vdout0_112ck460 FIND v(dout0_112) AT=235.025n

.meas tran vdout0_113ck460 FIND v(dout0_113) AT=235.025n

.meas tran vdout0_114ck460 FIND v(dout0_114) AT=235.025n

.meas tran vdout0_115ck460 FIND v(dout0_115) AT=235.025n

.meas tran vdout0_116ck460 FIND v(dout0_116) AT=235.025n

.meas tran vdout0_117ck460 FIND v(dout0_117) AT=235.025n

.meas tran vdout0_118ck460 FIND v(dout0_118) AT=235.025n

.meas tran vdout0_119ck460 FIND v(dout0_119) AT=235.025n

.meas tran vdout0_120ck460 FIND v(dout0_120) AT=235.025n

.meas tran vdout0_121ck460 FIND v(dout0_121) AT=235.025n

.meas tran vdout0_122ck460 FIND v(dout0_122) AT=235.025n

.meas tran vdout0_123ck460 FIND v(dout0_123) AT=235.025n

.meas tran vdout0_124ck460 FIND v(dout0_124) AT=235.025n

.meas tran vdout0_125ck460 FIND v(dout0_125) AT=235.025n

.meas tran vdout0_126ck460 FIND v(dout0_126) AT=235.025n

.meas tran vdout0_127ck460 FIND v(dout0_127) AT=235.025n

.meas tran vdout0_0ck470 FIND v(dout0_0) AT=240.025n

.meas tran vdout0_1ck470 FIND v(dout0_1) AT=240.025n

.meas tran vdout0_2ck470 FIND v(dout0_2) AT=240.025n

.meas tran vdout0_3ck470 FIND v(dout0_3) AT=240.025n

.meas tran vdout0_4ck470 FIND v(dout0_4) AT=240.025n

.meas tran vdout0_5ck470 FIND v(dout0_5) AT=240.025n

.meas tran vdout0_6ck470 FIND v(dout0_6) AT=240.025n

.meas tran vdout0_7ck470 FIND v(dout0_7) AT=240.025n

.meas tran vdout0_8ck470 FIND v(dout0_8) AT=240.025n

.meas tran vdout0_9ck470 FIND v(dout0_9) AT=240.025n

.meas tran vdout0_10ck470 FIND v(dout0_10) AT=240.025n

.meas tran vdout0_11ck470 FIND v(dout0_11) AT=240.025n

.meas tran vdout0_12ck470 FIND v(dout0_12) AT=240.025n

.meas tran vdout0_13ck470 FIND v(dout0_13) AT=240.025n

.meas tran vdout0_14ck470 FIND v(dout0_14) AT=240.025n

.meas tran vdout0_15ck470 FIND v(dout0_15) AT=240.025n

.meas tran vdout0_16ck470 FIND v(dout0_16) AT=240.025n

.meas tran vdout0_17ck470 FIND v(dout0_17) AT=240.025n

.meas tran vdout0_18ck470 FIND v(dout0_18) AT=240.025n

.meas tran vdout0_19ck470 FIND v(dout0_19) AT=240.025n

.meas tran vdout0_20ck470 FIND v(dout0_20) AT=240.025n

.meas tran vdout0_21ck470 FIND v(dout0_21) AT=240.025n

.meas tran vdout0_22ck470 FIND v(dout0_22) AT=240.025n

.meas tran vdout0_23ck470 FIND v(dout0_23) AT=240.025n

.meas tran vdout0_24ck470 FIND v(dout0_24) AT=240.025n

.meas tran vdout0_25ck470 FIND v(dout0_25) AT=240.025n

.meas tran vdout0_26ck470 FIND v(dout0_26) AT=240.025n

.meas tran vdout0_27ck470 FIND v(dout0_27) AT=240.025n

.meas tran vdout0_28ck470 FIND v(dout0_28) AT=240.025n

.meas tran vdout0_29ck470 FIND v(dout0_29) AT=240.025n

.meas tran vdout0_30ck470 FIND v(dout0_30) AT=240.025n

.meas tran vdout0_31ck470 FIND v(dout0_31) AT=240.025n

.meas tran vdout0_32ck470 FIND v(dout0_32) AT=240.025n

.meas tran vdout0_33ck470 FIND v(dout0_33) AT=240.025n

.meas tran vdout0_34ck470 FIND v(dout0_34) AT=240.025n

.meas tran vdout0_35ck470 FIND v(dout0_35) AT=240.025n

.meas tran vdout0_36ck470 FIND v(dout0_36) AT=240.025n

.meas tran vdout0_37ck470 FIND v(dout0_37) AT=240.025n

.meas tran vdout0_38ck470 FIND v(dout0_38) AT=240.025n

.meas tran vdout0_39ck470 FIND v(dout0_39) AT=240.025n

.meas tran vdout0_40ck470 FIND v(dout0_40) AT=240.025n

.meas tran vdout0_41ck470 FIND v(dout0_41) AT=240.025n

.meas tran vdout0_42ck470 FIND v(dout0_42) AT=240.025n

.meas tran vdout0_43ck470 FIND v(dout0_43) AT=240.025n

.meas tran vdout0_44ck470 FIND v(dout0_44) AT=240.025n

.meas tran vdout0_45ck470 FIND v(dout0_45) AT=240.025n

.meas tran vdout0_46ck470 FIND v(dout0_46) AT=240.025n

.meas tran vdout0_47ck470 FIND v(dout0_47) AT=240.025n

.meas tran vdout0_48ck470 FIND v(dout0_48) AT=240.025n

.meas tran vdout0_49ck470 FIND v(dout0_49) AT=240.025n

.meas tran vdout0_50ck470 FIND v(dout0_50) AT=240.025n

.meas tran vdout0_51ck470 FIND v(dout0_51) AT=240.025n

.meas tran vdout0_52ck470 FIND v(dout0_52) AT=240.025n

.meas tran vdout0_53ck470 FIND v(dout0_53) AT=240.025n

.meas tran vdout0_54ck470 FIND v(dout0_54) AT=240.025n

.meas tran vdout0_55ck470 FIND v(dout0_55) AT=240.025n

.meas tran vdout0_56ck470 FIND v(dout0_56) AT=240.025n

.meas tran vdout0_57ck470 FIND v(dout0_57) AT=240.025n

.meas tran vdout0_58ck470 FIND v(dout0_58) AT=240.025n

.meas tran vdout0_59ck470 FIND v(dout0_59) AT=240.025n

.meas tran vdout0_60ck470 FIND v(dout0_60) AT=240.025n

.meas tran vdout0_61ck470 FIND v(dout0_61) AT=240.025n

.meas tran vdout0_62ck470 FIND v(dout0_62) AT=240.025n

.meas tran vdout0_63ck470 FIND v(dout0_63) AT=240.025n

.meas tran vdout0_64ck470 FIND v(dout0_64) AT=240.025n

.meas tran vdout0_65ck470 FIND v(dout0_65) AT=240.025n

.meas tran vdout0_66ck470 FIND v(dout0_66) AT=240.025n

.meas tran vdout0_67ck470 FIND v(dout0_67) AT=240.025n

.meas tran vdout0_68ck470 FIND v(dout0_68) AT=240.025n

.meas tran vdout0_69ck470 FIND v(dout0_69) AT=240.025n

.meas tran vdout0_70ck470 FIND v(dout0_70) AT=240.025n

.meas tran vdout0_71ck470 FIND v(dout0_71) AT=240.025n

.meas tran vdout0_72ck470 FIND v(dout0_72) AT=240.025n

.meas tran vdout0_73ck470 FIND v(dout0_73) AT=240.025n

.meas tran vdout0_74ck470 FIND v(dout0_74) AT=240.025n

.meas tran vdout0_75ck470 FIND v(dout0_75) AT=240.025n

.meas tran vdout0_76ck470 FIND v(dout0_76) AT=240.025n

.meas tran vdout0_77ck470 FIND v(dout0_77) AT=240.025n

.meas tran vdout0_78ck470 FIND v(dout0_78) AT=240.025n

.meas tran vdout0_79ck470 FIND v(dout0_79) AT=240.025n

.meas tran vdout0_80ck470 FIND v(dout0_80) AT=240.025n

.meas tran vdout0_81ck470 FIND v(dout0_81) AT=240.025n

.meas tran vdout0_82ck470 FIND v(dout0_82) AT=240.025n

.meas tran vdout0_83ck470 FIND v(dout0_83) AT=240.025n

.meas tran vdout0_84ck470 FIND v(dout0_84) AT=240.025n

.meas tran vdout0_85ck470 FIND v(dout0_85) AT=240.025n

.meas tran vdout0_86ck470 FIND v(dout0_86) AT=240.025n

.meas tran vdout0_87ck470 FIND v(dout0_87) AT=240.025n

.meas tran vdout0_88ck470 FIND v(dout0_88) AT=240.025n

.meas tran vdout0_89ck470 FIND v(dout0_89) AT=240.025n

.meas tran vdout0_90ck470 FIND v(dout0_90) AT=240.025n

.meas tran vdout0_91ck470 FIND v(dout0_91) AT=240.025n

.meas tran vdout0_92ck470 FIND v(dout0_92) AT=240.025n

.meas tran vdout0_93ck470 FIND v(dout0_93) AT=240.025n

.meas tran vdout0_94ck470 FIND v(dout0_94) AT=240.025n

.meas tran vdout0_95ck470 FIND v(dout0_95) AT=240.025n

.meas tran vdout0_96ck470 FIND v(dout0_96) AT=240.025n

.meas tran vdout0_97ck470 FIND v(dout0_97) AT=240.025n

.meas tran vdout0_98ck470 FIND v(dout0_98) AT=240.025n

.meas tran vdout0_99ck470 FIND v(dout0_99) AT=240.025n

.meas tran vdout0_100ck470 FIND v(dout0_100) AT=240.025n

.meas tran vdout0_101ck470 FIND v(dout0_101) AT=240.025n

.meas tran vdout0_102ck470 FIND v(dout0_102) AT=240.025n

.meas tran vdout0_103ck470 FIND v(dout0_103) AT=240.025n

.meas tran vdout0_104ck470 FIND v(dout0_104) AT=240.025n

.meas tran vdout0_105ck470 FIND v(dout0_105) AT=240.025n

.meas tran vdout0_106ck470 FIND v(dout0_106) AT=240.025n

.meas tran vdout0_107ck470 FIND v(dout0_107) AT=240.025n

.meas tran vdout0_108ck470 FIND v(dout0_108) AT=240.025n

.meas tran vdout0_109ck470 FIND v(dout0_109) AT=240.025n

.meas tran vdout0_110ck470 FIND v(dout0_110) AT=240.025n

.meas tran vdout0_111ck470 FIND v(dout0_111) AT=240.025n

.meas tran vdout0_112ck470 FIND v(dout0_112) AT=240.025n

.meas tran vdout0_113ck470 FIND v(dout0_113) AT=240.025n

.meas tran vdout0_114ck470 FIND v(dout0_114) AT=240.025n

.meas tran vdout0_115ck470 FIND v(dout0_115) AT=240.025n

.meas tran vdout0_116ck470 FIND v(dout0_116) AT=240.025n

.meas tran vdout0_117ck470 FIND v(dout0_117) AT=240.025n

.meas tran vdout0_118ck470 FIND v(dout0_118) AT=240.025n

.meas tran vdout0_119ck470 FIND v(dout0_119) AT=240.025n

.meas tran vdout0_120ck470 FIND v(dout0_120) AT=240.025n

.meas tran vdout0_121ck470 FIND v(dout0_121) AT=240.025n

.meas tran vdout0_122ck470 FIND v(dout0_122) AT=240.025n

.meas tran vdout0_123ck470 FIND v(dout0_123) AT=240.025n

.meas tran vdout0_124ck470 FIND v(dout0_124) AT=240.025n

.meas tran vdout0_125ck470 FIND v(dout0_125) AT=240.025n

.meas tran vdout0_126ck470 FIND v(dout0_126) AT=240.025n

.meas tran vdout0_127ck470 FIND v(dout0_127) AT=240.025n

.meas tran vdout0_0ck480 FIND v(dout0_0) AT=245.025n

.meas tran vdout0_1ck480 FIND v(dout0_1) AT=245.025n

.meas tran vdout0_2ck480 FIND v(dout0_2) AT=245.025n

.meas tran vdout0_3ck480 FIND v(dout0_3) AT=245.025n

.meas tran vdout0_4ck480 FIND v(dout0_4) AT=245.025n

.meas tran vdout0_5ck480 FIND v(dout0_5) AT=245.025n

.meas tran vdout0_6ck480 FIND v(dout0_6) AT=245.025n

.meas tran vdout0_7ck480 FIND v(dout0_7) AT=245.025n

.meas tran vdout0_8ck480 FIND v(dout0_8) AT=245.025n

.meas tran vdout0_9ck480 FIND v(dout0_9) AT=245.025n

.meas tran vdout0_10ck480 FIND v(dout0_10) AT=245.025n

.meas tran vdout0_11ck480 FIND v(dout0_11) AT=245.025n

.meas tran vdout0_12ck480 FIND v(dout0_12) AT=245.025n

.meas tran vdout0_13ck480 FIND v(dout0_13) AT=245.025n

.meas tran vdout0_14ck480 FIND v(dout0_14) AT=245.025n

.meas tran vdout0_15ck480 FIND v(dout0_15) AT=245.025n

.meas tran vdout0_16ck480 FIND v(dout0_16) AT=245.025n

.meas tran vdout0_17ck480 FIND v(dout0_17) AT=245.025n

.meas tran vdout0_18ck480 FIND v(dout0_18) AT=245.025n

.meas tran vdout0_19ck480 FIND v(dout0_19) AT=245.025n

.meas tran vdout0_20ck480 FIND v(dout0_20) AT=245.025n

.meas tran vdout0_21ck480 FIND v(dout0_21) AT=245.025n

.meas tran vdout0_22ck480 FIND v(dout0_22) AT=245.025n

.meas tran vdout0_23ck480 FIND v(dout0_23) AT=245.025n

.meas tran vdout0_24ck480 FIND v(dout0_24) AT=245.025n

.meas tran vdout0_25ck480 FIND v(dout0_25) AT=245.025n

.meas tran vdout0_26ck480 FIND v(dout0_26) AT=245.025n

.meas tran vdout0_27ck480 FIND v(dout0_27) AT=245.025n

.meas tran vdout0_28ck480 FIND v(dout0_28) AT=245.025n

.meas tran vdout0_29ck480 FIND v(dout0_29) AT=245.025n

.meas tran vdout0_30ck480 FIND v(dout0_30) AT=245.025n

.meas tran vdout0_31ck480 FIND v(dout0_31) AT=245.025n

.meas tran vdout0_32ck480 FIND v(dout0_32) AT=245.025n

.meas tran vdout0_33ck480 FIND v(dout0_33) AT=245.025n

.meas tran vdout0_34ck480 FIND v(dout0_34) AT=245.025n

.meas tran vdout0_35ck480 FIND v(dout0_35) AT=245.025n

.meas tran vdout0_36ck480 FIND v(dout0_36) AT=245.025n

.meas tran vdout0_37ck480 FIND v(dout0_37) AT=245.025n

.meas tran vdout0_38ck480 FIND v(dout0_38) AT=245.025n

.meas tran vdout0_39ck480 FIND v(dout0_39) AT=245.025n

.meas tran vdout0_40ck480 FIND v(dout0_40) AT=245.025n

.meas tran vdout0_41ck480 FIND v(dout0_41) AT=245.025n

.meas tran vdout0_42ck480 FIND v(dout0_42) AT=245.025n

.meas tran vdout0_43ck480 FIND v(dout0_43) AT=245.025n

.meas tran vdout0_44ck480 FIND v(dout0_44) AT=245.025n

.meas tran vdout0_45ck480 FIND v(dout0_45) AT=245.025n

.meas tran vdout0_46ck480 FIND v(dout0_46) AT=245.025n

.meas tran vdout0_47ck480 FIND v(dout0_47) AT=245.025n

.meas tran vdout0_48ck480 FIND v(dout0_48) AT=245.025n

.meas tran vdout0_49ck480 FIND v(dout0_49) AT=245.025n

.meas tran vdout0_50ck480 FIND v(dout0_50) AT=245.025n

.meas tran vdout0_51ck480 FIND v(dout0_51) AT=245.025n

.meas tran vdout0_52ck480 FIND v(dout0_52) AT=245.025n

.meas tran vdout0_53ck480 FIND v(dout0_53) AT=245.025n

.meas tran vdout0_54ck480 FIND v(dout0_54) AT=245.025n

.meas tran vdout0_55ck480 FIND v(dout0_55) AT=245.025n

.meas tran vdout0_56ck480 FIND v(dout0_56) AT=245.025n

.meas tran vdout0_57ck480 FIND v(dout0_57) AT=245.025n

.meas tran vdout0_58ck480 FIND v(dout0_58) AT=245.025n

.meas tran vdout0_59ck480 FIND v(dout0_59) AT=245.025n

.meas tran vdout0_60ck480 FIND v(dout0_60) AT=245.025n

.meas tran vdout0_61ck480 FIND v(dout0_61) AT=245.025n

.meas tran vdout0_62ck480 FIND v(dout0_62) AT=245.025n

.meas tran vdout0_63ck480 FIND v(dout0_63) AT=245.025n

.meas tran vdout0_64ck480 FIND v(dout0_64) AT=245.025n

.meas tran vdout0_65ck480 FIND v(dout0_65) AT=245.025n

.meas tran vdout0_66ck480 FIND v(dout0_66) AT=245.025n

.meas tran vdout0_67ck480 FIND v(dout0_67) AT=245.025n

.meas tran vdout0_68ck480 FIND v(dout0_68) AT=245.025n

.meas tran vdout0_69ck480 FIND v(dout0_69) AT=245.025n

.meas tran vdout0_70ck480 FIND v(dout0_70) AT=245.025n

.meas tran vdout0_71ck480 FIND v(dout0_71) AT=245.025n

.meas tran vdout0_72ck480 FIND v(dout0_72) AT=245.025n

.meas tran vdout0_73ck480 FIND v(dout0_73) AT=245.025n

.meas tran vdout0_74ck480 FIND v(dout0_74) AT=245.025n

.meas tran vdout0_75ck480 FIND v(dout0_75) AT=245.025n

.meas tran vdout0_76ck480 FIND v(dout0_76) AT=245.025n

.meas tran vdout0_77ck480 FIND v(dout0_77) AT=245.025n

.meas tran vdout0_78ck480 FIND v(dout0_78) AT=245.025n

.meas tran vdout0_79ck480 FIND v(dout0_79) AT=245.025n

.meas tran vdout0_80ck480 FIND v(dout0_80) AT=245.025n

.meas tran vdout0_81ck480 FIND v(dout0_81) AT=245.025n

.meas tran vdout0_82ck480 FIND v(dout0_82) AT=245.025n

.meas tran vdout0_83ck480 FIND v(dout0_83) AT=245.025n

.meas tran vdout0_84ck480 FIND v(dout0_84) AT=245.025n

.meas tran vdout0_85ck480 FIND v(dout0_85) AT=245.025n

.meas tran vdout0_86ck480 FIND v(dout0_86) AT=245.025n

.meas tran vdout0_87ck480 FIND v(dout0_87) AT=245.025n

.meas tran vdout0_88ck480 FIND v(dout0_88) AT=245.025n

.meas tran vdout0_89ck480 FIND v(dout0_89) AT=245.025n

.meas tran vdout0_90ck480 FIND v(dout0_90) AT=245.025n

.meas tran vdout0_91ck480 FIND v(dout0_91) AT=245.025n

.meas tran vdout0_92ck480 FIND v(dout0_92) AT=245.025n

.meas tran vdout0_93ck480 FIND v(dout0_93) AT=245.025n

.meas tran vdout0_94ck480 FIND v(dout0_94) AT=245.025n

.meas tran vdout0_95ck480 FIND v(dout0_95) AT=245.025n

.meas tran vdout0_96ck480 FIND v(dout0_96) AT=245.025n

.meas tran vdout0_97ck480 FIND v(dout0_97) AT=245.025n

.meas tran vdout0_98ck480 FIND v(dout0_98) AT=245.025n

.meas tran vdout0_99ck480 FIND v(dout0_99) AT=245.025n

.meas tran vdout0_100ck480 FIND v(dout0_100) AT=245.025n

.meas tran vdout0_101ck480 FIND v(dout0_101) AT=245.025n

.meas tran vdout0_102ck480 FIND v(dout0_102) AT=245.025n

.meas tran vdout0_103ck480 FIND v(dout0_103) AT=245.025n

.meas tran vdout0_104ck480 FIND v(dout0_104) AT=245.025n

.meas tran vdout0_105ck480 FIND v(dout0_105) AT=245.025n

.meas tran vdout0_106ck480 FIND v(dout0_106) AT=245.025n

.meas tran vdout0_107ck480 FIND v(dout0_107) AT=245.025n

.meas tran vdout0_108ck480 FIND v(dout0_108) AT=245.025n

.meas tran vdout0_109ck480 FIND v(dout0_109) AT=245.025n

.meas tran vdout0_110ck480 FIND v(dout0_110) AT=245.025n

.meas tran vdout0_111ck480 FIND v(dout0_111) AT=245.025n

.meas tran vdout0_112ck480 FIND v(dout0_112) AT=245.025n

.meas tran vdout0_113ck480 FIND v(dout0_113) AT=245.025n

.meas tran vdout0_114ck480 FIND v(dout0_114) AT=245.025n

.meas tran vdout0_115ck480 FIND v(dout0_115) AT=245.025n

.meas tran vdout0_116ck480 FIND v(dout0_116) AT=245.025n

.meas tran vdout0_117ck480 FIND v(dout0_117) AT=245.025n

.meas tran vdout0_118ck480 FIND v(dout0_118) AT=245.025n

.meas tran vdout0_119ck480 FIND v(dout0_119) AT=245.025n

.meas tran vdout0_120ck480 FIND v(dout0_120) AT=245.025n

.meas tran vdout0_121ck480 FIND v(dout0_121) AT=245.025n

.meas tran vdout0_122ck480 FIND v(dout0_122) AT=245.025n

.meas tran vdout0_123ck480 FIND v(dout0_123) AT=245.025n

.meas tran vdout0_124ck480 FIND v(dout0_124) AT=245.025n

.meas tran vdout0_125ck480 FIND v(dout0_125) AT=245.025n

.meas tran vdout0_126ck480 FIND v(dout0_126) AT=245.025n

.meas tran vdout0_127ck480 FIND v(dout0_127) AT=245.025n

.meas tran vdout0_0ck490 FIND v(dout0_0) AT=250.025n

.meas tran vdout0_1ck490 FIND v(dout0_1) AT=250.025n

.meas tran vdout0_2ck490 FIND v(dout0_2) AT=250.025n

.meas tran vdout0_3ck490 FIND v(dout0_3) AT=250.025n

.meas tran vdout0_4ck490 FIND v(dout0_4) AT=250.025n

.meas tran vdout0_5ck490 FIND v(dout0_5) AT=250.025n

.meas tran vdout0_6ck490 FIND v(dout0_6) AT=250.025n

.meas tran vdout0_7ck490 FIND v(dout0_7) AT=250.025n

.meas tran vdout0_8ck490 FIND v(dout0_8) AT=250.025n

.meas tran vdout0_9ck490 FIND v(dout0_9) AT=250.025n

.meas tran vdout0_10ck490 FIND v(dout0_10) AT=250.025n

.meas tran vdout0_11ck490 FIND v(dout0_11) AT=250.025n

.meas tran vdout0_12ck490 FIND v(dout0_12) AT=250.025n

.meas tran vdout0_13ck490 FIND v(dout0_13) AT=250.025n

.meas tran vdout0_14ck490 FIND v(dout0_14) AT=250.025n

.meas tran vdout0_15ck490 FIND v(dout0_15) AT=250.025n

.meas tran vdout0_16ck490 FIND v(dout0_16) AT=250.025n

.meas tran vdout0_17ck490 FIND v(dout0_17) AT=250.025n

.meas tran vdout0_18ck490 FIND v(dout0_18) AT=250.025n

.meas tran vdout0_19ck490 FIND v(dout0_19) AT=250.025n

.meas tran vdout0_20ck490 FIND v(dout0_20) AT=250.025n

.meas tran vdout0_21ck490 FIND v(dout0_21) AT=250.025n

.meas tran vdout0_22ck490 FIND v(dout0_22) AT=250.025n

.meas tran vdout0_23ck490 FIND v(dout0_23) AT=250.025n

.meas tran vdout0_24ck490 FIND v(dout0_24) AT=250.025n

.meas tran vdout0_25ck490 FIND v(dout0_25) AT=250.025n

.meas tran vdout0_26ck490 FIND v(dout0_26) AT=250.025n

.meas tran vdout0_27ck490 FIND v(dout0_27) AT=250.025n

.meas tran vdout0_28ck490 FIND v(dout0_28) AT=250.025n

.meas tran vdout0_29ck490 FIND v(dout0_29) AT=250.025n

.meas tran vdout0_30ck490 FIND v(dout0_30) AT=250.025n

.meas tran vdout0_31ck490 FIND v(dout0_31) AT=250.025n

.meas tran vdout0_32ck490 FIND v(dout0_32) AT=250.025n

.meas tran vdout0_33ck490 FIND v(dout0_33) AT=250.025n

.meas tran vdout0_34ck490 FIND v(dout0_34) AT=250.025n

.meas tran vdout0_35ck490 FIND v(dout0_35) AT=250.025n

.meas tran vdout0_36ck490 FIND v(dout0_36) AT=250.025n

.meas tran vdout0_37ck490 FIND v(dout0_37) AT=250.025n

.meas tran vdout0_38ck490 FIND v(dout0_38) AT=250.025n

.meas tran vdout0_39ck490 FIND v(dout0_39) AT=250.025n

.meas tran vdout0_40ck490 FIND v(dout0_40) AT=250.025n

.meas tran vdout0_41ck490 FIND v(dout0_41) AT=250.025n

.meas tran vdout0_42ck490 FIND v(dout0_42) AT=250.025n

.meas tran vdout0_43ck490 FIND v(dout0_43) AT=250.025n

.meas tran vdout0_44ck490 FIND v(dout0_44) AT=250.025n

.meas tran vdout0_45ck490 FIND v(dout0_45) AT=250.025n

.meas tran vdout0_46ck490 FIND v(dout0_46) AT=250.025n

.meas tran vdout0_47ck490 FIND v(dout0_47) AT=250.025n

.meas tran vdout0_48ck490 FIND v(dout0_48) AT=250.025n

.meas tran vdout0_49ck490 FIND v(dout0_49) AT=250.025n

.meas tran vdout0_50ck490 FIND v(dout0_50) AT=250.025n

.meas tran vdout0_51ck490 FIND v(dout0_51) AT=250.025n

.meas tran vdout0_52ck490 FIND v(dout0_52) AT=250.025n

.meas tran vdout0_53ck490 FIND v(dout0_53) AT=250.025n

.meas tran vdout0_54ck490 FIND v(dout0_54) AT=250.025n

.meas tran vdout0_55ck490 FIND v(dout0_55) AT=250.025n

.meas tran vdout0_56ck490 FIND v(dout0_56) AT=250.025n

.meas tran vdout0_57ck490 FIND v(dout0_57) AT=250.025n

.meas tran vdout0_58ck490 FIND v(dout0_58) AT=250.025n

.meas tran vdout0_59ck490 FIND v(dout0_59) AT=250.025n

.meas tran vdout0_60ck490 FIND v(dout0_60) AT=250.025n

.meas tran vdout0_61ck490 FIND v(dout0_61) AT=250.025n

.meas tran vdout0_62ck490 FIND v(dout0_62) AT=250.025n

.meas tran vdout0_63ck490 FIND v(dout0_63) AT=250.025n

.meas tran vdout0_64ck490 FIND v(dout0_64) AT=250.025n

.meas tran vdout0_65ck490 FIND v(dout0_65) AT=250.025n

.meas tran vdout0_66ck490 FIND v(dout0_66) AT=250.025n

.meas tran vdout0_67ck490 FIND v(dout0_67) AT=250.025n

.meas tran vdout0_68ck490 FIND v(dout0_68) AT=250.025n

.meas tran vdout0_69ck490 FIND v(dout0_69) AT=250.025n

.meas tran vdout0_70ck490 FIND v(dout0_70) AT=250.025n

.meas tran vdout0_71ck490 FIND v(dout0_71) AT=250.025n

.meas tran vdout0_72ck490 FIND v(dout0_72) AT=250.025n

.meas tran vdout0_73ck490 FIND v(dout0_73) AT=250.025n

.meas tran vdout0_74ck490 FIND v(dout0_74) AT=250.025n

.meas tran vdout0_75ck490 FIND v(dout0_75) AT=250.025n

.meas tran vdout0_76ck490 FIND v(dout0_76) AT=250.025n

.meas tran vdout0_77ck490 FIND v(dout0_77) AT=250.025n

.meas tran vdout0_78ck490 FIND v(dout0_78) AT=250.025n

.meas tran vdout0_79ck490 FIND v(dout0_79) AT=250.025n

.meas tran vdout0_80ck490 FIND v(dout0_80) AT=250.025n

.meas tran vdout0_81ck490 FIND v(dout0_81) AT=250.025n

.meas tran vdout0_82ck490 FIND v(dout0_82) AT=250.025n

.meas tran vdout0_83ck490 FIND v(dout0_83) AT=250.025n

.meas tran vdout0_84ck490 FIND v(dout0_84) AT=250.025n

.meas tran vdout0_85ck490 FIND v(dout0_85) AT=250.025n

.meas tran vdout0_86ck490 FIND v(dout0_86) AT=250.025n

.meas tran vdout0_87ck490 FIND v(dout0_87) AT=250.025n

.meas tran vdout0_88ck490 FIND v(dout0_88) AT=250.025n

.meas tran vdout0_89ck490 FIND v(dout0_89) AT=250.025n

.meas tran vdout0_90ck490 FIND v(dout0_90) AT=250.025n

.meas tran vdout0_91ck490 FIND v(dout0_91) AT=250.025n

.meas tran vdout0_92ck490 FIND v(dout0_92) AT=250.025n

.meas tran vdout0_93ck490 FIND v(dout0_93) AT=250.025n

.meas tran vdout0_94ck490 FIND v(dout0_94) AT=250.025n

.meas tran vdout0_95ck490 FIND v(dout0_95) AT=250.025n

.meas tran vdout0_96ck490 FIND v(dout0_96) AT=250.025n

.meas tran vdout0_97ck490 FIND v(dout0_97) AT=250.025n

.meas tran vdout0_98ck490 FIND v(dout0_98) AT=250.025n

.meas tran vdout0_99ck490 FIND v(dout0_99) AT=250.025n

.meas tran vdout0_100ck490 FIND v(dout0_100) AT=250.025n

.meas tran vdout0_101ck490 FIND v(dout0_101) AT=250.025n

.meas tran vdout0_102ck490 FIND v(dout0_102) AT=250.025n

.meas tran vdout0_103ck490 FIND v(dout0_103) AT=250.025n

.meas tran vdout0_104ck490 FIND v(dout0_104) AT=250.025n

.meas tran vdout0_105ck490 FIND v(dout0_105) AT=250.025n

.meas tran vdout0_106ck490 FIND v(dout0_106) AT=250.025n

.meas tran vdout0_107ck490 FIND v(dout0_107) AT=250.025n

.meas tran vdout0_108ck490 FIND v(dout0_108) AT=250.025n

.meas tran vdout0_109ck490 FIND v(dout0_109) AT=250.025n

.meas tran vdout0_110ck490 FIND v(dout0_110) AT=250.025n

.meas tran vdout0_111ck490 FIND v(dout0_111) AT=250.025n

.meas tran vdout0_112ck490 FIND v(dout0_112) AT=250.025n

.meas tran vdout0_113ck490 FIND v(dout0_113) AT=250.025n

.meas tran vdout0_114ck490 FIND v(dout0_114) AT=250.025n

.meas tran vdout0_115ck490 FIND v(dout0_115) AT=250.025n

.meas tran vdout0_116ck490 FIND v(dout0_116) AT=250.025n

.meas tran vdout0_117ck490 FIND v(dout0_117) AT=250.025n

.meas tran vdout0_118ck490 FIND v(dout0_118) AT=250.025n

.meas tran vdout0_119ck490 FIND v(dout0_119) AT=250.025n

.meas tran vdout0_120ck490 FIND v(dout0_120) AT=250.025n

.meas tran vdout0_121ck490 FIND v(dout0_121) AT=250.025n

.meas tran vdout0_122ck490 FIND v(dout0_122) AT=250.025n

.meas tran vdout0_123ck490 FIND v(dout0_123) AT=250.025n

.meas tran vdout0_124ck490 FIND v(dout0_124) AT=250.025n

.meas tran vdout0_125ck490 FIND v(dout0_125) AT=250.025n

.meas tran vdout0_126ck490 FIND v(dout0_126) AT=250.025n

.meas tran vdout0_127ck490 FIND v(dout0_127) AT=250.025n

.meas tran vdout0_0ck510 FIND v(dout0_0) AT=260.025n

.meas tran vdout0_1ck510 FIND v(dout0_1) AT=260.025n

.meas tran vdout0_2ck510 FIND v(dout0_2) AT=260.025n

.meas tran vdout0_3ck510 FIND v(dout0_3) AT=260.025n

.meas tran vdout0_4ck510 FIND v(dout0_4) AT=260.025n

.meas tran vdout0_5ck510 FIND v(dout0_5) AT=260.025n

.meas tran vdout0_6ck510 FIND v(dout0_6) AT=260.025n

.meas tran vdout0_7ck510 FIND v(dout0_7) AT=260.025n

.meas tran vdout0_8ck510 FIND v(dout0_8) AT=260.025n

.meas tran vdout0_9ck510 FIND v(dout0_9) AT=260.025n

.meas tran vdout0_10ck510 FIND v(dout0_10) AT=260.025n

.meas tran vdout0_11ck510 FIND v(dout0_11) AT=260.025n

.meas tran vdout0_12ck510 FIND v(dout0_12) AT=260.025n

.meas tran vdout0_13ck510 FIND v(dout0_13) AT=260.025n

.meas tran vdout0_14ck510 FIND v(dout0_14) AT=260.025n

.meas tran vdout0_15ck510 FIND v(dout0_15) AT=260.025n

.meas tran vdout0_16ck510 FIND v(dout0_16) AT=260.025n

.meas tran vdout0_17ck510 FIND v(dout0_17) AT=260.025n

.meas tran vdout0_18ck510 FIND v(dout0_18) AT=260.025n

.meas tran vdout0_19ck510 FIND v(dout0_19) AT=260.025n

.meas tran vdout0_20ck510 FIND v(dout0_20) AT=260.025n

.meas tran vdout0_21ck510 FIND v(dout0_21) AT=260.025n

.meas tran vdout0_22ck510 FIND v(dout0_22) AT=260.025n

.meas tran vdout0_23ck510 FIND v(dout0_23) AT=260.025n

.meas tran vdout0_24ck510 FIND v(dout0_24) AT=260.025n

.meas tran vdout0_25ck510 FIND v(dout0_25) AT=260.025n

.meas tran vdout0_26ck510 FIND v(dout0_26) AT=260.025n

.meas tran vdout0_27ck510 FIND v(dout0_27) AT=260.025n

.meas tran vdout0_28ck510 FIND v(dout0_28) AT=260.025n

.meas tran vdout0_29ck510 FIND v(dout0_29) AT=260.025n

.meas tran vdout0_30ck510 FIND v(dout0_30) AT=260.025n

.meas tran vdout0_31ck510 FIND v(dout0_31) AT=260.025n

.meas tran vdout0_32ck510 FIND v(dout0_32) AT=260.025n

.meas tran vdout0_33ck510 FIND v(dout0_33) AT=260.025n

.meas tran vdout0_34ck510 FIND v(dout0_34) AT=260.025n

.meas tran vdout0_35ck510 FIND v(dout0_35) AT=260.025n

.meas tran vdout0_36ck510 FIND v(dout0_36) AT=260.025n

.meas tran vdout0_37ck510 FIND v(dout0_37) AT=260.025n

.meas tran vdout0_38ck510 FIND v(dout0_38) AT=260.025n

.meas tran vdout0_39ck510 FIND v(dout0_39) AT=260.025n

.meas tran vdout0_40ck510 FIND v(dout0_40) AT=260.025n

.meas tran vdout0_41ck510 FIND v(dout0_41) AT=260.025n

.meas tran vdout0_42ck510 FIND v(dout0_42) AT=260.025n

.meas tran vdout0_43ck510 FIND v(dout0_43) AT=260.025n

.meas tran vdout0_44ck510 FIND v(dout0_44) AT=260.025n

.meas tran vdout0_45ck510 FIND v(dout0_45) AT=260.025n

.meas tran vdout0_46ck510 FIND v(dout0_46) AT=260.025n

.meas tran vdout0_47ck510 FIND v(dout0_47) AT=260.025n

.meas tran vdout0_48ck510 FIND v(dout0_48) AT=260.025n

.meas tran vdout0_49ck510 FIND v(dout0_49) AT=260.025n

.meas tran vdout0_50ck510 FIND v(dout0_50) AT=260.025n

.meas tran vdout0_51ck510 FIND v(dout0_51) AT=260.025n

.meas tran vdout0_52ck510 FIND v(dout0_52) AT=260.025n

.meas tran vdout0_53ck510 FIND v(dout0_53) AT=260.025n

.meas tran vdout0_54ck510 FIND v(dout0_54) AT=260.025n

.meas tran vdout0_55ck510 FIND v(dout0_55) AT=260.025n

.meas tran vdout0_56ck510 FIND v(dout0_56) AT=260.025n

.meas tran vdout0_57ck510 FIND v(dout0_57) AT=260.025n

.meas tran vdout0_58ck510 FIND v(dout0_58) AT=260.025n

.meas tran vdout0_59ck510 FIND v(dout0_59) AT=260.025n

.meas tran vdout0_60ck510 FIND v(dout0_60) AT=260.025n

.meas tran vdout0_61ck510 FIND v(dout0_61) AT=260.025n

.meas tran vdout0_62ck510 FIND v(dout0_62) AT=260.025n

.meas tran vdout0_63ck510 FIND v(dout0_63) AT=260.025n

.meas tran vdout0_64ck510 FIND v(dout0_64) AT=260.025n

.meas tran vdout0_65ck510 FIND v(dout0_65) AT=260.025n

.meas tran vdout0_66ck510 FIND v(dout0_66) AT=260.025n

.meas tran vdout0_67ck510 FIND v(dout0_67) AT=260.025n

.meas tran vdout0_68ck510 FIND v(dout0_68) AT=260.025n

.meas tran vdout0_69ck510 FIND v(dout0_69) AT=260.025n

.meas tran vdout0_70ck510 FIND v(dout0_70) AT=260.025n

.meas tran vdout0_71ck510 FIND v(dout0_71) AT=260.025n

.meas tran vdout0_72ck510 FIND v(dout0_72) AT=260.025n

.meas tran vdout0_73ck510 FIND v(dout0_73) AT=260.025n

.meas tran vdout0_74ck510 FIND v(dout0_74) AT=260.025n

.meas tran vdout0_75ck510 FIND v(dout0_75) AT=260.025n

.meas tran vdout0_76ck510 FIND v(dout0_76) AT=260.025n

.meas tran vdout0_77ck510 FIND v(dout0_77) AT=260.025n

.meas tran vdout0_78ck510 FIND v(dout0_78) AT=260.025n

.meas tran vdout0_79ck510 FIND v(dout0_79) AT=260.025n

.meas tran vdout0_80ck510 FIND v(dout0_80) AT=260.025n

.meas tran vdout0_81ck510 FIND v(dout0_81) AT=260.025n

.meas tran vdout0_82ck510 FIND v(dout0_82) AT=260.025n

.meas tran vdout0_83ck510 FIND v(dout0_83) AT=260.025n

.meas tran vdout0_84ck510 FIND v(dout0_84) AT=260.025n

.meas tran vdout0_85ck510 FIND v(dout0_85) AT=260.025n

.meas tran vdout0_86ck510 FIND v(dout0_86) AT=260.025n

.meas tran vdout0_87ck510 FIND v(dout0_87) AT=260.025n

.meas tran vdout0_88ck510 FIND v(dout0_88) AT=260.025n

.meas tran vdout0_89ck510 FIND v(dout0_89) AT=260.025n

.meas tran vdout0_90ck510 FIND v(dout0_90) AT=260.025n

.meas tran vdout0_91ck510 FIND v(dout0_91) AT=260.025n

.meas tran vdout0_92ck510 FIND v(dout0_92) AT=260.025n

.meas tran vdout0_93ck510 FIND v(dout0_93) AT=260.025n

.meas tran vdout0_94ck510 FIND v(dout0_94) AT=260.025n

.meas tran vdout0_95ck510 FIND v(dout0_95) AT=260.025n

.meas tran vdout0_96ck510 FIND v(dout0_96) AT=260.025n

.meas tran vdout0_97ck510 FIND v(dout0_97) AT=260.025n

.meas tran vdout0_98ck510 FIND v(dout0_98) AT=260.025n

.meas tran vdout0_99ck510 FIND v(dout0_99) AT=260.025n

.meas tran vdout0_100ck510 FIND v(dout0_100) AT=260.025n

.meas tran vdout0_101ck510 FIND v(dout0_101) AT=260.025n

.meas tran vdout0_102ck510 FIND v(dout0_102) AT=260.025n

.meas tran vdout0_103ck510 FIND v(dout0_103) AT=260.025n

.meas tran vdout0_104ck510 FIND v(dout0_104) AT=260.025n

.meas tran vdout0_105ck510 FIND v(dout0_105) AT=260.025n

.meas tran vdout0_106ck510 FIND v(dout0_106) AT=260.025n

.meas tran vdout0_107ck510 FIND v(dout0_107) AT=260.025n

.meas tran vdout0_108ck510 FIND v(dout0_108) AT=260.025n

.meas tran vdout0_109ck510 FIND v(dout0_109) AT=260.025n

.meas tran vdout0_110ck510 FIND v(dout0_110) AT=260.025n

.meas tran vdout0_111ck510 FIND v(dout0_111) AT=260.025n

.meas tran vdout0_112ck510 FIND v(dout0_112) AT=260.025n

.meas tran vdout0_113ck510 FIND v(dout0_113) AT=260.025n

.meas tran vdout0_114ck510 FIND v(dout0_114) AT=260.025n

.meas tran vdout0_115ck510 FIND v(dout0_115) AT=260.025n

.meas tran vdout0_116ck510 FIND v(dout0_116) AT=260.025n

.meas tran vdout0_117ck510 FIND v(dout0_117) AT=260.025n

.meas tran vdout0_118ck510 FIND v(dout0_118) AT=260.025n

.meas tran vdout0_119ck510 FIND v(dout0_119) AT=260.025n

.meas tran vdout0_120ck510 FIND v(dout0_120) AT=260.025n

.meas tran vdout0_121ck510 FIND v(dout0_121) AT=260.025n

.meas tran vdout0_122ck510 FIND v(dout0_122) AT=260.025n

.meas tran vdout0_123ck510 FIND v(dout0_123) AT=260.025n

.meas tran vdout0_124ck510 FIND v(dout0_124) AT=260.025n

.meas tran vdout0_125ck510 FIND v(dout0_125) AT=260.025n

.meas tran vdout0_126ck510 FIND v(dout0_126) AT=260.025n

.meas tran vdout0_127ck510 FIND v(dout0_127) AT=260.025n

.meas tran vdout0_0ck520 FIND v(dout0_0) AT=265.025n

.meas tran vdout0_1ck520 FIND v(dout0_1) AT=265.025n

.meas tran vdout0_2ck520 FIND v(dout0_2) AT=265.025n

.meas tran vdout0_3ck520 FIND v(dout0_3) AT=265.025n

.meas tran vdout0_4ck520 FIND v(dout0_4) AT=265.025n

.meas tran vdout0_5ck520 FIND v(dout0_5) AT=265.025n

.meas tran vdout0_6ck520 FIND v(dout0_6) AT=265.025n

.meas tran vdout0_7ck520 FIND v(dout0_7) AT=265.025n

.meas tran vdout0_8ck520 FIND v(dout0_8) AT=265.025n

.meas tran vdout0_9ck520 FIND v(dout0_9) AT=265.025n

.meas tran vdout0_10ck520 FIND v(dout0_10) AT=265.025n

.meas tran vdout0_11ck520 FIND v(dout0_11) AT=265.025n

.meas tran vdout0_12ck520 FIND v(dout0_12) AT=265.025n

.meas tran vdout0_13ck520 FIND v(dout0_13) AT=265.025n

.meas tran vdout0_14ck520 FIND v(dout0_14) AT=265.025n

.meas tran vdout0_15ck520 FIND v(dout0_15) AT=265.025n

.meas tran vdout0_16ck520 FIND v(dout0_16) AT=265.025n

.meas tran vdout0_17ck520 FIND v(dout0_17) AT=265.025n

.meas tran vdout0_18ck520 FIND v(dout0_18) AT=265.025n

.meas tran vdout0_19ck520 FIND v(dout0_19) AT=265.025n

.meas tran vdout0_20ck520 FIND v(dout0_20) AT=265.025n

.meas tran vdout0_21ck520 FIND v(dout0_21) AT=265.025n

.meas tran vdout0_22ck520 FIND v(dout0_22) AT=265.025n

.meas tran vdout0_23ck520 FIND v(dout0_23) AT=265.025n

.meas tran vdout0_24ck520 FIND v(dout0_24) AT=265.025n

.meas tran vdout0_25ck520 FIND v(dout0_25) AT=265.025n

.meas tran vdout0_26ck520 FIND v(dout0_26) AT=265.025n

.meas tran vdout0_27ck520 FIND v(dout0_27) AT=265.025n

.meas tran vdout0_28ck520 FIND v(dout0_28) AT=265.025n

.meas tran vdout0_29ck520 FIND v(dout0_29) AT=265.025n

.meas tran vdout0_30ck520 FIND v(dout0_30) AT=265.025n

.meas tran vdout0_31ck520 FIND v(dout0_31) AT=265.025n

.meas tran vdout0_32ck520 FIND v(dout0_32) AT=265.025n

.meas tran vdout0_33ck520 FIND v(dout0_33) AT=265.025n

.meas tran vdout0_34ck520 FIND v(dout0_34) AT=265.025n

.meas tran vdout0_35ck520 FIND v(dout0_35) AT=265.025n

.meas tran vdout0_36ck520 FIND v(dout0_36) AT=265.025n

.meas tran vdout0_37ck520 FIND v(dout0_37) AT=265.025n

.meas tran vdout0_38ck520 FIND v(dout0_38) AT=265.025n

.meas tran vdout0_39ck520 FIND v(dout0_39) AT=265.025n

.meas tran vdout0_40ck520 FIND v(dout0_40) AT=265.025n

.meas tran vdout0_41ck520 FIND v(dout0_41) AT=265.025n

.meas tran vdout0_42ck520 FIND v(dout0_42) AT=265.025n

.meas tran vdout0_43ck520 FIND v(dout0_43) AT=265.025n

.meas tran vdout0_44ck520 FIND v(dout0_44) AT=265.025n

.meas tran vdout0_45ck520 FIND v(dout0_45) AT=265.025n

.meas tran vdout0_46ck520 FIND v(dout0_46) AT=265.025n

.meas tran vdout0_47ck520 FIND v(dout0_47) AT=265.025n

.meas tran vdout0_48ck520 FIND v(dout0_48) AT=265.025n

.meas tran vdout0_49ck520 FIND v(dout0_49) AT=265.025n

.meas tran vdout0_50ck520 FIND v(dout0_50) AT=265.025n

.meas tran vdout0_51ck520 FIND v(dout0_51) AT=265.025n

.meas tran vdout0_52ck520 FIND v(dout0_52) AT=265.025n

.meas tran vdout0_53ck520 FIND v(dout0_53) AT=265.025n

.meas tran vdout0_54ck520 FIND v(dout0_54) AT=265.025n

.meas tran vdout0_55ck520 FIND v(dout0_55) AT=265.025n

.meas tran vdout0_56ck520 FIND v(dout0_56) AT=265.025n

.meas tran vdout0_57ck520 FIND v(dout0_57) AT=265.025n

.meas tran vdout0_58ck520 FIND v(dout0_58) AT=265.025n

.meas tran vdout0_59ck520 FIND v(dout0_59) AT=265.025n

.meas tran vdout0_60ck520 FIND v(dout0_60) AT=265.025n

.meas tran vdout0_61ck520 FIND v(dout0_61) AT=265.025n

.meas tran vdout0_62ck520 FIND v(dout0_62) AT=265.025n

.meas tran vdout0_63ck520 FIND v(dout0_63) AT=265.025n

.meas tran vdout0_64ck520 FIND v(dout0_64) AT=265.025n

.meas tran vdout0_65ck520 FIND v(dout0_65) AT=265.025n

.meas tran vdout0_66ck520 FIND v(dout0_66) AT=265.025n

.meas tran vdout0_67ck520 FIND v(dout0_67) AT=265.025n

.meas tran vdout0_68ck520 FIND v(dout0_68) AT=265.025n

.meas tran vdout0_69ck520 FIND v(dout0_69) AT=265.025n

.meas tran vdout0_70ck520 FIND v(dout0_70) AT=265.025n

.meas tran vdout0_71ck520 FIND v(dout0_71) AT=265.025n

.meas tran vdout0_72ck520 FIND v(dout0_72) AT=265.025n

.meas tran vdout0_73ck520 FIND v(dout0_73) AT=265.025n

.meas tran vdout0_74ck520 FIND v(dout0_74) AT=265.025n

.meas tran vdout0_75ck520 FIND v(dout0_75) AT=265.025n

.meas tran vdout0_76ck520 FIND v(dout0_76) AT=265.025n

.meas tran vdout0_77ck520 FIND v(dout0_77) AT=265.025n

.meas tran vdout0_78ck520 FIND v(dout0_78) AT=265.025n

.meas tran vdout0_79ck520 FIND v(dout0_79) AT=265.025n

.meas tran vdout0_80ck520 FIND v(dout0_80) AT=265.025n

.meas tran vdout0_81ck520 FIND v(dout0_81) AT=265.025n

.meas tran vdout0_82ck520 FIND v(dout0_82) AT=265.025n

.meas tran vdout0_83ck520 FIND v(dout0_83) AT=265.025n

.meas tran vdout0_84ck520 FIND v(dout0_84) AT=265.025n

.meas tran vdout0_85ck520 FIND v(dout0_85) AT=265.025n

.meas tran vdout0_86ck520 FIND v(dout0_86) AT=265.025n

.meas tran vdout0_87ck520 FIND v(dout0_87) AT=265.025n

.meas tran vdout0_88ck520 FIND v(dout0_88) AT=265.025n

.meas tran vdout0_89ck520 FIND v(dout0_89) AT=265.025n

.meas tran vdout0_90ck520 FIND v(dout0_90) AT=265.025n

.meas tran vdout0_91ck520 FIND v(dout0_91) AT=265.025n

.meas tran vdout0_92ck520 FIND v(dout0_92) AT=265.025n

.meas tran vdout0_93ck520 FIND v(dout0_93) AT=265.025n

.meas tran vdout0_94ck520 FIND v(dout0_94) AT=265.025n

.meas tran vdout0_95ck520 FIND v(dout0_95) AT=265.025n

.meas tran vdout0_96ck520 FIND v(dout0_96) AT=265.025n

.meas tran vdout0_97ck520 FIND v(dout0_97) AT=265.025n

.meas tran vdout0_98ck520 FIND v(dout0_98) AT=265.025n

.meas tran vdout0_99ck520 FIND v(dout0_99) AT=265.025n

.meas tran vdout0_100ck520 FIND v(dout0_100) AT=265.025n

.meas tran vdout0_101ck520 FIND v(dout0_101) AT=265.025n

.meas tran vdout0_102ck520 FIND v(dout0_102) AT=265.025n

.meas tran vdout0_103ck520 FIND v(dout0_103) AT=265.025n

.meas tran vdout0_104ck520 FIND v(dout0_104) AT=265.025n

.meas tran vdout0_105ck520 FIND v(dout0_105) AT=265.025n

.meas tran vdout0_106ck520 FIND v(dout0_106) AT=265.025n

.meas tran vdout0_107ck520 FIND v(dout0_107) AT=265.025n

.meas tran vdout0_108ck520 FIND v(dout0_108) AT=265.025n

.meas tran vdout0_109ck520 FIND v(dout0_109) AT=265.025n

.meas tran vdout0_110ck520 FIND v(dout0_110) AT=265.025n

.meas tran vdout0_111ck520 FIND v(dout0_111) AT=265.025n

.meas tran vdout0_112ck520 FIND v(dout0_112) AT=265.025n

.meas tran vdout0_113ck520 FIND v(dout0_113) AT=265.025n

.meas tran vdout0_114ck520 FIND v(dout0_114) AT=265.025n

.meas tran vdout0_115ck520 FIND v(dout0_115) AT=265.025n

.meas tran vdout0_116ck520 FIND v(dout0_116) AT=265.025n

.meas tran vdout0_117ck520 FIND v(dout0_117) AT=265.025n

.meas tran vdout0_118ck520 FIND v(dout0_118) AT=265.025n

.meas tran vdout0_119ck520 FIND v(dout0_119) AT=265.025n

.meas tran vdout0_120ck520 FIND v(dout0_120) AT=265.025n

.meas tran vdout0_121ck520 FIND v(dout0_121) AT=265.025n

.meas tran vdout0_122ck520 FIND v(dout0_122) AT=265.025n

.meas tran vdout0_123ck520 FIND v(dout0_123) AT=265.025n

.meas tran vdout0_124ck520 FIND v(dout0_124) AT=265.025n

.meas tran vdout0_125ck520 FIND v(dout0_125) AT=265.025n

.meas tran vdout0_126ck520 FIND v(dout0_126) AT=265.025n

.meas tran vdout0_127ck520 FIND v(dout0_127) AT=265.025n

.meas tran vdout0_0ck580 FIND v(dout0_0) AT=295.025n

.meas tran vdout0_1ck580 FIND v(dout0_1) AT=295.025n

.meas tran vdout0_2ck580 FIND v(dout0_2) AT=295.025n

.meas tran vdout0_3ck580 FIND v(dout0_3) AT=295.025n

.meas tran vdout0_4ck580 FIND v(dout0_4) AT=295.025n

.meas tran vdout0_5ck580 FIND v(dout0_5) AT=295.025n

.meas tran vdout0_6ck580 FIND v(dout0_6) AT=295.025n

.meas tran vdout0_7ck580 FIND v(dout0_7) AT=295.025n

.meas tran vdout0_8ck580 FIND v(dout0_8) AT=295.025n

.meas tran vdout0_9ck580 FIND v(dout0_9) AT=295.025n

.meas tran vdout0_10ck580 FIND v(dout0_10) AT=295.025n

.meas tran vdout0_11ck580 FIND v(dout0_11) AT=295.025n

.meas tran vdout0_12ck580 FIND v(dout0_12) AT=295.025n

.meas tran vdout0_13ck580 FIND v(dout0_13) AT=295.025n

.meas tran vdout0_14ck580 FIND v(dout0_14) AT=295.025n

.meas tran vdout0_15ck580 FIND v(dout0_15) AT=295.025n

.meas tran vdout0_16ck580 FIND v(dout0_16) AT=295.025n

.meas tran vdout0_17ck580 FIND v(dout0_17) AT=295.025n

.meas tran vdout0_18ck580 FIND v(dout0_18) AT=295.025n

.meas tran vdout0_19ck580 FIND v(dout0_19) AT=295.025n

.meas tran vdout0_20ck580 FIND v(dout0_20) AT=295.025n

.meas tran vdout0_21ck580 FIND v(dout0_21) AT=295.025n

.meas tran vdout0_22ck580 FIND v(dout0_22) AT=295.025n

.meas tran vdout0_23ck580 FIND v(dout0_23) AT=295.025n

.meas tran vdout0_24ck580 FIND v(dout0_24) AT=295.025n

.meas tran vdout0_25ck580 FIND v(dout0_25) AT=295.025n

.meas tran vdout0_26ck580 FIND v(dout0_26) AT=295.025n

.meas tran vdout0_27ck580 FIND v(dout0_27) AT=295.025n

.meas tran vdout0_28ck580 FIND v(dout0_28) AT=295.025n

.meas tran vdout0_29ck580 FIND v(dout0_29) AT=295.025n

.meas tran vdout0_30ck580 FIND v(dout0_30) AT=295.025n

.meas tran vdout0_31ck580 FIND v(dout0_31) AT=295.025n

.meas tran vdout0_32ck580 FIND v(dout0_32) AT=295.025n

.meas tran vdout0_33ck580 FIND v(dout0_33) AT=295.025n

.meas tran vdout0_34ck580 FIND v(dout0_34) AT=295.025n

.meas tran vdout0_35ck580 FIND v(dout0_35) AT=295.025n

.meas tran vdout0_36ck580 FIND v(dout0_36) AT=295.025n

.meas tran vdout0_37ck580 FIND v(dout0_37) AT=295.025n

.meas tran vdout0_38ck580 FIND v(dout0_38) AT=295.025n

.meas tran vdout0_39ck580 FIND v(dout0_39) AT=295.025n

.meas tran vdout0_40ck580 FIND v(dout0_40) AT=295.025n

.meas tran vdout0_41ck580 FIND v(dout0_41) AT=295.025n

.meas tran vdout0_42ck580 FIND v(dout0_42) AT=295.025n

.meas tran vdout0_43ck580 FIND v(dout0_43) AT=295.025n

.meas tran vdout0_44ck580 FIND v(dout0_44) AT=295.025n

.meas tran vdout0_45ck580 FIND v(dout0_45) AT=295.025n

.meas tran vdout0_46ck580 FIND v(dout0_46) AT=295.025n

.meas tran vdout0_47ck580 FIND v(dout0_47) AT=295.025n

.meas tran vdout0_48ck580 FIND v(dout0_48) AT=295.025n

.meas tran vdout0_49ck580 FIND v(dout0_49) AT=295.025n

.meas tran vdout0_50ck580 FIND v(dout0_50) AT=295.025n

.meas tran vdout0_51ck580 FIND v(dout0_51) AT=295.025n

.meas tran vdout0_52ck580 FIND v(dout0_52) AT=295.025n

.meas tran vdout0_53ck580 FIND v(dout0_53) AT=295.025n

.meas tran vdout0_54ck580 FIND v(dout0_54) AT=295.025n

.meas tran vdout0_55ck580 FIND v(dout0_55) AT=295.025n

.meas tran vdout0_56ck580 FIND v(dout0_56) AT=295.025n

.meas tran vdout0_57ck580 FIND v(dout0_57) AT=295.025n

.meas tran vdout0_58ck580 FIND v(dout0_58) AT=295.025n

.meas tran vdout0_59ck580 FIND v(dout0_59) AT=295.025n

.meas tran vdout0_60ck580 FIND v(dout0_60) AT=295.025n

.meas tran vdout0_61ck580 FIND v(dout0_61) AT=295.025n

.meas tran vdout0_62ck580 FIND v(dout0_62) AT=295.025n

.meas tran vdout0_63ck580 FIND v(dout0_63) AT=295.025n

.meas tran vdout0_64ck580 FIND v(dout0_64) AT=295.025n

.meas tran vdout0_65ck580 FIND v(dout0_65) AT=295.025n

.meas tran vdout0_66ck580 FIND v(dout0_66) AT=295.025n

.meas tran vdout0_67ck580 FIND v(dout0_67) AT=295.025n

.meas tran vdout0_68ck580 FIND v(dout0_68) AT=295.025n

.meas tran vdout0_69ck580 FIND v(dout0_69) AT=295.025n

.meas tran vdout0_70ck580 FIND v(dout0_70) AT=295.025n

.meas tran vdout0_71ck580 FIND v(dout0_71) AT=295.025n

.meas tran vdout0_72ck580 FIND v(dout0_72) AT=295.025n

.meas tran vdout0_73ck580 FIND v(dout0_73) AT=295.025n

.meas tran vdout0_74ck580 FIND v(dout0_74) AT=295.025n

.meas tran vdout0_75ck580 FIND v(dout0_75) AT=295.025n

.meas tran vdout0_76ck580 FIND v(dout0_76) AT=295.025n

.meas tran vdout0_77ck580 FIND v(dout0_77) AT=295.025n

.meas tran vdout0_78ck580 FIND v(dout0_78) AT=295.025n

.meas tran vdout0_79ck580 FIND v(dout0_79) AT=295.025n

.meas tran vdout0_80ck580 FIND v(dout0_80) AT=295.025n

.meas tran vdout0_81ck580 FIND v(dout0_81) AT=295.025n

.meas tran vdout0_82ck580 FIND v(dout0_82) AT=295.025n

.meas tran vdout0_83ck580 FIND v(dout0_83) AT=295.025n

.meas tran vdout0_84ck580 FIND v(dout0_84) AT=295.025n

.meas tran vdout0_85ck580 FIND v(dout0_85) AT=295.025n

.meas tran vdout0_86ck580 FIND v(dout0_86) AT=295.025n

.meas tran vdout0_87ck580 FIND v(dout0_87) AT=295.025n

.meas tran vdout0_88ck580 FIND v(dout0_88) AT=295.025n

.meas tran vdout0_89ck580 FIND v(dout0_89) AT=295.025n

.meas tran vdout0_90ck580 FIND v(dout0_90) AT=295.025n

.meas tran vdout0_91ck580 FIND v(dout0_91) AT=295.025n

.meas tran vdout0_92ck580 FIND v(dout0_92) AT=295.025n

.meas tran vdout0_93ck580 FIND v(dout0_93) AT=295.025n

.meas tran vdout0_94ck580 FIND v(dout0_94) AT=295.025n

.meas tran vdout0_95ck580 FIND v(dout0_95) AT=295.025n

.meas tran vdout0_96ck580 FIND v(dout0_96) AT=295.025n

.meas tran vdout0_97ck580 FIND v(dout0_97) AT=295.025n

.meas tran vdout0_98ck580 FIND v(dout0_98) AT=295.025n

.meas tran vdout0_99ck580 FIND v(dout0_99) AT=295.025n

.meas tran vdout0_100ck580 FIND v(dout0_100) AT=295.025n

.meas tran vdout0_101ck580 FIND v(dout0_101) AT=295.025n

.meas tran vdout0_102ck580 FIND v(dout0_102) AT=295.025n

.meas tran vdout0_103ck580 FIND v(dout0_103) AT=295.025n

.meas tran vdout0_104ck580 FIND v(dout0_104) AT=295.025n

.meas tran vdout0_105ck580 FIND v(dout0_105) AT=295.025n

.meas tran vdout0_106ck580 FIND v(dout0_106) AT=295.025n

.meas tran vdout0_107ck580 FIND v(dout0_107) AT=295.025n

.meas tran vdout0_108ck580 FIND v(dout0_108) AT=295.025n

.meas tran vdout0_109ck580 FIND v(dout0_109) AT=295.025n

.meas tran vdout0_110ck580 FIND v(dout0_110) AT=295.025n

.meas tran vdout0_111ck580 FIND v(dout0_111) AT=295.025n

.meas tran vdout0_112ck580 FIND v(dout0_112) AT=295.025n

.meas tran vdout0_113ck580 FIND v(dout0_113) AT=295.025n

.meas tran vdout0_114ck580 FIND v(dout0_114) AT=295.025n

.meas tran vdout0_115ck580 FIND v(dout0_115) AT=295.025n

.meas tran vdout0_116ck580 FIND v(dout0_116) AT=295.025n

.meas tran vdout0_117ck580 FIND v(dout0_117) AT=295.025n

.meas tran vdout0_118ck580 FIND v(dout0_118) AT=295.025n

.meas tran vdout0_119ck580 FIND v(dout0_119) AT=295.025n

.meas tran vdout0_120ck580 FIND v(dout0_120) AT=295.025n

.meas tran vdout0_121ck580 FIND v(dout0_121) AT=295.025n

.meas tran vdout0_122ck580 FIND v(dout0_122) AT=295.025n

.meas tran vdout0_123ck580 FIND v(dout0_123) AT=295.025n

.meas tran vdout0_124ck580 FIND v(dout0_124) AT=295.025n

.meas tran vdout0_125ck580 FIND v(dout0_125) AT=295.025n

.meas tran vdout0_126ck580 FIND v(dout0_126) AT=295.025n

.meas tran vdout0_127ck580 FIND v(dout0_127) AT=295.025n

.meas tran vdout0_0ck590 FIND v(dout0_0) AT=300.025n

.meas tran vdout0_1ck590 FIND v(dout0_1) AT=300.025n

.meas tran vdout0_2ck590 FIND v(dout0_2) AT=300.025n

.meas tran vdout0_3ck590 FIND v(dout0_3) AT=300.025n

.meas tran vdout0_4ck590 FIND v(dout0_4) AT=300.025n

.meas tran vdout0_5ck590 FIND v(dout0_5) AT=300.025n

.meas tran vdout0_6ck590 FIND v(dout0_6) AT=300.025n

.meas tran vdout0_7ck590 FIND v(dout0_7) AT=300.025n

.meas tran vdout0_8ck590 FIND v(dout0_8) AT=300.025n

.meas tran vdout0_9ck590 FIND v(dout0_9) AT=300.025n

.meas tran vdout0_10ck590 FIND v(dout0_10) AT=300.025n

.meas tran vdout0_11ck590 FIND v(dout0_11) AT=300.025n

.meas tran vdout0_12ck590 FIND v(dout0_12) AT=300.025n

.meas tran vdout0_13ck590 FIND v(dout0_13) AT=300.025n

.meas tran vdout0_14ck590 FIND v(dout0_14) AT=300.025n

.meas tran vdout0_15ck590 FIND v(dout0_15) AT=300.025n

.meas tran vdout0_16ck590 FIND v(dout0_16) AT=300.025n

.meas tran vdout0_17ck590 FIND v(dout0_17) AT=300.025n

.meas tran vdout0_18ck590 FIND v(dout0_18) AT=300.025n

.meas tran vdout0_19ck590 FIND v(dout0_19) AT=300.025n

.meas tran vdout0_20ck590 FIND v(dout0_20) AT=300.025n

.meas tran vdout0_21ck590 FIND v(dout0_21) AT=300.025n

.meas tran vdout0_22ck590 FIND v(dout0_22) AT=300.025n

.meas tran vdout0_23ck590 FIND v(dout0_23) AT=300.025n

.meas tran vdout0_24ck590 FIND v(dout0_24) AT=300.025n

.meas tran vdout0_25ck590 FIND v(dout0_25) AT=300.025n

.meas tran vdout0_26ck590 FIND v(dout0_26) AT=300.025n

.meas tran vdout0_27ck590 FIND v(dout0_27) AT=300.025n

.meas tran vdout0_28ck590 FIND v(dout0_28) AT=300.025n

.meas tran vdout0_29ck590 FIND v(dout0_29) AT=300.025n

.meas tran vdout0_30ck590 FIND v(dout0_30) AT=300.025n

.meas tran vdout0_31ck590 FIND v(dout0_31) AT=300.025n

.meas tran vdout0_32ck590 FIND v(dout0_32) AT=300.025n

.meas tran vdout0_33ck590 FIND v(dout0_33) AT=300.025n

.meas tran vdout0_34ck590 FIND v(dout0_34) AT=300.025n

.meas tran vdout0_35ck590 FIND v(dout0_35) AT=300.025n

.meas tran vdout0_36ck590 FIND v(dout0_36) AT=300.025n

.meas tran vdout0_37ck590 FIND v(dout0_37) AT=300.025n

.meas tran vdout0_38ck590 FIND v(dout0_38) AT=300.025n

.meas tran vdout0_39ck590 FIND v(dout0_39) AT=300.025n

.meas tran vdout0_40ck590 FIND v(dout0_40) AT=300.025n

.meas tran vdout0_41ck590 FIND v(dout0_41) AT=300.025n

.meas tran vdout0_42ck590 FIND v(dout0_42) AT=300.025n

.meas tran vdout0_43ck590 FIND v(dout0_43) AT=300.025n

.meas tran vdout0_44ck590 FIND v(dout0_44) AT=300.025n

.meas tran vdout0_45ck590 FIND v(dout0_45) AT=300.025n

.meas tran vdout0_46ck590 FIND v(dout0_46) AT=300.025n

.meas tran vdout0_47ck590 FIND v(dout0_47) AT=300.025n

.meas tran vdout0_48ck590 FIND v(dout0_48) AT=300.025n

.meas tran vdout0_49ck590 FIND v(dout0_49) AT=300.025n

.meas tran vdout0_50ck590 FIND v(dout0_50) AT=300.025n

.meas tran vdout0_51ck590 FIND v(dout0_51) AT=300.025n

.meas tran vdout0_52ck590 FIND v(dout0_52) AT=300.025n

.meas tran vdout0_53ck590 FIND v(dout0_53) AT=300.025n

.meas tran vdout0_54ck590 FIND v(dout0_54) AT=300.025n

.meas tran vdout0_55ck590 FIND v(dout0_55) AT=300.025n

.meas tran vdout0_56ck590 FIND v(dout0_56) AT=300.025n

.meas tran vdout0_57ck590 FIND v(dout0_57) AT=300.025n

.meas tran vdout0_58ck590 FIND v(dout0_58) AT=300.025n

.meas tran vdout0_59ck590 FIND v(dout0_59) AT=300.025n

.meas tran vdout0_60ck590 FIND v(dout0_60) AT=300.025n

.meas tran vdout0_61ck590 FIND v(dout0_61) AT=300.025n

.meas tran vdout0_62ck590 FIND v(dout0_62) AT=300.025n

.meas tran vdout0_63ck590 FIND v(dout0_63) AT=300.025n

.meas tran vdout0_64ck590 FIND v(dout0_64) AT=300.025n

.meas tran vdout0_65ck590 FIND v(dout0_65) AT=300.025n

.meas tran vdout0_66ck590 FIND v(dout0_66) AT=300.025n

.meas tran vdout0_67ck590 FIND v(dout0_67) AT=300.025n

.meas tran vdout0_68ck590 FIND v(dout0_68) AT=300.025n

.meas tran vdout0_69ck590 FIND v(dout0_69) AT=300.025n

.meas tran vdout0_70ck590 FIND v(dout0_70) AT=300.025n

.meas tran vdout0_71ck590 FIND v(dout0_71) AT=300.025n

.meas tran vdout0_72ck590 FIND v(dout0_72) AT=300.025n

.meas tran vdout0_73ck590 FIND v(dout0_73) AT=300.025n

.meas tran vdout0_74ck590 FIND v(dout0_74) AT=300.025n

.meas tran vdout0_75ck590 FIND v(dout0_75) AT=300.025n

.meas tran vdout0_76ck590 FIND v(dout0_76) AT=300.025n

.meas tran vdout0_77ck590 FIND v(dout0_77) AT=300.025n

.meas tran vdout0_78ck590 FIND v(dout0_78) AT=300.025n

.meas tran vdout0_79ck590 FIND v(dout0_79) AT=300.025n

.meas tran vdout0_80ck590 FIND v(dout0_80) AT=300.025n

.meas tran vdout0_81ck590 FIND v(dout0_81) AT=300.025n

.meas tran vdout0_82ck590 FIND v(dout0_82) AT=300.025n

.meas tran vdout0_83ck590 FIND v(dout0_83) AT=300.025n

.meas tran vdout0_84ck590 FIND v(dout0_84) AT=300.025n

.meas tran vdout0_85ck590 FIND v(dout0_85) AT=300.025n

.meas tran vdout0_86ck590 FIND v(dout0_86) AT=300.025n

.meas tran vdout0_87ck590 FIND v(dout0_87) AT=300.025n

.meas tran vdout0_88ck590 FIND v(dout0_88) AT=300.025n

.meas tran vdout0_89ck590 FIND v(dout0_89) AT=300.025n

.meas tran vdout0_90ck590 FIND v(dout0_90) AT=300.025n

.meas tran vdout0_91ck590 FIND v(dout0_91) AT=300.025n

.meas tran vdout0_92ck590 FIND v(dout0_92) AT=300.025n

.meas tran vdout0_93ck590 FIND v(dout0_93) AT=300.025n

.meas tran vdout0_94ck590 FIND v(dout0_94) AT=300.025n

.meas tran vdout0_95ck590 FIND v(dout0_95) AT=300.025n

.meas tran vdout0_96ck590 FIND v(dout0_96) AT=300.025n

.meas tran vdout0_97ck590 FIND v(dout0_97) AT=300.025n

.meas tran vdout0_98ck590 FIND v(dout0_98) AT=300.025n

.meas tran vdout0_99ck590 FIND v(dout0_99) AT=300.025n

.meas tran vdout0_100ck590 FIND v(dout0_100) AT=300.025n

.meas tran vdout0_101ck590 FIND v(dout0_101) AT=300.025n

.meas tran vdout0_102ck590 FIND v(dout0_102) AT=300.025n

.meas tran vdout0_103ck590 FIND v(dout0_103) AT=300.025n

.meas tran vdout0_104ck590 FIND v(dout0_104) AT=300.025n

.meas tran vdout0_105ck590 FIND v(dout0_105) AT=300.025n

.meas tran vdout0_106ck590 FIND v(dout0_106) AT=300.025n

.meas tran vdout0_107ck590 FIND v(dout0_107) AT=300.025n

.meas tran vdout0_108ck590 FIND v(dout0_108) AT=300.025n

.meas tran vdout0_109ck590 FIND v(dout0_109) AT=300.025n

.meas tran vdout0_110ck590 FIND v(dout0_110) AT=300.025n

.meas tran vdout0_111ck590 FIND v(dout0_111) AT=300.025n

.meas tran vdout0_112ck590 FIND v(dout0_112) AT=300.025n

.meas tran vdout0_113ck590 FIND v(dout0_113) AT=300.025n

.meas tran vdout0_114ck590 FIND v(dout0_114) AT=300.025n

.meas tran vdout0_115ck590 FIND v(dout0_115) AT=300.025n

.meas tran vdout0_116ck590 FIND v(dout0_116) AT=300.025n

.meas tran vdout0_117ck590 FIND v(dout0_117) AT=300.025n

.meas tran vdout0_118ck590 FIND v(dout0_118) AT=300.025n

.meas tran vdout0_119ck590 FIND v(dout0_119) AT=300.025n

.meas tran vdout0_120ck590 FIND v(dout0_120) AT=300.025n

.meas tran vdout0_121ck590 FIND v(dout0_121) AT=300.025n

.meas tran vdout0_122ck590 FIND v(dout0_122) AT=300.025n

.meas tran vdout0_123ck590 FIND v(dout0_123) AT=300.025n

.meas tran vdout0_124ck590 FIND v(dout0_124) AT=300.025n

.meas tran vdout0_125ck590 FIND v(dout0_125) AT=300.025n

.meas tran vdout0_126ck590 FIND v(dout0_126) AT=300.025n

.meas tran vdout0_127ck590 FIND v(dout0_127) AT=300.025n

.meas tran vdout0_0ck600 FIND v(dout0_0) AT=305.025n

.meas tran vdout0_1ck600 FIND v(dout0_1) AT=305.025n

.meas tran vdout0_2ck600 FIND v(dout0_2) AT=305.025n

.meas tran vdout0_3ck600 FIND v(dout0_3) AT=305.025n

.meas tran vdout0_4ck600 FIND v(dout0_4) AT=305.025n

.meas tran vdout0_5ck600 FIND v(dout0_5) AT=305.025n

.meas tran vdout0_6ck600 FIND v(dout0_6) AT=305.025n

.meas tran vdout0_7ck600 FIND v(dout0_7) AT=305.025n

.meas tran vdout0_8ck600 FIND v(dout0_8) AT=305.025n

.meas tran vdout0_9ck600 FIND v(dout0_9) AT=305.025n

.meas tran vdout0_10ck600 FIND v(dout0_10) AT=305.025n

.meas tran vdout0_11ck600 FIND v(dout0_11) AT=305.025n

.meas tran vdout0_12ck600 FIND v(dout0_12) AT=305.025n

.meas tran vdout0_13ck600 FIND v(dout0_13) AT=305.025n

.meas tran vdout0_14ck600 FIND v(dout0_14) AT=305.025n

.meas tran vdout0_15ck600 FIND v(dout0_15) AT=305.025n

.meas tran vdout0_16ck600 FIND v(dout0_16) AT=305.025n

.meas tran vdout0_17ck600 FIND v(dout0_17) AT=305.025n

.meas tran vdout0_18ck600 FIND v(dout0_18) AT=305.025n

.meas tran vdout0_19ck600 FIND v(dout0_19) AT=305.025n

.meas tran vdout0_20ck600 FIND v(dout0_20) AT=305.025n

.meas tran vdout0_21ck600 FIND v(dout0_21) AT=305.025n

.meas tran vdout0_22ck600 FIND v(dout0_22) AT=305.025n

.meas tran vdout0_23ck600 FIND v(dout0_23) AT=305.025n

.meas tran vdout0_24ck600 FIND v(dout0_24) AT=305.025n

.meas tran vdout0_25ck600 FIND v(dout0_25) AT=305.025n

.meas tran vdout0_26ck600 FIND v(dout0_26) AT=305.025n

.meas tran vdout0_27ck600 FIND v(dout0_27) AT=305.025n

.meas tran vdout0_28ck600 FIND v(dout0_28) AT=305.025n

.meas tran vdout0_29ck600 FIND v(dout0_29) AT=305.025n

.meas tran vdout0_30ck600 FIND v(dout0_30) AT=305.025n

.meas tran vdout0_31ck600 FIND v(dout0_31) AT=305.025n

.meas tran vdout0_32ck600 FIND v(dout0_32) AT=305.025n

.meas tran vdout0_33ck600 FIND v(dout0_33) AT=305.025n

.meas tran vdout0_34ck600 FIND v(dout0_34) AT=305.025n

.meas tran vdout0_35ck600 FIND v(dout0_35) AT=305.025n

.meas tran vdout0_36ck600 FIND v(dout0_36) AT=305.025n

.meas tran vdout0_37ck600 FIND v(dout0_37) AT=305.025n

.meas tran vdout0_38ck600 FIND v(dout0_38) AT=305.025n

.meas tran vdout0_39ck600 FIND v(dout0_39) AT=305.025n

.meas tran vdout0_40ck600 FIND v(dout0_40) AT=305.025n

.meas tran vdout0_41ck600 FIND v(dout0_41) AT=305.025n

.meas tran vdout0_42ck600 FIND v(dout0_42) AT=305.025n

.meas tran vdout0_43ck600 FIND v(dout0_43) AT=305.025n

.meas tran vdout0_44ck600 FIND v(dout0_44) AT=305.025n

.meas tran vdout0_45ck600 FIND v(dout0_45) AT=305.025n

.meas tran vdout0_46ck600 FIND v(dout0_46) AT=305.025n

.meas tran vdout0_47ck600 FIND v(dout0_47) AT=305.025n

.meas tran vdout0_48ck600 FIND v(dout0_48) AT=305.025n

.meas tran vdout0_49ck600 FIND v(dout0_49) AT=305.025n

.meas tran vdout0_50ck600 FIND v(dout0_50) AT=305.025n

.meas tran vdout0_51ck600 FIND v(dout0_51) AT=305.025n

.meas tran vdout0_52ck600 FIND v(dout0_52) AT=305.025n

.meas tran vdout0_53ck600 FIND v(dout0_53) AT=305.025n

.meas tran vdout0_54ck600 FIND v(dout0_54) AT=305.025n

.meas tran vdout0_55ck600 FIND v(dout0_55) AT=305.025n

.meas tran vdout0_56ck600 FIND v(dout0_56) AT=305.025n

.meas tran vdout0_57ck600 FIND v(dout0_57) AT=305.025n

.meas tran vdout0_58ck600 FIND v(dout0_58) AT=305.025n

.meas tran vdout0_59ck600 FIND v(dout0_59) AT=305.025n

.meas tran vdout0_60ck600 FIND v(dout0_60) AT=305.025n

.meas tran vdout0_61ck600 FIND v(dout0_61) AT=305.025n

.meas tran vdout0_62ck600 FIND v(dout0_62) AT=305.025n

.meas tran vdout0_63ck600 FIND v(dout0_63) AT=305.025n

.meas tran vdout0_64ck600 FIND v(dout0_64) AT=305.025n

.meas tran vdout0_65ck600 FIND v(dout0_65) AT=305.025n

.meas tran vdout0_66ck600 FIND v(dout0_66) AT=305.025n

.meas tran vdout0_67ck600 FIND v(dout0_67) AT=305.025n

.meas tran vdout0_68ck600 FIND v(dout0_68) AT=305.025n

.meas tran vdout0_69ck600 FIND v(dout0_69) AT=305.025n

.meas tran vdout0_70ck600 FIND v(dout0_70) AT=305.025n

.meas tran vdout0_71ck600 FIND v(dout0_71) AT=305.025n

.meas tran vdout0_72ck600 FIND v(dout0_72) AT=305.025n

.meas tran vdout0_73ck600 FIND v(dout0_73) AT=305.025n

.meas tran vdout0_74ck600 FIND v(dout0_74) AT=305.025n

.meas tran vdout0_75ck600 FIND v(dout0_75) AT=305.025n

.meas tran vdout0_76ck600 FIND v(dout0_76) AT=305.025n

.meas tran vdout0_77ck600 FIND v(dout0_77) AT=305.025n

.meas tran vdout0_78ck600 FIND v(dout0_78) AT=305.025n

.meas tran vdout0_79ck600 FIND v(dout0_79) AT=305.025n

.meas tran vdout0_80ck600 FIND v(dout0_80) AT=305.025n

.meas tran vdout0_81ck600 FIND v(dout0_81) AT=305.025n

.meas tran vdout0_82ck600 FIND v(dout0_82) AT=305.025n

.meas tran vdout0_83ck600 FIND v(dout0_83) AT=305.025n

.meas tran vdout0_84ck600 FIND v(dout0_84) AT=305.025n

.meas tran vdout0_85ck600 FIND v(dout0_85) AT=305.025n

.meas tran vdout0_86ck600 FIND v(dout0_86) AT=305.025n

.meas tran vdout0_87ck600 FIND v(dout0_87) AT=305.025n

.meas tran vdout0_88ck600 FIND v(dout0_88) AT=305.025n

.meas tran vdout0_89ck600 FIND v(dout0_89) AT=305.025n

.meas tran vdout0_90ck600 FIND v(dout0_90) AT=305.025n

.meas tran vdout0_91ck600 FIND v(dout0_91) AT=305.025n

.meas tran vdout0_92ck600 FIND v(dout0_92) AT=305.025n

.meas tran vdout0_93ck600 FIND v(dout0_93) AT=305.025n

.meas tran vdout0_94ck600 FIND v(dout0_94) AT=305.025n

.meas tran vdout0_95ck600 FIND v(dout0_95) AT=305.025n

.meas tran vdout0_96ck600 FIND v(dout0_96) AT=305.025n

.meas tran vdout0_97ck600 FIND v(dout0_97) AT=305.025n

.meas tran vdout0_98ck600 FIND v(dout0_98) AT=305.025n

.meas tran vdout0_99ck600 FIND v(dout0_99) AT=305.025n

.meas tran vdout0_100ck600 FIND v(dout0_100) AT=305.025n

.meas tran vdout0_101ck600 FIND v(dout0_101) AT=305.025n

.meas tran vdout0_102ck600 FIND v(dout0_102) AT=305.025n

.meas tran vdout0_103ck600 FIND v(dout0_103) AT=305.025n

.meas tran vdout0_104ck600 FIND v(dout0_104) AT=305.025n

.meas tran vdout0_105ck600 FIND v(dout0_105) AT=305.025n

.meas tran vdout0_106ck600 FIND v(dout0_106) AT=305.025n

.meas tran vdout0_107ck600 FIND v(dout0_107) AT=305.025n

.meas tran vdout0_108ck600 FIND v(dout0_108) AT=305.025n

.meas tran vdout0_109ck600 FIND v(dout0_109) AT=305.025n

.meas tran vdout0_110ck600 FIND v(dout0_110) AT=305.025n

.meas tran vdout0_111ck600 FIND v(dout0_111) AT=305.025n

.meas tran vdout0_112ck600 FIND v(dout0_112) AT=305.025n

.meas tran vdout0_113ck600 FIND v(dout0_113) AT=305.025n

.meas tran vdout0_114ck600 FIND v(dout0_114) AT=305.025n

.meas tran vdout0_115ck600 FIND v(dout0_115) AT=305.025n

.meas tran vdout0_116ck600 FIND v(dout0_116) AT=305.025n

.meas tran vdout0_117ck600 FIND v(dout0_117) AT=305.025n

.meas tran vdout0_118ck600 FIND v(dout0_118) AT=305.025n

.meas tran vdout0_119ck600 FIND v(dout0_119) AT=305.025n

.meas tran vdout0_120ck600 FIND v(dout0_120) AT=305.025n

.meas tran vdout0_121ck600 FIND v(dout0_121) AT=305.025n

.meas tran vdout0_122ck600 FIND v(dout0_122) AT=305.025n

.meas tran vdout0_123ck600 FIND v(dout0_123) AT=305.025n

.meas tran vdout0_124ck600 FIND v(dout0_124) AT=305.025n

.meas tran vdout0_125ck600 FIND v(dout0_125) AT=305.025n

.meas tran vdout0_126ck600 FIND v(dout0_126) AT=305.025n

.meas tran vdout0_127ck600 FIND v(dout0_127) AT=305.025n

.meas tran vdout0_0ck630 FIND v(dout0_0) AT=320.025n

.meas tran vdout0_1ck630 FIND v(dout0_1) AT=320.025n

.meas tran vdout0_2ck630 FIND v(dout0_2) AT=320.025n

.meas tran vdout0_3ck630 FIND v(dout0_3) AT=320.025n

.meas tran vdout0_4ck630 FIND v(dout0_4) AT=320.025n

.meas tran vdout0_5ck630 FIND v(dout0_5) AT=320.025n

.meas tran vdout0_6ck630 FIND v(dout0_6) AT=320.025n

.meas tran vdout0_7ck630 FIND v(dout0_7) AT=320.025n

.meas tran vdout0_8ck630 FIND v(dout0_8) AT=320.025n

.meas tran vdout0_9ck630 FIND v(dout0_9) AT=320.025n

.meas tran vdout0_10ck630 FIND v(dout0_10) AT=320.025n

.meas tran vdout0_11ck630 FIND v(dout0_11) AT=320.025n

.meas tran vdout0_12ck630 FIND v(dout0_12) AT=320.025n

.meas tran vdout0_13ck630 FIND v(dout0_13) AT=320.025n

.meas tran vdout0_14ck630 FIND v(dout0_14) AT=320.025n

.meas tran vdout0_15ck630 FIND v(dout0_15) AT=320.025n

.meas tran vdout0_16ck630 FIND v(dout0_16) AT=320.025n

.meas tran vdout0_17ck630 FIND v(dout0_17) AT=320.025n

.meas tran vdout0_18ck630 FIND v(dout0_18) AT=320.025n

.meas tran vdout0_19ck630 FIND v(dout0_19) AT=320.025n

.meas tran vdout0_20ck630 FIND v(dout0_20) AT=320.025n

.meas tran vdout0_21ck630 FIND v(dout0_21) AT=320.025n

.meas tran vdout0_22ck630 FIND v(dout0_22) AT=320.025n

.meas tran vdout0_23ck630 FIND v(dout0_23) AT=320.025n

.meas tran vdout0_24ck630 FIND v(dout0_24) AT=320.025n

.meas tran vdout0_25ck630 FIND v(dout0_25) AT=320.025n

.meas tran vdout0_26ck630 FIND v(dout0_26) AT=320.025n

.meas tran vdout0_27ck630 FIND v(dout0_27) AT=320.025n

.meas tran vdout0_28ck630 FIND v(dout0_28) AT=320.025n

.meas tran vdout0_29ck630 FIND v(dout0_29) AT=320.025n

.meas tran vdout0_30ck630 FIND v(dout0_30) AT=320.025n

.meas tran vdout0_31ck630 FIND v(dout0_31) AT=320.025n

.meas tran vdout0_32ck630 FIND v(dout0_32) AT=320.025n

.meas tran vdout0_33ck630 FIND v(dout0_33) AT=320.025n

.meas tran vdout0_34ck630 FIND v(dout0_34) AT=320.025n

.meas tran vdout0_35ck630 FIND v(dout0_35) AT=320.025n

.meas tran vdout0_36ck630 FIND v(dout0_36) AT=320.025n

.meas tran vdout0_37ck630 FIND v(dout0_37) AT=320.025n

.meas tran vdout0_38ck630 FIND v(dout0_38) AT=320.025n

.meas tran vdout0_39ck630 FIND v(dout0_39) AT=320.025n

.meas tran vdout0_40ck630 FIND v(dout0_40) AT=320.025n

.meas tran vdout0_41ck630 FIND v(dout0_41) AT=320.025n

.meas tran vdout0_42ck630 FIND v(dout0_42) AT=320.025n

.meas tran vdout0_43ck630 FIND v(dout0_43) AT=320.025n

.meas tran vdout0_44ck630 FIND v(dout0_44) AT=320.025n

.meas tran vdout0_45ck630 FIND v(dout0_45) AT=320.025n

.meas tran vdout0_46ck630 FIND v(dout0_46) AT=320.025n

.meas tran vdout0_47ck630 FIND v(dout0_47) AT=320.025n

.meas tran vdout0_48ck630 FIND v(dout0_48) AT=320.025n

.meas tran vdout0_49ck630 FIND v(dout0_49) AT=320.025n

.meas tran vdout0_50ck630 FIND v(dout0_50) AT=320.025n

.meas tran vdout0_51ck630 FIND v(dout0_51) AT=320.025n

.meas tran vdout0_52ck630 FIND v(dout0_52) AT=320.025n

.meas tran vdout0_53ck630 FIND v(dout0_53) AT=320.025n

.meas tran vdout0_54ck630 FIND v(dout0_54) AT=320.025n

.meas tran vdout0_55ck630 FIND v(dout0_55) AT=320.025n

.meas tran vdout0_56ck630 FIND v(dout0_56) AT=320.025n

.meas tran vdout0_57ck630 FIND v(dout0_57) AT=320.025n

.meas tran vdout0_58ck630 FIND v(dout0_58) AT=320.025n

.meas tran vdout0_59ck630 FIND v(dout0_59) AT=320.025n

.meas tran vdout0_60ck630 FIND v(dout0_60) AT=320.025n

.meas tran vdout0_61ck630 FIND v(dout0_61) AT=320.025n

.meas tran vdout0_62ck630 FIND v(dout0_62) AT=320.025n

.meas tran vdout0_63ck630 FIND v(dout0_63) AT=320.025n

.meas tran vdout0_64ck630 FIND v(dout0_64) AT=320.025n

.meas tran vdout0_65ck630 FIND v(dout0_65) AT=320.025n

.meas tran vdout0_66ck630 FIND v(dout0_66) AT=320.025n

.meas tran vdout0_67ck630 FIND v(dout0_67) AT=320.025n

.meas tran vdout0_68ck630 FIND v(dout0_68) AT=320.025n

.meas tran vdout0_69ck630 FIND v(dout0_69) AT=320.025n

.meas tran vdout0_70ck630 FIND v(dout0_70) AT=320.025n

.meas tran vdout0_71ck630 FIND v(dout0_71) AT=320.025n

.meas tran vdout0_72ck630 FIND v(dout0_72) AT=320.025n

.meas tran vdout0_73ck630 FIND v(dout0_73) AT=320.025n

.meas tran vdout0_74ck630 FIND v(dout0_74) AT=320.025n

.meas tran vdout0_75ck630 FIND v(dout0_75) AT=320.025n

.meas tran vdout0_76ck630 FIND v(dout0_76) AT=320.025n

.meas tran vdout0_77ck630 FIND v(dout0_77) AT=320.025n

.meas tran vdout0_78ck630 FIND v(dout0_78) AT=320.025n

.meas tran vdout0_79ck630 FIND v(dout0_79) AT=320.025n

.meas tran vdout0_80ck630 FIND v(dout0_80) AT=320.025n

.meas tran vdout0_81ck630 FIND v(dout0_81) AT=320.025n

.meas tran vdout0_82ck630 FIND v(dout0_82) AT=320.025n

.meas tran vdout0_83ck630 FIND v(dout0_83) AT=320.025n

.meas tran vdout0_84ck630 FIND v(dout0_84) AT=320.025n

.meas tran vdout0_85ck630 FIND v(dout0_85) AT=320.025n

.meas tran vdout0_86ck630 FIND v(dout0_86) AT=320.025n

.meas tran vdout0_87ck630 FIND v(dout0_87) AT=320.025n

.meas tran vdout0_88ck630 FIND v(dout0_88) AT=320.025n

.meas tran vdout0_89ck630 FIND v(dout0_89) AT=320.025n

.meas tran vdout0_90ck630 FIND v(dout0_90) AT=320.025n

.meas tran vdout0_91ck630 FIND v(dout0_91) AT=320.025n

.meas tran vdout0_92ck630 FIND v(dout0_92) AT=320.025n

.meas tran vdout0_93ck630 FIND v(dout0_93) AT=320.025n

.meas tran vdout0_94ck630 FIND v(dout0_94) AT=320.025n

.meas tran vdout0_95ck630 FIND v(dout0_95) AT=320.025n

.meas tran vdout0_96ck630 FIND v(dout0_96) AT=320.025n

.meas tran vdout0_97ck630 FIND v(dout0_97) AT=320.025n

.meas tran vdout0_98ck630 FIND v(dout0_98) AT=320.025n

.meas tran vdout0_99ck630 FIND v(dout0_99) AT=320.025n

.meas tran vdout0_100ck630 FIND v(dout0_100) AT=320.025n

.meas tran vdout0_101ck630 FIND v(dout0_101) AT=320.025n

.meas tran vdout0_102ck630 FIND v(dout0_102) AT=320.025n

.meas tran vdout0_103ck630 FIND v(dout0_103) AT=320.025n

.meas tran vdout0_104ck630 FIND v(dout0_104) AT=320.025n

.meas tran vdout0_105ck630 FIND v(dout0_105) AT=320.025n

.meas tran vdout0_106ck630 FIND v(dout0_106) AT=320.025n

.meas tran vdout0_107ck630 FIND v(dout0_107) AT=320.025n

.meas tran vdout0_108ck630 FIND v(dout0_108) AT=320.025n

.meas tran vdout0_109ck630 FIND v(dout0_109) AT=320.025n

.meas tran vdout0_110ck630 FIND v(dout0_110) AT=320.025n

.meas tran vdout0_111ck630 FIND v(dout0_111) AT=320.025n

.meas tran vdout0_112ck630 FIND v(dout0_112) AT=320.025n

.meas tran vdout0_113ck630 FIND v(dout0_113) AT=320.025n

.meas tran vdout0_114ck630 FIND v(dout0_114) AT=320.025n

.meas tran vdout0_115ck630 FIND v(dout0_115) AT=320.025n

.meas tran vdout0_116ck630 FIND v(dout0_116) AT=320.025n

.meas tran vdout0_117ck630 FIND v(dout0_117) AT=320.025n

.meas tran vdout0_118ck630 FIND v(dout0_118) AT=320.025n

.meas tran vdout0_119ck630 FIND v(dout0_119) AT=320.025n

.meas tran vdout0_120ck630 FIND v(dout0_120) AT=320.025n

.meas tran vdout0_121ck630 FIND v(dout0_121) AT=320.025n

.meas tran vdout0_122ck630 FIND v(dout0_122) AT=320.025n

.meas tran vdout0_123ck630 FIND v(dout0_123) AT=320.025n

.meas tran vdout0_124ck630 FIND v(dout0_124) AT=320.025n

.meas tran vdout0_125ck630 FIND v(dout0_125) AT=320.025n

.meas tran vdout0_126ck630 FIND v(dout0_126) AT=320.025n

.meas tran vdout0_127ck630 FIND v(dout0_127) AT=320.025n

.meas tran vdout0_0ck640 FIND v(dout0_0) AT=325.025n

.meas tran vdout0_1ck640 FIND v(dout0_1) AT=325.025n

.meas tran vdout0_2ck640 FIND v(dout0_2) AT=325.025n

.meas tran vdout0_3ck640 FIND v(dout0_3) AT=325.025n

.meas tran vdout0_4ck640 FIND v(dout0_4) AT=325.025n

.meas tran vdout0_5ck640 FIND v(dout0_5) AT=325.025n

.meas tran vdout0_6ck640 FIND v(dout0_6) AT=325.025n

.meas tran vdout0_7ck640 FIND v(dout0_7) AT=325.025n

.meas tran vdout0_8ck640 FIND v(dout0_8) AT=325.025n

.meas tran vdout0_9ck640 FIND v(dout0_9) AT=325.025n

.meas tran vdout0_10ck640 FIND v(dout0_10) AT=325.025n

.meas tran vdout0_11ck640 FIND v(dout0_11) AT=325.025n

.meas tran vdout0_12ck640 FIND v(dout0_12) AT=325.025n

.meas tran vdout0_13ck640 FIND v(dout0_13) AT=325.025n

.meas tran vdout0_14ck640 FIND v(dout0_14) AT=325.025n

.meas tran vdout0_15ck640 FIND v(dout0_15) AT=325.025n

.meas tran vdout0_16ck640 FIND v(dout0_16) AT=325.025n

.meas tran vdout0_17ck640 FIND v(dout0_17) AT=325.025n

.meas tran vdout0_18ck640 FIND v(dout0_18) AT=325.025n

.meas tran vdout0_19ck640 FIND v(dout0_19) AT=325.025n

.meas tran vdout0_20ck640 FIND v(dout0_20) AT=325.025n

.meas tran vdout0_21ck640 FIND v(dout0_21) AT=325.025n

.meas tran vdout0_22ck640 FIND v(dout0_22) AT=325.025n

.meas tran vdout0_23ck640 FIND v(dout0_23) AT=325.025n

.meas tran vdout0_24ck640 FIND v(dout0_24) AT=325.025n

.meas tran vdout0_25ck640 FIND v(dout0_25) AT=325.025n

.meas tran vdout0_26ck640 FIND v(dout0_26) AT=325.025n

.meas tran vdout0_27ck640 FIND v(dout0_27) AT=325.025n

.meas tran vdout0_28ck640 FIND v(dout0_28) AT=325.025n

.meas tran vdout0_29ck640 FIND v(dout0_29) AT=325.025n

.meas tran vdout0_30ck640 FIND v(dout0_30) AT=325.025n

.meas tran vdout0_31ck640 FIND v(dout0_31) AT=325.025n

.meas tran vdout0_32ck640 FIND v(dout0_32) AT=325.025n

.meas tran vdout0_33ck640 FIND v(dout0_33) AT=325.025n

.meas tran vdout0_34ck640 FIND v(dout0_34) AT=325.025n

.meas tran vdout0_35ck640 FIND v(dout0_35) AT=325.025n

.meas tran vdout0_36ck640 FIND v(dout0_36) AT=325.025n

.meas tran vdout0_37ck640 FIND v(dout0_37) AT=325.025n

.meas tran vdout0_38ck640 FIND v(dout0_38) AT=325.025n

.meas tran vdout0_39ck640 FIND v(dout0_39) AT=325.025n

.meas tran vdout0_40ck640 FIND v(dout0_40) AT=325.025n

.meas tran vdout0_41ck640 FIND v(dout0_41) AT=325.025n

.meas tran vdout0_42ck640 FIND v(dout0_42) AT=325.025n

.meas tran vdout0_43ck640 FIND v(dout0_43) AT=325.025n

.meas tran vdout0_44ck640 FIND v(dout0_44) AT=325.025n

.meas tran vdout0_45ck640 FIND v(dout0_45) AT=325.025n

.meas tran vdout0_46ck640 FIND v(dout0_46) AT=325.025n

.meas tran vdout0_47ck640 FIND v(dout0_47) AT=325.025n

.meas tran vdout0_48ck640 FIND v(dout0_48) AT=325.025n

.meas tran vdout0_49ck640 FIND v(dout0_49) AT=325.025n

.meas tran vdout0_50ck640 FIND v(dout0_50) AT=325.025n

.meas tran vdout0_51ck640 FIND v(dout0_51) AT=325.025n

.meas tran vdout0_52ck640 FIND v(dout0_52) AT=325.025n

.meas tran vdout0_53ck640 FIND v(dout0_53) AT=325.025n

.meas tran vdout0_54ck640 FIND v(dout0_54) AT=325.025n

.meas tran vdout0_55ck640 FIND v(dout0_55) AT=325.025n

.meas tran vdout0_56ck640 FIND v(dout0_56) AT=325.025n

.meas tran vdout0_57ck640 FIND v(dout0_57) AT=325.025n

.meas tran vdout0_58ck640 FIND v(dout0_58) AT=325.025n

.meas tran vdout0_59ck640 FIND v(dout0_59) AT=325.025n

.meas tran vdout0_60ck640 FIND v(dout0_60) AT=325.025n

.meas tran vdout0_61ck640 FIND v(dout0_61) AT=325.025n

.meas tran vdout0_62ck640 FIND v(dout0_62) AT=325.025n

.meas tran vdout0_63ck640 FIND v(dout0_63) AT=325.025n

.meas tran vdout0_64ck640 FIND v(dout0_64) AT=325.025n

.meas tran vdout0_65ck640 FIND v(dout0_65) AT=325.025n

.meas tran vdout0_66ck640 FIND v(dout0_66) AT=325.025n

.meas tran vdout0_67ck640 FIND v(dout0_67) AT=325.025n

.meas tran vdout0_68ck640 FIND v(dout0_68) AT=325.025n

.meas tran vdout0_69ck640 FIND v(dout0_69) AT=325.025n

.meas tran vdout0_70ck640 FIND v(dout0_70) AT=325.025n

.meas tran vdout0_71ck640 FIND v(dout0_71) AT=325.025n

.meas tran vdout0_72ck640 FIND v(dout0_72) AT=325.025n

.meas tran vdout0_73ck640 FIND v(dout0_73) AT=325.025n

.meas tran vdout0_74ck640 FIND v(dout0_74) AT=325.025n

.meas tran vdout0_75ck640 FIND v(dout0_75) AT=325.025n

.meas tran vdout0_76ck640 FIND v(dout0_76) AT=325.025n

.meas tran vdout0_77ck640 FIND v(dout0_77) AT=325.025n

.meas tran vdout0_78ck640 FIND v(dout0_78) AT=325.025n

.meas tran vdout0_79ck640 FIND v(dout0_79) AT=325.025n

.meas tran vdout0_80ck640 FIND v(dout0_80) AT=325.025n

.meas tran vdout0_81ck640 FIND v(dout0_81) AT=325.025n

.meas tran vdout0_82ck640 FIND v(dout0_82) AT=325.025n

.meas tran vdout0_83ck640 FIND v(dout0_83) AT=325.025n

.meas tran vdout0_84ck640 FIND v(dout0_84) AT=325.025n

.meas tran vdout0_85ck640 FIND v(dout0_85) AT=325.025n

.meas tran vdout0_86ck640 FIND v(dout0_86) AT=325.025n

.meas tran vdout0_87ck640 FIND v(dout0_87) AT=325.025n

.meas tran vdout0_88ck640 FIND v(dout0_88) AT=325.025n

.meas tran vdout0_89ck640 FIND v(dout0_89) AT=325.025n

.meas tran vdout0_90ck640 FIND v(dout0_90) AT=325.025n

.meas tran vdout0_91ck640 FIND v(dout0_91) AT=325.025n

.meas tran vdout0_92ck640 FIND v(dout0_92) AT=325.025n

.meas tran vdout0_93ck640 FIND v(dout0_93) AT=325.025n

.meas tran vdout0_94ck640 FIND v(dout0_94) AT=325.025n

.meas tran vdout0_95ck640 FIND v(dout0_95) AT=325.025n

.meas tran vdout0_96ck640 FIND v(dout0_96) AT=325.025n

.meas tran vdout0_97ck640 FIND v(dout0_97) AT=325.025n

.meas tran vdout0_98ck640 FIND v(dout0_98) AT=325.025n

.meas tran vdout0_99ck640 FIND v(dout0_99) AT=325.025n

.meas tran vdout0_100ck640 FIND v(dout0_100) AT=325.025n

.meas tran vdout0_101ck640 FIND v(dout0_101) AT=325.025n

.meas tran vdout0_102ck640 FIND v(dout0_102) AT=325.025n

.meas tran vdout0_103ck640 FIND v(dout0_103) AT=325.025n

.meas tran vdout0_104ck640 FIND v(dout0_104) AT=325.025n

.meas tran vdout0_105ck640 FIND v(dout0_105) AT=325.025n

.meas tran vdout0_106ck640 FIND v(dout0_106) AT=325.025n

.meas tran vdout0_107ck640 FIND v(dout0_107) AT=325.025n

.meas tran vdout0_108ck640 FIND v(dout0_108) AT=325.025n

.meas tran vdout0_109ck640 FIND v(dout0_109) AT=325.025n

.meas tran vdout0_110ck640 FIND v(dout0_110) AT=325.025n

.meas tran vdout0_111ck640 FIND v(dout0_111) AT=325.025n

.meas tran vdout0_112ck640 FIND v(dout0_112) AT=325.025n

.meas tran vdout0_113ck640 FIND v(dout0_113) AT=325.025n

.meas tran vdout0_114ck640 FIND v(dout0_114) AT=325.025n

.meas tran vdout0_115ck640 FIND v(dout0_115) AT=325.025n

.meas tran vdout0_116ck640 FIND v(dout0_116) AT=325.025n

.meas tran vdout0_117ck640 FIND v(dout0_117) AT=325.025n

.meas tran vdout0_118ck640 FIND v(dout0_118) AT=325.025n

.meas tran vdout0_119ck640 FIND v(dout0_119) AT=325.025n

.meas tran vdout0_120ck640 FIND v(dout0_120) AT=325.025n

.meas tran vdout0_121ck640 FIND v(dout0_121) AT=325.025n

.meas tran vdout0_122ck640 FIND v(dout0_122) AT=325.025n

.meas tran vdout0_123ck640 FIND v(dout0_123) AT=325.025n

.meas tran vdout0_124ck640 FIND v(dout0_124) AT=325.025n

.meas tran vdout0_125ck640 FIND v(dout0_125) AT=325.025n

.meas tran vdout0_126ck640 FIND v(dout0_126) AT=325.025n

.meas tran vdout0_127ck640 FIND v(dout0_127) AT=325.025n

.meas tran vdout0_0ck650 FIND v(dout0_0) AT=330.025n

.meas tran vdout0_1ck650 FIND v(dout0_1) AT=330.025n

.meas tran vdout0_2ck650 FIND v(dout0_2) AT=330.025n

.meas tran vdout0_3ck650 FIND v(dout0_3) AT=330.025n

.meas tran vdout0_4ck650 FIND v(dout0_4) AT=330.025n

.meas tran vdout0_5ck650 FIND v(dout0_5) AT=330.025n

.meas tran vdout0_6ck650 FIND v(dout0_6) AT=330.025n

.meas tran vdout0_7ck650 FIND v(dout0_7) AT=330.025n

.meas tran vdout0_8ck650 FIND v(dout0_8) AT=330.025n

.meas tran vdout0_9ck650 FIND v(dout0_9) AT=330.025n

.meas tran vdout0_10ck650 FIND v(dout0_10) AT=330.025n

.meas tran vdout0_11ck650 FIND v(dout0_11) AT=330.025n

.meas tran vdout0_12ck650 FIND v(dout0_12) AT=330.025n

.meas tran vdout0_13ck650 FIND v(dout0_13) AT=330.025n

.meas tran vdout0_14ck650 FIND v(dout0_14) AT=330.025n

.meas tran vdout0_15ck650 FIND v(dout0_15) AT=330.025n

.meas tran vdout0_16ck650 FIND v(dout0_16) AT=330.025n

.meas tran vdout0_17ck650 FIND v(dout0_17) AT=330.025n

.meas tran vdout0_18ck650 FIND v(dout0_18) AT=330.025n

.meas tran vdout0_19ck650 FIND v(dout0_19) AT=330.025n

.meas tran vdout0_20ck650 FIND v(dout0_20) AT=330.025n

.meas tran vdout0_21ck650 FIND v(dout0_21) AT=330.025n

.meas tran vdout0_22ck650 FIND v(dout0_22) AT=330.025n

.meas tran vdout0_23ck650 FIND v(dout0_23) AT=330.025n

.meas tran vdout0_24ck650 FIND v(dout0_24) AT=330.025n

.meas tran vdout0_25ck650 FIND v(dout0_25) AT=330.025n

.meas tran vdout0_26ck650 FIND v(dout0_26) AT=330.025n

.meas tran vdout0_27ck650 FIND v(dout0_27) AT=330.025n

.meas tran vdout0_28ck650 FIND v(dout0_28) AT=330.025n

.meas tran vdout0_29ck650 FIND v(dout0_29) AT=330.025n

.meas tran vdout0_30ck650 FIND v(dout0_30) AT=330.025n

.meas tran vdout0_31ck650 FIND v(dout0_31) AT=330.025n

.meas tran vdout0_32ck650 FIND v(dout0_32) AT=330.025n

.meas tran vdout0_33ck650 FIND v(dout0_33) AT=330.025n

.meas tran vdout0_34ck650 FIND v(dout0_34) AT=330.025n

.meas tran vdout0_35ck650 FIND v(dout0_35) AT=330.025n

.meas tran vdout0_36ck650 FIND v(dout0_36) AT=330.025n

.meas tran vdout0_37ck650 FIND v(dout0_37) AT=330.025n

.meas tran vdout0_38ck650 FIND v(dout0_38) AT=330.025n

.meas tran vdout0_39ck650 FIND v(dout0_39) AT=330.025n

.meas tran vdout0_40ck650 FIND v(dout0_40) AT=330.025n

.meas tran vdout0_41ck650 FIND v(dout0_41) AT=330.025n

.meas tran vdout0_42ck650 FIND v(dout0_42) AT=330.025n

.meas tran vdout0_43ck650 FIND v(dout0_43) AT=330.025n

.meas tran vdout0_44ck650 FIND v(dout0_44) AT=330.025n

.meas tran vdout0_45ck650 FIND v(dout0_45) AT=330.025n

.meas tran vdout0_46ck650 FIND v(dout0_46) AT=330.025n

.meas tran vdout0_47ck650 FIND v(dout0_47) AT=330.025n

.meas tran vdout0_48ck650 FIND v(dout0_48) AT=330.025n

.meas tran vdout0_49ck650 FIND v(dout0_49) AT=330.025n

.meas tran vdout0_50ck650 FIND v(dout0_50) AT=330.025n

.meas tran vdout0_51ck650 FIND v(dout0_51) AT=330.025n

.meas tran vdout0_52ck650 FIND v(dout0_52) AT=330.025n

.meas tran vdout0_53ck650 FIND v(dout0_53) AT=330.025n

.meas tran vdout0_54ck650 FIND v(dout0_54) AT=330.025n

.meas tran vdout0_55ck650 FIND v(dout0_55) AT=330.025n

.meas tran vdout0_56ck650 FIND v(dout0_56) AT=330.025n

.meas tran vdout0_57ck650 FIND v(dout0_57) AT=330.025n

.meas tran vdout0_58ck650 FIND v(dout0_58) AT=330.025n

.meas tran vdout0_59ck650 FIND v(dout0_59) AT=330.025n

.meas tran vdout0_60ck650 FIND v(dout0_60) AT=330.025n

.meas tran vdout0_61ck650 FIND v(dout0_61) AT=330.025n

.meas tran vdout0_62ck650 FIND v(dout0_62) AT=330.025n

.meas tran vdout0_63ck650 FIND v(dout0_63) AT=330.025n

.meas tran vdout0_64ck650 FIND v(dout0_64) AT=330.025n

.meas tran vdout0_65ck650 FIND v(dout0_65) AT=330.025n

.meas tran vdout0_66ck650 FIND v(dout0_66) AT=330.025n

.meas tran vdout0_67ck650 FIND v(dout0_67) AT=330.025n

.meas tran vdout0_68ck650 FIND v(dout0_68) AT=330.025n

.meas tran vdout0_69ck650 FIND v(dout0_69) AT=330.025n

.meas tran vdout0_70ck650 FIND v(dout0_70) AT=330.025n

.meas tran vdout0_71ck650 FIND v(dout0_71) AT=330.025n

.meas tran vdout0_72ck650 FIND v(dout0_72) AT=330.025n

.meas tran vdout0_73ck650 FIND v(dout0_73) AT=330.025n

.meas tran vdout0_74ck650 FIND v(dout0_74) AT=330.025n

.meas tran vdout0_75ck650 FIND v(dout0_75) AT=330.025n

.meas tran vdout0_76ck650 FIND v(dout0_76) AT=330.025n

.meas tran vdout0_77ck650 FIND v(dout0_77) AT=330.025n

.meas tran vdout0_78ck650 FIND v(dout0_78) AT=330.025n

.meas tran vdout0_79ck650 FIND v(dout0_79) AT=330.025n

.meas tran vdout0_80ck650 FIND v(dout0_80) AT=330.025n

.meas tran vdout0_81ck650 FIND v(dout0_81) AT=330.025n

.meas tran vdout0_82ck650 FIND v(dout0_82) AT=330.025n

.meas tran vdout0_83ck650 FIND v(dout0_83) AT=330.025n

.meas tran vdout0_84ck650 FIND v(dout0_84) AT=330.025n

.meas tran vdout0_85ck650 FIND v(dout0_85) AT=330.025n

.meas tran vdout0_86ck650 FIND v(dout0_86) AT=330.025n

.meas tran vdout0_87ck650 FIND v(dout0_87) AT=330.025n

.meas tran vdout0_88ck650 FIND v(dout0_88) AT=330.025n

.meas tran vdout0_89ck650 FIND v(dout0_89) AT=330.025n

.meas tran vdout0_90ck650 FIND v(dout0_90) AT=330.025n

.meas tran vdout0_91ck650 FIND v(dout0_91) AT=330.025n

.meas tran vdout0_92ck650 FIND v(dout0_92) AT=330.025n

.meas tran vdout0_93ck650 FIND v(dout0_93) AT=330.025n

.meas tran vdout0_94ck650 FIND v(dout0_94) AT=330.025n

.meas tran vdout0_95ck650 FIND v(dout0_95) AT=330.025n

.meas tran vdout0_96ck650 FIND v(dout0_96) AT=330.025n

.meas tran vdout0_97ck650 FIND v(dout0_97) AT=330.025n

.meas tran vdout0_98ck650 FIND v(dout0_98) AT=330.025n

.meas tran vdout0_99ck650 FIND v(dout0_99) AT=330.025n

.meas tran vdout0_100ck650 FIND v(dout0_100) AT=330.025n

.meas tran vdout0_101ck650 FIND v(dout0_101) AT=330.025n

.meas tran vdout0_102ck650 FIND v(dout0_102) AT=330.025n

.meas tran vdout0_103ck650 FIND v(dout0_103) AT=330.025n

.meas tran vdout0_104ck650 FIND v(dout0_104) AT=330.025n

.meas tran vdout0_105ck650 FIND v(dout0_105) AT=330.025n

.meas tran vdout0_106ck650 FIND v(dout0_106) AT=330.025n

.meas tran vdout0_107ck650 FIND v(dout0_107) AT=330.025n

.meas tran vdout0_108ck650 FIND v(dout0_108) AT=330.025n

.meas tran vdout0_109ck650 FIND v(dout0_109) AT=330.025n

.meas tran vdout0_110ck650 FIND v(dout0_110) AT=330.025n

.meas tran vdout0_111ck650 FIND v(dout0_111) AT=330.025n

.meas tran vdout0_112ck650 FIND v(dout0_112) AT=330.025n

.meas tran vdout0_113ck650 FIND v(dout0_113) AT=330.025n

.meas tran vdout0_114ck650 FIND v(dout0_114) AT=330.025n

.meas tran vdout0_115ck650 FIND v(dout0_115) AT=330.025n

.meas tran vdout0_116ck650 FIND v(dout0_116) AT=330.025n

.meas tran vdout0_117ck650 FIND v(dout0_117) AT=330.025n

.meas tran vdout0_118ck650 FIND v(dout0_118) AT=330.025n

.meas tran vdout0_119ck650 FIND v(dout0_119) AT=330.025n

.meas tran vdout0_120ck650 FIND v(dout0_120) AT=330.025n

.meas tran vdout0_121ck650 FIND v(dout0_121) AT=330.025n

.meas tran vdout0_122ck650 FIND v(dout0_122) AT=330.025n

.meas tran vdout0_123ck650 FIND v(dout0_123) AT=330.025n

.meas tran vdout0_124ck650 FIND v(dout0_124) AT=330.025n

.meas tran vdout0_125ck650 FIND v(dout0_125) AT=330.025n

.meas tran vdout0_126ck650 FIND v(dout0_126) AT=330.025n

.meas tran vdout0_127ck650 FIND v(dout0_127) AT=330.025n

.meas tran vdout0_0ck670 FIND v(dout0_0) AT=340.025n

.meas tran vdout0_1ck670 FIND v(dout0_1) AT=340.025n

.meas tran vdout0_2ck670 FIND v(dout0_2) AT=340.025n

.meas tran vdout0_3ck670 FIND v(dout0_3) AT=340.025n

.meas tran vdout0_4ck670 FIND v(dout0_4) AT=340.025n

.meas tran vdout0_5ck670 FIND v(dout0_5) AT=340.025n

.meas tran vdout0_6ck670 FIND v(dout0_6) AT=340.025n

.meas tran vdout0_7ck670 FIND v(dout0_7) AT=340.025n

.meas tran vdout0_8ck670 FIND v(dout0_8) AT=340.025n

.meas tran vdout0_9ck670 FIND v(dout0_9) AT=340.025n

.meas tran vdout0_10ck670 FIND v(dout0_10) AT=340.025n

.meas tran vdout0_11ck670 FIND v(dout0_11) AT=340.025n

.meas tran vdout0_12ck670 FIND v(dout0_12) AT=340.025n

.meas tran vdout0_13ck670 FIND v(dout0_13) AT=340.025n

.meas tran vdout0_14ck670 FIND v(dout0_14) AT=340.025n

.meas tran vdout0_15ck670 FIND v(dout0_15) AT=340.025n

.meas tran vdout0_16ck670 FIND v(dout0_16) AT=340.025n

.meas tran vdout0_17ck670 FIND v(dout0_17) AT=340.025n

.meas tran vdout0_18ck670 FIND v(dout0_18) AT=340.025n

.meas tran vdout0_19ck670 FIND v(dout0_19) AT=340.025n

.meas tran vdout0_20ck670 FIND v(dout0_20) AT=340.025n

.meas tran vdout0_21ck670 FIND v(dout0_21) AT=340.025n

.meas tran vdout0_22ck670 FIND v(dout0_22) AT=340.025n

.meas tran vdout0_23ck670 FIND v(dout0_23) AT=340.025n

.meas tran vdout0_24ck670 FIND v(dout0_24) AT=340.025n

.meas tran vdout0_25ck670 FIND v(dout0_25) AT=340.025n

.meas tran vdout0_26ck670 FIND v(dout0_26) AT=340.025n

.meas tran vdout0_27ck670 FIND v(dout0_27) AT=340.025n

.meas tran vdout0_28ck670 FIND v(dout0_28) AT=340.025n

.meas tran vdout0_29ck670 FIND v(dout0_29) AT=340.025n

.meas tran vdout0_30ck670 FIND v(dout0_30) AT=340.025n

.meas tran vdout0_31ck670 FIND v(dout0_31) AT=340.025n

.meas tran vdout0_32ck670 FIND v(dout0_32) AT=340.025n

.meas tran vdout0_33ck670 FIND v(dout0_33) AT=340.025n

.meas tran vdout0_34ck670 FIND v(dout0_34) AT=340.025n

.meas tran vdout0_35ck670 FIND v(dout0_35) AT=340.025n

.meas tran vdout0_36ck670 FIND v(dout0_36) AT=340.025n

.meas tran vdout0_37ck670 FIND v(dout0_37) AT=340.025n

.meas tran vdout0_38ck670 FIND v(dout0_38) AT=340.025n

.meas tran vdout0_39ck670 FIND v(dout0_39) AT=340.025n

.meas tran vdout0_40ck670 FIND v(dout0_40) AT=340.025n

.meas tran vdout0_41ck670 FIND v(dout0_41) AT=340.025n

.meas tran vdout0_42ck670 FIND v(dout0_42) AT=340.025n

.meas tran vdout0_43ck670 FIND v(dout0_43) AT=340.025n

.meas tran vdout0_44ck670 FIND v(dout0_44) AT=340.025n

.meas tran vdout0_45ck670 FIND v(dout0_45) AT=340.025n

.meas tran vdout0_46ck670 FIND v(dout0_46) AT=340.025n

.meas tran vdout0_47ck670 FIND v(dout0_47) AT=340.025n

.meas tran vdout0_48ck670 FIND v(dout0_48) AT=340.025n

.meas tran vdout0_49ck670 FIND v(dout0_49) AT=340.025n

.meas tran vdout0_50ck670 FIND v(dout0_50) AT=340.025n

.meas tran vdout0_51ck670 FIND v(dout0_51) AT=340.025n

.meas tran vdout0_52ck670 FIND v(dout0_52) AT=340.025n

.meas tran vdout0_53ck670 FIND v(dout0_53) AT=340.025n

.meas tran vdout0_54ck670 FIND v(dout0_54) AT=340.025n

.meas tran vdout0_55ck670 FIND v(dout0_55) AT=340.025n

.meas tran vdout0_56ck670 FIND v(dout0_56) AT=340.025n

.meas tran vdout0_57ck670 FIND v(dout0_57) AT=340.025n

.meas tran vdout0_58ck670 FIND v(dout0_58) AT=340.025n

.meas tran vdout0_59ck670 FIND v(dout0_59) AT=340.025n

.meas tran vdout0_60ck670 FIND v(dout0_60) AT=340.025n

.meas tran vdout0_61ck670 FIND v(dout0_61) AT=340.025n

.meas tran vdout0_62ck670 FIND v(dout0_62) AT=340.025n

.meas tran vdout0_63ck670 FIND v(dout0_63) AT=340.025n

.meas tran vdout0_64ck670 FIND v(dout0_64) AT=340.025n

.meas tran vdout0_65ck670 FIND v(dout0_65) AT=340.025n

.meas tran vdout0_66ck670 FIND v(dout0_66) AT=340.025n

.meas tran vdout0_67ck670 FIND v(dout0_67) AT=340.025n

.meas tran vdout0_68ck670 FIND v(dout0_68) AT=340.025n

.meas tran vdout0_69ck670 FIND v(dout0_69) AT=340.025n

.meas tran vdout0_70ck670 FIND v(dout0_70) AT=340.025n

.meas tran vdout0_71ck670 FIND v(dout0_71) AT=340.025n

.meas tran vdout0_72ck670 FIND v(dout0_72) AT=340.025n

.meas tran vdout0_73ck670 FIND v(dout0_73) AT=340.025n

.meas tran vdout0_74ck670 FIND v(dout0_74) AT=340.025n

.meas tran vdout0_75ck670 FIND v(dout0_75) AT=340.025n

.meas tran vdout0_76ck670 FIND v(dout0_76) AT=340.025n

.meas tran vdout0_77ck670 FIND v(dout0_77) AT=340.025n

.meas tran vdout0_78ck670 FIND v(dout0_78) AT=340.025n

.meas tran vdout0_79ck670 FIND v(dout0_79) AT=340.025n

.meas tran vdout0_80ck670 FIND v(dout0_80) AT=340.025n

.meas tran vdout0_81ck670 FIND v(dout0_81) AT=340.025n

.meas tran vdout0_82ck670 FIND v(dout0_82) AT=340.025n

.meas tran vdout0_83ck670 FIND v(dout0_83) AT=340.025n

.meas tran vdout0_84ck670 FIND v(dout0_84) AT=340.025n

.meas tran vdout0_85ck670 FIND v(dout0_85) AT=340.025n

.meas tran vdout0_86ck670 FIND v(dout0_86) AT=340.025n

.meas tran vdout0_87ck670 FIND v(dout0_87) AT=340.025n

.meas tran vdout0_88ck670 FIND v(dout0_88) AT=340.025n

.meas tran vdout0_89ck670 FIND v(dout0_89) AT=340.025n

.meas tran vdout0_90ck670 FIND v(dout0_90) AT=340.025n

.meas tran vdout0_91ck670 FIND v(dout0_91) AT=340.025n

.meas tran vdout0_92ck670 FIND v(dout0_92) AT=340.025n

.meas tran vdout0_93ck670 FIND v(dout0_93) AT=340.025n

.meas tran vdout0_94ck670 FIND v(dout0_94) AT=340.025n

.meas tran vdout0_95ck670 FIND v(dout0_95) AT=340.025n

.meas tran vdout0_96ck670 FIND v(dout0_96) AT=340.025n

.meas tran vdout0_97ck670 FIND v(dout0_97) AT=340.025n

.meas tran vdout0_98ck670 FIND v(dout0_98) AT=340.025n

.meas tran vdout0_99ck670 FIND v(dout0_99) AT=340.025n

.meas tran vdout0_100ck670 FIND v(dout0_100) AT=340.025n

.meas tran vdout0_101ck670 FIND v(dout0_101) AT=340.025n

.meas tran vdout0_102ck670 FIND v(dout0_102) AT=340.025n

.meas tran vdout0_103ck670 FIND v(dout0_103) AT=340.025n

.meas tran vdout0_104ck670 FIND v(dout0_104) AT=340.025n

.meas tran vdout0_105ck670 FIND v(dout0_105) AT=340.025n

.meas tran vdout0_106ck670 FIND v(dout0_106) AT=340.025n

.meas tran vdout0_107ck670 FIND v(dout0_107) AT=340.025n

.meas tran vdout0_108ck670 FIND v(dout0_108) AT=340.025n

.meas tran vdout0_109ck670 FIND v(dout0_109) AT=340.025n

.meas tran vdout0_110ck670 FIND v(dout0_110) AT=340.025n

.meas tran vdout0_111ck670 FIND v(dout0_111) AT=340.025n

.meas tran vdout0_112ck670 FIND v(dout0_112) AT=340.025n

.meas tran vdout0_113ck670 FIND v(dout0_113) AT=340.025n

.meas tran vdout0_114ck670 FIND v(dout0_114) AT=340.025n

.meas tran vdout0_115ck670 FIND v(dout0_115) AT=340.025n

.meas tran vdout0_116ck670 FIND v(dout0_116) AT=340.025n

.meas tran vdout0_117ck670 FIND v(dout0_117) AT=340.025n

.meas tran vdout0_118ck670 FIND v(dout0_118) AT=340.025n

.meas tran vdout0_119ck670 FIND v(dout0_119) AT=340.025n

.meas tran vdout0_120ck670 FIND v(dout0_120) AT=340.025n

.meas tran vdout0_121ck670 FIND v(dout0_121) AT=340.025n

.meas tran vdout0_122ck670 FIND v(dout0_122) AT=340.025n

.meas tran vdout0_123ck670 FIND v(dout0_123) AT=340.025n

.meas tran vdout0_124ck670 FIND v(dout0_124) AT=340.025n

.meas tran vdout0_125ck670 FIND v(dout0_125) AT=340.025n

.meas tran vdout0_126ck670 FIND v(dout0_126) AT=340.025n

.meas tran vdout0_127ck670 FIND v(dout0_127) AT=340.025n

.meas tran vdout0_0ck680 FIND v(dout0_0) AT=345.025n

.meas tran vdout0_1ck680 FIND v(dout0_1) AT=345.025n

.meas tran vdout0_2ck680 FIND v(dout0_2) AT=345.025n

.meas tran vdout0_3ck680 FIND v(dout0_3) AT=345.025n

.meas tran vdout0_4ck680 FIND v(dout0_4) AT=345.025n

.meas tran vdout0_5ck680 FIND v(dout0_5) AT=345.025n

.meas tran vdout0_6ck680 FIND v(dout0_6) AT=345.025n

.meas tran vdout0_7ck680 FIND v(dout0_7) AT=345.025n

.meas tran vdout0_8ck680 FIND v(dout0_8) AT=345.025n

.meas tran vdout0_9ck680 FIND v(dout0_9) AT=345.025n

.meas tran vdout0_10ck680 FIND v(dout0_10) AT=345.025n

.meas tran vdout0_11ck680 FIND v(dout0_11) AT=345.025n

.meas tran vdout0_12ck680 FIND v(dout0_12) AT=345.025n

.meas tran vdout0_13ck680 FIND v(dout0_13) AT=345.025n

.meas tran vdout0_14ck680 FIND v(dout0_14) AT=345.025n

.meas tran vdout0_15ck680 FIND v(dout0_15) AT=345.025n

.meas tran vdout0_16ck680 FIND v(dout0_16) AT=345.025n

.meas tran vdout0_17ck680 FIND v(dout0_17) AT=345.025n

.meas tran vdout0_18ck680 FIND v(dout0_18) AT=345.025n

.meas tran vdout0_19ck680 FIND v(dout0_19) AT=345.025n

.meas tran vdout0_20ck680 FIND v(dout0_20) AT=345.025n

.meas tran vdout0_21ck680 FIND v(dout0_21) AT=345.025n

.meas tran vdout0_22ck680 FIND v(dout0_22) AT=345.025n

.meas tran vdout0_23ck680 FIND v(dout0_23) AT=345.025n

.meas tran vdout0_24ck680 FIND v(dout0_24) AT=345.025n

.meas tran vdout0_25ck680 FIND v(dout0_25) AT=345.025n

.meas tran vdout0_26ck680 FIND v(dout0_26) AT=345.025n

.meas tran vdout0_27ck680 FIND v(dout0_27) AT=345.025n

.meas tran vdout0_28ck680 FIND v(dout0_28) AT=345.025n

.meas tran vdout0_29ck680 FIND v(dout0_29) AT=345.025n

.meas tran vdout0_30ck680 FIND v(dout0_30) AT=345.025n

.meas tran vdout0_31ck680 FIND v(dout0_31) AT=345.025n

.meas tran vdout0_32ck680 FIND v(dout0_32) AT=345.025n

.meas tran vdout0_33ck680 FIND v(dout0_33) AT=345.025n

.meas tran vdout0_34ck680 FIND v(dout0_34) AT=345.025n

.meas tran vdout0_35ck680 FIND v(dout0_35) AT=345.025n

.meas tran vdout0_36ck680 FIND v(dout0_36) AT=345.025n

.meas tran vdout0_37ck680 FIND v(dout0_37) AT=345.025n

.meas tran vdout0_38ck680 FIND v(dout0_38) AT=345.025n

.meas tran vdout0_39ck680 FIND v(dout0_39) AT=345.025n

.meas tran vdout0_40ck680 FIND v(dout0_40) AT=345.025n

.meas tran vdout0_41ck680 FIND v(dout0_41) AT=345.025n

.meas tran vdout0_42ck680 FIND v(dout0_42) AT=345.025n

.meas tran vdout0_43ck680 FIND v(dout0_43) AT=345.025n

.meas tran vdout0_44ck680 FIND v(dout0_44) AT=345.025n

.meas tran vdout0_45ck680 FIND v(dout0_45) AT=345.025n

.meas tran vdout0_46ck680 FIND v(dout0_46) AT=345.025n

.meas tran vdout0_47ck680 FIND v(dout0_47) AT=345.025n

.meas tran vdout0_48ck680 FIND v(dout0_48) AT=345.025n

.meas tran vdout0_49ck680 FIND v(dout0_49) AT=345.025n

.meas tran vdout0_50ck680 FIND v(dout0_50) AT=345.025n

.meas tran vdout0_51ck680 FIND v(dout0_51) AT=345.025n

.meas tran vdout0_52ck680 FIND v(dout0_52) AT=345.025n

.meas tran vdout0_53ck680 FIND v(dout0_53) AT=345.025n

.meas tran vdout0_54ck680 FIND v(dout0_54) AT=345.025n

.meas tran vdout0_55ck680 FIND v(dout0_55) AT=345.025n

.meas tran vdout0_56ck680 FIND v(dout0_56) AT=345.025n

.meas tran vdout0_57ck680 FIND v(dout0_57) AT=345.025n

.meas tran vdout0_58ck680 FIND v(dout0_58) AT=345.025n

.meas tran vdout0_59ck680 FIND v(dout0_59) AT=345.025n

.meas tran vdout0_60ck680 FIND v(dout0_60) AT=345.025n

.meas tran vdout0_61ck680 FIND v(dout0_61) AT=345.025n

.meas tran vdout0_62ck680 FIND v(dout0_62) AT=345.025n

.meas tran vdout0_63ck680 FIND v(dout0_63) AT=345.025n

.meas tran vdout0_64ck680 FIND v(dout0_64) AT=345.025n

.meas tran vdout0_65ck680 FIND v(dout0_65) AT=345.025n

.meas tran vdout0_66ck680 FIND v(dout0_66) AT=345.025n

.meas tran vdout0_67ck680 FIND v(dout0_67) AT=345.025n

.meas tran vdout0_68ck680 FIND v(dout0_68) AT=345.025n

.meas tran vdout0_69ck680 FIND v(dout0_69) AT=345.025n

.meas tran vdout0_70ck680 FIND v(dout0_70) AT=345.025n

.meas tran vdout0_71ck680 FIND v(dout0_71) AT=345.025n

.meas tran vdout0_72ck680 FIND v(dout0_72) AT=345.025n

.meas tran vdout0_73ck680 FIND v(dout0_73) AT=345.025n

.meas tran vdout0_74ck680 FIND v(dout0_74) AT=345.025n

.meas tran vdout0_75ck680 FIND v(dout0_75) AT=345.025n

.meas tran vdout0_76ck680 FIND v(dout0_76) AT=345.025n

.meas tran vdout0_77ck680 FIND v(dout0_77) AT=345.025n

.meas tran vdout0_78ck680 FIND v(dout0_78) AT=345.025n

.meas tran vdout0_79ck680 FIND v(dout0_79) AT=345.025n

.meas tran vdout0_80ck680 FIND v(dout0_80) AT=345.025n

.meas tran vdout0_81ck680 FIND v(dout0_81) AT=345.025n

.meas tran vdout0_82ck680 FIND v(dout0_82) AT=345.025n

.meas tran vdout0_83ck680 FIND v(dout0_83) AT=345.025n

.meas tran vdout0_84ck680 FIND v(dout0_84) AT=345.025n

.meas tran vdout0_85ck680 FIND v(dout0_85) AT=345.025n

.meas tran vdout0_86ck680 FIND v(dout0_86) AT=345.025n

.meas tran vdout0_87ck680 FIND v(dout0_87) AT=345.025n

.meas tran vdout0_88ck680 FIND v(dout0_88) AT=345.025n

.meas tran vdout0_89ck680 FIND v(dout0_89) AT=345.025n

.meas tran vdout0_90ck680 FIND v(dout0_90) AT=345.025n

.meas tran vdout0_91ck680 FIND v(dout0_91) AT=345.025n

.meas tran vdout0_92ck680 FIND v(dout0_92) AT=345.025n

.meas tran vdout0_93ck680 FIND v(dout0_93) AT=345.025n

.meas tran vdout0_94ck680 FIND v(dout0_94) AT=345.025n

.meas tran vdout0_95ck680 FIND v(dout0_95) AT=345.025n

.meas tran vdout0_96ck680 FIND v(dout0_96) AT=345.025n

.meas tran vdout0_97ck680 FIND v(dout0_97) AT=345.025n

.meas tran vdout0_98ck680 FIND v(dout0_98) AT=345.025n

.meas tran vdout0_99ck680 FIND v(dout0_99) AT=345.025n

.meas tran vdout0_100ck680 FIND v(dout0_100) AT=345.025n

.meas tran vdout0_101ck680 FIND v(dout0_101) AT=345.025n

.meas tran vdout0_102ck680 FIND v(dout0_102) AT=345.025n

.meas tran vdout0_103ck680 FIND v(dout0_103) AT=345.025n

.meas tran vdout0_104ck680 FIND v(dout0_104) AT=345.025n

.meas tran vdout0_105ck680 FIND v(dout0_105) AT=345.025n

.meas tran vdout0_106ck680 FIND v(dout0_106) AT=345.025n

.meas tran vdout0_107ck680 FIND v(dout0_107) AT=345.025n

.meas tran vdout0_108ck680 FIND v(dout0_108) AT=345.025n

.meas tran vdout0_109ck680 FIND v(dout0_109) AT=345.025n

.meas tran vdout0_110ck680 FIND v(dout0_110) AT=345.025n

.meas tran vdout0_111ck680 FIND v(dout0_111) AT=345.025n

.meas tran vdout0_112ck680 FIND v(dout0_112) AT=345.025n

.meas tran vdout0_113ck680 FIND v(dout0_113) AT=345.025n

.meas tran vdout0_114ck680 FIND v(dout0_114) AT=345.025n

.meas tran vdout0_115ck680 FIND v(dout0_115) AT=345.025n

.meas tran vdout0_116ck680 FIND v(dout0_116) AT=345.025n

.meas tran vdout0_117ck680 FIND v(dout0_117) AT=345.025n

.meas tran vdout0_118ck680 FIND v(dout0_118) AT=345.025n

.meas tran vdout0_119ck680 FIND v(dout0_119) AT=345.025n

.meas tran vdout0_120ck680 FIND v(dout0_120) AT=345.025n

.meas tran vdout0_121ck680 FIND v(dout0_121) AT=345.025n

.meas tran vdout0_122ck680 FIND v(dout0_122) AT=345.025n

.meas tran vdout0_123ck680 FIND v(dout0_123) AT=345.025n

.meas tran vdout0_124ck680 FIND v(dout0_124) AT=345.025n

.meas tran vdout0_125ck680 FIND v(dout0_125) AT=345.025n

.meas tran vdout0_126ck680 FIND v(dout0_126) AT=345.025n

.meas tran vdout0_127ck680 FIND v(dout0_127) AT=345.025n

.meas tran vdout0_0ck690 FIND v(dout0_0) AT=350.025n

.meas tran vdout0_1ck690 FIND v(dout0_1) AT=350.025n

.meas tran vdout0_2ck690 FIND v(dout0_2) AT=350.025n

.meas tran vdout0_3ck690 FIND v(dout0_3) AT=350.025n

.meas tran vdout0_4ck690 FIND v(dout0_4) AT=350.025n

.meas tran vdout0_5ck690 FIND v(dout0_5) AT=350.025n

.meas tran vdout0_6ck690 FIND v(dout0_6) AT=350.025n

.meas tran vdout0_7ck690 FIND v(dout0_7) AT=350.025n

.meas tran vdout0_8ck690 FIND v(dout0_8) AT=350.025n

.meas tran vdout0_9ck690 FIND v(dout0_9) AT=350.025n

.meas tran vdout0_10ck690 FIND v(dout0_10) AT=350.025n

.meas tran vdout0_11ck690 FIND v(dout0_11) AT=350.025n

.meas tran vdout0_12ck690 FIND v(dout0_12) AT=350.025n

.meas tran vdout0_13ck690 FIND v(dout0_13) AT=350.025n

.meas tran vdout0_14ck690 FIND v(dout0_14) AT=350.025n

.meas tran vdout0_15ck690 FIND v(dout0_15) AT=350.025n

.meas tran vdout0_16ck690 FIND v(dout0_16) AT=350.025n

.meas tran vdout0_17ck690 FIND v(dout0_17) AT=350.025n

.meas tran vdout0_18ck690 FIND v(dout0_18) AT=350.025n

.meas tran vdout0_19ck690 FIND v(dout0_19) AT=350.025n

.meas tran vdout0_20ck690 FIND v(dout0_20) AT=350.025n

.meas tran vdout0_21ck690 FIND v(dout0_21) AT=350.025n

.meas tran vdout0_22ck690 FIND v(dout0_22) AT=350.025n

.meas tran vdout0_23ck690 FIND v(dout0_23) AT=350.025n

.meas tran vdout0_24ck690 FIND v(dout0_24) AT=350.025n

.meas tran vdout0_25ck690 FIND v(dout0_25) AT=350.025n

.meas tran vdout0_26ck690 FIND v(dout0_26) AT=350.025n

.meas tran vdout0_27ck690 FIND v(dout0_27) AT=350.025n

.meas tran vdout0_28ck690 FIND v(dout0_28) AT=350.025n

.meas tran vdout0_29ck690 FIND v(dout0_29) AT=350.025n

.meas tran vdout0_30ck690 FIND v(dout0_30) AT=350.025n

.meas tran vdout0_31ck690 FIND v(dout0_31) AT=350.025n

.meas tran vdout0_32ck690 FIND v(dout0_32) AT=350.025n

.meas tran vdout0_33ck690 FIND v(dout0_33) AT=350.025n

.meas tran vdout0_34ck690 FIND v(dout0_34) AT=350.025n

.meas tran vdout0_35ck690 FIND v(dout0_35) AT=350.025n

.meas tran vdout0_36ck690 FIND v(dout0_36) AT=350.025n

.meas tran vdout0_37ck690 FIND v(dout0_37) AT=350.025n

.meas tran vdout0_38ck690 FIND v(dout0_38) AT=350.025n

.meas tran vdout0_39ck690 FIND v(dout0_39) AT=350.025n

.meas tran vdout0_40ck690 FIND v(dout0_40) AT=350.025n

.meas tran vdout0_41ck690 FIND v(dout0_41) AT=350.025n

.meas tran vdout0_42ck690 FIND v(dout0_42) AT=350.025n

.meas tran vdout0_43ck690 FIND v(dout0_43) AT=350.025n

.meas tran vdout0_44ck690 FIND v(dout0_44) AT=350.025n

.meas tran vdout0_45ck690 FIND v(dout0_45) AT=350.025n

.meas tran vdout0_46ck690 FIND v(dout0_46) AT=350.025n

.meas tran vdout0_47ck690 FIND v(dout0_47) AT=350.025n

.meas tran vdout0_48ck690 FIND v(dout0_48) AT=350.025n

.meas tran vdout0_49ck690 FIND v(dout0_49) AT=350.025n

.meas tran vdout0_50ck690 FIND v(dout0_50) AT=350.025n

.meas tran vdout0_51ck690 FIND v(dout0_51) AT=350.025n

.meas tran vdout0_52ck690 FIND v(dout0_52) AT=350.025n

.meas tran vdout0_53ck690 FIND v(dout0_53) AT=350.025n

.meas tran vdout0_54ck690 FIND v(dout0_54) AT=350.025n

.meas tran vdout0_55ck690 FIND v(dout0_55) AT=350.025n

.meas tran vdout0_56ck690 FIND v(dout0_56) AT=350.025n

.meas tran vdout0_57ck690 FIND v(dout0_57) AT=350.025n

.meas tran vdout0_58ck690 FIND v(dout0_58) AT=350.025n

.meas tran vdout0_59ck690 FIND v(dout0_59) AT=350.025n

.meas tran vdout0_60ck690 FIND v(dout0_60) AT=350.025n

.meas tran vdout0_61ck690 FIND v(dout0_61) AT=350.025n

.meas tran vdout0_62ck690 FIND v(dout0_62) AT=350.025n

.meas tran vdout0_63ck690 FIND v(dout0_63) AT=350.025n

.meas tran vdout0_64ck690 FIND v(dout0_64) AT=350.025n

.meas tran vdout0_65ck690 FIND v(dout0_65) AT=350.025n

.meas tran vdout0_66ck690 FIND v(dout0_66) AT=350.025n

.meas tran vdout0_67ck690 FIND v(dout0_67) AT=350.025n

.meas tran vdout0_68ck690 FIND v(dout0_68) AT=350.025n

.meas tran vdout0_69ck690 FIND v(dout0_69) AT=350.025n

.meas tran vdout0_70ck690 FIND v(dout0_70) AT=350.025n

.meas tran vdout0_71ck690 FIND v(dout0_71) AT=350.025n

.meas tran vdout0_72ck690 FIND v(dout0_72) AT=350.025n

.meas tran vdout0_73ck690 FIND v(dout0_73) AT=350.025n

.meas tran vdout0_74ck690 FIND v(dout0_74) AT=350.025n

.meas tran vdout0_75ck690 FIND v(dout0_75) AT=350.025n

.meas tran vdout0_76ck690 FIND v(dout0_76) AT=350.025n

.meas tran vdout0_77ck690 FIND v(dout0_77) AT=350.025n

.meas tran vdout0_78ck690 FIND v(dout0_78) AT=350.025n

.meas tran vdout0_79ck690 FIND v(dout0_79) AT=350.025n

.meas tran vdout0_80ck690 FIND v(dout0_80) AT=350.025n

.meas tran vdout0_81ck690 FIND v(dout0_81) AT=350.025n

.meas tran vdout0_82ck690 FIND v(dout0_82) AT=350.025n

.meas tran vdout0_83ck690 FIND v(dout0_83) AT=350.025n

.meas tran vdout0_84ck690 FIND v(dout0_84) AT=350.025n

.meas tran vdout0_85ck690 FIND v(dout0_85) AT=350.025n

.meas tran vdout0_86ck690 FIND v(dout0_86) AT=350.025n

.meas tran vdout0_87ck690 FIND v(dout0_87) AT=350.025n

.meas tran vdout0_88ck690 FIND v(dout0_88) AT=350.025n

.meas tran vdout0_89ck690 FIND v(dout0_89) AT=350.025n

.meas tran vdout0_90ck690 FIND v(dout0_90) AT=350.025n

.meas tran vdout0_91ck690 FIND v(dout0_91) AT=350.025n

.meas tran vdout0_92ck690 FIND v(dout0_92) AT=350.025n

.meas tran vdout0_93ck690 FIND v(dout0_93) AT=350.025n

.meas tran vdout0_94ck690 FIND v(dout0_94) AT=350.025n

.meas tran vdout0_95ck690 FIND v(dout0_95) AT=350.025n

.meas tran vdout0_96ck690 FIND v(dout0_96) AT=350.025n

.meas tran vdout0_97ck690 FIND v(dout0_97) AT=350.025n

.meas tran vdout0_98ck690 FIND v(dout0_98) AT=350.025n

.meas tran vdout0_99ck690 FIND v(dout0_99) AT=350.025n

.meas tran vdout0_100ck690 FIND v(dout0_100) AT=350.025n

.meas tran vdout0_101ck690 FIND v(dout0_101) AT=350.025n

.meas tran vdout0_102ck690 FIND v(dout0_102) AT=350.025n

.meas tran vdout0_103ck690 FIND v(dout0_103) AT=350.025n

.meas tran vdout0_104ck690 FIND v(dout0_104) AT=350.025n

.meas tran vdout0_105ck690 FIND v(dout0_105) AT=350.025n

.meas tran vdout0_106ck690 FIND v(dout0_106) AT=350.025n

.meas tran vdout0_107ck690 FIND v(dout0_107) AT=350.025n

.meas tran vdout0_108ck690 FIND v(dout0_108) AT=350.025n

.meas tran vdout0_109ck690 FIND v(dout0_109) AT=350.025n

.meas tran vdout0_110ck690 FIND v(dout0_110) AT=350.025n

.meas tran vdout0_111ck690 FIND v(dout0_111) AT=350.025n

.meas tran vdout0_112ck690 FIND v(dout0_112) AT=350.025n

.meas tran vdout0_113ck690 FIND v(dout0_113) AT=350.025n

.meas tran vdout0_114ck690 FIND v(dout0_114) AT=350.025n

.meas tran vdout0_115ck690 FIND v(dout0_115) AT=350.025n

.meas tran vdout0_116ck690 FIND v(dout0_116) AT=350.025n

.meas tran vdout0_117ck690 FIND v(dout0_117) AT=350.025n

.meas tran vdout0_118ck690 FIND v(dout0_118) AT=350.025n

.meas tran vdout0_119ck690 FIND v(dout0_119) AT=350.025n

.meas tran vdout0_120ck690 FIND v(dout0_120) AT=350.025n

.meas tran vdout0_121ck690 FIND v(dout0_121) AT=350.025n

.meas tran vdout0_122ck690 FIND v(dout0_122) AT=350.025n

.meas tran vdout0_123ck690 FIND v(dout0_123) AT=350.025n

.meas tran vdout0_124ck690 FIND v(dout0_124) AT=350.025n

.meas tran vdout0_125ck690 FIND v(dout0_125) AT=350.025n

.meas tran vdout0_126ck690 FIND v(dout0_126) AT=350.025n

.meas tran vdout0_127ck690 FIND v(dout0_127) AT=350.025n

.meas tran vdout0_0ck700 FIND v(dout0_0) AT=355.025n

.meas tran vdout0_1ck700 FIND v(dout0_1) AT=355.025n

.meas tran vdout0_2ck700 FIND v(dout0_2) AT=355.025n

.meas tran vdout0_3ck700 FIND v(dout0_3) AT=355.025n

.meas tran vdout0_4ck700 FIND v(dout0_4) AT=355.025n

.meas tran vdout0_5ck700 FIND v(dout0_5) AT=355.025n

.meas tran vdout0_6ck700 FIND v(dout0_6) AT=355.025n

.meas tran vdout0_7ck700 FIND v(dout0_7) AT=355.025n

.meas tran vdout0_8ck700 FIND v(dout0_8) AT=355.025n

.meas tran vdout0_9ck700 FIND v(dout0_9) AT=355.025n

.meas tran vdout0_10ck700 FIND v(dout0_10) AT=355.025n

.meas tran vdout0_11ck700 FIND v(dout0_11) AT=355.025n

.meas tran vdout0_12ck700 FIND v(dout0_12) AT=355.025n

.meas tran vdout0_13ck700 FIND v(dout0_13) AT=355.025n

.meas tran vdout0_14ck700 FIND v(dout0_14) AT=355.025n

.meas tran vdout0_15ck700 FIND v(dout0_15) AT=355.025n

.meas tran vdout0_16ck700 FIND v(dout0_16) AT=355.025n

.meas tran vdout0_17ck700 FIND v(dout0_17) AT=355.025n

.meas tran vdout0_18ck700 FIND v(dout0_18) AT=355.025n

.meas tran vdout0_19ck700 FIND v(dout0_19) AT=355.025n

.meas tran vdout0_20ck700 FIND v(dout0_20) AT=355.025n

.meas tran vdout0_21ck700 FIND v(dout0_21) AT=355.025n

.meas tran vdout0_22ck700 FIND v(dout0_22) AT=355.025n

.meas tran vdout0_23ck700 FIND v(dout0_23) AT=355.025n

.meas tran vdout0_24ck700 FIND v(dout0_24) AT=355.025n

.meas tran vdout0_25ck700 FIND v(dout0_25) AT=355.025n

.meas tran vdout0_26ck700 FIND v(dout0_26) AT=355.025n

.meas tran vdout0_27ck700 FIND v(dout0_27) AT=355.025n

.meas tran vdout0_28ck700 FIND v(dout0_28) AT=355.025n

.meas tran vdout0_29ck700 FIND v(dout0_29) AT=355.025n

.meas tran vdout0_30ck700 FIND v(dout0_30) AT=355.025n

.meas tran vdout0_31ck700 FIND v(dout0_31) AT=355.025n

.meas tran vdout0_32ck700 FIND v(dout0_32) AT=355.025n

.meas tran vdout0_33ck700 FIND v(dout0_33) AT=355.025n

.meas tran vdout0_34ck700 FIND v(dout0_34) AT=355.025n

.meas tran vdout0_35ck700 FIND v(dout0_35) AT=355.025n

.meas tran vdout0_36ck700 FIND v(dout0_36) AT=355.025n

.meas tran vdout0_37ck700 FIND v(dout0_37) AT=355.025n

.meas tran vdout0_38ck700 FIND v(dout0_38) AT=355.025n

.meas tran vdout0_39ck700 FIND v(dout0_39) AT=355.025n

.meas tran vdout0_40ck700 FIND v(dout0_40) AT=355.025n

.meas tran vdout0_41ck700 FIND v(dout0_41) AT=355.025n

.meas tran vdout0_42ck700 FIND v(dout0_42) AT=355.025n

.meas tran vdout0_43ck700 FIND v(dout0_43) AT=355.025n

.meas tran vdout0_44ck700 FIND v(dout0_44) AT=355.025n

.meas tran vdout0_45ck700 FIND v(dout0_45) AT=355.025n

.meas tran vdout0_46ck700 FIND v(dout0_46) AT=355.025n

.meas tran vdout0_47ck700 FIND v(dout0_47) AT=355.025n

.meas tran vdout0_48ck700 FIND v(dout0_48) AT=355.025n

.meas tran vdout0_49ck700 FIND v(dout0_49) AT=355.025n

.meas tran vdout0_50ck700 FIND v(dout0_50) AT=355.025n

.meas tran vdout0_51ck700 FIND v(dout0_51) AT=355.025n

.meas tran vdout0_52ck700 FIND v(dout0_52) AT=355.025n

.meas tran vdout0_53ck700 FIND v(dout0_53) AT=355.025n

.meas tran vdout0_54ck700 FIND v(dout0_54) AT=355.025n

.meas tran vdout0_55ck700 FIND v(dout0_55) AT=355.025n

.meas tran vdout0_56ck700 FIND v(dout0_56) AT=355.025n

.meas tran vdout0_57ck700 FIND v(dout0_57) AT=355.025n

.meas tran vdout0_58ck700 FIND v(dout0_58) AT=355.025n

.meas tran vdout0_59ck700 FIND v(dout0_59) AT=355.025n

.meas tran vdout0_60ck700 FIND v(dout0_60) AT=355.025n

.meas tran vdout0_61ck700 FIND v(dout0_61) AT=355.025n

.meas tran vdout0_62ck700 FIND v(dout0_62) AT=355.025n

.meas tran vdout0_63ck700 FIND v(dout0_63) AT=355.025n

.meas tran vdout0_64ck700 FIND v(dout0_64) AT=355.025n

.meas tran vdout0_65ck700 FIND v(dout0_65) AT=355.025n

.meas tran vdout0_66ck700 FIND v(dout0_66) AT=355.025n

.meas tran vdout0_67ck700 FIND v(dout0_67) AT=355.025n

.meas tran vdout0_68ck700 FIND v(dout0_68) AT=355.025n

.meas tran vdout0_69ck700 FIND v(dout0_69) AT=355.025n

.meas tran vdout0_70ck700 FIND v(dout0_70) AT=355.025n

.meas tran vdout0_71ck700 FIND v(dout0_71) AT=355.025n

.meas tran vdout0_72ck700 FIND v(dout0_72) AT=355.025n

.meas tran vdout0_73ck700 FIND v(dout0_73) AT=355.025n

.meas tran vdout0_74ck700 FIND v(dout0_74) AT=355.025n

.meas tran vdout0_75ck700 FIND v(dout0_75) AT=355.025n

.meas tran vdout0_76ck700 FIND v(dout0_76) AT=355.025n

.meas tran vdout0_77ck700 FIND v(dout0_77) AT=355.025n

.meas tran vdout0_78ck700 FIND v(dout0_78) AT=355.025n

.meas tran vdout0_79ck700 FIND v(dout0_79) AT=355.025n

.meas tran vdout0_80ck700 FIND v(dout0_80) AT=355.025n

.meas tran vdout0_81ck700 FIND v(dout0_81) AT=355.025n

.meas tran vdout0_82ck700 FIND v(dout0_82) AT=355.025n

.meas tran vdout0_83ck700 FIND v(dout0_83) AT=355.025n

.meas tran vdout0_84ck700 FIND v(dout0_84) AT=355.025n

.meas tran vdout0_85ck700 FIND v(dout0_85) AT=355.025n

.meas tran vdout0_86ck700 FIND v(dout0_86) AT=355.025n

.meas tran vdout0_87ck700 FIND v(dout0_87) AT=355.025n

.meas tran vdout0_88ck700 FIND v(dout0_88) AT=355.025n

.meas tran vdout0_89ck700 FIND v(dout0_89) AT=355.025n

.meas tran vdout0_90ck700 FIND v(dout0_90) AT=355.025n

.meas tran vdout0_91ck700 FIND v(dout0_91) AT=355.025n

.meas tran vdout0_92ck700 FIND v(dout0_92) AT=355.025n

.meas tran vdout0_93ck700 FIND v(dout0_93) AT=355.025n

.meas tran vdout0_94ck700 FIND v(dout0_94) AT=355.025n

.meas tran vdout0_95ck700 FIND v(dout0_95) AT=355.025n

.meas tran vdout0_96ck700 FIND v(dout0_96) AT=355.025n

.meas tran vdout0_97ck700 FIND v(dout0_97) AT=355.025n

.meas tran vdout0_98ck700 FIND v(dout0_98) AT=355.025n

.meas tran vdout0_99ck700 FIND v(dout0_99) AT=355.025n

.meas tran vdout0_100ck700 FIND v(dout0_100) AT=355.025n

.meas tran vdout0_101ck700 FIND v(dout0_101) AT=355.025n

.meas tran vdout0_102ck700 FIND v(dout0_102) AT=355.025n

.meas tran vdout0_103ck700 FIND v(dout0_103) AT=355.025n

.meas tran vdout0_104ck700 FIND v(dout0_104) AT=355.025n

.meas tran vdout0_105ck700 FIND v(dout0_105) AT=355.025n

.meas tran vdout0_106ck700 FIND v(dout0_106) AT=355.025n

.meas tran vdout0_107ck700 FIND v(dout0_107) AT=355.025n

.meas tran vdout0_108ck700 FIND v(dout0_108) AT=355.025n

.meas tran vdout0_109ck700 FIND v(dout0_109) AT=355.025n

.meas tran vdout0_110ck700 FIND v(dout0_110) AT=355.025n

.meas tran vdout0_111ck700 FIND v(dout0_111) AT=355.025n

.meas tran vdout0_112ck700 FIND v(dout0_112) AT=355.025n

.meas tran vdout0_113ck700 FIND v(dout0_113) AT=355.025n

.meas tran vdout0_114ck700 FIND v(dout0_114) AT=355.025n

.meas tran vdout0_115ck700 FIND v(dout0_115) AT=355.025n

.meas tran vdout0_116ck700 FIND v(dout0_116) AT=355.025n

.meas tran vdout0_117ck700 FIND v(dout0_117) AT=355.025n

.meas tran vdout0_118ck700 FIND v(dout0_118) AT=355.025n

.meas tran vdout0_119ck700 FIND v(dout0_119) AT=355.025n

.meas tran vdout0_120ck700 FIND v(dout0_120) AT=355.025n

.meas tran vdout0_121ck700 FIND v(dout0_121) AT=355.025n

.meas tran vdout0_122ck700 FIND v(dout0_122) AT=355.025n

.meas tran vdout0_123ck700 FIND v(dout0_123) AT=355.025n

.meas tran vdout0_124ck700 FIND v(dout0_124) AT=355.025n

.meas tran vdout0_125ck700 FIND v(dout0_125) AT=355.025n

.meas tran vdout0_126ck700 FIND v(dout0_126) AT=355.025n

.meas tran vdout0_127ck700 FIND v(dout0_127) AT=355.025n

.meas tran vdout0_0ck710 FIND v(dout0_0) AT=360.025n

.meas tran vdout0_1ck710 FIND v(dout0_1) AT=360.025n

.meas tran vdout0_2ck710 FIND v(dout0_2) AT=360.025n

.meas tran vdout0_3ck710 FIND v(dout0_3) AT=360.025n

.meas tran vdout0_4ck710 FIND v(dout0_4) AT=360.025n

.meas tran vdout0_5ck710 FIND v(dout0_5) AT=360.025n

.meas tran vdout0_6ck710 FIND v(dout0_6) AT=360.025n

.meas tran vdout0_7ck710 FIND v(dout0_7) AT=360.025n

.meas tran vdout0_8ck710 FIND v(dout0_8) AT=360.025n

.meas tran vdout0_9ck710 FIND v(dout0_9) AT=360.025n

.meas tran vdout0_10ck710 FIND v(dout0_10) AT=360.025n

.meas tran vdout0_11ck710 FIND v(dout0_11) AT=360.025n

.meas tran vdout0_12ck710 FIND v(dout0_12) AT=360.025n

.meas tran vdout0_13ck710 FIND v(dout0_13) AT=360.025n

.meas tran vdout0_14ck710 FIND v(dout0_14) AT=360.025n

.meas tran vdout0_15ck710 FIND v(dout0_15) AT=360.025n

.meas tran vdout0_16ck710 FIND v(dout0_16) AT=360.025n

.meas tran vdout0_17ck710 FIND v(dout0_17) AT=360.025n

.meas tran vdout0_18ck710 FIND v(dout0_18) AT=360.025n

.meas tran vdout0_19ck710 FIND v(dout0_19) AT=360.025n

.meas tran vdout0_20ck710 FIND v(dout0_20) AT=360.025n

.meas tran vdout0_21ck710 FIND v(dout0_21) AT=360.025n

.meas tran vdout0_22ck710 FIND v(dout0_22) AT=360.025n

.meas tran vdout0_23ck710 FIND v(dout0_23) AT=360.025n

.meas tran vdout0_24ck710 FIND v(dout0_24) AT=360.025n

.meas tran vdout0_25ck710 FIND v(dout0_25) AT=360.025n

.meas tran vdout0_26ck710 FIND v(dout0_26) AT=360.025n

.meas tran vdout0_27ck710 FIND v(dout0_27) AT=360.025n

.meas tran vdout0_28ck710 FIND v(dout0_28) AT=360.025n

.meas tran vdout0_29ck710 FIND v(dout0_29) AT=360.025n

.meas tran vdout0_30ck710 FIND v(dout0_30) AT=360.025n

.meas tran vdout0_31ck710 FIND v(dout0_31) AT=360.025n

.meas tran vdout0_32ck710 FIND v(dout0_32) AT=360.025n

.meas tran vdout0_33ck710 FIND v(dout0_33) AT=360.025n

.meas tran vdout0_34ck710 FIND v(dout0_34) AT=360.025n

.meas tran vdout0_35ck710 FIND v(dout0_35) AT=360.025n

.meas tran vdout0_36ck710 FIND v(dout0_36) AT=360.025n

.meas tran vdout0_37ck710 FIND v(dout0_37) AT=360.025n

.meas tran vdout0_38ck710 FIND v(dout0_38) AT=360.025n

.meas tran vdout0_39ck710 FIND v(dout0_39) AT=360.025n

.meas tran vdout0_40ck710 FIND v(dout0_40) AT=360.025n

.meas tran vdout0_41ck710 FIND v(dout0_41) AT=360.025n

.meas tran vdout0_42ck710 FIND v(dout0_42) AT=360.025n

.meas tran vdout0_43ck710 FIND v(dout0_43) AT=360.025n

.meas tran vdout0_44ck710 FIND v(dout0_44) AT=360.025n

.meas tran vdout0_45ck710 FIND v(dout0_45) AT=360.025n

.meas tran vdout0_46ck710 FIND v(dout0_46) AT=360.025n

.meas tran vdout0_47ck710 FIND v(dout0_47) AT=360.025n

.meas tran vdout0_48ck710 FIND v(dout0_48) AT=360.025n

.meas tran vdout0_49ck710 FIND v(dout0_49) AT=360.025n

.meas tran vdout0_50ck710 FIND v(dout0_50) AT=360.025n

.meas tran vdout0_51ck710 FIND v(dout0_51) AT=360.025n

.meas tran vdout0_52ck710 FIND v(dout0_52) AT=360.025n

.meas tran vdout0_53ck710 FIND v(dout0_53) AT=360.025n

.meas tran vdout0_54ck710 FIND v(dout0_54) AT=360.025n

.meas tran vdout0_55ck710 FIND v(dout0_55) AT=360.025n

.meas tran vdout0_56ck710 FIND v(dout0_56) AT=360.025n

.meas tran vdout0_57ck710 FIND v(dout0_57) AT=360.025n

.meas tran vdout0_58ck710 FIND v(dout0_58) AT=360.025n

.meas tran vdout0_59ck710 FIND v(dout0_59) AT=360.025n

.meas tran vdout0_60ck710 FIND v(dout0_60) AT=360.025n

.meas tran vdout0_61ck710 FIND v(dout0_61) AT=360.025n

.meas tran vdout0_62ck710 FIND v(dout0_62) AT=360.025n

.meas tran vdout0_63ck710 FIND v(dout0_63) AT=360.025n

.meas tran vdout0_64ck710 FIND v(dout0_64) AT=360.025n

.meas tran vdout0_65ck710 FIND v(dout0_65) AT=360.025n

.meas tran vdout0_66ck710 FIND v(dout0_66) AT=360.025n

.meas tran vdout0_67ck710 FIND v(dout0_67) AT=360.025n

.meas tran vdout0_68ck710 FIND v(dout0_68) AT=360.025n

.meas tran vdout0_69ck710 FIND v(dout0_69) AT=360.025n

.meas tran vdout0_70ck710 FIND v(dout0_70) AT=360.025n

.meas tran vdout0_71ck710 FIND v(dout0_71) AT=360.025n

.meas tran vdout0_72ck710 FIND v(dout0_72) AT=360.025n

.meas tran vdout0_73ck710 FIND v(dout0_73) AT=360.025n

.meas tran vdout0_74ck710 FIND v(dout0_74) AT=360.025n

.meas tran vdout0_75ck710 FIND v(dout0_75) AT=360.025n

.meas tran vdout0_76ck710 FIND v(dout0_76) AT=360.025n

.meas tran vdout0_77ck710 FIND v(dout0_77) AT=360.025n

.meas tran vdout0_78ck710 FIND v(dout0_78) AT=360.025n

.meas tran vdout0_79ck710 FIND v(dout0_79) AT=360.025n

.meas tran vdout0_80ck710 FIND v(dout0_80) AT=360.025n

.meas tran vdout0_81ck710 FIND v(dout0_81) AT=360.025n

.meas tran vdout0_82ck710 FIND v(dout0_82) AT=360.025n

.meas tran vdout0_83ck710 FIND v(dout0_83) AT=360.025n

.meas tran vdout0_84ck710 FIND v(dout0_84) AT=360.025n

.meas tran vdout0_85ck710 FIND v(dout0_85) AT=360.025n

.meas tran vdout0_86ck710 FIND v(dout0_86) AT=360.025n

.meas tran vdout0_87ck710 FIND v(dout0_87) AT=360.025n

.meas tran vdout0_88ck710 FIND v(dout0_88) AT=360.025n

.meas tran vdout0_89ck710 FIND v(dout0_89) AT=360.025n

.meas tran vdout0_90ck710 FIND v(dout0_90) AT=360.025n

.meas tran vdout0_91ck710 FIND v(dout0_91) AT=360.025n

.meas tran vdout0_92ck710 FIND v(dout0_92) AT=360.025n

.meas tran vdout0_93ck710 FIND v(dout0_93) AT=360.025n

.meas tran vdout0_94ck710 FIND v(dout0_94) AT=360.025n

.meas tran vdout0_95ck710 FIND v(dout0_95) AT=360.025n

.meas tran vdout0_96ck710 FIND v(dout0_96) AT=360.025n

.meas tran vdout0_97ck710 FIND v(dout0_97) AT=360.025n

.meas tran vdout0_98ck710 FIND v(dout0_98) AT=360.025n

.meas tran vdout0_99ck710 FIND v(dout0_99) AT=360.025n

.meas tran vdout0_100ck710 FIND v(dout0_100) AT=360.025n

.meas tran vdout0_101ck710 FIND v(dout0_101) AT=360.025n

.meas tran vdout0_102ck710 FIND v(dout0_102) AT=360.025n

.meas tran vdout0_103ck710 FIND v(dout0_103) AT=360.025n

.meas tran vdout0_104ck710 FIND v(dout0_104) AT=360.025n

.meas tran vdout0_105ck710 FIND v(dout0_105) AT=360.025n

.meas tran vdout0_106ck710 FIND v(dout0_106) AT=360.025n

.meas tran vdout0_107ck710 FIND v(dout0_107) AT=360.025n

.meas tran vdout0_108ck710 FIND v(dout0_108) AT=360.025n

.meas tran vdout0_109ck710 FIND v(dout0_109) AT=360.025n

.meas tran vdout0_110ck710 FIND v(dout0_110) AT=360.025n

.meas tran vdout0_111ck710 FIND v(dout0_111) AT=360.025n

.meas tran vdout0_112ck710 FIND v(dout0_112) AT=360.025n

.meas tran vdout0_113ck710 FIND v(dout0_113) AT=360.025n

.meas tran vdout0_114ck710 FIND v(dout0_114) AT=360.025n

.meas tran vdout0_115ck710 FIND v(dout0_115) AT=360.025n

.meas tran vdout0_116ck710 FIND v(dout0_116) AT=360.025n

.meas tran vdout0_117ck710 FIND v(dout0_117) AT=360.025n

.meas tran vdout0_118ck710 FIND v(dout0_118) AT=360.025n

.meas tran vdout0_119ck710 FIND v(dout0_119) AT=360.025n

.meas tran vdout0_120ck710 FIND v(dout0_120) AT=360.025n

.meas tran vdout0_121ck710 FIND v(dout0_121) AT=360.025n

.meas tran vdout0_122ck710 FIND v(dout0_122) AT=360.025n

.meas tran vdout0_123ck710 FIND v(dout0_123) AT=360.025n

.meas tran vdout0_124ck710 FIND v(dout0_124) AT=360.025n

.meas tran vdout0_125ck710 FIND v(dout0_125) AT=360.025n

.meas tran vdout0_126ck710 FIND v(dout0_126) AT=360.025n

.meas tran vdout0_127ck710 FIND v(dout0_127) AT=360.025n

.meas tran vdout0_0ck750 FIND v(dout0_0) AT=380.025n

.meas tran vdout0_1ck750 FIND v(dout0_1) AT=380.025n

.meas tran vdout0_2ck750 FIND v(dout0_2) AT=380.025n

.meas tran vdout0_3ck750 FIND v(dout0_3) AT=380.025n

.meas tran vdout0_4ck750 FIND v(dout0_4) AT=380.025n

.meas tran vdout0_5ck750 FIND v(dout0_5) AT=380.025n

.meas tran vdout0_6ck750 FIND v(dout0_6) AT=380.025n

.meas tran vdout0_7ck750 FIND v(dout0_7) AT=380.025n

.meas tran vdout0_8ck750 FIND v(dout0_8) AT=380.025n

.meas tran vdout0_9ck750 FIND v(dout0_9) AT=380.025n

.meas tran vdout0_10ck750 FIND v(dout0_10) AT=380.025n

.meas tran vdout0_11ck750 FIND v(dout0_11) AT=380.025n

.meas tran vdout0_12ck750 FIND v(dout0_12) AT=380.025n

.meas tran vdout0_13ck750 FIND v(dout0_13) AT=380.025n

.meas tran vdout0_14ck750 FIND v(dout0_14) AT=380.025n

.meas tran vdout0_15ck750 FIND v(dout0_15) AT=380.025n

.meas tran vdout0_16ck750 FIND v(dout0_16) AT=380.025n

.meas tran vdout0_17ck750 FIND v(dout0_17) AT=380.025n

.meas tran vdout0_18ck750 FIND v(dout0_18) AT=380.025n

.meas tran vdout0_19ck750 FIND v(dout0_19) AT=380.025n

.meas tran vdout0_20ck750 FIND v(dout0_20) AT=380.025n

.meas tran vdout0_21ck750 FIND v(dout0_21) AT=380.025n

.meas tran vdout0_22ck750 FIND v(dout0_22) AT=380.025n

.meas tran vdout0_23ck750 FIND v(dout0_23) AT=380.025n

.meas tran vdout0_24ck750 FIND v(dout0_24) AT=380.025n

.meas tran vdout0_25ck750 FIND v(dout0_25) AT=380.025n

.meas tran vdout0_26ck750 FIND v(dout0_26) AT=380.025n

.meas tran vdout0_27ck750 FIND v(dout0_27) AT=380.025n

.meas tran vdout0_28ck750 FIND v(dout0_28) AT=380.025n

.meas tran vdout0_29ck750 FIND v(dout0_29) AT=380.025n

.meas tran vdout0_30ck750 FIND v(dout0_30) AT=380.025n

.meas tran vdout0_31ck750 FIND v(dout0_31) AT=380.025n

.meas tran vdout0_32ck750 FIND v(dout0_32) AT=380.025n

.meas tran vdout0_33ck750 FIND v(dout0_33) AT=380.025n

.meas tran vdout0_34ck750 FIND v(dout0_34) AT=380.025n

.meas tran vdout0_35ck750 FIND v(dout0_35) AT=380.025n

.meas tran vdout0_36ck750 FIND v(dout0_36) AT=380.025n

.meas tran vdout0_37ck750 FIND v(dout0_37) AT=380.025n

.meas tran vdout0_38ck750 FIND v(dout0_38) AT=380.025n

.meas tran vdout0_39ck750 FIND v(dout0_39) AT=380.025n

.meas tran vdout0_40ck750 FIND v(dout0_40) AT=380.025n

.meas tran vdout0_41ck750 FIND v(dout0_41) AT=380.025n

.meas tran vdout0_42ck750 FIND v(dout0_42) AT=380.025n

.meas tran vdout0_43ck750 FIND v(dout0_43) AT=380.025n

.meas tran vdout0_44ck750 FIND v(dout0_44) AT=380.025n

.meas tran vdout0_45ck750 FIND v(dout0_45) AT=380.025n

.meas tran vdout0_46ck750 FIND v(dout0_46) AT=380.025n

.meas tran vdout0_47ck750 FIND v(dout0_47) AT=380.025n

.meas tran vdout0_48ck750 FIND v(dout0_48) AT=380.025n

.meas tran vdout0_49ck750 FIND v(dout0_49) AT=380.025n

.meas tran vdout0_50ck750 FIND v(dout0_50) AT=380.025n

.meas tran vdout0_51ck750 FIND v(dout0_51) AT=380.025n

.meas tran vdout0_52ck750 FIND v(dout0_52) AT=380.025n

.meas tran vdout0_53ck750 FIND v(dout0_53) AT=380.025n

.meas tran vdout0_54ck750 FIND v(dout0_54) AT=380.025n

.meas tran vdout0_55ck750 FIND v(dout0_55) AT=380.025n

.meas tran vdout0_56ck750 FIND v(dout0_56) AT=380.025n

.meas tran vdout0_57ck750 FIND v(dout0_57) AT=380.025n

.meas tran vdout0_58ck750 FIND v(dout0_58) AT=380.025n

.meas tran vdout0_59ck750 FIND v(dout0_59) AT=380.025n

.meas tran vdout0_60ck750 FIND v(dout0_60) AT=380.025n

.meas tran vdout0_61ck750 FIND v(dout0_61) AT=380.025n

.meas tran vdout0_62ck750 FIND v(dout0_62) AT=380.025n

.meas tran vdout0_63ck750 FIND v(dout0_63) AT=380.025n

.meas tran vdout0_64ck750 FIND v(dout0_64) AT=380.025n

.meas tran vdout0_65ck750 FIND v(dout0_65) AT=380.025n

.meas tran vdout0_66ck750 FIND v(dout0_66) AT=380.025n

.meas tran vdout0_67ck750 FIND v(dout0_67) AT=380.025n

.meas tran vdout0_68ck750 FIND v(dout0_68) AT=380.025n

.meas tran vdout0_69ck750 FIND v(dout0_69) AT=380.025n

.meas tran vdout0_70ck750 FIND v(dout0_70) AT=380.025n

.meas tran vdout0_71ck750 FIND v(dout0_71) AT=380.025n

.meas tran vdout0_72ck750 FIND v(dout0_72) AT=380.025n

.meas tran vdout0_73ck750 FIND v(dout0_73) AT=380.025n

.meas tran vdout0_74ck750 FIND v(dout0_74) AT=380.025n

.meas tran vdout0_75ck750 FIND v(dout0_75) AT=380.025n

.meas tran vdout0_76ck750 FIND v(dout0_76) AT=380.025n

.meas tran vdout0_77ck750 FIND v(dout0_77) AT=380.025n

.meas tran vdout0_78ck750 FIND v(dout0_78) AT=380.025n

.meas tran vdout0_79ck750 FIND v(dout0_79) AT=380.025n

.meas tran vdout0_80ck750 FIND v(dout0_80) AT=380.025n

.meas tran vdout0_81ck750 FIND v(dout0_81) AT=380.025n

.meas tran vdout0_82ck750 FIND v(dout0_82) AT=380.025n

.meas tran vdout0_83ck750 FIND v(dout0_83) AT=380.025n

.meas tran vdout0_84ck750 FIND v(dout0_84) AT=380.025n

.meas tran vdout0_85ck750 FIND v(dout0_85) AT=380.025n

.meas tran vdout0_86ck750 FIND v(dout0_86) AT=380.025n

.meas tran vdout0_87ck750 FIND v(dout0_87) AT=380.025n

.meas tran vdout0_88ck750 FIND v(dout0_88) AT=380.025n

.meas tran vdout0_89ck750 FIND v(dout0_89) AT=380.025n

.meas tran vdout0_90ck750 FIND v(dout0_90) AT=380.025n

.meas tran vdout0_91ck750 FIND v(dout0_91) AT=380.025n

.meas tran vdout0_92ck750 FIND v(dout0_92) AT=380.025n

.meas tran vdout0_93ck750 FIND v(dout0_93) AT=380.025n

.meas tran vdout0_94ck750 FIND v(dout0_94) AT=380.025n

.meas tran vdout0_95ck750 FIND v(dout0_95) AT=380.025n

.meas tran vdout0_96ck750 FIND v(dout0_96) AT=380.025n

.meas tran vdout0_97ck750 FIND v(dout0_97) AT=380.025n

.meas tran vdout0_98ck750 FIND v(dout0_98) AT=380.025n

.meas tran vdout0_99ck750 FIND v(dout0_99) AT=380.025n

.meas tran vdout0_100ck750 FIND v(dout0_100) AT=380.025n

.meas tran vdout0_101ck750 FIND v(dout0_101) AT=380.025n

.meas tran vdout0_102ck750 FIND v(dout0_102) AT=380.025n

.meas tran vdout0_103ck750 FIND v(dout0_103) AT=380.025n

.meas tran vdout0_104ck750 FIND v(dout0_104) AT=380.025n

.meas tran vdout0_105ck750 FIND v(dout0_105) AT=380.025n

.meas tran vdout0_106ck750 FIND v(dout0_106) AT=380.025n

.meas tran vdout0_107ck750 FIND v(dout0_107) AT=380.025n

.meas tran vdout0_108ck750 FIND v(dout0_108) AT=380.025n

.meas tran vdout0_109ck750 FIND v(dout0_109) AT=380.025n

.meas tran vdout0_110ck750 FIND v(dout0_110) AT=380.025n

.meas tran vdout0_111ck750 FIND v(dout0_111) AT=380.025n

.meas tran vdout0_112ck750 FIND v(dout0_112) AT=380.025n

.meas tran vdout0_113ck750 FIND v(dout0_113) AT=380.025n

.meas tran vdout0_114ck750 FIND v(dout0_114) AT=380.025n

.meas tran vdout0_115ck750 FIND v(dout0_115) AT=380.025n

.meas tran vdout0_116ck750 FIND v(dout0_116) AT=380.025n

.meas tran vdout0_117ck750 FIND v(dout0_117) AT=380.025n

.meas tran vdout0_118ck750 FIND v(dout0_118) AT=380.025n

.meas tran vdout0_119ck750 FIND v(dout0_119) AT=380.025n

.meas tran vdout0_120ck750 FIND v(dout0_120) AT=380.025n

.meas tran vdout0_121ck750 FIND v(dout0_121) AT=380.025n

.meas tran vdout0_122ck750 FIND v(dout0_122) AT=380.025n

.meas tran vdout0_123ck750 FIND v(dout0_123) AT=380.025n

.meas tran vdout0_124ck750 FIND v(dout0_124) AT=380.025n

.meas tran vdout0_125ck750 FIND v(dout0_125) AT=380.025n

.meas tran vdout0_126ck750 FIND v(dout0_126) AT=380.025n

.meas tran vdout0_127ck750 FIND v(dout0_127) AT=380.025n

.meas tran vdout0_0ck800 FIND v(dout0_0) AT=405.025n

.meas tran vdout0_1ck800 FIND v(dout0_1) AT=405.025n

.meas tran vdout0_2ck800 FIND v(dout0_2) AT=405.025n

.meas tran vdout0_3ck800 FIND v(dout0_3) AT=405.025n

.meas tran vdout0_4ck800 FIND v(dout0_4) AT=405.025n

.meas tran vdout0_5ck800 FIND v(dout0_5) AT=405.025n

.meas tran vdout0_6ck800 FIND v(dout0_6) AT=405.025n

.meas tran vdout0_7ck800 FIND v(dout0_7) AT=405.025n

.meas tran vdout0_8ck800 FIND v(dout0_8) AT=405.025n

.meas tran vdout0_9ck800 FIND v(dout0_9) AT=405.025n

.meas tran vdout0_10ck800 FIND v(dout0_10) AT=405.025n

.meas tran vdout0_11ck800 FIND v(dout0_11) AT=405.025n

.meas tran vdout0_12ck800 FIND v(dout0_12) AT=405.025n

.meas tran vdout0_13ck800 FIND v(dout0_13) AT=405.025n

.meas tran vdout0_14ck800 FIND v(dout0_14) AT=405.025n

.meas tran vdout0_15ck800 FIND v(dout0_15) AT=405.025n

.meas tran vdout0_16ck800 FIND v(dout0_16) AT=405.025n

.meas tran vdout0_17ck800 FIND v(dout0_17) AT=405.025n

.meas tran vdout0_18ck800 FIND v(dout0_18) AT=405.025n

.meas tran vdout0_19ck800 FIND v(dout0_19) AT=405.025n

.meas tran vdout0_20ck800 FIND v(dout0_20) AT=405.025n

.meas tran vdout0_21ck800 FIND v(dout0_21) AT=405.025n

.meas tran vdout0_22ck800 FIND v(dout0_22) AT=405.025n

.meas tran vdout0_23ck800 FIND v(dout0_23) AT=405.025n

.meas tran vdout0_24ck800 FIND v(dout0_24) AT=405.025n

.meas tran vdout0_25ck800 FIND v(dout0_25) AT=405.025n

.meas tran vdout0_26ck800 FIND v(dout0_26) AT=405.025n

.meas tran vdout0_27ck800 FIND v(dout0_27) AT=405.025n

.meas tran vdout0_28ck800 FIND v(dout0_28) AT=405.025n

.meas tran vdout0_29ck800 FIND v(dout0_29) AT=405.025n

.meas tran vdout0_30ck800 FIND v(dout0_30) AT=405.025n

.meas tran vdout0_31ck800 FIND v(dout0_31) AT=405.025n

.meas tran vdout0_32ck800 FIND v(dout0_32) AT=405.025n

.meas tran vdout0_33ck800 FIND v(dout0_33) AT=405.025n

.meas tran vdout0_34ck800 FIND v(dout0_34) AT=405.025n

.meas tran vdout0_35ck800 FIND v(dout0_35) AT=405.025n

.meas tran vdout0_36ck800 FIND v(dout0_36) AT=405.025n

.meas tran vdout0_37ck800 FIND v(dout0_37) AT=405.025n

.meas tran vdout0_38ck800 FIND v(dout0_38) AT=405.025n

.meas tran vdout0_39ck800 FIND v(dout0_39) AT=405.025n

.meas tran vdout0_40ck800 FIND v(dout0_40) AT=405.025n

.meas tran vdout0_41ck800 FIND v(dout0_41) AT=405.025n

.meas tran vdout0_42ck800 FIND v(dout0_42) AT=405.025n

.meas tran vdout0_43ck800 FIND v(dout0_43) AT=405.025n

.meas tran vdout0_44ck800 FIND v(dout0_44) AT=405.025n

.meas tran vdout0_45ck800 FIND v(dout0_45) AT=405.025n

.meas tran vdout0_46ck800 FIND v(dout0_46) AT=405.025n

.meas tran vdout0_47ck800 FIND v(dout0_47) AT=405.025n

.meas tran vdout0_48ck800 FIND v(dout0_48) AT=405.025n

.meas tran vdout0_49ck800 FIND v(dout0_49) AT=405.025n

.meas tran vdout0_50ck800 FIND v(dout0_50) AT=405.025n

.meas tran vdout0_51ck800 FIND v(dout0_51) AT=405.025n

.meas tran vdout0_52ck800 FIND v(dout0_52) AT=405.025n

.meas tran vdout0_53ck800 FIND v(dout0_53) AT=405.025n

.meas tran vdout0_54ck800 FIND v(dout0_54) AT=405.025n

.meas tran vdout0_55ck800 FIND v(dout0_55) AT=405.025n

.meas tran vdout0_56ck800 FIND v(dout0_56) AT=405.025n

.meas tran vdout0_57ck800 FIND v(dout0_57) AT=405.025n

.meas tran vdout0_58ck800 FIND v(dout0_58) AT=405.025n

.meas tran vdout0_59ck800 FIND v(dout0_59) AT=405.025n

.meas tran vdout0_60ck800 FIND v(dout0_60) AT=405.025n

.meas tran vdout0_61ck800 FIND v(dout0_61) AT=405.025n

.meas tran vdout0_62ck800 FIND v(dout0_62) AT=405.025n

.meas tran vdout0_63ck800 FIND v(dout0_63) AT=405.025n

.meas tran vdout0_64ck800 FIND v(dout0_64) AT=405.025n

.meas tran vdout0_65ck800 FIND v(dout0_65) AT=405.025n

.meas tran vdout0_66ck800 FIND v(dout0_66) AT=405.025n

.meas tran vdout0_67ck800 FIND v(dout0_67) AT=405.025n

.meas tran vdout0_68ck800 FIND v(dout0_68) AT=405.025n

.meas tran vdout0_69ck800 FIND v(dout0_69) AT=405.025n

.meas tran vdout0_70ck800 FIND v(dout0_70) AT=405.025n

.meas tran vdout0_71ck800 FIND v(dout0_71) AT=405.025n

.meas tran vdout0_72ck800 FIND v(dout0_72) AT=405.025n

.meas tran vdout0_73ck800 FIND v(dout0_73) AT=405.025n

.meas tran vdout0_74ck800 FIND v(dout0_74) AT=405.025n

.meas tran vdout0_75ck800 FIND v(dout0_75) AT=405.025n

.meas tran vdout0_76ck800 FIND v(dout0_76) AT=405.025n

.meas tran vdout0_77ck800 FIND v(dout0_77) AT=405.025n

.meas tran vdout0_78ck800 FIND v(dout0_78) AT=405.025n

.meas tran vdout0_79ck800 FIND v(dout0_79) AT=405.025n

.meas tran vdout0_80ck800 FIND v(dout0_80) AT=405.025n

.meas tran vdout0_81ck800 FIND v(dout0_81) AT=405.025n

.meas tran vdout0_82ck800 FIND v(dout0_82) AT=405.025n

.meas tran vdout0_83ck800 FIND v(dout0_83) AT=405.025n

.meas tran vdout0_84ck800 FIND v(dout0_84) AT=405.025n

.meas tran vdout0_85ck800 FIND v(dout0_85) AT=405.025n

.meas tran vdout0_86ck800 FIND v(dout0_86) AT=405.025n

.meas tran vdout0_87ck800 FIND v(dout0_87) AT=405.025n

.meas tran vdout0_88ck800 FIND v(dout0_88) AT=405.025n

.meas tran vdout0_89ck800 FIND v(dout0_89) AT=405.025n

.meas tran vdout0_90ck800 FIND v(dout0_90) AT=405.025n

.meas tran vdout0_91ck800 FIND v(dout0_91) AT=405.025n

.meas tran vdout0_92ck800 FIND v(dout0_92) AT=405.025n

.meas tran vdout0_93ck800 FIND v(dout0_93) AT=405.025n

.meas tran vdout0_94ck800 FIND v(dout0_94) AT=405.025n

.meas tran vdout0_95ck800 FIND v(dout0_95) AT=405.025n

.meas tran vdout0_96ck800 FIND v(dout0_96) AT=405.025n

.meas tran vdout0_97ck800 FIND v(dout0_97) AT=405.025n

.meas tran vdout0_98ck800 FIND v(dout0_98) AT=405.025n

.meas tran vdout0_99ck800 FIND v(dout0_99) AT=405.025n

.meas tran vdout0_100ck800 FIND v(dout0_100) AT=405.025n

.meas tran vdout0_101ck800 FIND v(dout0_101) AT=405.025n

.meas tran vdout0_102ck800 FIND v(dout0_102) AT=405.025n

.meas tran vdout0_103ck800 FIND v(dout0_103) AT=405.025n

.meas tran vdout0_104ck800 FIND v(dout0_104) AT=405.025n

.meas tran vdout0_105ck800 FIND v(dout0_105) AT=405.025n

.meas tran vdout0_106ck800 FIND v(dout0_106) AT=405.025n

.meas tran vdout0_107ck800 FIND v(dout0_107) AT=405.025n

.meas tran vdout0_108ck800 FIND v(dout0_108) AT=405.025n

.meas tran vdout0_109ck800 FIND v(dout0_109) AT=405.025n

.meas tran vdout0_110ck800 FIND v(dout0_110) AT=405.025n

.meas tran vdout0_111ck800 FIND v(dout0_111) AT=405.025n

.meas tran vdout0_112ck800 FIND v(dout0_112) AT=405.025n

.meas tran vdout0_113ck800 FIND v(dout0_113) AT=405.025n

.meas tran vdout0_114ck800 FIND v(dout0_114) AT=405.025n

.meas tran vdout0_115ck800 FIND v(dout0_115) AT=405.025n

.meas tran vdout0_116ck800 FIND v(dout0_116) AT=405.025n

.meas tran vdout0_117ck800 FIND v(dout0_117) AT=405.025n

.meas tran vdout0_118ck800 FIND v(dout0_118) AT=405.025n

.meas tran vdout0_119ck800 FIND v(dout0_119) AT=405.025n

.meas tran vdout0_120ck800 FIND v(dout0_120) AT=405.025n

.meas tran vdout0_121ck800 FIND v(dout0_121) AT=405.025n

.meas tran vdout0_122ck800 FIND v(dout0_122) AT=405.025n

.meas tran vdout0_123ck800 FIND v(dout0_123) AT=405.025n

.meas tran vdout0_124ck800 FIND v(dout0_124) AT=405.025n

.meas tran vdout0_125ck800 FIND v(dout0_125) AT=405.025n

.meas tran vdout0_126ck800 FIND v(dout0_126) AT=405.025n

.meas tran vdout0_127ck800 FIND v(dout0_127) AT=405.025n

.meas tran vdout0_0ck810 FIND v(dout0_0) AT=410.025n

.meas tran vdout0_1ck810 FIND v(dout0_1) AT=410.025n

.meas tran vdout0_2ck810 FIND v(dout0_2) AT=410.025n

.meas tran vdout0_3ck810 FIND v(dout0_3) AT=410.025n

.meas tran vdout0_4ck810 FIND v(dout0_4) AT=410.025n

.meas tran vdout0_5ck810 FIND v(dout0_5) AT=410.025n

.meas tran vdout0_6ck810 FIND v(dout0_6) AT=410.025n

.meas tran vdout0_7ck810 FIND v(dout0_7) AT=410.025n

.meas tran vdout0_8ck810 FIND v(dout0_8) AT=410.025n

.meas tran vdout0_9ck810 FIND v(dout0_9) AT=410.025n

.meas tran vdout0_10ck810 FIND v(dout0_10) AT=410.025n

.meas tran vdout0_11ck810 FIND v(dout0_11) AT=410.025n

.meas tran vdout0_12ck810 FIND v(dout0_12) AT=410.025n

.meas tran vdout0_13ck810 FIND v(dout0_13) AT=410.025n

.meas tran vdout0_14ck810 FIND v(dout0_14) AT=410.025n

.meas tran vdout0_15ck810 FIND v(dout0_15) AT=410.025n

.meas tran vdout0_16ck810 FIND v(dout0_16) AT=410.025n

.meas tran vdout0_17ck810 FIND v(dout0_17) AT=410.025n

.meas tran vdout0_18ck810 FIND v(dout0_18) AT=410.025n

.meas tran vdout0_19ck810 FIND v(dout0_19) AT=410.025n

.meas tran vdout0_20ck810 FIND v(dout0_20) AT=410.025n

.meas tran vdout0_21ck810 FIND v(dout0_21) AT=410.025n

.meas tran vdout0_22ck810 FIND v(dout0_22) AT=410.025n

.meas tran vdout0_23ck810 FIND v(dout0_23) AT=410.025n

.meas tran vdout0_24ck810 FIND v(dout0_24) AT=410.025n

.meas tran vdout0_25ck810 FIND v(dout0_25) AT=410.025n

.meas tran vdout0_26ck810 FIND v(dout0_26) AT=410.025n

.meas tran vdout0_27ck810 FIND v(dout0_27) AT=410.025n

.meas tran vdout0_28ck810 FIND v(dout0_28) AT=410.025n

.meas tran vdout0_29ck810 FIND v(dout0_29) AT=410.025n

.meas tran vdout0_30ck810 FIND v(dout0_30) AT=410.025n

.meas tran vdout0_31ck810 FIND v(dout0_31) AT=410.025n

.meas tran vdout0_32ck810 FIND v(dout0_32) AT=410.025n

.meas tran vdout0_33ck810 FIND v(dout0_33) AT=410.025n

.meas tran vdout0_34ck810 FIND v(dout0_34) AT=410.025n

.meas tran vdout0_35ck810 FIND v(dout0_35) AT=410.025n

.meas tran vdout0_36ck810 FIND v(dout0_36) AT=410.025n

.meas tran vdout0_37ck810 FIND v(dout0_37) AT=410.025n

.meas tran vdout0_38ck810 FIND v(dout0_38) AT=410.025n

.meas tran vdout0_39ck810 FIND v(dout0_39) AT=410.025n

.meas tran vdout0_40ck810 FIND v(dout0_40) AT=410.025n

.meas tran vdout0_41ck810 FIND v(dout0_41) AT=410.025n

.meas tran vdout0_42ck810 FIND v(dout0_42) AT=410.025n

.meas tran vdout0_43ck810 FIND v(dout0_43) AT=410.025n

.meas tran vdout0_44ck810 FIND v(dout0_44) AT=410.025n

.meas tran vdout0_45ck810 FIND v(dout0_45) AT=410.025n

.meas tran vdout0_46ck810 FIND v(dout0_46) AT=410.025n

.meas tran vdout0_47ck810 FIND v(dout0_47) AT=410.025n

.meas tran vdout0_48ck810 FIND v(dout0_48) AT=410.025n

.meas tran vdout0_49ck810 FIND v(dout0_49) AT=410.025n

.meas tran vdout0_50ck810 FIND v(dout0_50) AT=410.025n

.meas tran vdout0_51ck810 FIND v(dout0_51) AT=410.025n

.meas tran vdout0_52ck810 FIND v(dout0_52) AT=410.025n

.meas tran vdout0_53ck810 FIND v(dout0_53) AT=410.025n

.meas tran vdout0_54ck810 FIND v(dout0_54) AT=410.025n

.meas tran vdout0_55ck810 FIND v(dout0_55) AT=410.025n

.meas tran vdout0_56ck810 FIND v(dout0_56) AT=410.025n

.meas tran vdout0_57ck810 FIND v(dout0_57) AT=410.025n

.meas tran vdout0_58ck810 FIND v(dout0_58) AT=410.025n

.meas tran vdout0_59ck810 FIND v(dout0_59) AT=410.025n

.meas tran vdout0_60ck810 FIND v(dout0_60) AT=410.025n

.meas tran vdout0_61ck810 FIND v(dout0_61) AT=410.025n

.meas tran vdout0_62ck810 FIND v(dout0_62) AT=410.025n

.meas tran vdout0_63ck810 FIND v(dout0_63) AT=410.025n

.meas tran vdout0_64ck810 FIND v(dout0_64) AT=410.025n

.meas tran vdout0_65ck810 FIND v(dout0_65) AT=410.025n

.meas tran vdout0_66ck810 FIND v(dout0_66) AT=410.025n

.meas tran vdout0_67ck810 FIND v(dout0_67) AT=410.025n

.meas tran vdout0_68ck810 FIND v(dout0_68) AT=410.025n

.meas tran vdout0_69ck810 FIND v(dout0_69) AT=410.025n

.meas tran vdout0_70ck810 FIND v(dout0_70) AT=410.025n

.meas tran vdout0_71ck810 FIND v(dout0_71) AT=410.025n

.meas tran vdout0_72ck810 FIND v(dout0_72) AT=410.025n

.meas tran vdout0_73ck810 FIND v(dout0_73) AT=410.025n

.meas tran vdout0_74ck810 FIND v(dout0_74) AT=410.025n

.meas tran vdout0_75ck810 FIND v(dout0_75) AT=410.025n

.meas tran vdout0_76ck810 FIND v(dout0_76) AT=410.025n

.meas tran vdout0_77ck810 FIND v(dout0_77) AT=410.025n

.meas tran vdout0_78ck810 FIND v(dout0_78) AT=410.025n

.meas tran vdout0_79ck810 FIND v(dout0_79) AT=410.025n

.meas tran vdout0_80ck810 FIND v(dout0_80) AT=410.025n

.meas tran vdout0_81ck810 FIND v(dout0_81) AT=410.025n

.meas tran vdout0_82ck810 FIND v(dout0_82) AT=410.025n

.meas tran vdout0_83ck810 FIND v(dout0_83) AT=410.025n

.meas tran vdout0_84ck810 FIND v(dout0_84) AT=410.025n

.meas tran vdout0_85ck810 FIND v(dout0_85) AT=410.025n

.meas tran vdout0_86ck810 FIND v(dout0_86) AT=410.025n

.meas tran vdout0_87ck810 FIND v(dout0_87) AT=410.025n

.meas tran vdout0_88ck810 FIND v(dout0_88) AT=410.025n

.meas tran vdout0_89ck810 FIND v(dout0_89) AT=410.025n

.meas tran vdout0_90ck810 FIND v(dout0_90) AT=410.025n

.meas tran vdout0_91ck810 FIND v(dout0_91) AT=410.025n

.meas tran vdout0_92ck810 FIND v(dout0_92) AT=410.025n

.meas tran vdout0_93ck810 FIND v(dout0_93) AT=410.025n

.meas tran vdout0_94ck810 FIND v(dout0_94) AT=410.025n

.meas tran vdout0_95ck810 FIND v(dout0_95) AT=410.025n

.meas tran vdout0_96ck810 FIND v(dout0_96) AT=410.025n

.meas tran vdout0_97ck810 FIND v(dout0_97) AT=410.025n

.meas tran vdout0_98ck810 FIND v(dout0_98) AT=410.025n

.meas tran vdout0_99ck810 FIND v(dout0_99) AT=410.025n

.meas tran vdout0_100ck810 FIND v(dout0_100) AT=410.025n

.meas tran vdout0_101ck810 FIND v(dout0_101) AT=410.025n

.meas tran vdout0_102ck810 FIND v(dout0_102) AT=410.025n

.meas tran vdout0_103ck810 FIND v(dout0_103) AT=410.025n

.meas tran vdout0_104ck810 FIND v(dout0_104) AT=410.025n

.meas tran vdout0_105ck810 FIND v(dout0_105) AT=410.025n

.meas tran vdout0_106ck810 FIND v(dout0_106) AT=410.025n

.meas tran vdout0_107ck810 FIND v(dout0_107) AT=410.025n

.meas tran vdout0_108ck810 FIND v(dout0_108) AT=410.025n

.meas tran vdout0_109ck810 FIND v(dout0_109) AT=410.025n

.meas tran vdout0_110ck810 FIND v(dout0_110) AT=410.025n

.meas tran vdout0_111ck810 FIND v(dout0_111) AT=410.025n

.meas tran vdout0_112ck810 FIND v(dout0_112) AT=410.025n

.meas tran vdout0_113ck810 FIND v(dout0_113) AT=410.025n

.meas tran vdout0_114ck810 FIND v(dout0_114) AT=410.025n

.meas tran vdout0_115ck810 FIND v(dout0_115) AT=410.025n

.meas tran vdout0_116ck810 FIND v(dout0_116) AT=410.025n

.meas tran vdout0_117ck810 FIND v(dout0_117) AT=410.025n

.meas tran vdout0_118ck810 FIND v(dout0_118) AT=410.025n

.meas tran vdout0_119ck810 FIND v(dout0_119) AT=410.025n

.meas tran vdout0_120ck810 FIND v(dout0_120) AT=410.025n

.meas tran vdout0_121ck810 FIND v(dout0_121) AT=410.025n

.meas tran vdout0_122ck810 FIND v(dout0_122) AT=410.025n

.meas tran vdout0_123ck810 FIND v(dout0_123) AT=410.025n

.meas tran vdout0_124ck810 FIND v(dout0_124) AT=410.025n

.meas tran vdout0_125ck810 FIND v(dout0_125) AT=410.025n

.meas tran vdout0_126ck810 FIND v(dout0_126) AT=410.025n

.meas tran vdout0_127ck810 FIND v(dout0_127) AT=410.025n

.meas tran vdout0_0ck820 FIND v(dout0_0) AT=415.025n

.meas tran vdout0_1ck820 FIND v(dout0_1) AT=415.025n

.meas tran vdout0_2ck820 FIND v(dout0_2) AT=415.025n

.meas tran vdout0_3ck820 FIND v(dout0_3) AT=415.025n

.meas tran vdout0_4ck820 FIND v(dout0_4) AT=415.025n

.meas tran vdout0_5ck820 FIND v(dout0_5) AT=415.025n

.meas tran vdout0_6ck820 FIND v(dout0_6) AT=415.025n

.meas tran vdout0_7ck820 FIND v(dout0_7) AT=415.025n

.meas tran vdout0_8ck820 FIND v(dout0_8) AT=415.025n

.meas tran vdout0_9ck820 FIND v(dout0_9) AT=415.025n

.meas tran vdout0_10ck820 FIND v(dout0_10) AT=415.025n

.meas tran vdout0_11ck820 FIND v(dout0_11) AT=415.025n

.meas tran vdout0_12ck820 FIND v(dout0_12) AT=415.025n

.meas tran vdout0_13ck820 FIND v(dout0_13) AT=415.025n

.meas tran vdout0_14ck820 FIND v(dout0_14) AT=415.025n

.meas tran vdout0_15ck820 FIND v(dout0_15) AT=415.025n

.meas tran vdout0_16ck820 FIND v(dout0_16) AT=415.025n

.meas tran vdout0_17ck820 FIND v(dout0_17) AT=415.025n

.meas tran vdout0_18ck820 FIND v(dout0_18) AT=415.025n

.meas tran vdout0_19ck820 FIND v(dout0_19) AT=415.025n

.meas tran vdout0_20ck820 FIND v(dout0_20) AT=415.025n

.meas tran vdout0_21ck820 FIND v(dout0_21) AT=415.025n

.meas tran vdout0_22ck820 FIND v(dout0_22) AT=415.025n

.meas tran vdout0_23ck820 FIND v(dout0_23) AT=415.025n

.meas tran vdout0_24ck820 FIND v(dout0_24) AT=415.025n

.meas tran vdout0_25ck820 FIND v(dout0_25) AT=415.025n

.meas tran vdout0_26ck820 FIND v(dout0_26) AT=415.025n

.meas tran vdout0_27ck820 FIND v(dout0_27) AT=415.025n

.meas tran vdout0_28ck820 FIND v(dout0_28) AT=415.025n

.meas tran vdout0_29ck820 FIND v(dout0_29) AT=415.025n

.meas tran vdout0_30ck820 FIND v(dout0_30) AT=415.025n

.meas tran vdout0_31ck820 FIND v(dout0_31) AT=415.025n

.meas tran vdout0_32ck820 FIND v(dout0_32) AT=415.025n

.meas tran vdout0_33ck820 FIND v(dout0_33) AT=415.025n

.meas tran vdout0_34ck820 FIND v(dout0_34) AT=415.025n

.meas tran vdout0_35ck820 FIND v(dout0_35) AT=415.025n

.meas tran vdout0_36ck820 FIND v(dout0_36) AT=415.025n

.meas tran vdout0_37ck820 FIND v(dout0_37) AT=415.025n

.meas tran vdout0_38ck820 FIND v(dout0_38) AT=415.025n

.meas tran vdout0_39ck820 FIND v(dout0_39) AT=415.025n

.meas tran vdout0_40ck820 FIND v(dout0_40) AT=415.025n

.meas tran vdout0_41ck820 FIND v(dout0_41) AT=415.025n

.meas tran vdout0_42ck820 FIND v(dout0_42) AT=415.025n

.meas tran vdout0_43ck820 FIND v(dout0_43) AT=415.025n

.meas tran vdout0_44ck820 FIND v(dout0_44) AT=415.025n

.meas tran vdout0_45ck820 FIND v(dout0_45) AT=415.025n

.meas tran vdout0_46ck820 FIND v(dout0_46) AT=415.025n

.meas tran vdout0_47ck820 FIND v(dout0_47) AT=415.025n

.meas tran vdout0_48ck820 FIND v(dout0_48) AT=415.025n

.meas tran vdout0_49ck820 FIND v(dout0_49) AT=415.025n

.meas tran vdout0_50ck820 FIND v(dout0_50) AT=415.025n

.meas tran vdout0_51ck820 FIND v(dout0_51) AT=415.025n

.meas tran vdout0_52ck820 FIND v(dout0_52) AT=415.025n

.meas tran vdout0_53ck820 FIND v(dout0_53) AT=415.025n

.meas tran vdout0_54ck820 FIND v(dout0_54) AT=415.025n

.meas tran vdout0_55ck820 FIND v(dout0_55) AT=415.025n

.meas tran vdout0_56ck820 FIND v(dout0_56) AT=415.025n

.meas tran vdout0_57ck820 FIND v(dout0_57) AT=415.025n

.meas tran vdout0_58ck820 FIND v(dout0_58) AT=415.025n

.meas tran vdout0_59ck820 FIND v(dout0_59) AT=415.025n

.meas tran vdout0_60ck820 FIND v(dout0_60) AT=415.025n

.meas tran vdout0_61ck820 FIND v(dout0_61) AT=415.025n

.meas tran vdout0_62ck820 FIND v(dout0_62) AT=415.025n

.meas tran vdout0_63ck820 FIND v(dout0_63) AT=415.025n

.meas tran vdout0_64ck820 FIND v(dout0_64) AT=415.025n

.meas tran vdout0_65ck820 FIND v(dout0_65) AT=415.025n

.meas tran vdout0_66ck820 FIND v(dout0_66) AT=415.025n

.meas tran vdout0_67ck820 FIND v(dout0_67) AT=415.025n

.meas tran vdout0_68ck820 FIND v(dout0_68) AT=415.025n

.meas tran vdout0_69ck820 FIND v(dout0_69) AT=415.025n

.meas tran vdout0_70ck820 FIND v(dout0_70) AT=415.025n

.meas tran vdout0_71ck820 FIND v(dout0_71) AT=415.025n

.meas tran vdout0_72ck820 FIND v(dout0_72) AT=415.025n

.meas tran vdout0_73ck820 FIND v(dout0_73) AT=415.025n

.meas tran vdout0_74ck820 FIND v(dout0_74) AT=415.025n

.meas tran vdout0_75ck820 FIND v(dout0_75) AT=415.025n

.meas tran vdout0_76ck820 FIND v(dout0_76) AT=415.025n

.meas tran vdout0_77ck820 FIND v(dout0_77) AT=415.025n

.meas tran vdout0_78ck820 FIND v(dout0_78) AT=415.025n

.meas tran vdout0_79ck820 FIND v(dout0_79) AT=415.025n

.meas tran vdout0_80ck820 FIND v(dout0_80) AT=415.025n

.meas tran vdout0_81ck820 FIND v(dout0_81) AT=415.025n

.meas tran vdout0_82ck820 FIND v(dout0_82) AT=415.025n

.meas tran vdout0_83ck820 FIND v(dout0_83) AT=415.025n

.meas tran vdout0_84ck820 FIND v(dout0_84) AT=415.025n

.meas tran vdout0_85ck820 FIND v(dout0_85) AT=415.025n

.meas tran vdout0_86ck820 FIND v(dout0_86) AT=415.025n

.meas tran vdout0_87ck820 FIND v(dout0_87) AT=415.025n

.meas tran vdout0_88ck820 FIND v(dout0_88) AT=415.025n

.meas tran vdout0_89ck820 FIND v(dout0_89) AT=415.025n

.meas tran vdout0_90ck820 FIND v(dout0_90) AT=415.025n

.meas tran vdout0_91ck820 FIND v(dout0_91) AT=415.025n

.meas tran vdout0_92ck820 FIND v(dout0_92) AT=415.025n

.meas tran vdout0_93ck820 FIND v(dout0_93) AT=415.025n

.meas tran vdout0_94ck820 FIND v(dout0_94) AT=415.025n

.meas tran vdout0_95ck820 FIND v(dout0_95) AT=415.025n

.meas tran vdout0_96ck820 FIND v(dout0_96) AT=415.025n

.meas tran vdout0_97ck820 FIND v(dout0_97) AT=415.025n

.meas tran vdout0_98ck820 FIND v(dout0_98) AT=415.025n

.meas tran vdout0_99ck820 FIND v(dout0_99) AT=415.025n

.meas tran vdout0_100ck820 FIND v(dout0_100) AT=415.025n

.meas tran vdout0_101ck820 FIND v(dout0_101) AT=415.025n

.meas tran vdout0_102ck820 FIND v(dout0_102) AT=415.025n

.meas tran vdout0_103ck820 FIND v(dout0_103) AT=415.025n

.meas tran vdout0_104ck820 FIND v(dout0_104) AT=415.025n

.meas tran vdout0_105ck820 FIND v(dout0_105) AT=415.025n

.meas tran vdout0_106ck820 FIND v(dout0_106) AT=415.025n

.meas tran vdout0_107ck820 FIND v(dout0_107) AT=415.025n

.meas tran vdout0_108ck820 FIND v(dout0_108) AT=415.025n

.meas tran vdout0_109ck820 FIND v(dout0_109) AT=415.025n

.meas tran vdout0_110ck820 FIND v(dout0_110) AT=415.025n

.meas tran vdout0_111ck820 FIND v(dout0_111) AT=415.025n

.meas tran vdout0_112ck820 FIND v(dout0_112) AT=415.025n

.meas tran vdout0_113ck820 FIND v(dout0_113) AT=415.025n

.meas tran vdout0_114ck820 FIND v(dout0_114) AT=415.025n

.meas tran vdout0_115ck820 FIND v(dout0_115) AT=415.025n

.meas tran vdout0_116ck820 FIND v(dout0_116) AT=415.025n

.meas tran vdout0_117ck820 FIND v(dout0_117) AT=415.025n

.meas tran vdout0_118ck820 FIND v(dout0_118) AT=415.025n

.meas tran vdout0_119ck820 FIND v(dout0_119) AT=415.025n

.meas tran vdout0_120ck820 FIND v(dout0_120) AT=415.025n

.meas tran vdout0_121ck820 FIND v(dout0_121) AT=415.025n

.meas tran vdout0_122ck820 FIND v(dout0_122) AT=415.025n

.meas tran vdout0_123ck820 FIND v(dout0_123) AT=415.025n

.meas tran vdout0_124ck820 FIND v(dout0_124) AT=415.025n

.meas tran vdout0_125ck820 FIND v(dout0_125) AT=415.025n

.meas tran vdout0_126ck820 FIND v(dout0_126) AT=415.025n

.meas tran vdout0_127ck820 FIND v(dout0_127) AT=415.025n

.meas tran vdout0_0ck850 FIND v(dout0_0) AT=430.025n

.meas tran vdout0_1ck850 FIND v(dout0_1) AT=430.025n

.meas tran vdout0_2ck850 FIND v(dout0_2) AT=430.025n

.meas tran vdout0_3ck850 FIND v(dout0_3) AT=430.025n

.meas tran vdout0_4ck850 FIND v(dout0_4) AT=430.025n

.meas tran vdout0_5ck850 FIND v(dout0_5) AT=430.025n

.meas tran vdout0_6ck850 FIND v(dout0_6) AT=430.025n

.meas tran vdout0_7ck850 FIND v(dout0_7) AT=430.025n

.meas tran vdout0_8ck850 FIND v(dout0_8) AT=430.025n

.meas tran vdout0_9ck850 FIND v(dout0_9) AT=430.025n

.meas tran vdout0_10ck850 FIND v(dout0_10) AT=430.025n

.meas tran vdout0_11ck850 FIND v(dout0_11) AT=430.025n

.meas tran vdout0_12ck850 FIND v(dout0_12) AT=430.025n

.meas tran vdout0_13ck850 FIND v(dout0_13) AT=430.025n

.meas tran vdout0_14ck850 FIND v(dout0_14) AT=430.025n

.meas tran vdout0_15ck850 FIND v(dout0_15) AT=430.025n

.meas tran vdout0_16ck850 FIND v(dout0_16) AT=430.025n

.meas tran vdout0_17ck850 FIND v(dout0_17) AT=430.025n

.meas tran vdout0_18ck850 FIND v(dout0_18) AT=430.025n

.meas tran vdout0_19ck850 FIND v(dout0_19) AT=430.025n

.meas tran vdout0_20ck850 FIND v(dout0_20) AT=430.025n

.meas tran vdout0_21ck850 FIND v(dout0_21) AT=430.025n

.meas tran vdout0_22ck850 FIND v(dout0_22) AT=430.025n

.meas tran vdout0_23ck850 FIND v(dout0_23) AT=430.025n

.meas tran vdout0_24ck850 FIND v(dout0_24) AT=430.025n

.meas tran vdout0_25ck850 FIND v(dout0_25) AT=430.025n

.meas tran vdout0_26ck850 FIND v(dout0_26) AT=430.025n

.meas tran vdout0_27ck850 FIND v(dout0_27) AT=430.025n

.meas tran vdout0_28ck850 FIND v(dout0_28) AT=430.025n

.meas tran vdout0_29ck850 FIND v(dout0_29) AT=430.025n

.meas tran vdout0_30ck850 FIND v(dout0_30) AT=430.025n

.meas tran vdout0_31ck850 FIND v(dout0_31) AT=430.025n

.meas tran vdout0_32ck850 FIND v(dout0_32) AT=430.025n

.meas tran vdout0_33ck850 FIND v(dout0_33) AT=430.025n

.meas tran vdout0_34ck850 FIND v(dout0_34) AT=430.025n

.meas tran vdout0_35ck850 FIND v(dout0_35) AT=430.025n

.meas tran vdout0_36ck850 FIND v(dout0_36) AT=430.025n

.meas tran vdout0_37ck850 FIND v(dout0_37) AT=430.025n

.meas tran vdout0_38ck850 FIND v(dout0_38) AT=430.025n

.meas tran vdout0_39ck850 FIND v(dout0_39) AT=430.025n

.meas tran vdout0_40ck850 FIND v(dout0_40) AT=430.025n

.meas tran vdout0_41ck850 FIND v(dout0_41) AT=430.025n

.meas tran vdout0_42ck850 FIND v(dout0_42) AT=430.025n

.meas tran vdout0_43ck850 FIND v(dout0_43) AT=430.025n

.meas tran vdout0_44ck850 FIND v(dout0_44) AT=430.025n

.meas tran vdout0_45ck850 FIND v(dout0_45) AT=430.025n

.meas tran vdout0_46ck850 FIND v(dout0_46) AT=430.025n

.meas tran vdout0_47ck850 FIND v(dout0_47) AT=430.025n

.meas tran vdout0_48ck850 FIND v(dout0_48) AT=430.025n

.meas tran vdout0_49ck850 FIND v(dout0_49) AT=430.025n

.meas tran vdout0_50ck850 FIND v(dout0_50) AT=430.025n

.meas tran vdout0_51ck850 FIND v(dout0_51) AT=430.025n

.meas tran vdout0_52ck850 FIND v(dout0_52) AT=430.025n

.meas tran vdout0_53ck850 FIND v(dout0_53) AT=430.025n

.meas tran vdout0_54ck850 FIND v(dout0_54) AT=430.025n

.meas tran vdout0_55ck850 FIND v(dout0_55) AT=430.025n

.meas tran vdout0_56ck850 FIND v(dout0_56) AT=430.025n

.meas tran vdout0_57ck850 FIND v(dout0_57) AT=430.025n

.meas tran vdout0_58ck850 FIND v(dout0_58) AT=430.025n

.meas tran vdout0_59ck850 FIND v(dout0_59) AT=430.025n

.meas tran vdout0_60ck850 FIND v(dout0_60) AT=430.025n

.meas tran vdout0_61ck850 FIND v(dout0_61) AT=430.025n

.meas tran vdout0_62ck850 FIND v(dout0_62) AT=430.025n

.meas tran vdout0_63ck850 FIND v(dout0_63) AT=430.025n

.meas tran vdout0_64ck850 FIND v(dout0_64) AT=430.025n

.meas tran vdout0_65ck850 FIND v(dout0_65) AT=430.025n

.meas tran vdout0_66ck850 FIND v(dout0_66) AT=430.025n

.meas tran vdout0_67ck850 FIND v(dout0_67) AT=430.025n

.meas tran vdout0_68ck850 FIND v(dout0_68) AT=430.025n

.meas tran vdout0_69ck850 FIND v(dout0_69) AT=430.025n

.meas tran vdout0_70ck850 FIND v(dout0_70) AT=430.025n

.meas tran vdout0_71ck850 FIND v(dout0_71) AT=430.025n

.meas tran vdout0_72ck850 FIND v(dout0_72) AT=430.025n

.meas tran vdout0_73ck850 FIND v(dout0_73) AT=430.025n

.meas tran vdout0_74ck850 FIND v(dout0_74) AT=430.025n

.meas tran vdout0_75ck850 FIND v(dout0_75) AT=430.025n

.meas tran vdout0_76ck850 FIND v(dout0_76) AT=430.025n

.meas tran vdout0_77ck850 FIND v(dout0_77) AT=430.025n

.meas tran vdout0_78ck850 FIND v(dout0_78) AT=430.025n

.meas tran vdout0_79ck850 FIND v(dout0_79) AT=430.025n

.meas tran vdout0_80ck850 FIND v(dout0_80) AT=430.025n

.meas tran vdout0_81ck850 FIND v(dout0_81) AT=430.025n

.meas tran vdout0_82ck850 FIND v(dout0_82) AT=430.025n

.meas tran vdout0_83ck850 FIND v(dout0_83) AT=430.025n

.meas tran vdout0_84ck850 FIND v(dout0_84) AT=430.025n

.meas tran vdout0_85ck850 FIND v(dout0_85) AT=430.025n

.meas tran vdout0_86ck850 FIND v(dout0_86) AT=430.025n

.meas tran vdout0_87ck850 FIND v(dout0_87) AT=430.025n

.meas tran vdout0_88ck850 FIND v(dout0_88) AT=430.025n

.meas tran vdout0_89ck850 FIND v(dout0_89) AT=430.025n

.meas tran vdout0_90ck850 FIND v(dout0_90) AT=430.025n

.meas tran vdout0_91ck850 FIND v(dout0_91) AT=430.025n

.meas tran vdout0_92ck850 FIND v(dout0_92) AT=430.025n

.meas tran vdout0_93ck850 FIND v(dout0_93) AT=430.025n

.meas tran vdout0_94ck850 FIND v(dout0_94) AT=430.025n

.meas tran vdout0_95ck850 FIND v(dout0_95) AT=430.025n

.meas tran vdout0_96ck850 FIND v(dout0_96) AT=430.025n

.meas tran vdout0_97ck850 FIND v(dout0_97) AT=430.025n

.meas tran vdout0_98ck850 FIND v(dout0_98) AT=430.025n

.meas tran vdout0_99ck850 FIND v(dout0_99) AT=430.025n

.meas tran vdout0_100ck850 FIND v(dout0_100) AT=430.025n

.meas tran vdout0_101ck850 FIND v(dout0_101) AT=430.025n

.meas tran vdout0_102ck850 FIND v(dout0_102) AT=430.025n

.meas tran vdout0_103ck850 FIND v(dout0_103) AT=430.025n

.meas tran vdout0_104ck850 FIND v(dout0_104) AT=430.025n

.meas tran vdout0_105ck850 FIND v(dout0_105) AT=430.025n

.meas tran vdout0_106ck850 FIND v(dout0_106) AT=430.025n

.meas tran vdout0_107ck850 FIND v(dout0_107) AT=430.025n

.meas tran vdout0_108ck850 FIND v(dout0_108) AT=430.025n

.meas tran vdout0_109ck850 FIND v(dout0_109) AT=430.025n

.meas tran vdout0_110ck850 FIND v(dout0_110) AT=430.025n

.meas tran vdout0_111ck850 FIND v(dout0_111) AT=430.025n

.meas tran vdout0_112ck850 FIND v(dout0_112) AT=430.025n

.meas tran vdout0_113ck850 FIND v(dout0_113) AT=430.025n

.meas tran vdout0_114ck850 FIND v(dout0_114) AT=430.025n

.meas tran vdout0_115ck850 FIND v(dout0_115) AT=430.025n

.meas tran vdout0_116ck850 FIND v(dout0_116) AT=430.025n

.meas tran vdout0_117ck850 FIND v(dout0_117) AT=430.025n

.meas tran vdout0_118ck850 FIND v(dout0_118) AT=430.025n

.meas tran vdout0_119ck850 FIND v(dout0_119) AT=430.025n

.meas tran vdout0_120ck850 FIND v(dout0_120) AT=430.025n

.meas tran vdout0_121ck850 FIND v(dout0_121) AT=430.025n

.meas tran vdout0_122ck850 FIND v(dout0_122) AT=430.025n

.meas tran vdout0_123ck850 FIND v(dout0_123) AT=430.025n

.meas tran vdout0_124ck850 FIND v(dout0_124) AT=430.025n

.meas tran vdout0_125ck850 FIND v(dout0_125) AT=430.025n

.meas tran vdout0_126ck850 FIND v(dout0_126) AT=430.025n

.meas tran vdout0_127ck850 FIND v(dout0_127) AT=430.025n

.meas tran vdout0_0ck870 FIND v(dout0_0) AT=440.025n

.meas tran vdout0_1ck870 FIND v(dout0_1) AT=440.025n

.meas tran vdout0_2ck870 FIND v(dout0_2) AT=440.025n

.meas tran vdout0_3ck870 FIND v(dout0_3) AT=440.025n

.meas tran vdout0_4ck870 FIND v(dout0_4) AT=440.025n

.meas tran vdout0_5ck870 FIND v(dout0_5) AT=440.025n

.meas tran vdout0_6ck870 FIND v(dout0_6) AT=440.025n

.meas tran vdout0_7ck870 FIND v(dout0_7) AT=440.025n

.meas tran vdout0_8ck870 FIND v(dout0_8) AT=440.025n

.meas tran vdout0_9ck870 FIND v(dout0_9) AT=440.025n

.meas tran vdout0_10ck870 FIND v(dout0_10) AT=440.025n

.meas tran vdout0_11ck870 FIND v(dout0_11) AT=440.025n

.meas tran vdout0_12ck870 FIND v(dout0_12) AT=440.025n

.meas tran vdout0_13ck870 FIND v(dout0_13) AT=440.025n

.meas tran vdout0_14ck870 FIND v(dout0_14) AT=440.025n

.meas tran vdout0_15ck870 FIND v(dout0_15) AT=440.025n

.meas tran vdout0_16ck870 FIND v(dout0_16) AT=440.025n

.meas tran vdout0_17ck870 FIND v(dout0_17) AT=440.025n

.meas tran vdout0_18ck870 FIND v(dout0_18) AT=440.025n

.meas tran vdout0_19ck870 FIND v(dout0_19) AT=440.025n

.meas tran vdout0_20ck870 FIND v(dout0_20) AT=440.025n

.meas tran vdout0_21ck870 FIND v(dout0_21) AT=440.025n

.meas tran vdout0_22ck870 FIND v(dout0_22) AT=440.025n

.meas tran vdout0_23ck870 FIND v(dout0_23) AT=440.025n

.meas tran vdout0_24ck870 FIND v(dout0_24) AT=440.025n

.meas tran vdout0_25ck870 FIND v(dout0_25) AT=440.025n

.meas tran vdout0_26ck870 FIND v(dout0_26) AT=440.025n

.meas tran vdout0_27ck870 FIND v(dout0_27) AT=440.025n

.meas tran vdout0_28ck870 FIND v(dout0_28) AT=440.025n

.meas tran vdout0_29ck870 FIND v(dout0_29) AT=440.025n

.meas tran vdout0_30ck870 FIND v(dout0_30) AT=440.025n

.meas tran vdout0_31ck870 FIND v(dout0_31) AT=440.025n

.meas tran vdout0_32ck870 FIND v(dout0_32) AT=440.025n

.meas tran vdout0_33ck870 FIND v(dout0_33) AT=440.025n

.meas tran vdout0_34ck870 FIND v(dout0_34) AT=440.025n

.meas tran vdout0_35ck870 FIND v(dout0_35) AT=440.025n

.meas tran vdout0_36ck870 FIND v(dout0_36) AT=440.025n

.meas tran vdout0_37ck870 FIND v(dout0_37) AT=440.025n

.meas tran vdout0_38ck870 FIND v(dout0_38) AT=440.025n

.meas tran vdout0_39ck870 FIND v(dout0_39) AT=440.025n

.meas tran vdout0_40ck870 FIND v(dout0_40) AT=440.025n

.meas tran vdout0_41ck870 FIND v(dout0_41) AT=440.025n

.meas tran vdout0_42ck870 FIND v(dout0_42) AT=440.025n

.meas tran vdout0_43ck870 FIND v(dout0_43) AT=440.025n

.meas tran vdout0_44ck870 FIND v(dout0_44) AT=440.025n

.meas tran vdout0_45ck870 FIND v(dout0_45) AT=440.025n

.meas tran vdout0_46ck870 FIND v(dout0_46) AT=440.025n

.meas tran vdout0_47ck870 FIND v(dout0_47) AT=440.025n

.meas tran vdout0_48ck870 FIND v(dout0_48) AT=440.025n

.meas tran vdout0_49ck870 FIND v(dout0_49) AT=440.025n

.meas tran vdout0_50ck870 FIND v(dout0_50) AT=440.025n

.meas tran vdout0_51ck870 FIND v(dout0_51) AT=440.025n

.meas tran vdout0_52ck870 FIND v(dout0_52) AT=440.025n

.meas tran vdout0_53ck870 FIND v(dout0_53) AT=440.025n

.meas tran vdout0_54ck870 FIND v(dout0_54) AT=440.025n

.meas tran vdout0_55ck870 FIND v(dout0_55) AT=440.025n

.meas tran vdout0_56ck870 FIND v(dout0_56) AT=440.025n

.meas tran vdout0_57ck870 FIND v(dout0_57) AT=440.025n

.meas tran vdout0_58ck870 FIND v(dout0_58) AT=440.025n

.meas tran vdout0_59ck870 FIND v(dout0_59) AT=440.025n

.meas tran vdout0_60ck870 FIND v(dout0_60) AT=440.025n

.meas tran vdout0_61ck870 FIND v(dout0_61) AT=440.025n

.meas tran vdout0_62ck870 FIND v(dout0_62) AT=440.025n

.meas tran vdout0_63ck870 FIND v(dout0_63) AT=440.025n

.meas tran vdout0_64ck870 FIND v(dout0_64) AT=440.025n

.meas tran vdout0_65ck870 FIND v(dout0_65) AT=440.025n

.meas tran vdout0_66ck870 FIND v(dout0_66) AT=440.025n

.meas tran vdout0_67ck870 FIND v(dout0_67) AT=440.025n

.meas tran vdout0_68ck870 FIND v(dout0_68) AT=440.025n

.meas tran vdout0_69ck870 FIND v(dout0_69) AT=440.025n

.meas tran vdout0_70ck870 FIND v(dout0_70) AT=440.025n

.meas tran vdout0_71ck870 FIND v(dout0_71) AT=440.025n

.meas tran vdout0_72ck870 FIND v(dout0_72) AT=440.025n

.meas tran vdout0_73ck870 FIND v(dout0_73) AT=440.025n

.meas tran vdout0_74ck870 FIND v(dout0_74) AT=440.025n

.meas tran vdout0_75ck870 FIND v(dout0_75) AT=440.025n

.meas tran vdout0_76ck870 FIND v(dout0_76) AT=440.025n

.meas tran vdout0_77ck870 FIND v(dout0_77) AT=440.025n

.meas tran vdout0_78ck870 FIND v(dout0_78) AT=440.025n

.meas tran vdout0_79ck870 FIND v(dout0_79) AT=440.025n

.meas tran vdout0_80ck870 FIND v(dout0_80) AT=440.025n

.meas tran vdout0_81ck870 FIND v(dout0_81) AT=440.025n

.meas tran vdout0_82ck870 FIND v(dout0_82) AT=440.025n

.meas tran vdout0_83ck870 FIND v(dout0_83) AT=440.025n

.meas tran vdout0_84ck870 FIND v(dout0_84) AT=440.025n

.meas tran vdout0_85ck870 FIND v(dout0_85) AT=440.025n

.meas tran vdout0_86ck870 FIND v(dout0_86) AT=440.025n

.meas tran vdout0_87ck870 FIND v(dout0_87) AT=440.025n

.meas tran vdout0_88ck870 FIND v(dout0_88) AT=440.025n

.meas tran vdout0_89ck870 FIND v(dout0_89) AT=440.025n

.meas tran vdout0_90ck870 FIND v(dout0_90) AT=440.025n

.meas tran vdout0_91ck870 FIND v(dout0_91) AT=440.025n

.meas tran vdout0_92ck870 FIND v(dout0_92) AT=440.025n

.meas tran vdout0_93ck870 FIND v(dout0_93) AT=440.025n

.meas tran vdout0_94ck870 FIND v(dout0_94) AT=440.025n

.meas tran vdout0_95ck870 FIND v(dout0_95) AT=440.025n

.meas tran vdout0_96ck870 FIND v(dout0_96) AT=440.025n

.meas tran vdout0_97ck870 FIND v(dout0_97) AT=440.025n

.meas tran vdout0_98ck870 FIND v(dout0_98) AT=440.025n

.meas tran vdout0_99ck870 FIND v(dout0_99) AT=440.025n

.meas tran vdout0_100ck870 FIND v(dout0_100) AT=440.025n

.meas tran vdout0_101ck870 FIND v(dout0_101) AT=440.025n

.meas tran vdout0_102ck870 FIND v(dout0_102) AT=440.025n

.meas tran vdout0_103ck870 FIND v(dout0_103) AT=440.025n

.meas tran vdout0_104ck870 FIND v(dout0_104) AT=440.025n

.meas tran vdout0_105ck870 FIND v(dout0_105) AT=440.025n

.meas tran vdout0_106ck870 FIND v(dout0_106) AT=440.025n

.meas tran vdout0_107ck870 FIND v(dout0_107) AT=440.025n

.meas tran vdout0_108ck870 FIND v(dout0_108) AT=440.025n

.meas tran vdout0_109ck870 FIND v(dout0_109) AT=440.025n

.meas tran vdout0_110ck870 FIND v(dout0_110) AT=440.025n

.meas tran vdout0_111ck870 FIND v(dout0_111) AT=440.025n

.meas tran vdout0_112ck870 FIND v(dout0_112) AT=440.025n

.meas tran vdout0_113ck870 FIND v(dout0_113) AT=440.025n

.meas tran vdout0_114ck870 FIND v(dout0_114) AT=440.025n

.meas tran vdout0_115ck870 FIND v(dout0_115) AT=440.025n

.meas tran vdout0_116ck870 FIND v(dout0_116) AT=440.025n

.meas tran vdout0_117ck870 FIND v(dout0_117) AT=440.025n

.meas tran vdout0_118ck870 FIND v(dout0_118) AT=440.025n

.meas tran vdout0_119ck870 FIND v(dout0_119) AT=440.025n

.meas tran vdout0_120ck870 FIND v(dout0_120) AT=440.025n

.meas tran vdout0_121ck870 FIND v(dout0_121) AT=440.025n

.meas tran vdout0_122ck870 FIND v(dout0_122) AT=440.025n

.meas tran vdout0_123ck870 FIND v(dout0_123) AT=440.025n

.meas tran vdout0_124ck870 FIND v(dout0_124) AT=440.025n

.meas tran vdout0_125ck870 FIND v(dout0_125) AT=440.025n

.meas tran vdout0_126ck870 FIND v(dout0_126) AT=440.025n

.meas tran vdout0_127ck870 FIND v(dout0_127) AT=440.025n

.meas tran vdout0_0ck900 FIND v(dout0_0) AT=455.025n

.meas tran vdout0_1ck900 FIND v(dout0_1) AT=455.025n

.meas tran vdout0_2ck900 FIND v(dout0_2) AT=455.025n

.meas tran vdout0_3ck900 FIND v(dout0_3) AT=455.025n

.meas tran vdout0_4ck900 FIND v(dout0_4) AT=455.025n

.meas tran vdout0_5ck900 FIND v(dout0_5) AT=455.025n

.meas tran vdout0_6ck900 FIND v(dout0_6) AT=455.025n

.meas tran vdout0_7ck900 FIND v(dout0_7) AT=455.025n

.meas tran vdout0_8ck900 FIND v(dout0_8) AT=455.025n

.meas tran vdout0_9ck900 FIND v(dout0_9) AT=455.025n

.meas tran vdout0_10ck900 FIND v(dout0_10) AT=455.025n

.meas tran vdout0_11ck900 FIND v(dout0_11) AT=455.025n

.meas tran vdout0_12ck900 FIND v(dout0_12) AT=455.025n

.meas tran vdout0_13ck900 FIND v(dout0_13) AT=455.025n

.meas tran vdout0_14ck900 FIND v(dout0_14) AT=455.025n

.meas tran vdout0_15ck900 FIND v(dout0_15) AT=455.025n

.meas tran vdout0_16ck900 FIND v(dout0_16) AT=455.025n

.meas tran vdout0_17ck900 FIND v(dout0_17) AT=455.025n

.meas tran vdout0_18ck900 FIND v(dout0_18) AT=455.025n

.meas tran vdout0_19ck900 FIND v(dout0_19) AT=455.025n

.meas tran vdout0_20ck900 FIND v(dout0_20) AT=455.025n

.meas tran vdout0_21ck900 FIND v(dout0_21) AT=455.025n

.meas tran vdout0_22ck900 FIND v(dout0_22) AT=455.025n

.meas tran vdout0_23ck900 FIND v(dout0_23) AT=455.025n

.meas tran vdout0_24ck900 FIND v(dout0_24) AT=455.025n

.meas tran vdout0_25ck900 FIND v(dout0_25) AT=455.025n

.meas tran vdout0_26ck900 FIND v(dout0_26) AT=455.025n

.meas tran vdout0_27ck900 FIND v(dout0_27) AT=455.025n

.meas tran vdout0_28ck900 FIND v(dout0_28) AT=455.025n

.meas tran vdout0_29ck900 FIND v(dout0_29) AT=455.025n

.meas tran vdout0_30ck900 FIND v(dout0_30) AT=455.025n

.meas tran vdout0_31ck900 FIND v(dout0_31) AT=455.025n

.meas tran vdout0_32ck900 FIND v(dout0_32) AT=455.025n

.meas tran vdout0_33ck900 FIND v(dout0_33) AT=455.025n

.meas tran vdout0_34ck900 FIND v(dout0_34) AT=455.025n

.meas tran vdout0_35ck900 FIND v(dout0_35) AT=455.025n

.meas tran vdout0_36ck900 FIND v(dout0_36) AT=455.025n

.meas tran vdout0_37ck900 FIND v(dout0_37) AT=455.025n

.meas tran vdout0_38ck900 FIND v(dout0_38) AT=455.025n

.meas tran vdout0_39ck900 FIND v(dout0_39) AT=455.025n

.meas tran vdout0_40ck900 FIND v(dout0_40) AT=455.025n

.meas tran vdout0_41ck900 FIND v(dout0_41) AT=455.025n

.meas tran vdout0_42ck900 FIND v(dout0_42) AT=455.025n

.meas tran vdout0_43ck900 FIND v(dout0_43) AT=455.025n

.meas tran vdout0_44ck900 FIND v(dout0_44) AT=455.025n

.meas tran vdout0_45ck900 FIND v(dout0_45) AT=455.025n

.meas tran vdout0_46ck900 FIND v(dout0_46) AT=455.025n

.meas tran vdout0_47ck900 FIND v(dout0_47) AT=455.025n

.meas tran vdout0_48ck900 FIND v(dout0_48) AT=455.025n

.meas tran vdout0_49ck900 FIND v(dout0_49) AT=455.025n

.meas tran vdout0_50ck900 FIND v(dout0_50) AT=455.025n

.meas tran vdout0_51ck900 FIND v(dout0_51) AT=455.025n

.meas tran vdout0_52ck900 FIND v(dout0_52) AT=455.025n

.meas tran vdout0_53ck900 FIND v(dout0_53) AT=455.025n

.meas tran vdout0_54ck900 FIND v(dout0_54) AT=455.025n

.meas tran vdout0_55ck900 FIND v(dout0_55) AT=455.025n

.meas tran vdout0_56ck900 FIND v(dout0_56) AT=455.025n

.meas tran vdout0_57ck900 FIND v(dout0_57) AT=455.025n

.meas tran vdout0_58ck900 FIND v(dout0_58) AT=455.025n

.meas tran vdout0_59ck900 FIND v(dout0_59) AT=455.025n

.meas tran vdout0_60ck900 FIND v(dout0_60) AT=455.025n

.meas tran vdout0_61ck900 FIND v(dout0_61) AT=455.025n

.meas tran vdout0_62ck900 FIND v(dout0_62) AT=455.025n

.meas tran vdout0_63ck900 FIND v(dout0_63) AT=455.025n

.meas tran vdout0_64ck900 FIND v(dout0_64) AT=455.025n

.meas tran vdout0_65ck900 FIND v(dout0_65) AT=455.025n

.meas tran vdout0_66ck900 FIND v(dout0_66) AT=455.025n

.meas tran vdout0_67ck900 FIND v(dout0_67) AT=455.025n

.meas tran vdout0_68ck900 FIND v(dout0_68) AT=455.025n

.meas tran vdout0_69ck900 FIND v(dout0_69) AT=455.025n

.meas tran vdout0_70ck900 FIND v(dout0_70) AT=455.025n

.meas tran vdout0_71ck900 FIND v(dout0_71) AT=455.025n

.meas tran vdout0_72ck900 FIND v(dout0_72) AT=455.025n

.meas tran vdout0_73ck900 FIND v(dout0_73) AT=455.025n

.meas tran vdout0_74ck900 FIND v(dout0_74) AT=455.025n

.meas tran vdout0_75ck900 FIND v(dout0_75) AT=455.025n

.meas tran vdout0_76ck900 FIND v(dout0_76) AT=455.025n

.meas tran vdout0_77ck900 FIND v(dout0_77) AT=455.025n

.meas tran vdout0_78ck900 FIND v(dout0_78) AT=455.025n

.meas tran vdout0_79ck900 FIND v(dout0_79) AT=455.025n

.meas tran vdout0_80ck900 FIND v(dout0_80) AT=455.025n

.meas tran vdout0_81ck900 FIND v(dout0_81) AT=455.025n

.meas tran vdout0_82ck900 FIND v(dout0_82) AT=455.025n

.meas tran vdout0_83ck900 FIND v(dout0_83) AT=455.025n

.meas tran vdout0_84ck900 FIND v(dout0_84) AT=455.025n

.meas tran vdout0_85ck900 FIND v(dout0_85) AT=455.025n

.meas tran vdout0_86ck900 FIND v(dout0_86) AT=455.025n

.meas tran vdout0_87ck900 FIND v(dout0_87) AT=455.025n

.meas tran vdout0_88ck900 FIND v(dout0_88) AT=455.025n

.meas tran vdout0_89ck900 FIND v(dout0_89) AT=455.025n

.meas tran vdout0_90ck900 FIND v(dout0_90) AT=455.025n

.meas tran vdout0_91ck900 FIND v(dout0_91) AT=455.025n

.meas tran vdout0_92ck900 FIND v(dout0_92) AT=455.025n

.meas tran vdout0_93ck900 FIND v(dout0_93) AT=455.025n

.meas tran vdout0_94ck900 FIND v(dout0_94) AT=455.025n

.meas tran vdout0_95ck900 FIND v(dout0_95) AT=455.025n

.meas tran vdout0_96ck900 FIND v(dout0_96) AT=455.025n

.meas tran vdout0_97ck900 FIND v(dout0_97) AT=455.025n

.meas tran vdout0_98ck900 FIND v(dout0_98) AT=455.025n

.meas tran vdout0_99ck900 FIND v(dout0_99) AT=455.025n

.meas tran vdout0_100ck900 FIND v(dout0_100) AT=455.025n

.meas tran vdout0_101ck900 FIND v(dout0_101) AT=455.025n

.meas tran vdout0_102ck900 FIND v(dout0_102) AT=455.025n

.meas tran vdout0_103ck900 FIND v(dout0_103) AT=455.025n

.meas tran vdout0_104ck900 FIND v(dout0_104) AT=455.025n

.meas tran vdout0_105ck900 FIND v(dout0_105) AT=455.025n

.meas tran vdout0_106ck900 FIND v(dout0_106) AT=455.025n

.meas tran vdout0_107ck900 FIND v(dout0_107) AT=455.025n

.meas tran vdout0_108ck900 FIND v(dout0_108) AT=455.025n

.meas tran vdout0_109ck900 FIND v(dout0_109) AT=455.025n

.meas tran vdout0_110ck900 FIND v(dout0_110) AT=455.025n

.meas tran vdout0_111ck900 FIND v(dout0_111) AT=455.025n

.meas tran vdout0_112ck900 FIND v(dout0_112) AT=455.025n

.meas tran vdout0_113ck900 FIND v(dout0_113) AT=455.025n

.meas tran vdout0_114ck900 FIND v(dout0_114) AT=455.025n

.meas tran vdout0_115ck900 FIND v(dout0_115) AT=455.025n

.meas tran vdout0_116ck900 FIND v(dout0_116) AT=455.025n

.meas tran vdout0_117ck900 FIND v(dout0_117) AT=455.025n

.meas tran vdout0_118ck900 FIND v(dout0_118) AT=455.025n

.meas tran vdout0_119ck900 FIND v(dout0_119) AT=455.025n

.meas tran vdout0_120ck900 FIND v(dout0_120) AT=455.025n

.meas tran vdout0_121ck900 FIND v(dout0_121) AT=455.025n

.meas tran vdout0_122ck900 FIND v(dout0_122) AT=455.025n

.meas tran vdout0_123ck900 FIND v(dout0_123) AT=455.025n

.meas tran vdout0_124ck900 FIND v(dout0_124) AT=455.025n

.meas tran vdout0_125ck900 FIND v(dout0_125) AT=455.025n

.meas tran vdout0_126ck900 FIND v(dout0_126) AT=455.025n

.meas tran vdout0_127ck900 FIND v(dout0_127) AT=455.025n

.meas tran vdout0_0ck920 FIND v(dout0_0) AT=465.025n

.meas tran vdout0_1ck920 FIND v(dout0_1) AT=465.025n

.meas tran vdout0_2ck920 FIND v(dout0_2) AT=465.025n

.meas tran vdout0_3ck920 FIND v(dout0_3) AT=465.025n

.meas tran vdout0_4ck920 FIND v(dout0_4) AT=465.025n

.meas tran vdout0_5ck920 FIND v(dout0_5) AT=465.025n

.meas tran vdout0_6ck920 FIND v(dout0_6) AT=465.025n

.meas tran vdout0_7ck920 FIND v(dout0_7) AT=465.025n

.meas tran vdout0_8ck920 FIND v(dout0_8) AT=465.025n

.meas tran vdout0_9ck920 FIND v(dout0_9) AT=465.025n

.meas tran vdout0_10ck920 FIND v(dout0_10) AT=465.025n

.meas tran vdout0_11ck920 FIND v(dout0_11) AT=465.025n

.meas tran vdout0_12ck920 FIND v(dout0_12) AT=465.025n

.meas tran vdout0_13ck920 FIND v(dout0_13) AT=465.025n

.meas tran vdout0_14ck920 FIND v(dout0_14) AT=465.025n

.meas tran vdout0_15ck920 FIND v(dout0_15) AT=465.025n

.meas tran vdout0_16ck920 FIND v(dout0_16) AT=465.025n

.meas tran vdout0_17ck920 FIND v(dout0_17) AT=465.025n

.meas tran vdout0_18ck920 FIND v(dout0_18) AT=465.025n

.meas tran vdout0_19ck920 FIND v(dout0_19) AT=465.025n

.meas tran vdout0_20ck920 FIND v(dout0_20) AT=465.025n

.meas tran vdout0_21ck920 FIND v(dout0_21) AT=465.025n

.meas tran vdout0_22ck920 FIND v(dout0_22) AT=465.025n

.meas tran vdout0_23ck920 FIND v(dout0_23) AT=465.025n

.meas tran vdout0_24ck920 FIND v(dout0_24) AT=465.025n

.meas tran vdout0_25ck920 FIND v(dout0_25) AT=465.025n

.meas tran vdout0_26ck920 FIND v(dout0_26) AT=465.025n

.meas tran vdout0_27ck920 FIND v(dout0_27) AT=465.025n

.meas tran vdout0_28ck920 FIND v(dout0_28) AT=465.025n

.meas tran vdout0_29ck920 FIND v(dout0_29) AT=465.025n

.meas tran vdout0_30ck920 FIND v(dout0_30) AT=465.025n

.meas tran vdout0_31ck920 FIND v(dout0_31) AT=465.025n

.meas tran vdout0_32ck920 FIND v(dout0_32) AT=465.025n

.meas tran vdout0_33ck920 FIND v(dout0_33) AT=465.025n

.meas tran vdout0_34ck920 FIND v(dout0_34) AT=465.025n

.meas tran vdout0_35ck920 FIND v(dout0_35) AT=465.025n

.meas tran vdout0_36ck920 FIND v(dout0_36) AT=465.025n

.meas tran vdout0_37ck920 FIND v(dout0_37) AT=465.025n

.meas tran vdout0_38ck920 FIND v(dout0_38) AT=465.025n

.meas tran vdout0_39ck920 FIND v(dout0_39) AT=465.025n

.meas tran vdout0_40ck920 FIND v(dout0_40) AT=465.025n

.meas tran vdout0_41ck920 FIND v(dout0_41) AT=465.025n

.meas tran vdout0_42ck920 FIND v(dout0_42) AT=465.025n

.meas tran vdout0_43ck920 FIND v(dout0_43) AT=465.025n

.meas tran vdout0_44ck920 FIND v(dout0_44) AT=465.025n

.meas tran vdout0_45ck920 FIND v(dout0_45) AT=465.025n

.meas tran vdout0_46ck920 FIND v(dout0_46) AT=465.025n

.meas tran vdout0_47ck920 FIND v(dout0_47) AT=465.025n

.meas tran vdout0_48ck920 FIND v(dout0_48) AT=465.025n

.meas tran vdout0_49ck920 FIND v(dout0_49) AT=465.025n

.meas tran vdout0_50ck920 FIND v(dout0_50) AT=465.025n

.meas tran vdout0_51ck920 FIND v(dout0_51) AT=465.025n

.meas tran vdout0_52ck920 FIND v(dout0_52) AT=465.025n

.meas tran vdout0_53ck920 FIND v(dout0_53) AT=465.025n

.meas tran vdout0_54ck920 FIND v(dout0_54) AT=465.025n

.meas tran vdout0_55ck920 FIND v(dout0_55) AT=465.025n

.meas tran vdout0_56ck920 FIND v(dout0_56) AT=465.025n

.meas tran vdout0_57ck920 FIND v(dout0_57) AT=465.025n

.meas tran vdout0_58ck920 FIND v(dout0_58) AT=465.025n

.meas tran vdout0_59ck920 FIND v(dout0_59) AT=465.025n

.meas tran vdout0_60ck920 FIND v(dout0_60) AT=465.025n

.meas tran vdout0_61ck920 FIND v(dout0_61) AT=465.025n

.meas tran vdout0_62ck920 FIND v(dout0_62) AT=465.025n

.meas tran vdout0_63ck920 FIND v(dout0_63) AT=465.025n

.meas tran vdout0_64ck920 FIND v(dout0_64) AT=465.025n

.meas tran vdout0_65ck920 FIND v(dout0_65) AT=465.025n

.meas tran vdout0_66ck920 FIND v(dout0_66) AT=465.025n

.meas tran vdout0_67ck920 FIND v(dout0_67) AT=465.025n

.meas tran vdout0_68ck920 FIND v(dout0_68) AT=465.025n

.meas tran vdout0_69ck920 FIND v(dout0_69) AT=465.025n

.meas tran vdout0_70ck920 FIND v(dout0_70) AT=465.025n

.meas tran vdout0_71ck920 FIND v(dout0_71) AT=465.025n

.meas tran vdout0_72ck920 FIND v(dout0_72) AT=465.025n

.meas tran vdout0_73ck920 FIND v(dout0_73) AT=465.025n

.meas tran vdout0_74ck920 FIND v(dout0_74) AT=465.025n

.meas tran vdout0_75ck920 FIND v(dout0_75) AT=465.025n

.meas tran vdout0_76ck920 FIND v(dout0_76) AT=465.025n

.meas tran vdout0_77ck920 FIND v(dout0_77) AT=465.025n

.meas tran vdout0_78ck920 FIND v(dout0_78) AT=465.025n

.meas tran vdout0_79ck920 FIND v(dout0_79) AT=465.025n

.meas tran vdout0_80ck920 FIND v(dout0_80) AT=465.025n

.meas tran vdout0_81ck920 FIND v(dout0_81) AT=465.025n

.meas tran vdout0_82ck920 FIND v(dout0_82) AT=465.025n

.meas tran vdout0_83ck920 FIND v(dout0_83) AT=465.025n

.meas tran vdout0_84ck920 FIND v(dout0_84) AT=465.025n

.meas tran vdout0_85ck920 FIND v(dout0_85) AT=465.025n

.meas tran vdout0_86ck920 FIND v(dout0_86) AT=465.025n

.meas tran vdout0_87ck920 FIND v(dout0_87) AT=465.025n

.meas tran vdout0_88ck920 FIND v(dout0_88) AT=465.025n

.meas tran vdout0_89ck920 FIND v(dout0_89) AT=465.025n

.meas tran vdout0_90ck920 FIND v(dout0_90) AT=465.025n

.meas tran vdout0_91ck920 FIND v(dout0_91) AT=465.025n

.meas tran vdout0_92ck920 FIND v(dout0_92) AT=465.025n

.meas tran vdout0_93ck920 FIND v(dout0_93) AT=465.025n

.meas tran vdout0_94ck920 FIND v(dout0_94) AT=465.025n

.meas tran vdout0_95ck920 FIND v(dout0_95) AT=465.025n

.meas tran vdout0_96ck920 FIND v(dout0_96) AT=465.025n

.meas tran vdout0_97ck920 FIND v(dout0_97) AT=465.025n

.meas tran vdout0_98ck920 FIND v(dout0_98) AT=465.025n

.meas tran vdout0_99ck920 FIND v(dout0_99) AT=465.025n

.meas tran vdout0_100ck920 FIND v(dout0_100) AT=465.025n

.meas tran vdout0_101ck920 FIND v(dout0_101) AT=465.025n

.meas tran vdout0_102ck920 FIND v(dout0_102) AT=465.025n

.meas tran vdout0_103ck920 FIND v(dout0_103) AT=465.025n

.meas tran vdout0_104ck920 FIND v(dout0_104) AT=465.025n

.meas tran vdout0_105ck920 FIND v(dout0_105) AT=465.025n

.meas tran vdout0_106ck920 FIND v(dout0_106) AT=465.025n

.meas tran vdout0_107ck920 FIND v(dout0_107) AT=465.025n

.meas tran vdout0_108ck920 FIND v(dout0_108) AT=465.025n

.meas tran vdout0_109ck920 FIND v(dout0_109) AT=465.025n

.meas tran vdout0_110ck920 FIND v(dout0_110) AT=465.025n

.meas tran vdout0_111ck920 FIND v(dout0_111) AT=465.025n

.meas tran vdout0_112ck920 FIND v(dout0_112) AT=465.025n

.meas tran vdout0_113ck920 FIND v(dout0_113) AT=465.025n

.meas tran vdout0_114ck920 FIND v(dout0_114) AT=465.025n

.meas tran vdout0_115ck920 FIND v(dout0_115) AT=465.025n

.meas tran vdout0_116ck920 FIND v(dout0_116) AT=465.025n

.meas tran vdout0_117ck920 FIND v(dout0_117) AT=465.025n

.meas tran vdout0_118ck920 FIND v(dout0_118) AT=465.025n

.meas tran vdout0_119ck920 FIND v(dout0_119) AT=465.025n

.meas tran vdout0_120ck920 FIND v(dout0_120) AT=465.025n

.meas tran vdout0_121ck920 FIND v(dout0_121) AT=465.025n

.meas tran vdout0_122ck920 FIND v(dout0_122) AT=465.025n

.meas tran vdout0_123ck920 FIND v(dout0_123) AT=465.025n

.meas tran vdout0_124ck920 FIND v(dout0_124) AT=465.025n

.meas tran vdout0_125ck920 FIND v(dout0_125) AT=465.025n

.meas tran vdout0_126ck920 FIND v(dout0_126) AT=465.025n

.meas tran vdout0_127ck920 FIND v(dout0_127) AT=465.025n

.meas tran vdout0_0ck940 FIND v(dout0_0) AT=475.025n

.meas tran vdout0_1ck940 FIND v(dout0_1) AT=475.025n

.meas tran vdout0_2ck940 FIND v(dout0_2) AT=475.025n

.meas tran vdout0_3ck940 FIND v(dout0_3) AT=475.025n

.meas tran vdout0_4ck940 FIND v(dout0_4) AT=475.025n

.meas tran vdout0_5ck940 FIND v(dout0_5) AT=475.025n

.meas tran vdout0_6ck940 FIND v(dout0_6) AT=475.025n

.meas tran vdout0_7ck940 FIND v(dout0_7) AT=475.025n

.meas tran vdout0_8ck940 FIND v(dout0_8) AT=475.025n

.meas tran vdout0_9ck940 FIND v(dout0_9) AT=475.025n

.meas tran vdout0_10ck940 FIND v(dout0_10) AT=475.025n

.meas tran vdout0_11ck940 FIND v(dout0_11) AT=475.025n

.meas tran vdout0_12ck940 FIND v(dout0_12) AT=475.025n

.meas tran vdout0_13ck940 FIND v(dout0_13) AT=475.025n

.meas tran vdout0_14ck940 FIND v(dout0_14) AT=475.025n

.meas tran vdout0_15ck940 FIND v(dout0_15) AT=475.025n

.meas tran vdout0_16ck940 FIND v(dout0_16) AT=475.025n

.meas tran vdout0_17ck940 FIND v(dout0_17) AT=475.025n

.meas tran vdout0_18ck940 FIND v(dout0_18) AT=475.025n

.meas tran vdout0_19ck940 FIND v(dout0_19) AT=475.025n

.meas tran vdout0_20ck940 FIND v(dout0_20) AT=475.025n

.meas tran vdout0_21ck940 FIND v(dout0_21) AT=475.025n

.meas tran vdout0_22ck940 FIND v(dout0_22) AT=475.025n

.meas tran vdout0_23ck940 FIND v(dout0_23) AT=475.025n

.meas tran vdout0_24ck940 FIND v(dout0_24) AT=475.025n

.meas tran vdout0_25ck940 FIND v(dout0_25) AT=475.025n

.meas tran vdout0_26ck940 FIND v(dout0_26) AT=475.025n

.meas tran vdout0_27ck940 FIND v(dout0_27) AT=475.025n

.meas tran vdout0_28ck940 FIND v(dout0_28) AT=475.025n

.meas tran vdout0_29ck940 FIND v(dout0_29) AT=475.025n

.meas tran vdout0_30ck940 FIND v(dout0_30) AT=475.025n

.meas tran vdout0_31ck940 FIND v(dout0_31) AT=475.025n

.meas tran vdout0_32ck940 FIND v(dout0_32) AT=475.025n

.meas tran vdout0_33ck940 FIND v(dout0_33) AT=475.025n

.meas tran vdout0_34ck940 FIND v(dout0_34) AT=475.025n

.meas tran vdout0_35ck940 FIND v(dout0_35) AT=475.025n

.meas tran vdout0_36ck940 FIND v(dout0_36) AT=475.025n

.meas tran vdout0_37ck940 FIND v(dout0_37) AT=475.025n

.meas tran vdout0_38ck940 FIND v(dout0_38) AT=475.025n

.meas tran vdout0_39ck940 FIND v(dout0_39) AT=475.025n

.meas tran vdout0_40ck940 FIND v(dout0_40) AT=475.025n

.meas tran vdout0_41ck940 FIND v(dout0_41) AT=475.025n

.meas tran vdout0_42ck940 FIND v(dout0_42) AT=475.025n

.meas tran vdout0_43ck940 FIND v(dout0_43) AT=475.025n

.meas tran vdout0_44ck940 FIND v(dout0_44) AT=475.025n

.meas tran vdout0_45ck940 FIND v(dout0_45) AT=475.025n

.meas tran vdout0_46ck940 FIND v(dout0_46) AT=475.025n

.meas tran vdout0_47ck940 FIND v(dout0_47) AT=475.025n

.meas tran vdout0_48ck940 FIND v(dout0_48) AT=475.025n

.meas tran vdout0_49ck940 FIND v(dout0_49) AT=475.025n

.meas tran vdout0_50ck940 FIND v(dout0_50) AT=475.025n

.meas tran vdout0_51ck940 FIND v(dout0_51) AT=475.025n

.meas tran vdout0_52ck940 FIND v(dout0_52) AT=475.025n

.meas tran vdout0_53ck940 FIND v(dout0_53) AT=475.025n

.meas tran vdout0_54ck940 FIND v(dout0_54) AT=475.025n

.meas tran vdout0_55ck940 FIND v(dout0_55) AT=475.025n

.meas tran vdout0_56ck940 FIND v(dout0_56) AT=475.025n

.meas tran vdout0_57ck940 FIND v(dout0_57) AT=475.025n

.meas tran vdout0_58ck940 FIND v(dout0_58) AT=475.025n

.meas tran vdout0_59ck940 FIND v(dout0_59) AT=475.025n

.meas tran vdout0_60ck940 FIND v(dout0_60) AT=475.025n

.meas tran vdout0_61ck940 FIND v(dout0_61) AT=475.025n

.meas tran vdout0_62ck940 FIND v(dout0_62) AT=475.025n

.meas tran vdout0_63ck940 FIND v(dout0_63) AT=475.025n

.meas tran vdout0_64ck940 FIND v(dout0_64) AT=475.025n

.meas tran vdout0_65ck940 FIND v(dout0_65) AT=475.025n

.meas tran vdout0_66ck940 FIND v(dout0_66) AT=475.025n

.meas tran vdout0_67ck940 FIND v(dout0_67) AT=475.025n

.meas tran vdout0_68ck940 FIND v(dout0_68) AT=475.025n

.meas tran vdout0_69ck940 FIND v(dout0_69) AT=475.025n

.meas tran vdout0_70ck940 FIND v(dout0_70) AT=475.025n

.meas tran vdout0_71ck940 FIND v(dout0_71) AT=475.025n

.meas tran vdout0_72ck940 FIND v(dout0_72) AT=475.025n

.meas tran vdout0_73ck940 FIND v(dout0_73) AT=475.025n

.meas tran vdout0_74ck940 FIND v(dout0_74) AT=475.025n

.meas tran vdout0_75ck940 FIND v(dout0_75) AT=475.025n

.meas tran vdout0_76ck940 FIND v(dout0_76) AT=475.025n

.meas tran vdout0_77ck940 FIND v(dout0_77) AT=475.025n

.meas tran vdout0_78ck940 FIND v(dout0_78) AT=475.025n

.meas tran vdout0_79ck940 FIND v(dout0_79) AT=475.025n

.meas tran vdout0_80ck940 FIND v(dout0_80) AT=475.025n

.meas tran vdout0_81ck940 FIND v(dout0_81) AT=475.025n

.meas tran vdout0_82ck940 FIND v(dout0_82) AT=475.025n

.meas tran vdout0_83ck940 FIND v(dout0_83) AT=475.025n

.meas tran vdout0_84ck940 FIND v(dout0_84) AT=475.025n

.meas tran vdout0_85ck940 FIND v(dout0_85) AT=475.025n

.meas tran vdout0_86ck940 FIND v(dout0_86) AT=475.025n

.meas tran vdout0_87ck940 FIND v(dout0_87) AT=475.025n

.meas tran vdout0_88ck940 FIND v(dout0_88) AT=475.025n

.meas tran vdout0_89ck940 FIND v(dout0_89) AT=475.025n

.meas tran vdout0_90ck940 FIND v(dout0_90) AT=475.025n

.meas tran vdout0_91ck940 FIND v(dout0_91) AT=475.025n

.meas tran vdout0_92ck940 FIND v(dout0_92) AT=475.025n

.meas tran vdout0_93ck940 FIND v(dout0_93) AT=475.025n

.meas tran vdout0_94ck940 FIND v(dout0_94) AT=475.025n

.meas tran vdout0_95ck940 FIND v(dout0_95) AT=475.025n

.meas tran vdout0_96ck940 FIND v(dout0_96) AT=475.025n

.meas tran vdout0_97ck940 FIND v(dout0_97) AT=475.025n

.meas tran vdout0_98ck940 FIND v(dout0_98) AT=475.025n

.meas tran vdout0_99ck940 FIND v(dout0_99) AT=475.025n

.meas tran vdout0_100ck940 FIND v(dout0_100) AT=475.025n

.meas tran vdout0_101ck940 FIND v(dout0_101) AT=475.025n

.meas tran vdout0_102ck940 FIND v(dout0_102) AT=475.025n

.meas tran vdout0_103ck940 FIND v(dout0_103) AT=475.025n

.meas tran vdout0_104ck940 FIND v(dout0_104) AT=475.025n

.meas tran vdout0_105ck940 FIND v(dout0_105) AT=475.025n

.meas tran vdout0_106ck940 FIND v(dout0_106) AT=475.025n

.meas tran vdout0_107ck940 FIND v(dout0_107) AT=475.025n

.meas tran vdout0_108ck940 FIND v(dout0_108) AT=475.025n

.meas tran vdout0_109ck940 FIND v(dout0_109) AT=475.025n

.meas tran vdout0_110ck940 FIND v(dout0_110) AT=475.025n

.meas tran vdout0_111ck940 FIND v(dout0_111) AT=475.025n

.meas tran vdout0_112ck940 FIND v(dout0_112) AT=475.025n

.meas tran vdout0_113ck940 FIND v(dout0_113) AT=475.025n

.meas tran vdout0_114ck940 FIND v(dout0_114) AT=475.025n

.meas tran vdout0_115ck940 FIND v(dout0_115) AT=475.025n

.meas tran vdout0_116ck940 FIND v(dout0_116) AT=475.025n

.meas tran vdout0_117ck940 FIND v(dout0_117) AT=475.025n

.meas tran vdout0_118ck940 FIND v(dout0_118) AT=475.025n

.meas tran vdout0_119ck940 FIND v(dout0_119) AT=475.025n

.meas tran vdout0_120ck940 FIND v(dout0_120) AT=475.025n

.meas tran vdout0_121ck940 FIND v(dout0_121) AT=475.025n

.meas tran vdout0_122ck940 FIND v(dout0_122) AT=475.025n

.meas tran vdout0_123ck940 FIND v(dout0_123) AT=475.025n

.meas tran vdout0_124ck940 FIND v(dout0_124) AT=475.025n

.meas tran vdout0_125ck940 FIND v(dout0_125) AT=475.025n

.meas tran vdout0_126ck940 FIND v(dout0_126) AT=475.025n

.meas tran vdout0_127ck940 FIND v(dout0_127) AT=475.025n

.meas tran vdout0_0ck960 FIND v(dout0_0) AT=485.025n

.meas tran vdout0_1ck960 FIND v(dout0_1) AT=485.025n

.meas tran vdout0_2ck960 FIND v(dout0_2) AT=485.025n

.meas tran vdout0_3ck960 FIND v(dout0_3) AT=485.025n

.meas tran vdout0_4ck960 FIND v(dout0_4) AT=485.025n

.meas tran vdout0_5ck960 FIND v(dout0_5) AT=485.025n

.meas tran vdout0_6ck960 FIND v(dout0_6) AT=485.025n

.meas tran vdout0_7ck960 FIND v(dout0_7) AT=485.025n

.meas tran vdout0_8ck960 FIND v(dout0_8) AT=485.025n

.meas tran vdout0_9ck960 FIND v(dout0_9) AT=485.025n

.meas tran vdout0_10ck960 FIND v(dout0_10) AT=485.025n

.meas tran vdout0_11ck960 FIND v(dout0_11) AT=485.025n

.meas tran vdout0_12ck960 FIND v(dout0_12) AT=485.025n

.meas tran vdout0_13ck960 FIND v(dout0_13) AT=485.025n

.meas tran vdout0_14ck960 FIND v(dout0_14) AT=485.025n

.meas tran vdout0_15ck960 FIND v(dout0_15) AT=485.025n

.meas tran vdout0_16ck960 FIND v(dout0_16) AT=485.025n

.meas tran vdout0_17ck960 FIND v(dout0_17) AT=485.025n

.meas tran vdout0_18ck960 FIND v(dout0_18) AT=485.025n

.meas tran vdout0_19ck960 FIND v(dout0_19) AT=485.025n

.meas tran vdout0_20ck960 FIND v(dout0_20) AT=485.025n

.meas tran vdout0_21ck960 FIND v(dout0_21) AT=485.025n

.meas tran vdout0_22ck960 FIND v(dout0_22) AT=485.025n

.meas tran vdout0_23ck960 FIND v(dout0_23) AT=485.025n

.meas tran vdout0_24ck960 FIND v(dout0_24) AT=485.025n

.meas tran vdout0_25ck960 FIND v(dout0_25) AT=485.025n

.meas tran vdout0_26ck960 FIND v(dout0_26) AT=485.025n

.meas tran vdout0_27ck960 FIND v(dout0_27) AT=485.025n

.meas tran vdout0_28ck960 FIND v(dout0_28) AT=485.025n

.meas tran vdout0_29ck960 FIND v(dout0_29) AT=485.025n

.meas tran vdout0_30ck960 FIND v(dout0_30) AT=485.025n

.meas tran vdout0_31ck960 FIND v(dout0_31) AT=485.025n

.meas tran vdout0_32ck960 FIND v(dout0_32) AT=485.025n

.meas tran vdout0_33ck960 FIND v(dout0_33) AT=485.025n

.meas tran vdout0_34ck960 FIND v(dout0_34) AT=485.025n

.meas tran vdout0_35ck960 FIND v(dout0_35) AT=485.025n

.meas tran vdout0_36ck960 FIND v(dout0_36) AT=485.025n

.meas tran vdout0_37ck960 FIND v(dout0_37) AT=485.025n

.meas tran vdout0_38ck960 FIND v(dout0_38) AT=485.025n

.meas tran vdout0_39ck960 FIND v(dout0_39) AT=485.025n

.meas tran vdout0_40ck960 FIND v(dout0_40) AT=485.025n

.meas tran vdout0_41ck960 FIND v(dout0_41) AT=485.025n

.meas tran vdout0_42ck960 FIND v(dout0_42) AT=485.025n

.meas tran vdout0_43ck960 FIND v(dout0_43) AT=485.025n

.meas tran vdout0_44ck960 FIND v(dout0_44) AT=485.025n

.meas tran vdout0_45ck960 FIND v(dout0_45) AT=485.025n

.meas tran vdout0_46ck960 FIND v(dout0_46) AT=485.025n

.meas tran vdout0_47ck960 FIND v(dout0_47) AT=485.025n

.meas tran vdout0_48ck960 FIND v(dout0_48) AT=485.025n

.meas tran vdout0_49ck960 FIND v(dout0_49) AT=485.025n

.meas tran vdout0_50ck960 FIND v(dout0_50) AT=485.025n

.meas tran vdout0_51ck960 FIND v(dout0_51) AT=485.025n

.meas tran vdout0_52ck960 FIND v(dout0_52) AT=485.025n

.meas tran vdout0_53ck960 FIND v(dout0_53) AT=485.025n

.meas tran vdout0_54ck960 FIND v(dout0_54) AT=485.025n

.meas tran vdout0_55ck960 FIND v(dout0_55) AT=485.025n

.meas tran vdout0_56ck960 FIND v(dout0_56) AT=485.025n

.meas tran vdout0_57ck960 FIND v(dout0_57) AT=485.025n

.meas tran vdout0_58ck960 FIND v(dout0_58) AT=485.025n

.meas tran vdout0_59ck960 FIND v(dout0_59) AT=485.025n

.meas tran vdout0_60ck960 FIND v(dout0_60) AT=485.025n

.meas tran vdout0_61ck960 FIND v(dout0_61) AT=485.025n

.meas tran vdout0_62ck960 FIND v(dout0_62) AT=485.025n

.meas tran vdout0_63ck960 FIND v(dout0_63) AT=485.025n

.meas tran vdout0_64ck960 FIND v(dout0_64) AT=485.025n

.meas tran vdout0_65ck960 FIND v(dout0_65) AT=485.025n

.meas tran vdout0_66ck960 FIND v(dout0_66) AT=485.025n

.meas tran vdout0_67ck960 FIND v(dout0_67) AT=485.025n

.meas tran vdout0_68ck960 FIND v(dout0_68) AT=485.025n

.meas tran vdout0_69ck960 FIND v(dout0_69) AT=485.025n

.meas tran vdout0_70ck960 FIND v(dout0_70) AT=485.025n

.meas tran vdout0_71ck960 FIND v(dout0_71) AT=485.025n

.meas tran vdout0_72ck960 FIND v(dout0_72) AT=485.025n

.meas tran vdout0_73ck960 FIND v(dout0_73) AT=485.025n

.meas tran vdout0_74ck960 FIND v(dout0_74) AT=485.025n

.meas tran vdout0_75ck960 FIND v(dout0_75) AT=485.025n

.meas tran vdout0_76ck960 FIND v(dout0_76) AT=485.025n

.meas tran vdout0_77ck960 FIND v(dout0_77) AT=485.025n

.meas tran vdout0_78ck960 FIND v(dout0_78) AT=485.025n

.meas tran vdout0_79ck960 FIND v(dout0_79) AT=485.025n

.meas tran vdout0_80ck960 FIND v(dout0_80) AT=485.025n

.meas tran vdout0_81ck960 FIND v(dout0_81) AT=485.025n

.meas tran vdout0_82ck960 FIND v(dout0_82) AT=485.025n

.meas tran vdout0_83ck960 FIND v(dout0_83) AT=485.025n

.meas tran vdout0_84ck960 FIND v(dout0_84) AT=485.025n

.meas tran vdout0_85ck960 FIND v(dout0_85) AT=485.025n

.meas tran vdout0_86ck960 FIND v(dout0_86) AT=485.025n

.meas tran vdout0_87ck960 FIND v(dout0_87) AT=485.025n

.meas tran vdout0_88ck960 FIND v(dout0_88) AT=485.025n

.meas tran vdout0_89ck960 FIND v(dout0_89) AT=485.025n

.meas tran vdout0_90ck960 FIND v(dout0_90) AT=485.025n

.meas tran vdout0_91ck960 FIND v(dout0_91) AT=485.025n

.meas tran vdout0_92ck960 FIND v(dout0_92) AT=485.025n

.meas tran vdout0_93ck960 FIND v(dout0_93) AT=485.025n

.meas tran vdout0_94ck960 FIND v(dout0_94) AT=485.025n

.meas tran vdout0_95ck960 FIND v(dout0_95) AT=485.025n

.meas tran vdout0_96ck960 FIND v(dout0_96) AT=485.025n

.meas tran vdout0_97ck960 FIND v(dout0_97) AT=485.025n

.meas tran vdout0_98ck960 FIND v(dout0_98) AT=485.025n

.meas tran vdout0_99ck960 FIND v(dout0_99) AT=485.025n

.meas tran vdout0_100ck960 FIND v(dout0_100) AT=485.025n

.meas tran vdout0_101ck960 FIND v(dout0_101) AT=485.025n

.meas tran vdout0_102ck960 FIND v(dout0_102) AT=485.025n

.meas tran vdout0_103ck960 FIND v(dout0_103) AT=485.025n

.meas tran vdout0_104ck960 FIND v(dout0_104) AT=485.025n

.meas tran vdout0_105ck960 FIND v(dout0_105) AT=485.025n

.meas tran vdout0_106ck960 FIND v(dout0_106) AT=485.025n

.meas tran vdout0_107ck960 FIND v(dout0_107) AT=485.025n

.meas tran vdout0_108ck960 FIND v(dout0_108) AT=485.025n

.meas tran vdout0_109ck960 FIND v(dout0_109) AT=485.025n

.meas tran vdout0_110ck960 FIND v(dout0_110) AT=485.025n

.meas tran vdout0_111ck960 FIND v(dout0_111) AT=485.025n

.meas tran vdout0_112ck960 FIND v(dout0_112) AT=485.025n

.meas tran vdout0_113ck960 FIND v(dout0_113) AT=485.025n

.meas tran vdout0_114ck960 FIND v(dout0_114) AT=485.025n

.meas tran vdout0_115ck960 FIND v(dout0_115) AT=485.025n

.meas tran vdout0_116ck960 FIND v(dout0_116) AT=485.025n

.meas tran vdout0_117ck960 FIND v(dout0_117) AT=485.025n

.meas tran vdout0_118ck960 FIND v(dout0_118) AT=485.025n

.meas tran vdout0_119ck960 FIND v(dout0_119) AT=485.025n

.meas tran vdout0_120ck960 FIND v(dout0_120) AT=485.025n

.meas tran vdout0_121ck960 FIND v(dout0_121) AT=485.025n

.meas tran vdout0_122ck960 FIND v(dout0_122) AT=485.025n

.meas tran vdout0_123ck960 FIND v(dout0_123) AT=485.025n

.meas tran vdout0_124ck960 FIND v(dout0_124) AT=485.025n

.meas tran vdout0_125ck960 FIND v(dout0_125) AT=485.025n

.meas tran vdout0_126ck960 FIND v(dout0_126) AT=485.025n

.meas tran vdout0_127ck960 FIND v(dout0_127) AT=485.025n

.meas tran vdout0_0ck970 FIND v(dout0_0) AT=490.025n

.meas tran vdout0_1ck970 FIND v(dout0_1) AT=490.025n

.meas tran vdout0_2ck970 FIND v(dout0_2) AT=490.025n

.meas tran vdout0_3ck970 FIND v(dout0_3) AT=490.025n

.meas tran vdout0_4ck970 FIND v(dout0_4) AT=490.025n

.meas tran vdout0_5ck970 FIND v(dout0_5) AT=490.025n

.meas tran vdout0_6ck970 FIND v(dout0_6) AT=490.025n

.meas tran vdout0_7ck970 FIND v(dout0_7) AT=490.025n

.meas tran vdout0_8ck970 FIND v(dout0_8) AT=490.025n

.meas tran vdout0_9ck970 FIND v(dout0_9) AT=490.025n

.meas tran vdout0_10ck970 FIND v(dout0_10) AT=490.025n

.meas tran vdout0_11ck970 FIND v(dout0_11) AT=490.025n

.meas tran vdout0_12ck970 FIND v(dout0_12) AT=490.025n

.meas tran vdout0_13ck970 FIND v(dout0_13) AT=490.025n

.meas tran vdout0_14ck970 FIND v(dout0_14) AT=490.025n

.meas tran vdout0_15ck970 FIND v(dout0_15) AT=490.025n

.meas tran vdout0_16ck970 FIND v(dout0_16) AT=490.025n

.meas tran vdout0_17ck970 FIND v(dout0_17) AT=490.025n

.meas tran vdout0_18ck970 FIND v(dout0_18) AT=490.025n

.meas tran vdout0_19ck970 FIND v(dout0_19) AT=490.025n

.meas tran vdout0_20ck970 FIND v(dout0_20) AT=490.025n

.meas tran vdout0_21ck970 FIND v(dout0_21) AT=490.025n

.meas tran vdout0_22ck970 FIND v(dout0_22) AT=490.025n

.meas tran vdout0_23ck970 FIND v(dout0_23) AT=490.025n

.meas tran vdout0_24ck970 FIND v(dout0_24) AT=490.025n

.meas tran vdout0_25ck970 FIND v(dout0_25) AT=490.025n

.meas tran vdout0_26ck970 FIND v(dout0_26) AT=490.025n

.meas tran vdout0_27ck970 FIND v(dout0_27) AT=490.025n

.meas tran vdout0_28ck970 FIND v(dout0_28) AT=490.025n

.meas tran vdout0_29ck970 FIND v(dout0_29) AT=490.025n

.meas tran vdout0_30ck970 FIND v(dout0_30) AT=490.025n

.meas tran vdout0_31ck970 FIND v(dout0_31) AT=490.025n

.meas tran vdout0_32ck970 FIND v(dout0_32) AT=490.025n

.meas tran vdout0_33ck970 FIND v(dout0_33) AT=490.025n

.meas tran vdout0_34ck970 FIND v(dout0_34) AT=490.025n

.meas tran vdout0_35ck970 FIND v(dout0_35) AT=490.025n

.meas tran vdout0_36ck970 FIND v(dout0_36) AT=490.025n

.meas tran vdout0_37ck970 FIND v(dout0_37) AT=490.025n

.meas tran vdout0_38ck970 FIND v(dout0_38) AT=490.025n

.meas tran vdout0_39ck970 FIND v(dout0_39) AT=490.025n

.meas tran vdout0_40ck970 FIND v(dout0_40) AT=490.025n

.meas tran vdout0_41ck970 FIND v(dout0_41) AT=490.025n

.meas tran vdout0_42ck970 FIND v(dout0_42) AT=490.025n

.meas tran vdout0_43ck970 FIND v(dout0_43) AT=490.025n

.meas tran vdout0_44ck970 FIND v(dout0_44) AT=490.025n

.meas tran vdout0_45ck970 FIND v(dout0_45) AT=490.025n

.meas tran vdout0_46ck970 FIND v(dout0_46) AT=490.025n

.meas tran vdout0_47ck970 FIND v(dout0_47) AT=490.025n

.meas tran vdout0_48ck970 FIND v(dout0_48) AT=490.025n

.meas tran vdout0_49ck970 FIND v(dout0_49) AT=490.025n

.meas tran vdout0_50ck970 FIND v(dout0_50) AT=490.025n

.meas tran vdout0_51ck970 FIND v(dout0_51) AT=490.025n

.meas tran vdout0_52ck970 FIND v(dout0_52) AT=490.025n

.meas tran vdout0_53ck970 FIND v(dout0_53) AT=490.025n

.meas tran vdout0_54ck970 FIND v(dout0_54) AT=490.025n

.meas tran vdout0_55ck970 FIND v(dout0_55) AT=490.025n

.meas tran vdout0_56ck970 FIND v(dout0_56) AT=490.025n

.meas tran vdout0_57ck970 FIND v(dout0_57) AT=490.025n

.meas tran vdout0_58ck970 FIND v(dout0_58) AT=490.025n

.meas tran vdout0_59ck970 FIND v(dout0_59) AT=490.025n

.meas tran vdout0_60ck970 FIND v(dout0_60) AT=490.025n

.meas tran vdout0_61ck970 FIND v(dout0_61) AT=490.025n

.meas tran vdout0_62ck970 FIND v(dout0_62) AT=490.025n

.meas tran vdout0_63ck970 FIND v(dout0_63) AT=490.025n

.meas tran vdout0_64ck970 FIND v(dout0_64) AT=490.025n

.meas tran vdout0_65ck970 FIND v(dout0_65) AT=490.025n

.meas tran vdout0_66ck970 FIND v(dout0_66) AT=490.025n

.meas tran vdout0_67ck970 FIND v(dout0_67) AT=490.025n

.meas tran vdout0_68ck970 FIND v(dout0_68) AT=490.025n

.meas tran vdout0_69ck970 FIND v(dout0_69) AT=490.025n

.meas tran vdout0_70ck970 FIND v(dout0_70) AT=490.025n

.meas tran vdout0_71ck970 FIND v(dout0_71) AT=490.025n

.meas tran vdout0_72ck970 FIND v(dout0_72) AT=490.025n

.meas tran vdout0_73ck970 FIND v(dout0_73) AT=490.025n

.meas tran vdout0_74ck970 FIND v(dout0_74) AT=490.025n

.meas tran vdout0_75ck970 FIND v(dout0_75) AT=490.025n

.meas tran vdout0_76ck970 FIND v(dout0_76) AT=490.025n

.meas tran vdout0_77ck970 FIND v(dout0_77) AT=490.025n

.meas tran vdout0_78ck970 FIND v(dout0_78) AT=490.025n

.meas tran vdout0_79ck970 FIND v(dout0_79) AT=490.025n

.meas tran vdout0_80ck970 FIND v(dout0_80) AT=490.025n

.meas tran vdout0_81ck970 FIND v(dout0_81) AT=490.025n

.meas tran vdout0_82ck970 FIND v(dout0_82) AT=490.025n

.meas tran vdout0_83ck970 FIND v(dout0_83) AT=490.025n

.meas tran vdout0_84ck970 FIND v(dout0_84) AT=490.025n

.meas tran vdout0_85ck970 FIND v(dout0_85) AT=490.025n

.meas tran vdout0_86ck970 FIND v(dout0_86) AT=490.025n

.meas tran vdout0_87ck970 FIND v(dout0_87) AT=490.025n

.meas tran vdout0_88ck970 FIND v(dout0_88) AT=490.025n

.meas tran vdout0_89ck970 FIND v(dout0_89) AT=490.025n

.meas tran vdout0_90ck970 FIND v(dout0_90) AT=490.025n

.meas tran vdout0_91ck970 FIND v(dout0_91) AT=490.025n

.meas tran vdout0_92ck970 FIND v(dout0_92) AT=490.025n

.meas tran vdout0_93ck970 FIND v(dout0_93) AT=490.025n

.meas tran vdout0_94ck970 FIND v(dout0_94) AT=490.025n

.meas tran vdout0_95ck970 FIND v(dout0_95) AT=490.025n

.meas tran vdout0_96ck970 FIND v(dout0_96) AT=490.025n

.meas tran vdout0_97ck970 FIND v(dout0_97) AT=490.025n

.meas tran vdout0_98ck970 FIND v(dout0_98) AT=490.025n

.meas tran vdout0_99ck970 FIND v(dout0_99) AT=490.025n

.meas tran vdout0_100ck970 FIND v(dout0_100) AT=490.025n

.meas tran vdout0_101ck970 FIND v(dout0_101) AT=490.025n

.meas tran vdout0_102ck970 FIND v(dout0_102) AT=490.025n

.meas tran vdout0_103ck970 FIND v(dout0_103) AT=490.025n

.meas tran vdout0_104ck970 FIND v(dout0_104) AT=490.025n

.meas tran vdout0_105ck970 FIND v(dout0_105) AT=490.025n

.meas tran vdout0_106ck970 FIND v(dout0_106) AT=490.025n

.meas tran vdout0_107ck970 FIND v(dout0_107) AT=490.025n

.meas tran vdout0_108ck970 FIND v(dout0_108) AT=490.025n

.meas tran vdout0_109ck970 FIND v(dout0_109) AT=490.025n

.meas tran vdout0_110ck970 FIND v(dout0_110) AT=490.025n

.meas tran vdout0_111ck970 FIND v(dout0_111) AT=490.025n

.meas tran vdout0_112ck970 FIND v(dout0_112) AT=490.025n

.meas tran vdout0_113ck970 FIND v(dout0_113) AT=490.025n

.meas tran vdout0_114ck970 FIND v(dout0_114) AT=490.025n

.meas tran vdout0_115ck970 FIND v(dout0_115) AT=490.025n

.meas tran vdout0_116ck970 FIND v(dout0_116) AT=490.025n

.meas tran vdout0_117ck970 FIND v(dout0_117) AT=490.025n

.meas tran vdout0_118ck970 FIND v(dout0_118) AT=490.025n

.meas tran vdout0_119ck970 FIND v(dout0_119) AT=490.025n

.meas tran vdout0_120ck970 FIND v(dout0_120) AT=490.025n

.meas tran vdout0_121ck970 FIND v(dout0_121) AT=490.025n

.meas tran vdout0_122ck970 FIND v(dout0_122) AT=490.025n

.meas tran vdout0_123ck970 FIND v(dout0_123) AT=490.025n

.meas tran vdout0_124ck970 FIND v(dout0_124) AT=490.025n

.meas tran vdout0_125ck970 FIND v(dout0_125) AT=490.025n

.meas tran vdout0_126ck970 FIND v(dout0_126) AT=490.025n

.meas tran vdout0_127ck970 FIND v(dout0_127) AT=490.025n

.meas tran vdout0_0ck990 FIND v(dout0_0) AT=500.025n

.meas tran vdout0_1ck990 FIND v(dout0_1) AT=500.025n

.meas tran vdout0_2ck990 FIND v(dout0_2) AT=500.025n

.meas tran vdout0_3ck990 FIND v(dout0_3) AT=500.025n

.meas tran vdout0_4ck990 FIND v(dout0_4) AT=500.025n

.meas tran vdout0_5ck990 FIND v(dout0_5) AT=500.025n

.meas tran vdout0_6ck990 FIND v(dout0_6) AT=500.025n

.meas tran vdout0_7ck990 FIND v(dout0_7) AT=500.025n

.meas tran vdout0_8ck990 FIND v(dout0_8) AT=500.025n

.meas tran vdout0_9ck990 FIND v(dout0_9) AT=500.025n

.meas tran vdout0_10ck990 FIND v(dout0_10) AT=500.025n

.meas tran vdout0_11ck990 FIND v(dout0_11) AT=500.025n

.meas tran vdout0_12ck990 FIND v(dout0_12) AT=500.025n

.meas tran vdout0_13ck990 FIND v(dout0_13) AT=500.025n

.meas tran vdout0_14ck990 FIND v(dout0_14) AT=500.025n

.meas tran vdout0_15ck990 FIND v(dout0_15) AT=500.025n

.meas tran vdout0_16ck990 FIND v(dout0_16) AT=500.025n

.meas tran vdout0_17ck990 FIND v(dout0_17) AT=500.025n

.meas tran vdout0_18ck990 FIND v(dout0_18) AT=500.025n

.meas tran vdout0_19ck990 FIND v(dout0_19) AT=500.025n

.meas tran vdout0_20ck990 FIND v(dout0_20) AT=500.025n

.meas tran vdout0_21ck990 FIND v(dout0_21) AT=500.025n

.meas tran vdout0_22ck990 FIND v(dout0_22) AT=500.025n

.meas tran vdout0_23ck990 FIND v(dout0_23) AT=500.025n

.meas tran vdout0_24ck990 FIND v(dout0_24) AT=500.025n

.meas tran vdout0_25ck990 FIND v(dout0_25) AT=500.025n

.meas tran vdout0_26ck990 FIND v(dout0_26) AT=500.025n

.meas tran vdout0_27ck990 FIND v(dout0_27) AT=500.025n

.meas tran vdout0_28ck990 FIND v(dout0_28) AT=500.025n

.meas tran vdout0_29ck990 FIND v(dout0_29) AT=500.025n

.meas tran vdout0_30ck990 FIND v(dout0_30) AT=500.025n

.meas tran vdout0_31ck990 FIND v(dout0_31) AT=500.025n

.meas tran vdout0_32ck990 FIND v(dout0_32) AT=500.025n

.meas tran vdout0_33ck990 FIND v(dout0_33) AT=500.025n

.meas tran vdout0_34ck990 FIND v(dout0_34) AT=500.025n

.meas tran vdout0_35ck990 FIND v(dout0_35) AT=500.025n

.meas tran vdout0_36ck990 FIND v(dout0_36) AT=500.025n

.meas tran vdout0_37ck990 FIND v(dout0_37) AT=500.025n

.meas tran vdout0_38ck990 FIND v(dout0_38) AT=500.025n

.meas tran vdout0_39ck990 FIND v(dout0_39) AT=500.025n

.meas tran vdout0_40ck990 FIND v(dout0_40) AT=500.025n

.meas tran vdout0_41ck990 FIND v(dout0_41) AT=500.025n

.meas tran vdout0_42ck990 FIND v(dout0_42) AT=500.025n

.meas tran vdout0_43ck990 FIND v(dout0_43) AT=500.025n

.meas tran vdout0_44ck990 FIND v(dout0_44) AT=500.025n

.meas tran vdout0_45ck990 FIND v(dout0_45) AT=500.025n

.meas tran vdout0_46ck990 FIND v(dout0_46) AT=500.025n

.meas tran vdout0_47ck990 FIND v(dout0_47) AT=500.025n

.meas tran vdout0_48ck990 FIND v(dout0_48) AT=500.025n

.meas tran vdout0_49ck990 FIND v(dout0_49) AT=500.025n

.meas tran vdout0_50ck990 FIND v(dout0_50) AT=500.025n

.meas tran vdout0_51ck990 FIND v(dout0_51) AT=500.025n

.meas tran vdout0_52ck990 FIND v(dout0_52) AT=500.025n

.meas tran vdout0_53ck990 FIND v(dout0_53) AT=500.025n

.meas tran vdout0_54ck990 FIND v(dout0_54) AT=500.025n

.meas tran vdout0_55ck990 FIND v(dout0_55) AT=500.025n

.meas tran vdout0_56ck990 FIND v(dout0_56) AT=500.025n

.meas tran vdout0_57ck990 FIND v(dout0_57) AT=500.025n

.meas tran vdout0_58ck990 FIND v(dout0_58) AT=500.025n

.meas tran vdout0_59ck990 FIND v(dout0_59) AT=500.025n

.meas tran vdout0_60ck990 FIND v(dout0_60) AT=500.025n

.meas tran vdout0_61ck990 FIND v(dout0_61) AT=500.025n

.meas tran vdout0_62ck990 FIND v(dout0_62) AT=500.025n

.meas tran vdout0_63ck990 FIND v(dout0_63) AT=500.025n

.meas tran vdout0_64ck990 FIND v(dout0_64) AT=500.025n

.meas tran vdout0_65ck990 FIND v(dout0_65) AT=500.025n

.meas tran vdout0_66ck990 FIND v(dout0_66) AT=500.025n

.meas tran vdout0_67ck990 FIND v(dout0_67) AT=500.025n

.meas tran vdout0_68ck990 FIND v(dout0_68) AT=500.025n

.meas tran vdout0_69ck990 FIND v(dout0_69) AT=500.025n

.meas tran vdout0_70ck990 FIND v(dout0_70) AT=500.025n

.meas tran vdout0_71ck990 FIND v(dout0_71) AT=500.025n

.meas tran vdout0_72ck990 FIND v(dout0_72) AT=500.025n

.meas tran vdout0_73ck990 FIND v(dout0_73) AT=500.025n

.meas tran vdout0_74ck990 FIND v(dout0_74) AT=500.025n

.meas tran vdout0_75ck990 FIND v(dout0_75) AT=500.025n

.meas tran vdout0_76ck990 FIND v(dout0_76) AT=500.025n

.meas tran vdout0_77ck990 FIND v(dout0_77) AT=500.025n

.meas tran vdout0_78ck990 FIND v(dout0_78) AT=500.025n

.meas tran vdout0_79ck990 FIND v(dout0_79) AT=500.025n

.meas tran vdout0_80ck990 FIND v(dout0_80) AT=500.025n

.meas tran vdout0_81ck990 FIND v(dout0_81) AT=500.025n

.meas tran vdout0_82ck990 FIND v(dout0_82) AT=500.025n

.meas tran vdout0_83ck990 FIND v(dout0_83) AT=500.025n

.meas tran vdout0_84ck990 FIND v(dout0_84) AT=500.025n

.meas tran vdout0_85ck990 FIND v(dout0_85) AT=500.025n

.meas tran vdout0_86ck990 FIND v(dout0_86) AT=500.025n

.meas tran vdout0_87ck990 FIND v(dout0_87) AT=500.025n

.meas tran vdout0_88ck990 FIND v(dout0_88) AT=500.025n

.meas tran vdout0_89ck990 FIND v(dout0_89) AT=500.025n

.meas tran vdout0_90ck990 FIND v(dout0_90) AT=500.025n

.meas tran vdout0_91ck990 FIND v(dout0_91) AT=500.025n

.meas tran vdout0_92ck990 FIND v(dout0_92) AT=500.025n

.meas tran vdout0_93ck990 FIND v(dout0_93) AT=500.025n

.meas tran vdout0_94ck990 FIND v(dout0_94) AT=500.025n

.meas tran vdout0_95ck990 FIND v(dout0_95) AT=500.025n

.meas tran vdout0_96ck990 FIND v(dout0_96) AT=500.025n

.meas tran vdout0_97ck990 FIND v(dout0_97) AT=500.025n

.meas tran vdout0_98ck990 FIND v(dout0_98) AT=500.025n

.meas tran vdout0_99ck990 FIND v(dout0_99) AT=500.025n

.meas tran vdout0_100ck990 FIND v(dout0_100) AT=500.025n

.meas tran vdout0_101ck990 FIND v(dout0_101) AT=500.025n

.meas tran vdout0_102ck990 FIND v(dout0_102) AT=500.025n

.meas tran vdout0_103ck990 FIND v(dout0_103) AT=500.025n

.meas tran vdout0_104ck990 FIND v(dout0_104) AT=500.025n

.meas tran vdout0_105ck990 FIND v(dout0_105) AT=500.025n

.meas tran vdout0_106ck990 FIND v(dout0_106) AT=500.025n

.meas tran vdout0_107ck990 FIND v(dout0_107) AT=500.025n

.meas tran vdout0_108ck990 FIND v(dout0_108) AT=500.025n

.meas tran vdout0_109ck990 FIND v(dout0_109) AT=500.025n

.meas tran vdout0_110ck990 FIND v(dout0_110) AT=500.025n

.meas tran vdout0_111ck990 FIND v(dout0_111) AT=500.025n

.meas tran vdout0_112ck990 FIND v(dout0_112) AT=500.025n

.meas tran vdout0_113ck990 FIND v(dout0_113) AT=500.025n

.meas tran vdout0_114ck990 FIND v(dout0_114) AT=500.025n

.meas tran vdout0_115ck990 FIND v(dout0_115) AT=500.025n

.meas tran vdout0_116ck990 FIND v(dout0_116) AT=500.025n

.meas tran vdout0_117ck990 FIND v(dout0_117) AT=500.025n

.meas tran vdout0_118ck990 FIND v(dout0_118) AT=500.025n

.meas tran vdout0_119ck990 FIND v(dout0_119) AT=500.025n

.meas tran vdout0_120ck990 FIND v(dout0_120) AT=500.025n

.meas tran vdout0_121ck990 FIND v(dout0_121) AT=500.025n

.meas tran vdout0_122ck990 FIND v(dout0_122) AT=500.025n

.meas tran vdout0_123ck990 FIND v(dout0_123) AT=500.025n

.meas tran vdout0_124ck990 FIND v(dout0_124) AT=500.025n

.meas tran vdout0_125ck990 FIND v(dout0_125) AT=500.025n

.meas tran vdout0_126ck990 FIND v(dout0_126) AT=500.025n

.meas tran vdout0_127ck990 FIND v(dout0_127) AT=500.025n

.meas tran vdout0_0ck1000 FIND v(dout0_0) AT=505.025n

.meas tran vdout0_1ck1000 FIND v(dout0_1) AT=505.025n

.meas tran vdout0_2ck1000 FIND v(dout0_2) AT=505.025n

.meas tran vdout0_3ck1000 FIND v(dout0_3) AT=505.025n

.meas tran vdout0_4ck1000 FIND v(dout0_4) AT=505.025n

.meas tran vdout0_5ck1000 FIND v(dout0_5) AT=505.025n

.meas tran vdout0_6ck1000 FIND v(dout0_6) AT=505.025n

.meas tran vdout0_7ck1000 FIND v(dout0_7) AT=505.025n

.meas tran vdout0_8ck1000 FIND v(dout0_8) AT=505.025n

.meas tran vdout0_9ck1000 FIND v(dout0_9) AT=505.025n

.meas tran vdout0_10ck1000 FIND v(dout0_10) AT=505.025n

.meas tran vdout0_11ck1000 FIND v(dout0_11) AT=505.025n

.meas tran vdout0_12ck1000 FIND v(dout0_12) AT=505.025n

.meas tran vdout0_13ck1000 FIND v(dout0_13) AT=505.025n

.meas tran vdout0_14ck1000 FIND v(dout0_14) AT=505.025n

.meas tran vdout0_15ck1000 FIND v(dout0_15) AT=505.025n

.meas tran vdout0_16ck1000 FIND v(dout0_16) AT=505.025n

.meas tran vdout0_17ck1000 FIND v(dout0_17) AT=505.025n

.meas tran vdout0_18ck1000 FIND v(dout0_18) AT=505.025n

.meas tran vdout0_19ck1000 FIND v(dout0_19) AT=505.025n

.meas tran vdout0_20ck1000 FIND v(dout0_20) AT=505.025n

.meas tran vdout0_21ck1000 FIND v(dout0_21) AT=505.025n

.meas tran vdout0_22ck1000 FIND v(dout0_22) AT=505.025n

.meas tran vdout0_23ck1000 FIND v(dout0_23) AT=505.025n

.meas tran vdout0_24ck1000 FIND v(dout0_24) AT=505.025n

.meas tran vdout0_25ck1000 FIND v(dout0_25) AT=505.025n

.meas tran vdout0_26ck1000 FIND v(dout0_26) AT=505.025n

.meas tran vdout0_27ck1000 FIND v(dout0_27) AT=505.025n

.meas tran vdout0_28ck1000 FIND v(dout0_28) AT=505.025n

.meas tran vdout0_29ck1000 FIND v(dout0_29) AT=505.025n

.meas tran vdout0_30ck1000 FIND v(dout0_30) AT=505.025n

.meas tran vdout0_31ck1000 FIND v(dout0_31) AT=505.025n

.meas tran vdout0_32ck1000 FIND v(dout0_32) AT=505.025n

.meas tran vdout0_33ck1000 FIND v(dout0_33) AT=505.025n

.meas tran vdout0_34ck1000 FIND v(dout0_34) AT=505.025n

.meas tran vdout0_35ck1000 FIND v(dout0_35) AT=505.025n

.meas tran vdout0_36ck1000 FIND v(dout0_36) AT=505.025n

.meas tran vdout0_37ck1000 FIND v(dout0_37) AT=505.025n

.meas tran vdout0_38ck1000 FIND v(dout0_38) AT=505.025n

.meas tran vdout0_39ck1000 FIND v(dout0_39) AT=505.025n

.meas tran vdout0_40ck1000 FIND v(dout0_40) AT=505.025n

.meas tran vdout0_41ck1000 FIND v(dout0_41) AT=505.025n

.meas tran vdout0_42ck1000 FIND v(dout0_42) AT=505.025n

.meas tran vdout0_43ck1000 FIND v(dout0_43) AT=505.025n

.meas tran vdout0_44ck1000 FIND v(dout0_44) AT=505.025n

.meas tran vdout0_45ck1000 FIND v(dout0_45) AT=505.025n

.meas tran vdout0_46ck1000 FIND v(dout0_46) AT=505.025n

.meas tran vdout0_47ck1000 FIND v(dout0_47) AT=505.025n

.meas tran vdout0_48ck1000 FIND v(dout0_48) AT=505.025n

.meas tran vdout0_49ck1000 FIND v(dout0_49) AT=505.025n

.meas tran vdout0_50ck1000 FIND v(dout0_50) AT=505.025n

.meas tran vdout0_51ck1000 FIND v(dout0_51) AT=505.025n

.meas tran vdout0_52ck1000 FIND v(dout0_52) AT=505.025n

.meas tran vdout0_53ck1000 FIND v(dout0_53) AT=505.025n

.meas tran vdout0_54ck1000 FIND v(dout0_54) AT=505.025n

.meas tran vdout0_55ck1000 FIND v(dout0_55) AT=505.025n

.meas tran vdout0_56ck1000 FIND v(dout0_56) AT=505.025n

.meas tran vdout0_57ck1000 FIND v(dout0_57) AT=505.025n

.meas tran vdout0_58ck1000 FIND v(dout0_58) AT=505.025n

.meas tran vdout0_59ck1000 FIND v(dout0_59) AT=505.025n

.meas tran vdout0_60ck1000 FIND v(dout0_60) AT=505.025n

.meas tran vdout0_61ck1000 FIND v(dout0_61) AT=505.025n

.meas tran vdout0_62ck1000 FIND v(dout0_62) AT=505.025n

.meas tran vdout0_63ck1000 FIND v(dout0_63) AT=505.025n

.meas tran vdout0_64ck1000 FIND v(dout0_64) AT=505.025n

.meas tran vdout0_65ck1000 FIND v(dout0_65) AT=505.025n

.meas tran vdout0_66ck1000 FIND v(dout0_66) AT=505.025n

.meas tran vdout0_67ck1000 FIND v(dout0_67) AT=505.025n

.meas tran vdout0_68ck1000 FIND v(dout0_68) AT=505.025n

.meas tran vdout0_69ck1000 FIND v(dout0_69) AT=505.025n

.meas tran vdout0_70ck1000 FIND v(dout0_70) AT=505.025n

.meas tran vdout0_71ck1000 FIND v(dout0_71) AT=505.025n

.meas tran vdout0_72ck1000 FIND v(dout0_72) AT=505.025n

.meas tran vdout0_73ck1000 FIND v(dout0_73) AT=505.025n

.meas tran vdout0_74ck1000 FIND v(dout0_74) AT=505.025n

.meas tran vdout0_75ck1000 FIND v(dout0_75) AT=505.025n

.meas tran vdout0_76ck1000 FIND v(dout0_76) AT=505.025n

.meas tran vdout0_77ck1000 FIND v(dout0_77) AT=505.025n

.meas tran vdout0_78ck1000 FIND v(dout0_78) AT=505.025n

.meas tran vdout0_79ck1000 FIND v(dout0_79) AT=505.025n

.meas tran vdout0_80ck1000 FIND v(dout0_80) AT=505.025n

.meas tran vdout0_81ck1000 FIND v(dout0_81) AT=505.025n

.meas tran vdout0_82ck1000 FIND v(dout0_82) AT=505.025n

.meas tran vdout0_83ck1000 FIND v(dout0_83) AT=505.025n

.meas tran vdout0_84ck1000 FIND v(dout0_84) AT=505.025n

.meas tran vdout0_85ck1000 FIND v(dout0_85) AT=505.025n

.meas tran vdout0_86ck1000 FIND v(dout0_86) AT=505.025n

.meas tran vdout0_87ck1000 FIND v(dout0_87) AT=505.025n

.meas tran vdout0_88ck1000 FIND v(dout0_88) AT=505.025n

.meas tran vdout0_89ck1000 FIND v(dout0_89) AT=505.025n

.meas tran vdout0_90ck1000 FIND v(dout0_90) AT=505.025n

.meas tran vdout0_91ck1000 FIND v(dout0_91) AT=505.025n

.meas tran vdout0_92ck1000 FIND v(dout0_92) AT=505.025n

.meas tran vdout0_93ck1000 FIND v(dout0_93) AT=505.025n

.meas tran vdout0_94ck1000 FIND v(dout0_94) AT=505.025n

.meas tran vdout0_95ck1000 FIND v(dout0_95) AT=505.025n

.meas tran vdout0_96ck1000 FIND v(dout0_96) AT=505.025n

.meas tran vdout0_97ck1000 FIND v(dout0_97) AT=505.025n

.meas tran vdout0_98ck1000 FIND v(dout0_98) AT=505.025n

.meas tran vdout0_99ck1000 FIND v(dout0_99) AT=505.025n

.meas tran vdout0_100ck1000 FIND v(dout0_100) AT=505.025n

.meas tran vdout0_101ck1000 FIND v(dout0_101) AT=505.025n

.meas tran vdout0_102ck1000 FIND v(dout0_102) AT=505.025n

.meas tran vdout0_103ck1000 FIND v(dout0_103) AT=505.025n

.meas tran vdout0_104ck1000 FIND v(dout0_104) AT=505.025n

.meas tran vdout0_105ck1000 FIND v(dout0_105) AT=505.025n

.meas tran vdout0_106ck1000 FIND v(dout0_106) AT=505.025n

.meas tran vdout0_107ck1000 FIND v(dout0_107) AT=505.025n

.meas tran vdout0_108ck1000 FIND v(dout0_108) AT=505.025n

.meas tran vdout0_109ck1000 FIND v(dout0_109) AT=505.025n

.meas tran vdout0_110ck1000 FIND v(dout0_110) AT=505.025n

.meas tran vdout0_111ck1000 FIND v(dout0_111) AT=505.025n

.meas tran vdout0_112ck1000 FIND v(dout0_112) AT=505.025n

.meas tran vdout0_113ck1000 FIND v(dout0_113) AT=505.025n

.meas tran vdout0_114ck1000 FIND v(dout0_114) AT=505.025n

.meas tran vdout0_115ck1000 FIND v(dout0_115) AT=505.025n

.meas tran vdout0_116ck1000 FIND v(dout0_116) AT=505.025n

.meas tran vdout0_117ck1000 FIND v(dout0_117) AT=505.025n

.meas tran vdout0_118ck1000 FIND v(dout0_118) AT=505.025n

.meas tran vdout0_119ck1000 FIND v(dout0_119) AT=505.025n

.meas tran vdout0_120ck1000 FIND v(dout0_120) AT=505.025n

.meas tran vdout0_121ck1000 FIND v(dout0_121) AT=505.025n

.meas tran vdout0_122ck1000 FIND v(dout0_122) AT=505.025n

.meas tran vdout0_123ck1000 FIND v(dout0_123) AT=505.025n

.meas tran vdout0_124ck1000 FIND v(dout0_124) AT=505.025n

.meas tran vdout0_125ck1000 FIND v(dout0_125) AT=505.025n

.meas tran vdout0_126ck1000 FIND v(dout0_126) AT=505.025n

.meas tran vdout0_127ck1000 FIND v(dout0_127) AT=505.025n

.meas tran vdout0_0ck1040 FIND v(dout0_0) AT=525.025n

.meas tran vdout0_1ck1040 FIND v(dout0_1) AT=525.025n

.meas tran vdout0_2ck1040 FIND v(dout0_2) AT=525.025n

.meas tran vdout0_3ck1040 FIND v(dout0_3) AT=525.025n

.meas tran vdout0_4ck1040 FIND v(dout0_4) AT=525.025n

.meas tran vdout0_5ck1040 FIND v(dout0_5) AT=525.025n

.meas tran vdout0_6ck1040 FIND v(dout0_6) AT=525.025n

.meas tran vdout0_7ck1040 FIND v(dout0_7) AT=525.025n

.meas tran vdout0_8ck1040 FIND v(dout0_8) AT=525.025n

.meas tran vdout0_9ck1040 FIND v(dout0_9) AT=525.025n

.meas tran vdout0_10ck1040 FIND v(dout0_10) AT=525.025n

.meas tran vdout0_11ck1040 FIND v(dout0_11) AT=525.025n

.meas tran vdout0_12ck1040 FIND v(dout0_12) AT=525.025n

.meas tran vdout0_13ck1040 FIND v(dout0_13) AT=525.025n

.meas tran vdout0_14ck1040 FIND v(dout0_14) AT=525.025n

.meas tran vdout0_15ck1040 FIND v(dout0_15) AT=525.025n

.meas tran vdout0_16ck1040 FIND v(dout0_16) AT=525.025n

.meas tran vdout0_17ck1040 FIND v(dout0_17) AT=525.025n

.meas tran vdout0_18ck1040 FIND v(dout0_18) AT=525.025n

.meas tran vdout0_19ck1040 FIND v(dout0_19) AT=525.025n

.meas tran vdout0_20ck1040 FIND v(dout0_20) AT=525.025n

.meas tran vdout0_21ck1040 FIND v(dout0_21) AT=525.025n

.meas tran vdout0_22ck1040 FIND v(dout0_22) AT=525.025n

.meas tran vdout0_23ck1040 FIND v(dout0_23) AT=525.025n

.meas tran vdout0_24ck1040 FIND v(dout0_24) AT=525.025n

.meas tran vdout0_25ck1040 FIND v(dout0_25) AT=525.025n

.meas tran vdout0_26ck1040 FIND v(dout0_26) AT=525.025n

.meas tran vdout0_27ck1040 FIND v(dout0_27) AT=525.025n

.meas tran vdout0_28ck1040 FIND v(dout0_28) AT=525.025n

.meas tran vdout0_29ck1040 FIND v(dout0_29) AT=525.025n

.meas tran vdout0_30ck1040 FIND v(dout0_30) AT=525.025n

.meas tran vdout0_31ck1040 FIND v(dout0_31) AT=525.025n

.meas tran vdout0_32ck1040 FIND v(dout0_32) AT=525.025n

.meas tran vdout0_33ck1040 FIND v(dout0_33) AT=525.025n

.meas tran vdout0_34ck1040 FIND v(dout0_34) AT=525.025n

.meas tran vdout0_35ck1040 FIND v(dout0_35) AT=525.025n

.meas tran vdout0_36ck1040 FIND v(dout0_36) AT=525.025n

.meas tran vdout0_37ck1040 FIND v(dout0_37) AT=525.025n

.meas tran vdout0_38ck1040 FIND v(dout0_38) AT=525.025n

.meas tran vdout0_39ck1040 FIND v(dout0_39) AT=525.025n

.meas tran vdout0_40ck1040 FIND v(dout0_40) AT=525.025n

.meas tran vdout0_41ck1040 FIND v(dout0_41) AT=525.025n

.meas tran vdout0_42ck1040 FIND v(dout0_42) AT=525.025n

.meas tran vdout0_43ck1040 FIND v(dout0_43) AT=525.025n

.meas tran vdout0_44ck1040 FIND v(dout0_44) AT=525.025n

.meas tran vdout0_45ck1040 FIND v(dout0_45) AT=525.025n

.meas tran vdout0_46ck1040 FIND v(dout0_46) AT=525.025n

.meas tran vdout0_47ck1040 FIND v(dout0_47) AT=525.025n

.meas tran vdout0_48ck1040 FIND v(dout0_48) AT=525.025n

.meas tran vdout0_49ck1040 FIND v(dout0_49) AT=525.025n

.meas tran vdout0_50ck1040 FIND v(dout0_50) AT=525.025n

.meas tran vdout0_51ck1040 FIND v(dout0_51) AT=525.025n

.meas tran vdout0_52ck1040 FIND v(dout0_52) AT=525.025n

.meas tran vdout0_53ck1040 FIND v(dout0_53) AT=525.025n

.meas tran vdout0_54ck1040 FIND v(dout0_54) AT=525.025n

.meas tran vdout0_55ck1040 FIND v(dout0_55) AT=525.025n

.meas tran vdout0_56ck1040 FIND v(dout0_56) AT=525.025n

.meas tran vdout0_57ck1040 FIND v(dout0_57) AT=525.025n

.meas tran vdout0_58ck1040 FIND v(dout0_58) AT=525.025n

.meas tran vdout0_59ck1040 FIND v(dout0_59) AT=525.025n

.meas tran vdout0_60ck1040 FIND v(dout0_60) AT=525.025n

.meas tran vdout0_61ck1040 FIND v(dout0_61) AT=525.025n

.meas tran vdout0_62ck1040 FIND v(dout0_62) AT=525.025n

.meas tran vdout0_63ck1040 FIND v(dout0_63) AT=525.025n

.meas tran vdout0_64ck1040 FIND v(dout0_64) AT=525.025n

.meas tran vdout0_65ck1040 FIND v(dout0_65) AT=525.025n

.meas tran vdout0_66ck1040 FIND v(dout0_66) AT=525.025n

.meas tran vdout0_67ck1040 FIND v(dout0_67) AT=525.025n

.meas tran vdout0_68ck1040 FIND v(dout0_68) AT=525.025n

.meas tran vdout0_69ck1040 FIND v(dout0_69) AT=525.025n

.meas tran vdout0_70ck1040 FIND v(dout0_70) AT=525.025n

.meas tran vdout0_71ck1040 FIND v(dout0_71) AT=525.025n

.meas tran vdout0_72ck1040 FIND v(dout0_72) AT=525.025n

.meas tran vdout0_73ck1040 FIND v(dout0_73) AT=525.025n

.meas tran vdout0_74ck1040 FIND v(dout0_74) AT=525.025n

.meas tran vdout0_75ck1040 FIND v(dout0_75) AT=525.025n

.meas tran vdout0_76ck1040 FIND v(dout0_76) AT=525.025n

.meas tran vdout0_77ck1040 FIND v(dout0_77) AT=525.025n

.meas tran vdout0_78ck1040 FIND v(dout0_78) AT=525.025n

.meas tran vdout0_79ck1040 FIND v(dout0_79) AT=525.025n

.meas tran vdout0_80ck1040 FIND v(dout0_80) AT=525.025n

.meas tran vdout0_81ck1040 FIND v(dout0_81) AT=525.025n

.meas tran vdout0_82ck1040 FIND v(dout0_82) AT=525.025n

.meas tran vdout0_83ck1040 FIND v(dout0_83) AT=525.025n

.meas tran vdout0_84ck1040 FIND v(dout0_84) AT=525.025n

.meas tran vdout0_85ck1040 FIND v(dout0_85) AT=525.025n

.meas tran vdout0_86ck1040 FIND v(dout0_86) AT=525.025n

.meas tran vdout0_87ck1040 FIND v(dout0_87) AT=525.025n

.meas tran vdout0_88ck1040 FIND v(dout0_88) AT=525.025n

.meas tran vdout0_89ck1040 FIND v(dout0_89) AT=525.025n

.meas tran vdout0_90ck1040 FIND v(dout0_90) AT=525.025n

.meas tran vdout0_91ck1040 FIND v(dout0_91) AT=525.025n

.meas tran vdout0_92ck1040 FIND v(dout0_92) AT=525.025n

.meas tran vdout0_93ck1040 FIND v(dout0_93) AT=525.025n

.meas tran vdout0_94ck1040 FIND v(dout0_94) AT=525.025n

.meas tran vdout0_95ck1040 FIND v(dout0_95) AT=525.025n

.meas tran vdout0_96ck1040 FIND v(dout0_96) AT=525.025n

.meas tran vdout0_97ck1040 FIND v(dout0_97) AT=525.025n

.meas tran vdout0_98ck1040 FIND v(dout0_98) AT=525.025n

.meas tran vdout0_99ck1040 FIND v(dout0_99) AT=525.025n

.meas tran vdout0_100ck1040 FIND v(dout0_100) AT=525.025n

.meas tran vdout0_101ck1040 FIND v(dout0_101) AT=525.025n

.meas tran vdout0_102ck1040 FIND v(dout0_102) AT=525.025n

.meas tran vdout0_103ck1040 FIND v(dout0_103) AT=525.025n

.meas tran vdout0_104ck1040 FIND v(dout0_104) AT=525.025n

.meas tran vdout0_105ck1040 FIND v(dout0_105) AT=525.025n

.meas tran vdout0_106ck1040 FIND v(dout0_106) AT=525.025n

.meas tran vdout0_107ck1040 FIND v(dout0_107) AT=525.025n

.meas tran vdout0_108ck1040 FIND v(dout0_108) AT=525.025n

.meas tran vdout0_109ck1040 FIND v(dout0_109) AT=525.025n

.meas tran vdout0_110ck1040 FIND v(dout0_110) AT=525.025n

.meas tran vdout0_111ck1040 FIND v(dout0_111) AT=525.025n

.meas tran vdout0_112ck1040 FIND v(dout0_112) AT=525.025n

.meas tran vdout0_113ck1040 FIND v(dout0_113) AT=525.025n

.meas tran vdout0_114ck1040 FIND v(dout0_114) AT=525.025n

.meas tran vdout0_115ck1040 FIND v(dout0_115) AT=525.025n

.meas tran vdout0_116ck1040 FIND v(dout0_116) AT=525.025n

.meas tran vdout0_117ck1040 FIND v(dout0_117) AT=525.025n

.meas tran vdout0_118ck1040 FIND v(dout0_118) AT=525.025n

.meas tran vdout0_119ck1040 FIND v(dout0_119) AT=525.025n

.meas tran vdout0_120ck1040 FIND v(dout0_120) AT=525.025n

.meas tran vdout0_121ck1040 FIND v(dout0_121) AT=525.025n

.meas tran vdout0_122ck1040 FIND v(dout0_122) AT=525.025n

.meas tran vdout0_123ck1040 FIND v(dout0_123) AT=525.025n

.meas tran vdout0_124ck1040 FIND v(dout0_124) AT=525.025n

.meas tran vdout0_125ck1040 FIND v(dout0_125) AT=525.025n

.meas tran vdout0_126ck1040 FIND v(dout0_126) AT=525.025n

.meas tran vdout0_127ck1040 FIND v(dout0_127) AT=525.025n

.meas tran vdout0_0ck1070 FIND v(dout0_0) AT=540.025n

.meas tran vdout0_1ck1070 FIND v(dout0_1) AT=540.025n

.meas tran vdout0_2ck1070 FIND v(dout0_2) AT=540.025n

.meas tran vdout0_3ck1070 FIND v(dout0_3) AT=540.025n

.meas tran vdout0_4ck1070 FIND v(dout0_4) AT=540.025n

.meas tran vdout0_5ck1070 FIND v(dout0_5) AT=540.025n

.meas tran vdout0_6ck1070 FIND v(dout0_6) AT=540.025n

.meas tran vdout0_7ck1070 FIND v(dout0_7) AT=540.025n

.meas tran vdout0_8ck1070 FIND v(dout0_8) AT=540.025n

.meas tran vdout0_9ck1070 FIND v(dout0_9) AT=540.025n

.meas tran vdout0_10ck1070 FIND v(dout0_10) AT=540.025n

.meas tran vdout0_11ck1070 FIND v(dout0_11) AT=540.025n

.meas tran vdout0_12ck1070 FIND v(dout0_12) AT=540.025n

.meas tran vdout0_13ck1070 FIND v(dout0_13) AT=540.025n

.meas tran vdout0_14ck1070 FIND v(dout0_14) AT=540.025n

.meas tran vdout0_15ck1070 FIND v(dout0_15) AT=540.025n

.meas tran vdout0_16ck1070 FIND v(dout0_16) AT=540.025n

.meas tran vdout0_17ck1070 FIND v(dout0_17) AT=540.025n

.meas tran vdout0_18ck1070 FIND v(dout0_18) AT=540.025n

.meas tran vdout0_19ck1070 FIND v(dout0_19) AT=540.025n

.meas tran vdout0_20ck1070 FIND v(dout0_20) AT=540.025n

.meas tran vdout0_21ck1070 FIND v(dout0_21) AT=540.025n

.meas tran vdout0_22ck1070 FIND v(dout0_22) AT=540.025n

.meas tran vdout0_23ck1070 FIND v(dout0_23) AT=540.025n

.meas tran vdout0_24ck1070 FIND v(dout0_24) AT=540.025n

.meas tran vdout0_25ck1070 FIND v(dout0_25) AT=540.025n

.meas tran vdout0_26ck1070 FIND v(dout0_26) AT=540.025n

.meas tran vdout0_27ck1070 FIND v(dout0_27) AT=540.025n

.meas tran vdout0_28ck1070 FIND v(dout0_28) AT=540.025n

.meas tran vdout0_29ck1070 FIND v(dout0_29) AT=540.025n

.meas tran vdout0_30ck1070 FIND v(dout0_30) AT=540.025n

.meas tran vdout0_31ck1070 FIND v(dout0_31) AT=540.025n

.meas tran vdout0_32ck1070 FIND v(dout0_32) AT=540.025n

.meas tran vdout0_33ck1070 FIND v(dout0_33) AT=540.025n

.meas tran vdout0_34ck1070 FIND v(dout0_34) AT=540.025n

.meas tran vdout0_35ck1070 FIND v(dout0_35) AT=540.025n

.meas tran vdout0_36ck1070 FIND v(dout0_36) AT=540.025n

.meas tran vdout0_37ck1070 FIND v(dout0_37) AT=540.025n

.meas tran vdout0_38ck1070 FIND v(dout0_38) AT=540.025n

.meas tran vdout0_39ck1070 FIND v(dout0_39) AT=540.025n

.meas tran vdout0_40ck1070 FIND v(dout0_40) AT=540.025n

.meas tran vdout0_41ck1070 FIND v(dout0_41) AT=540.025n

.meas tran vdout0_42ck1070 FIND v(dout0_42) AT=540.025n

.meas tran vdout0_43ck1070 FIND v(dout0_43) AT=540.025n

.meas tran vdout0_44ck1070 FIND v(dout0_44) AT=540.025n

.meas tran vdout0_45ck1070 FIND v(dout0_45) AT=540.025n

.meas tran vdout0_46ck1070 FIND v(dout0_46) AT=540.025n

.meas tran vdout0_47ck1070 FIND v(dout0_47) AT=540.025n

.meas tran vdout0_48ck1070 FIND v(dout0_48) AT=540.025n

.meas tran vdout0_49ck1070 FIND v(dout0_49) AT=540.025n

.meas tran vdout0_50ck1070 FIND v(dout0_50) AT=540.025n

.meas tran vdout0_51ck1070 FIND v(dout0_51) AT=540.025n

.meas tran vdout0_52ck1070 FIND v(dout0_52) AT=540.025n

.meas tran vdout0_53ck1070 FIND v(dout0_53) AT=540.025n

.meas tran vdout0_54ck1070 FIND v(dout0_54) AT=540.025n

.meas tran vdout0_55ck1070 FIND v(dout0_55) AT=540.025n

.meas tran vdout0_56ck1070 FIND v(dout0_56) AT=540.025n

.meas tran vdout0_57ck1070 FIND v(dout0_57) AT=540.025n

.meas tran vdout0_58ck1070 FIND v(dout0_58) AT=540.025n

.meas tran vdout0_59ck1070 FIND v(dout0_59) AT=540.025n

.meas tran vdout0_60ck1070 FIND v(dout0_60) AT=540.025n

.meas tran vdout0_61ck1070 FIND v(dout0_61) AT=540.025n

.meas tran vdout0_62ck1070 FIND v(dout0_62) AT=540.025n

.meas tran vdout0_63ck1070 FIND v(dout0_63) AT=540.025n

.meas tran vdout0_64ck1070 FIND v(dout0_64) AT=540.025n

.meas tran vdout0_65ck1070 FIND v(dout0_65) AT=540.025n

.meas tran vdout0_66ck1070 FIND v(dout0_66) AT=540.025n

.meas tran vdout0_67ck1070 FIND v(dout0_67) AT=540.025n

.meas tran vdout0_68ck1070 FIND v(dout0_68) AT=540.025n

.meas tran vdout0_69ck1070 FIND v(dout0_69) AT=540.025n

.meas tran vdout0_70ck1070 FIND v(dout0_70) AT=540.025n

.meas tran vdout0_71ck1070 FIND v(dout0_71) AT=540.025n

.meas tran vdout0_72ck1070 FIND v(dout0_72) AT=540.025n

.meas tran vdout0_73ck1070 FIND v(dout0_73) AT=540.025n

.meas tran vdout0_74ck1070 FIND v(dout0_74) AT=540.025n

.meas tran vdout0_75ck1070 FIND v(dout0_75) AT=540.025n

.meas tran vdout0_76ck1070 FIND v(dout0_76) AT=540.025n

.meas tran vdout0_77ck1070 FIND v(dout0_77) AT=540.025n

.meas tran vdout0_78ck1070 FIND v(dout0_78) AT=540.025n

.meas tran vdout0_79ck1070 FIND v(dout0_79) AT=540.025n

.meas tran vdout0_80ck1070 FIND v(dout0_80) AT=540.025n

.meas tran vdout0_81ck1070 FIND v(dout0_81) AT=540.025n

.meas tran vdout0_82ck1070 FIND v(dout0_82) AT=540.025n

.meas tran vdout0_83ck1070 FIND v(dout0_83) AT=540.025n

.meas tran vdout0_84ck1070 FIND v(dout0_84) AT=540.025n

.meas tran vdout0_85ck1070 FIND v(dout0_85) AT=540.025n

.meas tran vdout0_86ck1070 FIND v(dout0_86) AT=540.025n

.meas tran vdout0_87ck1070 FIND v(dout0_87) AT=540.025n

.meas tran vdout0_88ck1070 FIND v(dout0_88) AT=540.025n

.meas tran vdout0_89ck1070 FIND v(dout0_89) AT=540.025n

.meas tran vdout0_90ck1070 FIND v(dout0_90) AT=540.025n

.meas tran vdout0_91ck1070 FIND v(dout0_91) AT=540.025n

.meas tran vdout0_92ck1070 FIND v(dout0_92) AT=540.025n

.meas tran vdout0_93ck1070 FIND v(dout0_93) AT=540.025n

.meas tran vdout0_94ck1070 FIND v(dout0_94) AT=540.025n

.meas tran vdout0_95ck1070 FIND v(dout0_95) AT=540.025n

.meas tran vdout0_96ck1070 FIND v(dout0_96) AT=540.025n

.meas tran vdout0_97ck1070 FIND v(dout0_97) AT=540.025n

.meas tran vdout0_98ck1070 FIND v(dout0_98) AT=540.025n

.meas tran vdout0_99ck1070 FIND v(dout0_99) AT=540.025n

.meas tran vdout0_100ck1070 FIND v(dout0_100) AT=540.025n

.meas tran vdout0_101ck1070 FIND v(dout0_101) AT=540.025n

.meas tran vdout0_102ck1070 FIND v(dout0_102) AT=540.025n

.meas tran vdout0_103ck1070 FIND v(dout0_103) AT=540.025n

.meas tran vdout0_104ck1070 FIND v(dout0_104) AT=540.025n

.meas tran vdout0_105ck1070 FIND v(dout0_105) AT=540.025n

.meas tran vdout0_106ck1070 FIND v(dout0_106) AT=540.025n

.meas tran vdout0_107ck1070 FIND v(dout0_107) AT=540.025n

.meas tran vdout0_108ck1070 FIND v(dout0_108) AT=540.025n

.meas tran vdout0_109ck1070 FIND v(dout0_109) AT=540.025n

.meas tran vdout0_110ck1070 FIND v(dout0_110) AT=540.025n

.meas tran vdout0_111ck1070 FIND v(dout0_111) AT=540.025n

.meas tran vdout0_112ck1070 FIND v(dout0_112) AT=540.025n

.meas tran vdout0_113ck1070 FIND v(dout0_113) AT=540.025n

.meas tran vdout0_114ck1070 FIND v(dout0_114) AT=540.025n

.meas tran vdout0_115ck1070 FIND v(dout0_115) AT=540.025n

.meas tran vdout0_116ck1070 FIND v(dout0_116) AT=540.025n

.meas tran vdout0_117ck1070 FIND v(dout0_117) AT=540.025n

.meas tran vdout0_118ck1070 FIND v(dout0_118) AT=540.025n

.meas tran vdout0_119ck1070 FIND v(dout0_119) AT=540.025n

.meas tran vdout0_120ck1070 FIND v(dout0_120) AT=540.025n

.meas tran vdout0_121ck1070 FIND v(dout0_121) AT=540.025n

.meas tran vdout0_122ck1070 FIND v(dout0_122) AT=540.025n

.meas tran vdout0_123ck1070 FIND v(dout0_123) AT=540.025n

.meas tran vdout0_124ck1070 FIND v(dout0_124) AT=540.025n

.meas tran vdout0_125ck1070 FIND v(dout0_125) AT=540.025n

.meas tran vdout0_126ck1070 FIND v(dout0_126) AT=540.025n

.meas tran vdout0_127ck1070 FIND v(dout0_127) AT=540.025n

.meas tran vdout0_0ck1080 FIND v(dout0_0) AT=545.025n

.meas tran vdout0_1ck1080 FIND v(dout0_1) AT=545.025n

.meas tran vdout0_2ck1080 FIND v(dout0_2) AT=545.025n

.meas tran vdout0_3ck1080 FIND v(dout0_3) AT=545.025n

.meas tran vdout0_4ck1080 FIND v(dout0_4) AT=545.025n

.meas tran vdout0_5ck1080 FIND v(dout0_5) AT=545.025n

.meas tran vdout0_6ck1080 FIND v(dout0_6) AT=545.025n

.meas tran vdout0_7ck1080 FIND v(dout0_7) AT=545.025n

.meas tran vdout0_8ck1080 FIND v(dout0_8) AT=545.025n

.meas tran vdout0_9ck1080 FIND v(dout0_9) AT=545.025n

.meas tran vdout0_10ck1080 FIND v(dout0_10) AT=545.025n

.meas tran vdout0_11ck1080 FIND v(dout0_11) AT=545.025n

.meas tran vdout0_12ck1080 FIND v(dout0_12) AT=545.025n

.meas tran vdout0_13ck1080 FIND v(dout0_13) AT=545.025n

.meas tran vdout0_14ck1080 FIND v(dout0_14) AT=545.025n

.meas tran vdout0_15ck1080 FIND v(dout0_15) AT=545.025n

.meas tran vdout0_16ck1080 FIND v(dout0_16) AT=545.025n

.meas tran vdout0_17ck1080 FIND v(dout0_17) AT=545.025n

.meas tran vdout0_18ck1080 FIND v(dout0_18) AT=545.025n

.meas tran vdout0_19ck1080 FIND v(dout0_19) AT=545.025n

.meas tran vdout0_20ck1080 FIND v(dout0_20) AT=545.025n

.meas tran vdout0_21ck1080 FIND v(dout0_21) AT=545.025n

.meas tran vdout0_22ck1080 FIND v(dout0_22) AT=545.025n

.meas tran vdout0_23ck1080 FIND v(dout0_23) AT=545.025n

.meas tran vdout0_24ck1080 FIND v(dout0_24) AT=545.025n

.meas tran vdout0_25ck1080 FIND v(dout0_25) AT=545.025n

.meas tran vdout0_26ck1080 FIND v(dout0_26) AT=545.025n

.meas tran vdout0_27ck1080 FIND v(dout0_27) AT=545.025n

.meas tran vdout0_28ck1080 FIND v(dout0_28) AT=545.025n

.meas tran vdout0_29ck1080 FIND v(dout0_29) AT=545.025n

.meas tran vdout0_30ck1080 FIND v(dout0_30) AT=545.025n

.meas tran vdout0_31ck1080 FIND v(dout0_31) AT=545.025n

.meas tran vdout0_32ck1080 FIND v(dout0_32) AT=545.025n

.meas tran vdout0_33ck1080 FIND v(dout0_33) AT=545.025n

.meas tran vdout0_34ck1080 FIND v(dout0_34) AT=545.025n

.meas tran vdout0_35ck1080 FIND v(dout0_35) AT=545.025n

.meas tran vdout0_36ck1080 FIND v(dout0_36) AT=545.025n

.meas tran vdout0_37ck1080 FIND v(dout0_37) AT=545.025n

.meas tran vdout0_38ck1080 FIND v(dout0_38) AT=545.025n

.meas tran vdout0_39ck1080 FIND v(dout0_39) AT=545.025n

.meas tran vdout0_40ck1080 FIND v(dout0_40) AT=545.025n

.meas tran vdout0_41ck1080 FIND v(dout0_41) AT=545.025n

.meas tran vdout0_42ck1080 FIND v(dout0_42) AT=545.025n

.meas tran vdout0_43ck1080 FIND v(dout0_43) AT=545.025n

.meas tran vdout0_44ck1080 FIND v(dout0_44) AT=545.025n

.meas tran vdout0_45ck1080 FIND v(dout0_45) AT=545.025n

.meas tran vdout0_46ck1080 FIND v(dout0_46) AT=545.025n

.meas tran vdout0_47ck1080 FIND v(dout0_47) AT=545.025n

.meas tran vdout0_48ck1080 FIND v(dout0_48) AT=545.025n

.meas tran vdout0_49ck1080 FIND v(dout0_49) AT=545.025n

.meas tran vdout0_50ck1080 FIND v(dout0_50) AT=545.025n

.meas tran vdout0_51ck1080 FIND v(dout0_51) AT=545.025n

.meas tran vdout0_52ck1080 FIND v(dout0_52) AT=545.025n

.meas tran vdout0_53ck1080 FIND v(dout0_53) AT=545.025n

.meas tran vdout0_54ck1080 FIND v(dout0_54) AT=545.025n

.meas tran vdout0_55ck1080 FIND v(dout0_55) AT=545.025n

.meas tran vdout0_56ck1080 FIND v(dout0_56) AT=545.025n

.meas tran vdout0_57ck1080 FIND v(dout0_57) AT=545.025n

.meas tran vdout0_58ck1080 FIND v(dout0_58) AT=545.025n

.meas tran vdout0_59ck1080 FIND v(dout0_59) AT=545.025n

.meas tran vdout0_60ck1080 FIND v(dout0_60) AT=545.025n

.meas tran vdout0_61ck1080 FIND v(dout0_61) AT=545.025n

.meas tran vdout0_62ck1080 FIND v(dout0_62) AT=545.025n

.meas tran vdout0_63ck1080 FIND v(dout0_63) AT=545.025n

.meas tran vdout0_64ck1080 FIND v(dout0_64) AT=545.025n

.meas tran vdout0_65ck1080 FIND v(dout0_65) AT=545.025n

.meas tran vdout0_66ck1080 FIND v(dout0_66) AT=545.025n

.meas tran vdout0_67ck1080 FIND v(dout0_67) AT=545.025n

.meas tran vdout0_68ck1080 FIND v(dout0_68) AT=545.025n

.meas tran vdout0_69ck1080 FIND v(dout0_69) AT=545.025n

.meas tran vdout0_70ck1080 FIND v(dout0_70) AT=545.025n

.meas tran vdout0_71ck1080 FIND v(dout0_71) AT=545.025n

.meas tran vdout0_72ck1080 FIND v(dout0_72) AT=545.025n

.meas tran vdout0_73ck1080 FIND v(dout0_73) AT=545.025n

.meas tran vdout0_74ck1080 FIND v(dout0_74) AT=545.025n

.meas tran vdout0_75ck1080 FIND v(dout0_75) AT=545.025n

.meas tran vdout0_76ck1080 FIND v(dout0_76) AT=545.025n

.meas tran vdout0_77ck1080 FIND v(dout0_77) AT=545.025n

.meas tran vdout0_78ck1080 FIND v(dout0_78) AT=545.025n

.meas tran vdout0_79ck1080 FIND v(dout0_79) AT=545.025n

.meas tran vdout0_80ck1080 FIND v(dout0_80) AT=545.025n

.meas tran vdout0_81ck1080 FIND v(dout0_81) AT=545.025n

.meas tran vdout0_82ck1080 FIND v(dout0_82) AT=545.025n

.meas tran vdout0_83ck1080 FIND v(dout0_83) AT=545.025n

.meas tran vdout0_84ck1080 FIND v(dout0_84) AT=545.025n

.meas tran vdout0_85ck1080 FIND v(dout0_85) AT=545.025n

.meas tran vdout0_86ck1080 FIND v(dout0_86) AT=545.025n

.meas tran vdout0_87ck1080 FIND v(dout0_87) AT=545.025n

.meas tran vdout0_88ck1080 FIND v(dout0_88) AT=545.025n

.meas tran vdout0_89ck1080 FIND v(dout0_89) AT=545.025n

.meas tran vdout0_90ck1080 FIND v(dout0_90) AT=545.025n

.meas tran vdout0_91ck1080 FIND v(dout0_91) AT=545.025n

.meas tran vdout0_92ck1080 FIND v(dout0_92) AT=545.025n

.meas tran vdout0_93ck1080 FIND v(dout0_93) AT=545.025n

.meas tran vdout0_94ck1080 FIND v(dout0_94) AT=545.025n

.meas tran vdout0_95ck1080 FIND v(dout0_95) AT=545.025n

.meas tran vdout0_96ck1080 FIND v(dout0_96) AT=545.025n

.meas tran vdout0_97ck1080 FIND v(dout0_97) AT=545.025n

.meas tran vdout0_98ck1080 FIND v(dout0_98) AT=545.025n

.meas tran vdout0_99ck1080 FIND v(dout0_99) AT=545.025n

.meas tran vdout0_100ck1080 FIND v(dout0_100) AT=545.025n

.meas tran vdout0_101ck1080 FIND v(dout0_101) AT=545.025n

.meas tran vdout0_102ck1080 FIND v(dout0_102) AT=545.025n

.meas tran vdout0_103ck1080 FIND v(dout0_103) AT=545.025n

.meas tran vdout0_104ck1080 FIND v(dout0_104) AT=545.025n

.meas tran vdout0_105ck1080 FIND v(dout0_105) AT=545.025n

.meas tran vdout0_106ck1080 FIND v(dout0_106) AT=545.025n

.meas tran vdout0_107ck1080 FIND v(dout0_107) AT=545.025n

.meas tran vdout0_108ck1080 FIND v(dout0_108) AT=545.025n

.meas tran vdout0_109ck1080 FIND v(dout0_109) AT=545.025n

.meas tran vdout0_110ck1080 FIND v(dout0_110) AT=545.025n

.meas tran vdout0_111ck1080 FIND v(dout0_111) AT=545.025n

.meas tran vdout0_112ck1080 FIND v(dout0_112) AT=545.025n

.meas tran vdout0_113ck1080 FIND v(dout0_113) AT=545.025n

.meas tran vdout0_114ck1080 FIND v(dout0_114) AT=545.025n

.meas tran vdout0_115ck1080 FIND v(dout0_115) AT=545.025n

.meas tran vdout0_116ck1080 FIND v(dout0_116) AT=545.025n

.meas tran vdout0_117ck1080 FIND v(dout0_117) AT=545.025n

.meas tran vdout0_118ck1080 FIND v(dout0_118) AT=545.025n

.meas tran vdout0_119ck1080 FIND v(dout0_119) AT=545.025n

.meas tran vdout0_120ck1080 FIND v(dout0_120) AT=545.025n

.meas tran vdout0_121ck1080 FIND v(dout0_121) AT=545.025n

.meas tran vdout0_122ck1080 FIND v(dout0_122) AT=545.025n

.meas tran vdout0_123ck1080 FIND v(dout0_123) AT=545.025n

.meas tran vdout0_124ck1080 FIND v(dout0_124) AT=545.025n

.meas tran vdout0_125ck1080 FIND v(dout0_125) AT=545.025n

.meas tran vdout0_126ck1080 FIND v(dout0_126) AT=545.025n

.meas tran vdout0_127ck1080 FIND v(dout0_127) AT=545.025n

.meas tran vdout0_0ck1100 FIND v(dout0_0) AT=555.025n

.meas tran vdout0_1ck1100 FIND v(dout0_1) AT=555.025n

.meas tran vdout0_2ck1100 FIND v(dout0_2) AT=555.025n

.meas tran vdout0_3ck1100 FIND v(dout0_3) AT=555.025n

.meas tran vdout0_4ck1100 FIND v(dout0_4) AT=555.025n

.meas tran vdout0_5ck1100 FIND v(dout0_5) AT=555.025n

.meas tran vdout0_6ck1100 FIND v(dout0_6) AT=555.025n

.meas tran vdout0_7ck1100 FIND v(dout0_7) AT=555.025n

.meas tran vdout0_8ck1100 FIND v(dout0_8) AT=555.025n

.meas tran vdout0_9ck1100 FIND v(dout0_9) AT=555.025n

.meas tran vdout0_10ck1100 FIND v(dout0_10) AT=555.025n

.meas tran vdout0_11ck1100 FIND v(dout0_11) AT=555.025n

.meas tran vdout0_12ck1100 FIND v(dout0_12) AT=555.025n

.meas tran vdout0_13ck1100 FIND v(dout0_13) AT=555.025n

.meas tran vdout0_14ck1100 FIND v(dout0_14) AT=555.025n

.meas tran vdout0_15ck1100 FIND v(dout0_15) AT=555.025n

.meas tran vdout0_16ck1100 FIND v(dout0_16) AT=555.025n

.meas tran vdout0_17ck1100 FIND v(dout0_17) AT=555.025n

.meas tran vdout0_18ck1100 FIND v(dout0_18) AT=555.025n

.meas tran vdout0_19ck1100 FIND v(dout0_19) AT=555.025n

.meas tran vdout0_20ck1100 FIND v(dout0_20) AT=555.025n

.meas tran vdout0_21ck1100 FIND v(dout0_21) AT=555.025n

.meas tran vdout0_22ck1100 FIND v(dout0_22) AT=555.025n

.meas tran vdout0_23ck1100 FIND v(dout0_23) AT=555.025n

.meas tran vdout0_24ck1100 FIND v(dout0_24) AT=555.025n

.meas tran vdout0_25ck1100 FIND v(dout0_25) AT=555.025n

.meas tran vdout0_26ck1100 FIND v(dout0_26) AT=555.025n

.meas tran vdout0_27ck1100 FIND v(dout0_27) AT=555.025n

.meas tran vdout0_28ck1100 FIND v(dout0_28) AT=555.025n

.meas tran vdout0_29ck1100 FIND v(dout0_29) AT=555.025n

.meas tran vdout0_30ck1100 FIND v(dout0_30) AT=555.025n

.meas tran vdout0_31ck1100 FIND v(dout0_31) AT=555.025n

.meas tran vdout0_32ck1100 FIND v(dout0_32) AT=555.025n

.meas tran vdout0_33ck1100 FIND v(dout0_33) AT=555.025n

.meas tran vdout0_34ck1100 FIND v(dout0_34) AT=555.025n

.meas tran vdout0_35ck1100 FIND v(dout0_35) AT=555.025n

.meas tran vdout0_36ck1100 FIND v(dout0_36) AT=555.025n

.meas tran vdout0_37ck1100 FIND v(dout0_37) AT=555.025n

.meas tran vdout0_38ck1100 FIND v(dout0_38) AT=555.025n

.meas tran vdout0_39ck1100 FIND v(dout0_39) AT=555.025n

.meas tran vdout0_40ck1100 FIND v(dout0_40) AT=555.025n

.meas tran vdout0_41ck1100 FIND v(dout0_41) AT=555.025n

.meas tran vdout0_42ck1100 FIND v(dout0_42) AT=555.025n

.meas tran vdout0_43ck1100 FIND v(dout0_43) AT=555.025n

.meas tran vdout0_44ck1100 FIND v(dout0_44) AT=555.025n

.meas tran vdout0_45ck1100 FIND v(dout0_45) AT=555.025n

.meas tran vdout0_46ck1100 FIND v(dout0_46) AT=555.025n

.meas tran vdout0_47ck1100 FIND v(dout0_47) AT=555.025n

.meas tran vdout0_48ck1100 FIND v(dout0_48) AT=555.025n

.meas tran vdout0_49ck1100 FIND v(dout0_49) AT=555.025n

.meas tran vdout0_50ck1100 FIND v(dout0_50) AT=555.025n

.meas tran vdout0_51ck1100 FIND v(dout0_51) AT=555.025n

.meas tran vdout0_52ck1100 FIND v(dout0_52) AT=555.025n

.meas tran vdout0_53ck1100 FIND v(dout0_53) AT=555.025n

.meas tran vdout0_54ck1100 FIND v(dout0_54) AT=555.025n

.meas tran vdout0_55ck1100 FIND v(dout0_55) AT=555.025n

.meas tran vdout0_56ck1100 FIND v(dout0_56) AT=555.025n

.meas tran vdout0_57ck1100 FIND v(dout0_57) AT=555.025n

.meas tran vdout0_58ck1100 FIND v(dout0_58) AT=555.025n

.meas tran vdout0_59ck1100 FIND v(dout0_59) AT=555.025n

.meas tran vdout0_60ck1100 FIND v(dout0_60) AT=555.025n

.meas tran vdout0_61ck1100 FIND v(dout0_61) AT=555.025n

.meas tran vdout0_62ck1100 FIND v(dout0_62) AT=555.025n

.meas tran vdout0_63ck1100 FIND v(dout0_63) AT=555.025n

.meas tran vdout0_64ck1100 FIND v(dout0_64) AT=555.025n

.meas tran vdout0_65ck1100 FIND v(dout0_65) AT=555.025n

.meas tran vdout0_66ck1100 FIND v(dout0_66) AT=555.025n

.meas tran vdout0_67ck1100 FIND v(dout0_67) AT=555.025n

.meas tran vdout0_68ck1100 FIND v(dout0_68) AT=555.025n

.meas tran vdout0_69ck1100 FIND v(dout0_69) AT=555.025n

.meas tran vdout0_70ck1100 FIND v(dout0_70) AT=555.025n

.meas tran vdout0_71ck1100 FIND v(dout0_71) AT=555.025n

.meas tran vdout0_72ck1100 FIND v(dout0_72) AT=555.025n

.meas tran vdout0_73ck1100 FIND v(dout0_73) AT=555.025n

.meas tran vdout0_74ck1100 FIND v(dout0_74) AT=555.025n

.meas tran vdout0_75ck1100 FIND v(dout0_75) AT=555.025n

.meas tran vdout0_76ck1100 FIND v(dout0_76) AT=555.025n

.meas tran vdout0_77ck1100 FIND v(dout0_77) AT=555.025n

.meas tran vdout0_78ck1100 FIND v(dout0_78) AT=555.025n

.meas tran vdout0_79ck1100 FIND v(dout0_79) AT=555.025n

.meas tran vdout0_80ck1100 FIND v(dout0_80) AT=555.025n

.meas tran vdout0_81ck1100 FIND v(dout0_81) AT=555.025n

.meas tran vdout0_82ck1100 FIND v(dout0_82) AT=555.025n

.meas tran vdout0_83ck1100 FIND v(dout0_83) AT=555.025n

.meas tran vdout0_84ck1100 FIND v(dout0_84) AT=555.025n

.meas tran vdout0_85ck1100 FIND v(dout0_85) AT=555.025n

.meas tran vdout0_86ck1100 FIND v(dout0_86) AT=555.025n

.meas tran vdout0_87ck1100 FIND v(dout0_87) AT=555.025n

.meas tran vdout0_88ck1100 FIND v(dout0_88) AT=555.025n

.meas tran vdout0_89ck1100 FIND v(dout0_89) AT=555.025n

.meas tran vdout0_90ck1100 FIND v(dout0_90) AT=555.025n

.meas tran vdout0_91ck1100 FIND v(dout0_91) AT=555.025n

.meas tran vdout0_92ck1100 FIND v(dout0_92) AT=555.025n

.meas tran vdout0_93ck1100 FIND v(dout0_93) AT=555.025n

.meas tran vdout0_94ck1100 FIND v(dout0_94) AT=555.025n

.meas tran vdout0_95ck1100 FIND v(dout0_95) AT=555.025n

.meas tran vdout0_96ck1100 FIND v(dout0_96) AT=555.025n

.meas tran vdout0_97ck1100 FIND v(dout0_97) AT=555.025n

.meas tran vdout0_98ck1100 FIND v(dout0_98) AT=555.025n

.meas tran vdout0_99ck1100 FIND v(dout0_99) AT=555.025n

.meas tran vdout0_100ck1100 FIND v(dout0_100) AT=555.025n

.meas tran vdout0_101ck1100 FIND v(dout0_101) AT=555.025n

.meas tran vdout0_102ck1100 FIND v(dout0_102) AT=555.025n

.meas tran vdout0_103ck1100 FIND v(dout0_103) AT=555.025n

.meas tran vdout0_104ck1100 FIND v(dout0_104) AT=555.025n

.meas tran vdout0_105ck1100 FIND v(dout0_105) AT=555.025n

.meas tran vdout0_106ck1100 FIND v(dout0_106) AT=555.025n

.meas tran vdout0_107ck1100 FIND v(dout0_107) AT=555.025n

.meas tran vdout0_108ck1100 FIND v(dout0_108) AT=555.025n

.meas tran vdout0_109ck1100 FIND v(dout0_109) AT=555.025n

.meas tran vdout0_110ck1100 FIND v(dout0_110) AT=555.025n

.meas tran vdout0_111ck1100 FIND v(dout0_111) AT=555.025n

.meas tran vdout0_112ck1100 FIND v(dout0_112) AT=555.025n

.meas tran vdout0_113ck1100 FIND v(dout0_113) AT=555.025n

.meas tran vdout0_114ck1100 FIND v(dout0_114) AT=555.025n

.meas tran vdout0_115ck1100 FIND v(dout0_115) AT=555.025n

.meas tran vdout0_116ck1100 FIND v(dout0_116) AT=555.025n

.meas tran vdout0_117ck1100 FIND v(dout0_117) AT=555.025n

.meas tran vdout0_118ck1100 FIND v(dout0_118) AT=555.025n

.meas tran vdout0_119ck1100 FIND v(dout0_119) AT=555.025n

.meas tran vdout0_120ck1100 FIND v(dout0_120) AT=555.025n

.meas tran vdout0_121ck1100 FIND v(dout0_121) AT=555.025n

.meas tran vdout0_122ck1100 FIND v(dout0_122) AT=555.025n

.meas tran vdout0_123ck1100 FIND v(dout0_123) AT=555.025n

.meas tran vdout0_124ck1100 FIND v(dout0_124) AT=555.025n

.meas tran vdout0_125ck1100 FIND v(dout0_125) AT=555.025n

.meas tran vdout0_126ck1100 FIND v(dout0_126) AT=555.025n

.meas tran vdout0_127ck1100 FIND v(dout0_127) AT=555.025n

.meas tran vdout0_0ck1140 FIND v(dout0_0) AT=575.025n

.meas tran vdout0_1ck1140 FIND v(dout0_1) AT=575.025n

.meas tran vdout0_2ck1140 FIND v(dout0_2) AT=575.025n

.meas tran vdout0_3ck1140 FIND v(dout0_3) AT=575.025n

.meas tran vdout0_4ck1140 FIND v(dout0_4) AT=575.025n

.meas tran vdout0_5ck1140 FIND v(dout0_5) AT=575.025n

.meas tran vdout0_6ck1140 FIND v(dout0_6) AT=575.025n

.meas tran vdout0_7ck1140 FIND v(dout0_7) AT=575.025n

.meas tran vdout0_8ck1140 FIND v(dout0_8) AT=575.025n

.meas tran vdout0_9ck1140 FIND v(dout0_9) AT=575.025n

.meas tran vdout0_10ck1140 FIND v(dout0_10) AT=575.025n

.meas tran vdout0_11ck1140 FIND v(dout0_11) AT=575.025n

.meas tran vdout0_12ck1140 FIND v(dout0_12) AT=575.025n

.meas tran vdout0_13ck1140 FIND v(dout0_13) AT=575.025n

.meas tran vdout0_14ck1140 FIND v(dout0_14) AT=575.025n

.meas tran vdout0_15ck1140 FIND v(dout0_15) AT=575.025n

.meas tran vdout0_16ck1140 FIND v(dout0_16) AT=575.025n

.meas tran vdout0_17ck1140 FIND v(dout0_17) AT=575.025n

.meas tran vdout0_18ck1140 FIND v(dout0_18) AT=575.025n

.meas tran vdout0_19ck1140 FIND v(dout0_19) AT=575.025n

.meas tran vdout0_20ck1140 FIND v(dout0_20) AT=575.025n

.meas tran vdout0_21ck1140 FIND v(dout0_21) AT=575.025n

.meas tran vdout0_22ck1140 FIND v(dout0_22) AT=575.025n

.meas tran vdout0_23ck1140 FIND v(dout0_23) AT=575.025n

.meas tran vdout0_24ck1140 FIND v(dout0_24) AT=575.025n

.meas tran vdout0_25ck1140 FIND v(dout0_25) AT=575.025n

.meas tran vdout0_26ck1140 FIND v(dout0_26) AT=575.025n

.meas tran vdout0_27ck1140 FIND v(dout0_27) AT=575.025n

.meas tran vdout0_28ck1140 FIND v(dout0_28) AT=575.025n

.meas tran vdout0_29ck1140 FIND v(dout0_29) AT=575.025n

.meas tran vdout0_30ck1140 FIND v(dout0_30) AT=575.025n

.meas tran vdout0_31ck1140 FIND v(dout0_31) AT=575.025n

.meas tran vdout0_32ck1140 FIND v(dout0_32) AT=575.025n

.meas tran vdout0_33ck1140 FIND v(dout0_33) AT=575.025n

.meas tran vdout0_34ck1140 FIND v(dout0_34) AT=575.025n

.meas tran vdout0_35ck1140 FIND v(dout0_35) AT=575.025n

.meas tran vdout0_36ck1140 FIND v(dout0_36) AT=575.025n

.meas tran vdout0_37ck1140 FIND v(dout0_37) AT=575.025n

.meas tran vdout0_38ck1140 FIND v(dout0_38) AT=575.025n

.meas tran vdout0_39ck1140 FIND v(dout0_39) AT=575.025n

.meas tran vdout0_40ck1140 FIND v(dout0_40) AT=575.025n

.meas tran vdout0_41ck1140 FIND v(dout0_41) AT=575.025n

.meas tran vdout0_42ck1140 FIND v(dout0_42) AT=575.025n

.meas tran vdout0_43ck1140 FIND v(dout0_43) AT=575.025n

.meas tran vdout0_44ck1140 FIND v(dout0_44) AT=575.025n

.meas tran vdout0_45ck1140 FIND v(dout0_45) AT=575.025n

.meas tran vdout0_46ck1140 FIND v(dout0_46) AT=575.025n

.meas tran vdout0_47ck1140 FIND v(dout0_47) AT=575.025n

.meas tran vdout0_48ck1140 FIND v(dout0_48) AT=575.025n

.meas tran vdout0_49ck1140 FIND v(dout0_49) AT=575.025n

.meas tran vdout0_50ck1140 FIND v(dout0_50) AT=575.025n

.meas tran vdout0_51ck1140 FIND v(dout0_51) AT=575.025n

.meas tran vdout0_52ck1140 FIND v(dout0_52) AT=575.025n

.meas tran vdout0_53ck1140 FIND v(dout0_53) AT=575.025n

.meas tran vdout0_54ck1140 FIND v(dout0_54) AT=575.025n

.meas tran vdout0_55ck1140 FIND v(dout0_55) AT=575.025n

.meas tran vdout0_56ck1140 FIND v(dout0_56) AT=575.025n

.meas tran vdout0_57ck1140 FIND v(dout0_57) AT=575.025n

.meas tran vdout0_58ck1140 FIND v(dout0_58) AT=575.025n

.meas tran vdout0_59ck1140 FIND v(dout0_59) AT=575.025n

.meas tran vdout0_60ck1140 FIND v(dout0_60) AT=575.025n

.meas tran vdout0_61ck1140 FIND v(dout0_61) AT=575.025n

.meas tran vdout0_62ck1140 FIND v(dout0_62) AT=575.025n

.meas tran vdout0_63ck1140 FIND v(dout0_63) AT=575.025n

.meas tran vdout0_64ck1140 FIND v(dout0_64) AT=575.025n

.meas tran vdout0_65ck1140 FIND v(dout0_65) AT=575.025n

.meas tran vdout0_66ck1140 FIND v(dout0_66) AT=575.025n

.meas tran vdout0_67ck1140 FIND v(dout0_67) AT=575.025n

.meas tran vdout0_68ck1140 FIND v(dout0_68) AT=575.025n

.meas tran vdout0_69ck1140 FIND v(dout0_69) AT=575.025n

.meas tran vdout0_70ck1140 FIND v(dout0_70) AT=575.025n

.meas tran vdout0_71ck1140 FIND v(dout0_71) AT=575.025n

.meas tran vdout0_72ck1140 FIND v(dout0_72) AT=575.025n

.meas tran vdout0_73ck1140 FIND v(dout0_73) AT=575.025n

.meas tran vdout0_74ck1140 FIND v(dout0_74) AT=575.025n

.meas tran vdout0_75ck1140 FIND v(dout0_75) AT=575.025n

.meas tran vdout0_76ck1140 FIND v(dout0_76) AT=575.025n

.meas tran vdout0_77ck1140 FIND v(dout0_77) AT=575.025n

.meas tran vdout0_78ck1140 FIND v(dout0_78) AT=575.025n

.meas tran vdout0_79ck1140 FIND v(dout0_79) AT=575.025n

.meas tran vdout0_80ck1140 FIND v(dout0_80) AT=575.025n

.meas tran vdout0_81ck1140 FIND v(dout0_81) AT=575.025n

.meas tran vdout0_82ck1140 FIND v(dout0_82) AT=575.025n

.meas tran vdout0_83ck1140 FIND v(dout0_83) AT=575.025n

.meas tran vdout0_84ck1140 FIND v(dout0_84) AT=575.025n

.meas tran vdout0_85ck1140 FIND v(dout0_85) AT=575.025n

.meas tran vdout0_86ck1140 FIND v(dout0_86) AT=575.025n

.meas tran vdout0_87ck1140 FIND v(dout0_87) AT=575.025n

.meas tran vdout0_88ck1140 FIND v(dout0_88) AT=575.025n

.meas tran vdout0_89ck1140 FIND v(dout0_89) AT=575.025n

.meas tran vdout0_90ck1140 FIND v(dout0_90) AT=575.025n

.meas tran vdout0_91ck1140 FIND v(dout0_91) AT=575.025n

.meas tran vdout0_92ck1140 FIND v(dout0_92) AT=575.025n

.meas tran vdout0_93ck1140 FIND v(dout0_93) AT=575.025n

.meas tran vdout0_94ck1140 FIND v(dout0_94) AT=575.025n

.meas tran vdout0_95ck1140 FIND v(dout0_95) AT=575.025n

.meas tran vdout0_96ck1140 FIND v(dout0_96) AT=575.025n

.meas tran vdout0_97ck1140 FIND v(dout0_97) AT=575.025n

.meas tran vdout0_98ck1140 FIND v(dout0_98) AT=575.025n

.meas tran vdout0_99ck1140 FIND v(dout0_99) AT=575.025n

.meas tran vdout0_100ck1140 FIND v(dout0_100) AT=575.025n

.meas tran vdout0_101ck1140 FIND v(dout0_101) AT=575.025n

.meas tran vdout0_102ck1140 FIND v(dout0_102) AT=575.025n

.meas tran vdout0_103ck1140 FIND v(dout0_103) AT=575.025n

.meas tran vdout0_104ck1140 FIND v(dout0_104) AT=575.025n

.meas tran vdout0_105ck1140 FIND v(dout0_105) AT=575.025n

.meas tran vdout0_106ck1140 FIND v(dout0_106) AT=575.025n

.meas tran vdout0_107ck1140 FIND v(dout0_107) AT=575.025n

.meas tran vdout0_108ck1140 FIND v(dout0_108) AT=575.025n

.meas tran vdout0_109ck1140 FIND v(dout0_109) AT=575.025n

.meas tran vdout0_110ck1140 FIND v(dout0_110) AT=575.025n

.meas tran vdout0_111ck1140 FIND v(dout0_111) AT=575.025n

.meas tran vdout0_112ck1140 FIND v(dout0_112) AT=575.025n

.meas tran vdout0_113ck1140 FIND v(dout0_113) AT=575.025n

.meas tran vdout0_114ck1140 FIND v(dout0_114) AT=575.025n

.meas tran vdout0_115ck1140 FIND v(dout0_115) AT=575.025n

.meas tran vdout0_116ck1140 FIND v(dout0_116) AT=575.025n

.meas tran vdout0_117ck1140 FIND v(dout0_117) AT=575.025n

.meas tran vdout0_118ck1140 FIND v(dout0_118) AT=575.025n

.meas tran vdout0_119ck1140 FIND v(dout0_119) AT=575.025n

.meas tran vdout0_120ck1140 FIND v(dout0_120) AT=575.025n

.meas tran vdout0_121ck1140 FIND v(dout0_121) AT=575.025n

.meas tran vdout0_122ck1140 FIND v(dout0_122) AT=575.025n

.meas tran vdout0_123ck1140 FIND v(dout0_123) AT=575.025n

.meas tran vdout0_124ck1140 FIND v(dout0_124) AT=575.025n

.meas tran vdout0_125ck1140 FIND v(dout0_125) AT=575.025n

.meas tran vdout0_126ck1140 FIND v(dout0_126) AT=575.025n

.meas tran vdout0_127ck1140 FIND v(dout0_127) AT=575.025n

.meas tran vdout0_0ck1220 FIND v(dout0_0) AT=615.025n

.meas tran vdout0_1ck1220 FIND v(dout0_1) AT=615.025n

.meas tran vdout0_2ck1220 FIND v(dout0_2) AT=615.025n

.meas tran vdout0_3ck1220 FIND v(dout0_3) AT=615.025n

.meas tran vdout0_4ck1220 FIND v(dout0_4) AT=615.025n

.meas tran vdout0_5ck1220 FIND v(dout0_5) AT=615.025n

.meas tran vdout0_6ck1220 FIND v(dout0_6) AT=615.025n

.meas tran vdout0_7ck1220 FIND v(dout0_7) AT=615.025n

.meas tran vdout0_8ck1220 FIND v(dout0_8) AT=615.025n

.meas tran vdout0_9ck1220 FIND v(dout0_9) AT=615.025n

.meas tran vdout0_10ck1220 FIND v(dout0_10) AT=615.025n

.meas tran vdout0_11ck1220 FIND v(dout0_11) AT=615.025n

.meas tran vdout0_12ck1220 FIND v(dout0_12) AT=615.025n

.meas tran vdout0_13ck1220 FIND v(dout0_13) AT=615.025n

.meas tran vdout0_14ck1220 FIND v(dout0_14) AT=615.025n

.meas tran vdout0_15ck1220 FIND v(dout0_15) AT=615.025n

.meas tran vdout0_16ck1220 FIND v(dout0_16) AT=615.025n

.meas tran vdout0_17ck1220 FIND v(dout0_17) AT=615.025n

.meas tran vdout0_18ck1220 FIND v(dout0_18) AT=615.025n

.meas tran vdout0_19ck1220 FIND v(dout0_19) AT=615.025n

.meas tran vdout0_20ck1220 FIND v(dout0_20) AT=615.025n

.meas tran vdout0_21ck1220 FIND v(dout0_21) AT=615.025n

.meas tran vdout0_22ck1220 FIND v(dout0_22) AT=615.025n

.meas tran vdout0_23ck1220 FIND v(dout0_23) AT=615.025n

.meas tran vdout0_24ck1220 FIND v(dout0_24) AT=615.025n

.meas tran vdout0_25ck1220 FIND v(dout0_25) AT=615.025n

.meas tran vdout0_26ck1220 FIND v(dout0_26) AT=615.025n

.meas tran vdout0_27ck1220 FIND v(dout0_27) AT=615.025n

.meas tran vdout0_28ck1220 FIND v(dout0_28) AT=615.025n

.meas tran vdout0_29ck1220 FIND v(dout0_29) AT=615.025n

.meas tran vdout0_30ck1220 FIND v(dout0_30) AT=615.025n

.meas tran vdout0_31ck1220 FIND v(dout0_31) AT=615.025n

.meas tran vdout0_32ck1220 FIND v(dout0_32) AT=615.025n

.meas tran vdout0_33ck1220 FIND v(dout0_33) AT=615.025n

.meas tran vdout0_34ck1220 FIND v(dout0_34) AT=615.025n

.meas tran vdout0_35ck1220 FIND v(dout0_35) AT=615.025n

.meas tran vdout0_36ck1220 FIND v(dout0_36) AT=615.025n

.meas tran vdout0_37ck1220 FIND v(dout0_37) AT=615.025n

.meas tran vdout0_38ck1220 FIND v(dout0_38) AT=615.025n

.meas tran vdout0_39ck1220 FIND v(dout0_39) AT=615.025n

.meas tran vdout0_40ck1220 FIND v(dout0_40) AT=615.025n

.meas tran vdout0_41ck1220 FIND v(dout0_41) AT=615.025n

.meas tran vdout0_42ck1220 FIND v(dout0_42) AT=615.025n

.meas tran vdout0_43ck1220 FIND v(dout0_43) AT=615.025n

.meas tran vdout0_44ck1220 FIND v(dout0_44) AT=615.025n

.meas tran vdout0_45ck1220 FIND v(dout0_45) AT=615.025n

.meas tran vdout0_46ck1220 FIND v(dout0_46) AT=615.025n

.meas tran vdout0_47ck1220 FIND v(dout0_47) AT=615.025n

.meas tran vdout0_48ck1220 FIND v(dout0_48) AT=615.025n

.meas tran vdout0_49ck1220 FIND v(dout0_49) AT=615.025n

.meas tran vdout0_50ck1220 FIND v(dout0_50) AT=615.025n

.meas tran vdout0_51ck1220 FIND v(dout0_51) AT=615.025n

.meas tran vdout0_52ck1220 FIND v(dout0_52) AT=615.025n

.meas tran vdout0_53ck1220 FIND v(dout0_53) AT=615.025n

.meas tran vdout0_54ck1220 FIND v(dout0_54) AT=615.025n

.meas tran vdout0_55ck1220 FIND v(dout0_55) AT=615.025n

.meas tran vdout0_56ck1220 FIND v(dout0_56) AT=615.025n

.meas tran vdout0_57ck1220 FIND v(dout0_57) AT=615.025n

.meas tran vdout0_58ck1220 FIND v(dout0_58) AT=615.025n

.meas tran vdout0_59ck1220 FIND v(dout0_59) AT=615.025n

.meas tran vdout0_60ck1220 FIND v(dout0_60) AT=615.025n

.meas tran vdout0_61ck1220 FIND v(dout0_61) AT=615.025n

.meas tran vdout0_62ck1220 FIND v(dout0_62) AT=615.025n

.meas tran vdout0_63ck1220 FIND v(dout0_63) AT=615.025n

.meas tran vdout0_64ck1220 FIND v(dout0_64) AT=615.025n

.meas tran vdout0_65ck1220 FIND v(dout0_65) AT=615.025n

.meas tran vdout0_66ck1220 FIND v(dout0_66) AT=615.025n

.meas tran vdout0_67ck1220 FIND v(dout0_67) AT=615.025n

.meas tran vdout0_68ck1220 FIND v(dout0_68) AT=615.025n

.meas tran vdout0_69ck1220 FIND v(dout0_69) AT=615.025n

.meas tran vdout0_70ck1220 FIND v(dout0_70) AT=615.025n

.meas tran vdout0_71ck1220 FIND v(dout0_71) AT=615.025n

.meas tran vdout0_72ck1220 FIND v(dout0_72) AT=615.025n

.meas tran vdout0_73ck1220 FIND v(dout0_73) AT=615.025n

.meas tran vdout0_74ck1220 FIND v(dout0_74) AT=615.025n

.meas tran vdout0_75ck1220 FIND v(dout0_75) AT=615.025n

.meas tran vdout0_76ck1220 FIND v(dout0_76) AT=615.025n

.meas tran vdout0_77ck1220 FIND v(dout0_77) AT=615.025n

.meas tran vdout0_78ck1220 FIND v(dout0_78) AT=615.025n

.meas tran vdout0_79ck1220 FIND v(dout0_79) AT=615.025n

.meas tran vdout0_80ck1220 FIND v(dout0_80) AT=615.025n

.meas tran vdout0_81ck1220 FIND v(dout0_81) AT=615.025n

.meas tran vdout0_82ck1220 FIND v(dout0_82) AT=615.025n

.meas tran vdout0_83ck1220 FIND v(dout0_83) AT=615.025n

.meas tran vdout0_84ck1220 FIND v(dout0_84) AT=615.025n

.meas tran vdout0_85ck1220 FIND v(dout0_85) AT=615.025n

.meas tran vdout0_86ck1220 FIND v(dout0_86) AT=615.025n

.meas tran vdout0_87ck1220 FIND v(dout0_87) AT=615.025n

.meas tran vdout0_88ck1220 FIND v(dout0_88) AT=615.025n

.meas tran vdout0_89ck1220 FIND v(dout0_89) AT=615.025n

.meas tran vdout0_90ck1220 FIND v(dout0_90) AT=615.025n

.meas tran vdout0_91ck1220 FIND v(dout0_91) AT=615.025n

.meas tran vdout0_92ck1220 FIND v(dout0_92) AT=615.025n

.meas tran vdout0_93ck1220 FIND v(dout0_93) AT=615.025n

.meas tran vdout0_94ck1220 FIND v(dout0_94) AT=615.025n

.meas tran vdout0_95ck1220 FIND v(dout0_95) AT=615.025n

.meas tran vdout0_96ck1220 FIND v(dout0_96) AT=615.025n

.meas tran vdout0_97ck1220 FIND v(dout0_97) AT=615.025n

.meas tran vdout0_98ck1220 FIND v(dout0_98) AT=615.025n

.meas tran vdout0_99ck1220 FIND v(dout0_99) AT=615.025n

.meas tran vdout0_100ck1220 FIND v(dout0_100) AT=615.025n

.meas tran vdout0_101ck1220 FIND v(dout0_101) AT=615.025n

.meas tran vdout0_102ck1220 FIND v(dout0_102) AT=615.025n

.meas tran vdout0_103ck1220 FIND v(dout0_103) AT=615.025n

.meas tran vdout0_104ck1220 FIND v(dout0_104) AT=615.025n

.meas tran vdout0_105ck1220 FIND v(dout0_105) AT=615.025n

.meas tran vdout0_106ck1220 FIND v(dout0_106) AT=615.025n

.meas tran vdout0_107ck1220 FIND v(dout0_107) AT=615.025n

.meas tran vdout0_108ck1220 FIND v(dout0_108) AT=615.025n

.meas tran vdout0_109ck1220 FIND v(dout0_109) AT=615.025n

.meas tran vdout0_110ck1220 FIND v(dout0_110) AT=615.025n

.meas tran vdout0_111ck1220 FIND v(dout0_111) AT=615.025n

.meas tran vdout0_112ck1220 FIND v(dout0_112) AT=615.025n

.meas tran vdout0_113ck1220 FIND v(dout0_113) AT=615.025n

.meas tran vdout0_114ck1220 FIND v(dout0_114) AT=615.025n

.meas tran vdout0_115ck1220 FIND v(dout0_115) AT=615.025n

.meas tran vdout0_116ck1220 FIND v(dout0_116) AT=615.025n

.meas tran vdout0_117ck1220 FIND v(dout0_117) AT=615.025n

.meas tran vdout0_118ck1220 FIND v(dout0_118) AT=615.025n

.meas tran vdout0_119ck1220 FIND v(dout0_119) AT=615.025n

.meas tran vdout0_120ck1220 FIND v(dout0_120) AT=615.025n

.meas tran vdout0_121ck1220 FIND v(dout0_121) AT=615.025n

.meas tran vdout0_122ck1220 FIND v(dout0_122) AT=615.025n

.meas tran vdout0_123ck1220 FIND v(dout0_123) AT=615.025n

.meas tran vdout0_124ck1220 FIND v(dout0_124) AT=615.025n

.meas tran vdout0_125ck1220 FIND v(dout0_125) AT=615.025n

.meas tran vdout0_126ck1220 FIND v(dout0_126) AT=615.025n

.meas tran vdout0_127ck1220 FIND v(dout0_127) AT=615.025n

.meas tran vdout0_0ck1230 FIND v(dout0_0) AT=620.025n

.meas tran vdout0_1ck1230 FIND v(dout0_1) AT=620.025n

.meas tran vdout0_2ck1230 FIND v(dout0_2) AT=620.025n

.meas tran vdout0_3ck1230 FIND v(dout0_3) AT=620.025n

.meas tran vdout0_4ck1230 FIND v(dout0_4) AT=620.025n

.meas tran vdout0_5ck1230 FIND v(dout0_5) AT=620.025n

.meas tran vdout0_6ck1230 FIND v(dout0_6) AT=620.025n

.meas tran vdout0_7ck1230 FIND v(dout0_7) AT=620.025n

.meas tran vdout0_8ck1230 FIND v(dout0_8) AT=620.025n

.meas tran vdout0_9ck1230 FIND v(dout0_9) AT=620.025n

.meas tran vdout0_10ck1230 FIND v(dout0_10) AT=620.025n

.meas tran vdout0_11ck1230 FIND v(dout0_11) AT=620.025n

.meas tran vdout0_12ck1230 FIND v(dout0_12) AT=620.025n

.meas tran vdout0_13ck1230 FIND v(dout0_13) AT=620.025n

.meas tran vdout0_14ck1230 FIND v(dout0_14) AT=620.025n

.meas tran vdout0_15ck1230 FIND v(dout0_15) AT=620.025n

.meas tran vdout0_16ck1230 FIND v(dout0_16) AT=620.025n

.meas tran vdout0_17ck1230 FIND v(dout0_17) AT=620.025n

.meas tran vdout0_18ck1230 FIND v(dout0_18) AT=620.025n

.meas tran vdout0_19ck1230 FIND v(dout0_19) AT=620.025n

.meas tran vdout0_20ck1230 FIND v(dout0_20) AT=620.025n

.meas tran vdout0_21ck1230 FIND v(dout0_21) AT=620.025n

.meas tran vdout0_22ck1230 FIND v(dout0_22) AT=620.025n

.meas tran vdout0_23ck1230 FIND v(dout0_23) AT=620.025n

.meas tran vdout0_24ck1230 FIND v(dout0_24) AT=620.025n

.meas tran vdout0_25ck1230 FIND v(dout0_25) AT=620.025n

.meas tran vdout0_26ck1230 FIND v(dout0_26) AT=620.025n

.meas tran vdout0_27ck1230 FIND v(dout0_27) AT=620.025n

.meas tran vdout0_28ck1230 FIND v(dout0_28) AT=620.025n

.meas tran vdout0_29ck1230 FIND v(dout0_29) AT=620.025n

.meas tran vdout0_30ck1230 FIND v(dout0_30) AT=620.025n

.meas tran vdout0_31ck1230 FIND v(dout0_31) AT=620.025n

.meas tran vdout0_32ck1230 FIND v(dout0_32) AT=620.025n

.meas tran vdout0_33ck1230 FIND v(dout0_33) AT=620.025n

.meas tran vdout0_34ck1230 FIND v(dout0_34) AT=620.025n

.meas tran vdout0_35ck1230 FIND v(dout0_35) AT=620.025n

.meas tran vdout0_36ck1230 FIND v(dout0_36) AT=620.025n

.meas tran vdout0_37ck1230 FIND v(dout0_37) AT=620.025n

.meas tran vdout0_38ck1230 FIND v(dout0_38) AT=620.025n

.meas tran vdout0_39ck1230 FIND v(dout0_39) AT=620.025n

.meas tran vdout0_40ck1230 FIND v(dout0_40) AT=620.025n

.meas tran vdout0_41ck1230 FIND v(dout0_41) AT=620.025n

.meas tran vdout0_42ck1230 FIND v(dout0_42) AT=620.025n

.meas tran vdout0_43ck1230 FIND v(dout0_43) AT=620.025n

.meas tran vdout0_44ck1230 FIND v(dout0_44) AT=620.025n

.meas tran vdout0_45ck1230 FIND v(dout0_45) AT=620.025n

.meas tran vdout0_46ck1230 FIND v(dout0_46) AT=620.025n

.meas tran vdout0_47ck1230 FIND v(dout0_47) AT=620.025n

.meas tran vdout0_48ck1230 FIND v(dout0_48) AT=620.025n

.meas tran vdout0_49ck1230 FIND v(dout0_49) AT=620.025n

.meas tran vdout0_50ck1230 FIND v(dout0_50) AT=620.025n

.meas tran vdout0_51ck1230 FIND v(dout0_51) AT=620.025n

.meas tran vdout0_52ck1230 FIND v(dout0_52) AT=620.025n

.meas tran vdout0_53ck1230 FIND v(dout0_53) AT=620.025n

.meas tran vdout0_54ck1230 FIND v(dout0_54) AT=620.025n

.meas tran vdout0_55ck1230 FIND v(dout0_55) AT=620.025n

.meas tran vdout0_56ck1230 FIND v(dout0_56) AT=620.025n

.meas tran vdout0_57ck1230 FIND v(dout0_57) AT=620.025n

.meas tran vdout0_58ck1230 FIND v(dout0_58) AT=620.025n

.meas tran vdout0_59ck1230 FIND v(dout0_59) AT=620.025n

.meas tran vdout0_60ck1230 FIND v(dout0_60) AT=620.025n

.meas tran vdout0_61ck1230 FIND v(dout0_61) AT=620.025n

.meas tran vdout0_62ck1230 FIND v(dout0_62) AT=620.025n

.meas tran vdout0_63ck1230 FIND v(dout0_63) AT=620.025n

.meas tran vdout0_64ck1230 FIND v(dout0_64) AT=620.025n

.meas tran vdout0_65ck1230 FIND v(dout0_65) AT=620.025n

.meas tran vdout0_66ck1230 FIND v(dout0_66) AT=620.025n

.meas tran vdout0_67ck1230 FIND v(dout0_67) AT=620.025n

.meas tran vdout0_68ck1230 FIND v(dout0_68) AT=620.025n

.meas tran vdout0_69ck1230 FIND v(dout0_69) AT=620.025n

.meas tran vdout0_70ck1230 FIND v(dout0_70) AT=620.025n

.meas tran vdout0_71ck1230 FIND v(dout0_71) AT=620.025n

.meas tran vdout0_72ck1230 FIND v(dout0_72) AT=620.025n

.meas tran vdout0_73ck1230 FIND v(dout0_73) AT=620.025n

.meas tran vdout0_74ck1230 FIND v(dout0_74) AT=620.025n

.meas tran vdout0_75ck1230 FIND v(dout0_75) AT=620.025n

.meas tran vdout0_76ck1230 FIND v(dout0_76) AT=620.025n

.meas tran vdout0_77ck1230 FIND v(dout0_77) AT=620.025n

.meas tran vdout0_78ck1230 FIND v(dout0_78) AT=620.025n

.meas tran vdout0_79ck1230 FIND v(dout0_79) AT=620.025n

.meas tran vdout0_80ck1230 FIND v(dout0_80) AT=620.025n

.meas tran vdout0_81ck1230 FIND v(dout0_81) AT=620.025n

.meas tran vdout0_82ck1230 FIND v(dout0_82) AT=620.025n

.meas tran vdout0_83ck1230 FIND v(dout0_83) AT=620.025n

.meas tran vdout0_84ck1230 FIND v(dout0_84) AT=620.025n

.meas tran vdout0_85ck1230 FIND v(dout0_85) AT=620.025n

.meas tran vdout0_86ck1230 FIND v(dout0_86) AT=620.025n

.meas tran vdout0_87ck1230 FIND v(dout0_87) AT=620.025n

.meas tran vdout0_88ck1230 FIND v(dout0_88) AT=620.025n

.meas tran vdout0_89ck1230 FIND v(dout0_89) AT=620.025n

.meas tran vdout0_90ck1230 FIND v(dout0_90) AT=620.025n

.meas tran vdout0_91ck1230 FIND v(dout0_91) AT=620.025n

.meas tran vdout0_92ck1230 FIND v(dout0_92) AT=620.025n

.meas tran vdout0_93ck1230 FIND v(dout0_93) AT=620.025n

.meas tran vdout0_94ck1230 FIND v(dout0_94) AT=620.025n

.meas tran vdout0_95ck1230 FIND v(dout0_95) AT=620.025n

.meas tran vdout0_96ck1230 FIND v(dout0_96) AT=620.025n

.meas tran vdout0_97ck1230 FIND v(dout0_97) AT=620.025n

.meas tran vdout0_98ck1230 FIND v(dout0_98) AT=620.025n

.meas tran vdout0_99ck1230 FIND v(dout0_99) AT=620.025n

.meas tran vdout0_100ck1230 FIND v(dout0_100) AT=620.025n

.meas tran vdout0_101ck1230 FIND v(dout0_101) AT=620.025n

.meas tran vdout0_102ck1230 FIND v(dout0_102) AT=620.025n

.meas tran vdout0_103ck1230 FIND v(dout0_103) AT=620.025n

.meas tran vdout0_104ck1230 FIND v(dout0_104) AT=620.025n

.meas tran vdout0_105ck1230 FIND v(dout0_105) AT=620.025n

.meas tran vdout0_106ck1230 FIND v(dout0_106) AT=620.025n

.meas tran vdout0_107ck1230 FIND v(dout0_107) AT=620.025n

.meas tran vdout0_108ck1230 FIND v(dout0_108) AT=620.025n

.meas tran vdout0_109ck1230 FIND v(dout0_109) AT=620.025n

.meas tran vdout0_110ck1230 FIND v(dout0_110) AT=620.025n

.meas tran vdout0_111ck1230 FIND v(dout0_111) AT=620.025n

.meas tran vdout0_112ck1230 FIND v(dout0_112) AT=620.025n

.meas tran vdout0_113ck1230 FIND v(dout0_113) AT=620.025n

.meas tran vdout0_114ck1230 FIND v(dout0_114) AT=620.025n

.meas tran vdout0_115ck1230 FIND v(dout0_115) AT=620.025n

.meas tran vdout0_116ck1230 FIND v(dout0_116) AT=620.025n

.meas tran vdout0_117ck1230 FIND v(dout0_117) AT=620.025n

.meas tran vdout0_118ck1230 FIND v(dout0_118) AT=620.025n

.meas tran vdout0_119ck1230 FIND v(dout0_119) AT=620.025n

.meas tran vdout0_120ck1230 FIND v(dout0_120) AT=620.025n

.meas tran vdout0_121ck1230 FIND v(dout0_121) AT=620.025n

.meas tran vdout0_122ck1230 FIND v(dout0_122) AT=620.025n

.meas tran vdout0_123ck1230 FIND v(dout0_123) AT=620.025n

.meas tran vdout0_124ck1230 FIND v(dout0_124) AT=620.025n

.meas tran vdout0_125ck1230 FIND v(dout0_125) AT=620.025n

.meas tran vdout0_126ck1230 FIND v(dout0_126) AT=620.025n

.meas tran vdout0_127ck1230 FIND v(dout0_127) AT=620.025n

.meas tran vdout0_0ck1250 FIND v(dout0_0) AT=630.025n

.meas tran vdout0_1ck1250 FIND v(dout0_1) AT=630.025n

.meas tran vdout0_2ck1250 FIND v(dout0_2) AT=630.025n

.meas tran vdout0_3ck1250 FIND v(dout0_3) AT=630.025n

.meas tran vdout0_4ck1250 FIND v(dout0_4) AT=630.025n

.meas tran vdout0_5ck1250 FIND v(dout0_5) AT=630.025n

.meas tran vdout0_6ck1250 FIND v(dout0_6) AT=630.025n

.meas tran vdout0_7ck1250 FIND v(dout0_7) AT=630.025n

.meas tran vdout0_8ck1250 FIND v(dout0_8) AT=630.025n

.meas tran vdout0_9ck1250 FIND v(dout0_9) AT=630.025n

.meas tran vdout0_10ck1250 FIND v(dout0_10) AT=630.025n

.meas tran vdout0_11ck1250 FIND v(dout0_11) AT=630.025n

.meas tran vdout0_12ck1250 FIND v(dout0_12) AT=630.025n

.meas tran vdout0_13ck1250 FIND v(dout0_13) AT=630.025n

.meas tran vdout0_14ck1250 FIND v(dout0_14) AT=630.025n

.meas tran vdout0_15ck1250 FIND v(dout0_15) AT=630.025n

.meas tran vdout0_16ck1250 FIND v(dout0_16) AT=630.025n

.meas tran vdout0_17ck1250 FIND v(dout0_17) AT=630.025n

.meas tran vdout0_18ck1250 FIND v(dout0_18) AT=630.025n

.meas tran vdout0_19ck1250 FIND v(dout0_19) AT=630.025n

.meas tran vdout0_20ck1250 FIND v(dout0_20) AT=630.025n

.meas tran vdout0_21ck1250 FIND v(dout0_21) AT=630.025n

.meas tran vdout0_22ck1250 FIND v(dout0_22) AT=630.025n

.meas tran vdout0_23ck1250 FIND v(dout0_23) AT=630.025n

.meas tran vdout0_24ck1250 FIND v(dout0_24) AT=630.025n

.meas tran vdout0_25ck1250 FIND v(dout0_25) AT=630.025n

.meas tran vdout0_26ck1250 FIND v(dout0_26) AT=630.025n

.meas tran vdout0_27ck1250 FIND v(dout0_27) AT=630.025n

.meas tran vdout0_28ck1250 FIND v(dout0_28) AT=630.025n

.meas tran vdout0_29ck1250 FIND v(dout0_29) AT=630.025n

.meas tran vdout0_30ck1250 FIND v(dout0_30) AT=630.025n

.meas tran vdout0_31ck1250 FIND v(dout0_31) AT=630.025n

.meas tran vdout0_32ck1250 FIND v(dout0_32) AT=630.025n

.meas tran vdout0_33ck1250 FIND v(dout0_33) AT=630.025n

.meas tran vdout0_34ck1250 FIND v(dout0_34) AT=630.025n

.meas tran vdout0_35ck1250 FIND v(dout0_35) AT=630.025n

.meas tran vdout0_36ck1250 FIND v(dout0_36) AT=630.025n

.meas tran vdout0_37ck1250 FIND v(dout0_37) AT=630.025n

.meas tran vdout0_38ck1250 FIND v(dout0_38) AT=630.025n

.meas tran vdout0_39ck1250 FIND v(dout0_39) AT=630.025n

.meas tran vdout0_40ck1250 FIND v(dout0_40) AT=630.025n

.meas tran vdout0_41ck1250 FIND v(dout0_41) AT=630.025n

.meas tran vdout0_42ck1250 FIND v(dout0_42) AT=630.025n

.meas tran vdout0_43ck1250 FIND v(dout0_43) AT=630.025n

.meas tran vdout0_44ck1250 FIND v(dout0_44) AT=630.025n

.meas tran vdout0_45ck1250 FIND v(dout0_45) AT=630.025n

.meas tran vdout0_46ck1250 FIND v(dout0_46) AT=630.025n

.meas tran vdout0_47ck1250 FIND v(dout0_47) AT=630.025n

.meas tran vdout0_48ck1250 FIND v(dout0_48) AT=630.025n

.meas tran vdout0_49ck1250 FIND v(dout0_49) AT=630.025n

.meas tran vdout0_50ck1250 FIND v(dout0_50) AT=630.025n

.meas tran vdout0_51ck1250 FIND v(dout0_51) AT=630.025n

.meas tran vdout0_52ck1250 FIND v(dout0_52) AT=630.025n

.meas tran vdout0_53ck1250 FIND v(dout0_53) AT=630.025n

.meas tran vdout0_54ck1250 FIND v(dout0_54) AT=630.025n

.meas tran vdout0_55ck1250 FIND v(dout0_55) AT=630.025n

.meas tran vdout0_56ck1250 FIND v(dout0_56) AT=630.025n

.meas tran vdout0_57ck1250 FIND v(dout0_57) AT=630.025n

.meas tran vdout0_58ck1250 FIND v(dout0_58) AT=630.025n

.meas tran vdout0_59ck1250 FIND v(dout0_59) AT=630.025n

.meas tran vdout0_60ck1250 FIND v(dout0_60) AT=630.025n

.meas tran vdout0_61ck1250 FIND v(dout0_61) AT=630.025n

.meas tran vdout0_62ck1250 FIND v(dout0_62) AT=630.025n

.meas tran vdout0_63ck1250 FIND v(dout0_63) AT=630.025n

.meas tran vdout0_64ck1250 FIND v(dout0_64) AT=630.025n

.meas tran vdout0_65ck1250 FIND v(dout0_65) AT=630.025n

.meas tran vdout0_66ck1250 FIND v(dout0_66) AT=630.025n

.meas tran vdout0_67ck1250 FIND v(dout0_67) AT=630.025n

.meas tran vdout0_68ck1250 FIND v(dout0_68) AT=630.025n

.meas tran vdout0_69ck1250 FIND v(dout0_69) AT=630.025n

.meas tran vdout0_70ck1250 FIND v(dout0_70) AT=630.025n

.meas tran vdout0_71ck1250 FIND v(dout0_71) AT=630.025n

.meas tran vdout0_72ck1250 FIND v(dout0_72) AT=630.025n

.meas tran vdout0_73ck1250 FIND v(dout0_73) AT=630.025n

.meas tran vdout0_74ck1250 FIND v(dout0_74) AT=630.025n

.meas tran vdout0_75ck1250 FIND v(dout0_75) AT=630.025n

.meas tran vdout0_76ck1250 FIND v(dout0_76) AT=630.025n

.meas tran vdout0_77ck1250 FIND v(dout0_77) AT=630.025n

.meas tran vdout0_78ck1250 FIND v(dout0_78) AT=630.025n

.meas tran vdout0_79ck1250 FIND v(dout0_79) AT=630.025n

.meas tran vdout0_80ck1250 FIND v(dout0_80) AT=630.025n

.meas tran vdout0_81ck1250 FIND v(dout0_81) AT=630.025n

.meas tran vdout0_82ck1250 FIND v(dout0_82) AT=630.025n

.meas tran vdout0_83ck1250 FIND v(dout0_83) AT=630.025n

.meas tran vdout0_84ck1250 FIND v(dout0_84) AT=630.025n

.meas tran vdout0_85ck1250 FIND v(dout0_85) AT=630.025n

.meas tran vdout0_86ck1250 FIND v(dout0_86) AT=630.025n

.meas tran vdout0_87ck1250 FIND v(dout0_87) AT=630.025n

.meas tran vdout0_88ck1250 FIND v(dout0_88) AT=630.025n

.meas tran vdout0_89ck1250 FIND v(dout0_89) AT=630.025n

.meas tran vdout0_90ck1250 FIND v(dout0_90) AT=630.025n

.meas tran vdout0_91ck1250 FIND v(dout0_91) AT=630.025n

.meas tran vdout0_92ck1250 FIND v(dout0_92) AT=630.025n

.meas tran vdout0_93ck1250 FIND v(dout0_93) AT=630.025n

.meas tran vdout0_94ck1250 FIND v(dout0_94) AT=630.025n

.meas tran vdout0_95ck1250 FIND v(dout0_95) AT=630.025n

.meas tran vdout0_96ck1250 FIND v(dout0_96) AT=630.025n

.meas tran vdout0_97ck1250 FIND v(dout0_97) AT=630.025n

.meas tran vdout0_98ck1250 FIND v(dout0_98) AT=630.025n

.meas tran vdout0_99ck1250 FIND v(dout0_99) AT=630.025n

.meas tran vdout0_100ck1250 FIND v(dout0_100) AT=630.025n

.meas tran vdout0_101ck1250 FIND v(dout0_101) AT=630.025n

.meas tran vdout0_102ck1250 FIND v(dout0_102) AT=630.025n

.meas tran vdout0_103ck1250 FIND v(dout0_103) AT=630.025n

.meas tran vdout0_104ck1250 FIND v(dout0_104) AT=630.025n

.meas tran vdout0_105ck1250 FIND v(dout0_105) AT=630.025n

.meas tran vdout0_106ck1250 FIND v(dout0_106) AT=630.025n

.meas tran vdout0_107ck1250 FIND v(dout0_107) AT=630.025n

.meas tran vdout0_108ck1250 FIND v(dout0_108) AT=630.025n

.meas tran vdout0_109ck1250 FIND v(dout0_109) AT=630.025n

.meas tran vdout0_110ck1250 FIND v(dout0_110) AT=630.025n

.meas tran vdout0_111ck1250 FIND v(dout0_111) AT=630.025n

.meas tran vdout0_112ck1250 FIND v(dout0_112) AT=630.025n

.meas tran vdout0_113ck1250 FIND v(dout0_113) AT=630.025n

.meas tran vdout0_114ck1250 FIND v(dout0_114) AT=630.025n

.meas tran vdout0_115ck1250 FIND v(dout0_115) AT=630.025n

.meas tran vdout0_116ck1250 FIND v(dout0_116) AT=630.025n

.meas tran vdout0_117ck1250 FIND v(dout0_117) AT=630.025n

.meas tran vdout0_118ck1250 FIND v(dout0_118) AT=630.025n

.meas tran vdout0_119ck1250 FIND v(dout0_119) AT=630.025n

.meas tran vdout0_120ck1250 FIND v(dout0_120) AT=630.025n

.meas tran vdout0_121ck1250 FIND v(dout0_121) AT=630.025n

.meas tran vdout0_122ck1250 FIND v(dout0_122) AT=630.025n

.meas tran vdout0_123ck1250 FIND v(dout0_123) AT=630.025n

.meas tran vdout0_124ck1250 FIND v(dout0_124) AT=630.025n

.meas tran vdout0_125ck1250 FIND v(dout0_125) AT=630.025n

.meas tran vdout0_126ck1250 FIND v(dout0_126) AT=630.025n

.meas tran vdout0_127ck1250 FIND v(dout0_127) AT=630.025n

.meas tran vdout0_0ck1260 FIND v(dout0_0) AT=635.025n

.meas tran vdout0_1ck1260 FIND v(dout0_1) AT=635.025n

.meas tran vdout0_2ck1260 FIND v(dout0_2) AT=635.025n

.meas tran vdout0_3ck1260 FIND v(dout0_3) AT=635.025n

.meas tran vdout0_4ck1260 FIND v(dout0_4) AT=635.025n

.meas tran vdout0_5ck1260 FIND v(dout0_5) AT=635.025n

.meas tran vdout0_6ck1260 FIND v(dout0_6) AT=635.025n

.meas tran vdout0_7ck1260 FIND v(dout0_7) AT=635.025n

.meas tran vdout0_8ck1260 FIND v(dout0_8) AT=635.025n

.meas tran vdout0_9ck1260 FIND v(dout0_9) AT=635.025n

.meas tran vdout0_10ck1260 FIND v(dout0_10) AT=635.025n

.meas tran vdout0_11ck1260 FIND v(dout0_11) AT=635.025n

.meas tran vdout0_12ck1260 FIND v(dout0_12) AT=635.025n

.meas tran vdout0_13ck1260 FIND v(dout0_13) AT=635.025n

.meas tran vdout0_14ck1260 FIND v(dout0_14) AT=635.025n

.meas tran vdout0_15ck1260 FIND v(dout0_15) AT=635.025n

.meas tran vdout0_16ck1260 FIND v(dout0_16) AT=635.025n

.meas tran vdout0_17ck1260 FIND v(dout0_17) AT=635.025n

.meas tran vdout0_18ck1260 FIND v(dout0_18) AT=635.025n

.meas tran vdout0_19ck1260 FIND v(dout0_19) AT=635.025n

.meas tran vdout0_20ck1260 FIND v(dout0_20) AT=635.025n

.meas tran vdout0_21ck1260 FIND v(dout0_21) AT=635.025n

.meas tran vdout0_22ck1260 FIND v(dout0_22) AT=635.025n

.meas tran vdout0_23ck1260 FIND v(dout0_23) AT=635.025n

.meas tran vdout0_24ck1260 FIND v(dout0_24) AT=635.025n

.meas tran vdout0_25ck1260 FIND v(dout0_25) AT=635.025n

.meas tran vdout0_26ck1260 FIND v(dout0_26) AT=635.025n

.meas tran vdout0_27ck1260 FIND v(dout0_27) AT=635.025n

.meas tran vdout0_28ck1260 FIND v(dout0_28) AT=635.025n

.meas tran vdout0_29ck1260 FIND v(dout0_29) AT=635.025n

.meas tran vdout0_30ck1260 FIND v(dout0_30) AT=635.025n

.meas tran vdout0_31ck1260 FIND v(dout0_31) AT=635.025n

.meas tran vdout0_32ck1260 FIND v(dout0_32) AT=635.025n

.meas tran vdout0_33ck1260 FIND v(dout0_33) AT=635.025n

.meas tran vdout0_34ck1260 FIND v(dout0_34) AT=635.025n

.meas tran vdout0_35ck1260 FIND v(dout0_35) AT=635.025n

.meas tran vdout0_36ck1260 FIND v(dout0_36) AT=635.025n

.meas tran vdout0_37ck1260 FIND v(dout0_37) AT=635.025n

.meas tran vdout0_38ck1260 FIND v(dout0_38) AT=635.025n

.meas tran vdout0_39ck1260 FIND v(dout0_39) AT=635.025n

.meas tran vdout0_40ck1260 FIND v(dout0_40) AT=635.025n

.meas tran vdout0_41ck1260 FIND v(dout0_41) AT=635.025n

.meas tran vdout0_42ck1260 FIND v(dout0_42) AT=635.025n

.meas tran vdout0_43ck1260 FIND v(dout0_43) AT=635.025n

.meas tran vdout0_44ck1260 FIND v(dout0_44) AT=635.025n

.meas tran vdout0_45ck1260 FIND v(dout0_45) AT=635.025n

.meas tran vdout0_46ck1260 FIND v(dout0_46) AT=635.025n

.meas tran vdout0_47ck1260 FIND v(dout0_47) AT=635.025n

.meas tran vdout0_48ck1260 FIND v(dout0_48) AT=635.025n

.meas tran vdout0_49ck1260 FIND v(dout0_49) AT=635.025n

.meas tran vdout0_50ck1260 FIND v(dout0_50) AT=635.025n

.meas tran vdout0_51ck1260 FIND v(dout0_51) AT=635.025n

.meas tran vdout0_52ck1260 FIND v(dout0_52) AT=635.025n

.meas tran vdout0_53ck1260 FIND v(dout0_53) AT=635.025n

.meas tran vdout0_54ck1260 FIND v(dout0_54) AT=635.025n

.meas tran vdout0_55ck1260 FIND v(dout0_55) AT=635.025n

.meas tran vdout0_56ck1260 FIND v(dout0_56) AT=635.025n

.meas tran vdout0_57ck1260 FIND v(dout0_57) AT=635.025n

.meas tran vdout0_58ck1260 FIND v(dout0_58) AT=635.025n

.meas tran vdout0_59ck1260 FIND v(dout0_59) AT=635.025n

.meas tran vdout0_60ck1260 FIND v(dout0_60) AT=635.025n

.meas tran vdout0_61ck1260 FIND v(dout0_61) AT=635.025n

.meas tran vdout0_62ck1260 FIND v(dout0_62) AT=635.025n

.meas tran vdout0_63ck1260 FIND v(dout0_63) AT=635.025n

.meas tran vdout0_64ck1260 FIND v(dout0_64) AT=635.025n

.meas tran vdout0_65ck1260 FIND v(dout0_65) AT=635.025n

.meas tran vdout0_66ck1260 FIND v(dout0_66) AT=635.025n

.meas tran vdout0_67ck1260 FIND v(dout0_67) AT=635.025n

.meas tran vdout0_68ck1260 FIND v(dout0_68) AT=635.025n

.meas tran vdout0_69ck1260 FIND v(dout0_69) AT=635.025n

.meas tran vdout0_70ck1260 FIND v(dout0_70) AT=635.025n

.meas tran vdout0_71ck1260 FIND v(dout0_71) AT=635.025n

.meas tran vdout0_72ck1260 FIND v(dout0_72) AT=635.025n

.meas tran vdout0_73ck1260 FIND v(dout0_73) AT=635.025n

.meas tran vdout0_74ck1260 FIND v(dout0_74) AT=635.025n

.meas tran vdout0_75ck1260 FIND v(dout0_75) AT=635.025n

.meas tran vdout0_76ck1260 FIND v(dout0_76) AT=635.025n

.meas tran vdout0_77ck1260 FIND v(dout0_77) AT=635.025n

.meas tran vdout0_78ck1260 FIND v(dout0_78) AT=635.025n

.meas tran vdout0_79ck1260 FIND v(dout0_79) AT=635.025n

.meas tran vdout0_80ck1260 FIND v(dout0_80) AT=635.025n

.meas tran vdout0_81ck1260 FIND v(dout0_81) AT=635.025n

.meas tran vdout0_82ck1260 FIND v(dout0_82) AT=635.025n

.meas tran vdout0_83ck1260 FIND v(dout0_83) AT=635.025n

.meas tran vdout0_84ck1260 FIND v(dout0_84) AT=635.025n

.meas tran vdout0_85ck1260 FIND v(dout0_85) AT=635.025n

.meas tran vdout0_86ck1260 FIND v(dout0_86) AT=635.025n

.meas tran vdout0_87ck1260 FIND v(dout0_87) AT=635.025n

.meas tran vdout0_88ck1260 FIND v(dout0_88) AT=635.025n

.meas tran vdout0_89ck1260 FIND v(dout0_89) AT=635.025n

.meas tran vdout0_90ck1260 FIND v(dout0_90) AT=635.025n

.meas tran vdout0_91ck1260 FIND v(dout0_91) AT=635.025n

.meas tran vdout0_92ck1260 FIND v(dout0_92) AT=635.025n

.meas tran vdout0_93ck1260 FIND v(dout0_93) AT=635.025n

.meas tran vdout0_94ck1260 FIND v(dout0_94) AT=635.025n

.meas tran vdout0_95ck1260 FIND v(dout0_95) AT=635.025n

.meas tran vdout0_96ck1260 FIND v(dout0_96) AT=635.025n

.meas tran vdout0_97ck1260 FIND v(dout0_97) AT=635.025n

.meas tran vdout0_98ck1260 FIND v(dout0_98) AT=635.025n

.meas tran vdout0_99ck1260 FIND v(dout0_99) AT=635.025n

.meas tran vdout0_100ck1260 FIND v(dout0_100) AT=635.025n

.meas tran vdout0_101ck1260 FIND v(dout0_101) AT=635.025n

.meas tran vdout0_102ck1260 FIND v(dout0_102) AT=635.025n

.meas tran vdout0_103ck1260 FIND v(dout0_103) AT=635.025n

.meas tran vdout0_104ck1260 FIND v(dout0_104) AT=635.025n

.meas tran vdout0_105ck1260 FIND v(dout0_105) AT=635.025n

.meas tran vdout0_106ck1260 FIND v(dout0_106) AT=635.025n

.meas tran vdout0_107ck1260 FIND v(dout0_107) AT=635.025n

.meas tran vdout0_108ck1260 FIND v(dout0_108) AT=635.025n

.meas tran vdout0_109ck1260 FIND v(dout0_109) AT=635.025n

.meas tran vdout0_110ck1260 FIND v(dout0_110) AT=635.025n

.meas tran vdout0_111ck1260 FIND v(dout0_111) AT=635.025n

.meas tran vdout0_112ck1260 FIND v(dout0_112) AT=635.025n

.meas tran vdout0_113ck1260 FIND v(dout0_113) AT=635.025n

.meas tran vdout0_114ck1260 FIND v(dout0_114) AT=635.025n

.meas tran vdout0_115ck1260 FIND v(dout0_115) AT=635.025n

.meas tran vdout0_116ck1260 FIND v(dout0_116) AT=635.025n

.meas tran vdout0_117ck1260 FIND v(dout0_117) AT=635.025n

.meas tran vdout0_118ck1260 FIND v(dout0_118) AT=635.025n

.meas tran vdout0_119ck1260 FIND v(dout0_119) AT=635.025n

.meas tran vdout0_120ck1260 FIND v(dout0_120) AT=635.025n

.meas tran vdout0_121ck1260 FIND v(dout0_121) AT=635.025n

.meas tran vdout0_122ck1260 FIND v(dout0_122) AT=635.025n

.meas tran vdout0_123ck1260 FIND v(dout0_123) AT=635.025n

.meas tran vdout0_124ck1260 FIND v(dout0_124) AT=635.025n

.meas tran vdout0_125ck1260 FIND v(dout0_125) AT=635.025n

.meas tran vdout0_126ck1260 FIND v(dout0_126) AT=635.025n

.meas tran vdout0_127ck1260 FIND v(dout0_127) AT=635.025n

.meas tran vdout0_0ck1280 FIND v(dout0_0) AT=645.025n

.meas tran vdout0_1ck1280 FIND v(dout0_1) AT=645.025n

.meas tran vdout0_2ck1280 FIND v(dout0_2) AT=645.025n

.meas tran vdout0_3ck1280 FIND v(dout0_3) AT=645.025n

.meas tran vdout0_4ck1280 FIND v(dout0_4) AT=645.025n

.meas tran vdout0_5ck1280 FIND v(dout0_5) AT=645.025n

.meas tran vdout0_6ck1280 FIND v(dout0_6) AT=645.025n

.meas tran vdout0_7ck1280 FIND v(dout0_7) AT=645.025n

.meas tran vdout0_8ck1280 FIND v(dout0_8) AT=645.025n

.meas tran vdout0_9ck1280 FIND v(dout0_9) AT=645.025n

.meas tran vdout0_10ck1280 FIND v(dout0_10) AT=645.025n

.meas tran vdout0_11ck1280 FIND v(dout0_11) AT=645.025n

.meas tran vdout0_12ck1280 FIND v(dout0_12) AT=645.025n

.meas tran vdout0_13ck1280 FIND v(dout0_13) AT=645.025n

.meas tran vdout0_14ck1280 FIND v(dout0_14) AT=645.025n

.meas tran vdout0_15ck1280 FIND v(dout0_15) AT=645.025n

.meas tran vdout0_16ck1280 FIND v(dout0_16) AT=645.025n

.meas tran vdout0_17ck1280 FIND v(dout0_17) AT=645.025n

.meas tran vdout0_18ck1280 FIND v(dout0_18) AT=645.025n

.meas tran vdout0_19ck1280 FIND v(dout0_19) AT=645.025n

.meas tran vdout0_20ck1280 FIND v(dout0_20) AT=645.025n

.meas tran vdout0_21ck1280 FIND v(dout0_21) AT=645.025n

.meas tran vdout0_22ck1280 FIND v(dout0_22) AT=645.025n

.meas tran vdout0_23ck1280 FIND v(dout0_23) AT=645.025n

.meas tran vdout0_24ck1280 FIND v(dout0_24) AT=645.025n

.meas tran vdout0_25ck1280 FIND v(dout0_25) AT=645.025n

.meas tran vdout0_26ck1280 FIND v(dout0_26) AT=645.025n

.meas tran vdout0_27ck1280 FIND v(dout0_27) AT=645.025n

.meas tran vdout0_28ck1280 FIND v(dout0_28) AT=645.025n

.meas tran vdout0_29ck1280 FIND v(dout0_29) AT=645.025n

.meas tran vdout0_30ck1280 FIND v(dout0_30) AT=645.025n

.meas tran vdout0_31ck1280 FIND v(dout0_31) AT=645.025n

.meas tran vdout0_32ck1280 FIND v(dout0_32) AT=645.025n

.meas tran vdout0_33ck1280 FIND v(dout0_33) AT=645.025n

.meas tran vdout0_34ck1280 FIND v(dout0_34) AT=645.025n

.meas tran vdout0_35ck1280 FIND v(dout0_35) AT=645.025n

.meas tran vdout0_36ck1280 FIND v(dout0_36) AT=645.025n

.meas tran vdout0_37ck1280 FIND v(dout0_37) AT=645.025n

.meas tran vdout0_38ck1280 FIND v(dout0_38) AT=645.025n

.meas tran vdout0_39ck1280 FIND v(dout0_39) AT=645.025n

.meas tran vdout0_40ck1280 FIND v(dout0_40) AT=645.025n

.meas tran vdout0_41ck1280 FIND v(dout0_41) AT=645.025n

.meas tran vdout0_42ck1280 FIND v(dout0_42) AT=645.025n

.meas tran vdout0_43ck1280 FIND v(dout0_43) AT=645.025n

.meas tran vdout0_44ck1280 FIND v(dout0_44) AT=645.025n

.meas tran vdout0_45ck1280 FIND v(dout0_45) AT=645.025n

.meas tran vdout0_46ck1280 FIND v(dout0_46) AT=645.025n

.meas tran vdout0_47ck1280 FIND v(dout0_47) AT=645.025n

.meas tran vdout0_48ck1280 FIND v(dout0_48) AT=645.025n

.meas tran vdout0_49ck1280 FIND v(dout0_49) AT=645.025n

.meas tran vdout0_50ck1280 FIND v(dout0_50) AT=645.025n

.meas tran vdout0_51ck1280 FIND v(dout0_51) AT=645.025n

.meas tran vdout0_52ck1280 FIND v(dout0_52) AT=645.025n

.meas tran vdout0_53ck1280 FIND v(dout0_53) AT=645.025n

.meas tran vdout0_54ck1280 FIND v(dout0_54) AT=645.025n

.meas tran vdout0_55ck1280 FIND v(dout0_55) AT=645.025n

.meas tran vdout0_56ck1280 FIND v(dout0_56) AT=645.025n

.meas tran vdout0_57ck1280 FIND v(dout0_57) AT=645.025n

.meas tran vdout0_58ck1280 FIND v(dout0_58) AT=645.025n

.meas tran vdout0_59ck1280 FIND v(dout0_59) AT=645.025n

.meas tran vdout0_60ck1280 FIND v(dout0_60) AT=645.025n

.meas tran vdout0_61ck1280 FIND v(dout0_61) AT=645.025n

.meas tran vdout0_62ck1280 FIND v(dout0_62) AT=645.025n

.meas tran vdout0_63ck1280 FIND v(dout0_63) AT=645.025n

.meas tran vdout0_64ck1280 FIND v(dout0_64) AT=645.025n

.meas tran vdout0_65ck1280 FIND v(dout0_65) AT=645.025n

.meas tran vdout0_66ck1280 FIND v(dout0_66) AT=645.025n

.meas tran vdout0_67ck1280 FIND v(dout0_67) AT=645.025n

.meas tran vdout0_68ck1280 FIND v(dout0_68) AT=645.025n

.meas tran vdout0_69ck1280 FIND v(dout0_69) AT=645.025n

.meas tran vdout0_70ck1280 FIND v(dout0_70) AT=645.025n

.meas tran vdout0_71ck1280 FIND v(dout0_71) AT=645.025n

.meas tran vdout0_72ck1280 FIND v(dout0_72) AT=645.025n

.meas tran vdout0_73ck1280 FIND v(dout0_73) AT=645.025n

.meas tran vdout0_74ck1280 FIND v(dout0_74) AT=645.025n

.meas tran vdout0_75ck1280 FIND v(dout0_75) AT=645.025n

.meas tran vdout0_76ck1280 FIND v(dout0_76) AT=645.025n

.meas tran vdout0_77ck1280 FIND v(dout0_77) AT=645.025n

.meas tran vdout0_78ck1280 FIND v(dout0_78) AT=645.025n

.meas tran vdout0_79ck1280 FIND v(dout0_79) AT=645.025n

.meas tran vdout0_80ck1280 FIND v(dout0_80) AT=645.025n

.meas tran vdout0_81ck1280 FIND v(dout0_81) AT=645.025n

.meas tran vdout0_82ck1280 FIND v(dout0_82) AT=645.025n

.meas tran vdout0_83ck1280 FIND v(dout0_83) AT=645.025n

.meas tran vdout0_84ck1280 FIND v(dout0_84) AT=645.025n

.meas tran vdout0_85ck1280 FIND v(dout0_85) AT=645.025n

.meas tran vdout0_86ck1280 FIND v(dout0_86) AT=645.025n

.meas tran vdout0_87ck1280 FIND v(dout0_87) AT=645.025n

.meas tran vdout0_88ck1280 FIND v(dout0_88) AT=645.025n

.meas tran vdout0_89ck1280 FIND v(dout0_89) AT=645.025n

.meas tran vdout0_90ck1280 FIND v(dout0_90) AT=645.025n

.meas tran vdout0_91ck1280 FIND v(dout0_91) AT=645.025n

.meas tran vdout0_92ck1280 FIND v(dout0_92) AT=645.025n

.meas tran vdout0_93ck1280 FIND v(dout0_93) AT=645.025n

.meas tran vdout0_94ck1280 FIND v(dout0_94) AT=645.025n

.meas tran vdout0_95ck1280 FIND v(dout0_95) AT=645.025n

.meas tran vdout0_96ck1280 FIND v(dout0_96) AT=645.025n

.meas tran vdout0_97ck1280 FIND v(dout0_97) AT=645.025n

.meas tran vdout0_98ck1280 FIND v(dout0_98) AT=645.025n

.meas tran vdout0_99ck1280 FIND v(dout0_99) AT=645.025n

.meas tran vdout0_100ck1280 FIND v(dout0_100) AT=645.025n

.meas tran vdout0_101ck1280 FIND v(dout0_101) AT=645.025n

.meas tran vdout0_102ck1280 FIND v(dout0_102) AT=645.025n

.meas tran vdout0_103ck1280 FIND v(dout0_103) AT=645.025n

.meas tran vdout0_104ck1280 FIND v(dout0_104) AT=645.025n

.meas tran vdout0_105ck1280 FIND v(dout0_105) AT=645.025n

.meas tran vdout0_106ck1280 FIND v(dout0_106) AT=645.025n

.meas tran vdout0_107ck1280 FIND v(dout0_107) AT=645.025n

.meas tran vdout0_108ck1280 FIND v(dout0_108) AT=645.025n

.meas tran vdout0_109ck1280 FIND v(dout0_109) AT=645.025n

.meas tran vdout0_110ck1280 FIND v(dout0_110) AT=645.025n

.meas tran vdout0_111ck1280 FIND v(dout0_111) AT=645.025n

.meas tran vdout0_112ck1280 FIND v(dout0_112) AT=645.025n

.meas tran vdout0_113ck1280 FIND v(dout0_113) AT=645.025n

.meas tran vdout0_114ck1280 FIND v(dout0_114) AT=645.025n

.meas tran vdout0_115ck1280 FIND v(dout0_115) AT=645.025n

.meas tran vdout0_116ck1280 FIND v(dout0_116) AT=645.025n

.meas tran vdout0_117ck1280 FIND v(dout0_117) AT=645.025n

.meas tran vdout0_118ck1280 FIND v(dout0_118) AT=645.025n

.meas tran vdout0_119ck1280 FIND v(dout0_119) AT=645.025n

.meas tran vdout0_120ck1280 FIND v(dout0_120) AT=645.025n

.meas tran vdout0_121ck1280 FIND v(dout0_121) AT=645.025n

.meas tran vdout0_122ck1280 FIND v(dout0_122) AT=645.025n

.meas tran vdout0_123ck1280 FIND v(dout0_123) AT=645.025n

.meas tran vdout0_124ck1280 FIND v(dout0_124) AT=645.025n

.meas tran vdout0_125ck1280 FIND v(dout0_125) AT=645.025n

.meas tran vdout0_126ck1280 FIND v(dout0_126) AT=645.025n

.meas tran vdout0_127ck1280 FIND v(dout0_127) AT=645.025n

.meas tran vdout0_0ck1330 FIND v(dout0_0) AT=670.025n

.meas tran vdout0_1ck1330 FIND v(dout0_1) AT=670.025n

.meas tran vdout0_2ck1330 FIND v(dout0_2) AT=670.025n

.meas tran vdout0_3ck1330 FIND v(dout0_3) AT=670.025n

.meas tran vdout0_4ck1330 FIND v(dout0_4) AT=670.025n

.meas tran vdout0_5ck1330 FIND v(dout0_5) AT=670.025n

.meas tran vdout0_6ck1330 FIND v(dout0_6) AT=670.025n

.meas tran vdout0_7ck1330 FIND v(dout0_7) AT=670.025n

.meas tran vdout0_8ck1330 FIND v(dout0_8) AT=670.025n

.meas tran vdout0_9ck1330 FIND v(dout0_9) AT=670.025n

.meas tran vdout0_10ck1330 FIND v(dout0_10) AT=670.025n

.meas tran vdout0_11ck1330 FIND v(dout0_11) AT=670.025n

.meas tran vdout0_12ck1330 FIND v(dout0_12) AT=670.025n

.meas tran vdout0_13ck1330 FIND v(dout0_13) AT=670.025n

.meas tran vdout0_14ck1330 FIND v(dout0_14) AT=670.025n

.meas tran vdout0_15ck1330 FIND v(dout0_15) AT=670.025n

.meas tran vdout0_16ck1330 FIND v(dout0_16) AT=670.025n

.meas tran vdout0_17ck1330 FIND v(dout0_17) AT=670.025n

.meas tran vdout0_18ck1330 FIND v(dout0_18) AT=670.025n

.meas tran vdout0_19ck1330 FIND v(dout0_19) AT=670.025n

.meas tran vdout0_20ck1330 FIND v(dout0_20) AT=670.025n

.meas tran vdout0_21ck1330 FIND v(dout0_21) AT=670.025n

.meas tran vdout0_22ck1330 FIND v(dout0_22) AT=670.025n

.meas tran vdout0_23ck1330 FIND v(dout0_23) AT=670.025n

.meas tran vdout0_24ck1330 FIND v(dout0_24) AT=670.025n

.meas tran vdout0_25ck1330 FIND v(dout0_25) AT=670.025n

.meas tran vdout0_26ck1330 FIND v(dout0_26) AT=670.025n

.meas tran vdout0_27ck1330 FIND v(dout0_27) AT=670.025n

.meas tran vdout0_28ck1330 FIND v(dout0_28) AT=670.025n

.meas tran vdout0_29ck1330 FIND v(dout0_29) AT=670.025n

.meas tran vdout0_30ck1330 FIND v(dout0_30) AT=670.025n

.meas tran vdout0_31ck1330 FIND v(dout0_31) AT=670.025n

.meas tran vdout0_32ck1330 FIND v(dout0_32) AT=670.025n

.meas tran vdout0_33ck1330 FIND v(dout0_33) AT=670.025n

.meas tran vdout0_34ck1330 FIND v(dout0_34) AT=670.025n

.meas tran vdout0_35ck1330 FIND v(dout0_35) AT=670.025n

.meas tran vdout0_36ck1330 FIND v(dout0_36) AT=670.025n

.meas tran vdout0_37ck1330 FIND v(dout0_37) AT=670.025n

.meas tran vdout0_38ck1330 FIND v(dout0_38) AT=670.025n

.meas tran vdout0_39ck1330 FIND v(dout0_39) AT=670.025n

.meas tran vdout0_40ck1330 FIND v(dout0_40) AT=670.025n

.meas tran vdout0_41ck1330 FIND v(dout0_41) AT=670.025n

.meas tran vdout0_42ck1330 FIND v(dout0_42) AT=670.025n

.meas tran vdout0_43ck1330 FIND v(dout0_43) AT=670.025n

.meas tran vdout0_44ck1330 FIND v(dout0_44) AT=670.025n

.meas tran vdout0_45ck1330 FIND v(dout0_45) AT=670.025n

.meas tran vdout0_46ck1330 FIND v(dout0_46) AT=670.025n

.meas tran vdout0_47ck1330 FIND v(dout0_47) AT=670.025n

.meas tran vdout0_48ck1330 FIND v(dout0_48) AT=670.025n

.meas tran vdout0_49ck1330 FIND v(dout0_49) AT=670.025n

.meas tran vdout0_50ck1330 FIND v(dout0_50) AT=670.025n

.meas tran vdout0_51ck1330 FIND v(dout0_51) AT=670.025n

.meas tran vdout0_52ck1330 FIND v(dout0_52) AT=670.025n

.meas tran vdout0_53ck1330 FIND v(dout0_53) AT=670.025n

.meas tran vdout0_54ck1330 FIND v(dout0_54) AT=670.025n

.meas tran vdout0_55ck1330 FIND v(dout0_55) AT=670.025n

.meas tran vdout0_56ck1330 FIND v(dout0_56) AT=670.025n

.meas tran vdout0_57ck1330 FIND v(dout0_57) AT=670.025n

.meas tran vdout0_58ck1330 FIND v(dout0_58) AT=670.025n

.meas tran vdout0_59ck1330 FIND v(dout0_59) AT=670.025n

.meas tran vdout0_60ck1330 FIND v(dout0_60) AT=670.025n

.meas tran vdout0_61ck1330 FIND v(dout0_61) AT=670.025n

.meas tran vdout0_62ck1330 FIND v(dout0_62) AT=670.025n

.meas tran vdout0_63ck1330 FIND v(dout0_63) AT=670.025n

.meas tran vdout0_64ck1330 FIND v(dout0_64) AT=670.025n

.meas tran vdout0_65ck1330 FIND v(dout0_65) AT=670.025n

.meas tran vdout0_66ck1330 FIND v(dout0_66) AT=670.025n

.meas tran vdout0_67ck1330 FIND v(dout0_67) AT=670.025n

.meas tran vdout0_68ck1330 FIND v(dout0_68) AT=670.025n

.meas tran vdout0_69ck1330 FIND v(dout0_69) AT=670.025n

.meas tran vdout0_70ck1330 FIND v(dout0_70) AT=670.025n

.meas tran vdout0_71ck1330 FIND v(dout0_71) AT=670.025n

.meas tran vdout0_72ck1330 FIND v(dout0_72) AT=670.025n

.meas tran vdout0_73ck1330 FIND v(dout0_73) AT=670.025n

.meas tran vdout0_74ck1330 FIND v(dout0_74) AT=670.025n

.meas tran vdout0_75ck1330 FIND v(dout0_75) AT=670.025n

.meas tran vdout0_76ck1330 FIND v(dout0_76) AT=670.025n

.meas tran vdout0_77ck1330 FIND v(dout0_77) AT=670.025n

.meas tran vdout0_78ck1330 FIND v(dout0_78) AT=670.025n

.meas tran vdout0_79ck1330 FIND v(dout0_79) AT=670.025n

.meas tran vdout0_80ck1330 FIND v(dout0_80) AT=670.025n

.meas tran vdout0_81ck1330 FIND v(dout0_81) AT=670.025n

.meas tran vdout0_82ck1330 FIND v(dout0_82) AT=670.025n

.meas tran vdout0_83ck1330 FIND v(dout0_83) AT=670.025n

.meas tran vdout0_84ck1330 FIND v(dout0_84) AT=670.025n

.meas tran vdout0_85ck1330 FIND v(dout0_85) AT=670.025n

.meas tran vdout0_86ck1330 FIND v(dout0_86) AT=670.025n

.meas tran vdout0_87ck1330 FIND v(dout0_87) AT=670.025n

.meas tran vdout0_88ck1330 FIND v(dout0_88) AT=670.025n

.meas tran vdout0_89ck1330 FIND v(dout0_89) AT=670.025n

.meas tran vdout0_90ck1330 FIND v(dout0_90) AT=670.025n

.meas tran vdout0_91ck1330 FIND v(dout0_91) AT=670.025n

.meas tran vdout0_92ck1330 FIND v(dout0_92) AT=670.025n

.meas tran vdout0_93ck1330 FIND v(dout0_93) AT=670.025n

.meas tran vdout0_94ck1330 FIND v(dout0_94) AT=670.025n

.meas tran vdout0_95ck1330 FIND v(dout0_95) AT=670.025n

.meas tran vdout0_96ck1330 FIND v(dout0_96) AT=670.025n

.meas tran vdout0_97ck1330 FIND v(dout0_97) AT=670.025n

.meas tran vdout0_98ck1330 FIND v(dout0_98) AT=670.025n

.meas tran vdout0_99ck1330 FIND v(dout0_99) AT=670.025n

.meas tran vdout0_100ck1330 FIND v(dout0_100) AT=670.025n

.meas tran vdout0_101ck1330 FIND v(dout0_101) AT=670.025n

.meas tran vdout0_102ck1330 FIND v(dout0_102) AT=670.025n

.meas tran vdout0_103ck1330 FIND v(dout0_103) AT=670.025n

.meas tran vdout0_104ck1330 FIND v(dout0_104) AT=670.025n

.meas tran vdout0_105ck1330 FIND v(dout0_105) AT=670.025n

.meas tran vdout0_106ck1330 FIND v(dout0_106) AT=670.025n

.meas tran vdout0_107ck1330 FIND v(dout0_107) AT=670.025n

.meas tran vdout0_108ck1330 FIND v(dout0_108) AT=670.025n

.meas tran vdout0_109ck1330 FIND v(dout0_109) AT=670.025n

.meas tran vdout0_110ck1330 FIND v(dout0_110) AT=670.025n

.meas tran vdout0_111ck1330 FIND v(dout0_111) AT=670.025n

.meas tran vdout0_112ck1330 FIND v(dout0_112) AT=670.025n

.meas tran vdout0_113ck1330 FIND v(dout0_113) AT=670.025n

.meas tran vdout0_114ck1330 FIND v(dout0_114) AT=670.025n

.meas tran vdout0_115ck1330 FIND v(dout0_115) AT=670.025n

.meas tran vdout0_116ck1330 FIND v(dout0_116) AT=670.025n

.meas tran vdout0_117ck1330 FIND v(dout0_117) AT=670.025n

.meas tran vdout0_118ck1330 FIND v(dout0_118) AT=670.025n

.meas tran vdout0_119ck1330 FIND v(dout0_119) AT=670.025n

.meas tran vdout0_120ck1330 FIND v(dout0_120) AT=670.025n

.meas tran vdout0_121ck1330 FIND v(dout0_121) AT=670.025n

.meas tran vdout0_122ck1330 FIND v(dout0_122) AT=670.025n

.meas tran vdout0_123ck1330 FIND v(dout0_123) AT=670.025n

.meas tran vdout0_124ck1330 FIND v(dout0_124) AT=670.025n

.meas tran vdout0_125ck1330 FIND v(dout0_125) AT=670.025n

.meas tran vdout0_126ck1330 FIND v(dout0_126) AT=670.025n

.meas tran vdout0_127ck1330 FIND v(dout0_127) AT=670.025n

.meas tran vdout0_0ck1340 FIND v(dout0_0) AT=675.025n

.meas tran vdout0_1ck1340 FIND v(dout0_1) AT=675.025n

.meas tran vdout0_2ck1340 FIND v(dout0_2) AT=675.025n

.meas tran vdout0_3ck1340 FIND v(dout0_3) AT=675.025n

.meas tran vdout0_4ck1340 FIND v(dout0_4) AT=675.025n

.meas tran vdout0_5ck1340 FIND v(dout0_5) AT=675.025n

.meas tran vdout0_6ck1340 FIND v(dout0_6) AT=675.025n

.meas tran vdout0_7ck1340 FIND v(dout0_7) AT=675.025n

.meas tran vdout0_8ck1340 FIND v(dout0_8) AT=675.025n

.meas tran vdout0_9ck1340 FIND v(dout0_9) AT=675.025n

.meas tran vdout0_10ck1340 FIND v(dout0_10) AT=675.025n

.meas tran vdout0_11ck1340 FIND v(dout0_11) AT=675.025n

.meas tran vdout0_12ck1340 FIND v(dout0_12) AT=675.025n

.meas tran vdout0_13ck1340 FIND v(dout0_13) AT=675.025n

.meas tran vdout0_14ck1340 FIND v(dout0_14) AT=675.025n

.meas tran vdout0_15ck1340 FIND v(dout0_15) AT=675.025n

.meas tran vdout0_16ck1340 FIND v(dout0_16) AT=675.025n

.meas tran vdout0_17ck1340 FIND v(dout0_17) AT=675.025n

.meas tran vdout0_18ck1340 FIND v(dout0_18) AT=675.025n

.meas tran vdout0_19ck1340 FIND v(dout0_19) AT=675.025n

.meas tran vdout0_20ck1340 FIND v(dout0_20) AT=675.025n

.meas tran vdout0_21ck1340 FIND v(dout0_21) AT=675.025n

.meas tran vdout0_22ck1340 FIND v(dout0_22) AT=675.025n

.meas tran vdout0_23ck1340 FIND v(dout0_23) AT=675.025n

.meas tran vdout0_24ck1340 FIND v(dout0_24) AT=675.025n

.meas tran vdout0_25ck1340 FIND v(dout0_25) AT=675.025n

.meas tran vdout0_26ck1340 FIND v(dout0_26) AT=675.025n

.meas tran vdout0_27ck1340 FIND v(dout0_27) AT=675.025n

.meas tran vdout0_28ck1340 FIND v(dout0_28) AT=675.025n

.meas tran vdout0_29ck1340 FIND v(dout0_29) AT=675.025n

.meas tran vdout0_30ck1340 FIND v(dout0_30) AT=675.025n

.meas tran vdout0_31ck1340 FIND v(dout0_31) AT=675.025n

.meas tran vdout0_32ck1340 FIND v(dout0_32) AT=675.025n

.meas tran vdout0_33ck1340 FIND v(dout0_33) AT=675.025n

.meas tran vdout0_34ck1340 FIND v(dout0_34) AT=675.025n

.meas tran vdout0_35ck1340 FIND v(dout0_35) AT=675.025n

.meas tran vdout0_36ck1340 FIND v(dout0_36) AT=675.025n

.meas tran vdout0_37ck1340 FIND v(dout0_37) AT=675.025n

.meas tran vdout0_38ck1340 FIND v(dout0_38) AT=675.025n

.meas tran vdout0_39ck1340 FIND v(dout0_39) AT=675.025n

.meas tran vdout0_40ck1340 FIND v(dout0_40) AT=675.025n

.meas tran vdout0_41ck1340 FIND v(dout0_41) AT=675.025n

.meas tran vdout0_42ck1340 FIND v(dout0_42) AT=675.025n

.meas tran vdout0_43ck1340 FIND v(dout0_43) AT=675.025n

.meas tran vdout0_44ck1340 FIND v(dout0_44) AT=675.025n

.meas tran vdout0_45ck1340 FIND v(dout0_45) AT=675.025n

.meas tran vdout0_46ck1340 FIND v(dout0_46) AT=675.025n

.meas tran vdout0_47ck1340 FIND v(dout0_47) AT=675.025n

.meas tran vdout0_48ck1340 FIND v(dout0_48) AT=675.025n

.meas tran vdout0_49ck1340 FIND v(dout0_49) AT=675.025n

.meas tran vdout0_50ck1340 FIND v(dout0_50) AT=675.025n

.meas tran vdout0_51ck1340 FIND v(dout0_51) AT=675.025n

.meas tran vdout0_52ck1340 FIND v(dout0_52) AT=675.025n

.meas tran vdout0_53ck1340 FIND v(dout0_53) AT=675.025n

.meas tran vdout0_54ck1340 FIND v(dout0_54) AT=675.025n

.meas tran vdout0_55ck1340 FIND v(dout0_55) AT=675.025n

.meas tran vdout0_56ck1340 FIND v(dout0_56) AT=675.025n

.meas tran vdout0_57ck1340 FIND v(dout0_57) AT=675.025n

.meas tran vdout0_58ck1340 FIND v(dout0_58) AT=675.025n

.meas tran vdout0_59ck1340 FIND v(dout0_59) AT=675.025n

.meas tran vdout0_60ck1340 FIND v(dout0_60) AT=675.025n

.meas tran vdout0_61ck1340 FIND v(dout0_61) AT=675.025n

.meas tran vdout0_62ck1340 FIND v(dout0_62) AT=675.025n

.meas tran vdout0_63ck1340 FIND v(dout0_63) AT=675.025n

.meas tran vdout0_64ck1340 FIND v(dout0_64) AT=675.025n

.meas tran vdout0_65ck1340 FIND v(dout0_65) AT=675.025n

.meas tran vdout0_66ck1340 FIND v(dout0_66) AT=675.025n

.meas tran vdout0_67ck1340 FIND v(dout0_67) AT=675.025n

.meas tran vdout0_68ck1340 FIND v(dout0_68) AT=675.025n

.meas tran vdout0_69ck1340 FIND v(dout0_69) AT=675.025n

.meas tran vdout0_70ck1340 FIND v(dout0_70) AT=675.025n

.meas tran vdout0_71ck1340 FIND v(dout0_71) AT=675.025n

.meas tran vdout0_72ck1340 FIND v(dout0_72) AT=675.025n

.meas tran vdout0_73ck1340 FIND v(dout0_73) AT=675.025n

.meas tran vdout0_74ck1340 FIND v(dout0_74) AT=675.025n

.meas tran vdout0_75ck1340 FIND v(dout0_75) AT=675.025n

.meas tran vdout0_76ck1340 FIND v(dout0_76) AT=675.025n

.meas tran vdout0_77ck1340 FIND v(dout0_77) AT=675.025n

.meas tran vdout0_78ck1340 FIND v(dout0_78) AT=675.025n

.meas tran vdout0_79ck1340 FIND v(dout0_79) AT=675.025n

.meas tran vdout0_80ck1340 FIND v(dout0_80) AT=675.025n

.meas tran vdout0_81ck1340 FIND v(dout0_81) AT=675.025n

.meas tran vdout0_82ck1340 FIND v(dout0_82) AT=675.025n

.meas tran vdout0_83ck1340 FIND v(dout0_83) AT=675.025n

.meas tran vdout0_84ck1340 FIND v(dout0_84) AT=675.025n

.meas tran vdout0_85ck1340 FIND v(dout0_85) AT=675.025n

.meas tran vdout0_86ck1340 FIND v(dout0_86) AT=675.025n

.meas tran vdout0_87ck1340 FIND v(dout0_87) AT=675.025n

.meas tran vdout0_88ck1340 FIND v(dout0_88) AT=675.025n

.meas tran vdout0_89ck1340 FIND v(dout0_89) AT=675.025n

.meas tran vdout0_90ck1340 FIND v(dout0_90) AT=675.025n

.meas tran vdout0_91ck1340 FIND v(dout0_91) AT=675.025n

.meas tran vdout0_92ck1340 FIND v(dout0_92) AT=675.025n

.meas tran vdout0_93ck1340 FIND v(dout0_93) AT=675.025n

.meas tran vdout0_94ck1340 FIND v(dout0_94) AT=675.025n

.meas tran vdout0_95ck1340 FIND v(dout0_95) AT=675.025n

.meas tran vdout0_96ck1340 FIND v(dout0_96) AT=675.025n

.meas tran vdout0_97ck1340 FIND v(dout0_97) AT=675.025n

.meas tran vdout0_98ck1340 FIND v(dout0_98) AT=675.025n

.meas tran vdout0_99ck1340 FIND v(dout0_99) AT=675.025n

.meas tran vdout0_100ck1340 FIND v(dout0_100) AT=675.025n

.meas tran vdout0_101ck1340 FIND v(dout0_101) AT=675.025n

.meas tran vdout0_102ck1340 FIND v(dout0_102) AT=675.025n

.meas tran vdout0_103ck1340 FIND v(dout0_103) AT=675.025n

.meas tran vdout0_104ck1340 FIND v(dout0_104) AT=675.025n

.meas tran vdout0_105ck1340 FIND v(dout0_105) AT=675.025n

.meas tran vdout0_106ck1340 FIND v(dout0_106) AT=675.025n

.meas tran vdout0_107ck1340 FIND v(dout0_107) AT=675.025n

.meas tran vdout0_108ck1340 FIND v(dout0_108) AT=675.025n

.meas tran vdout0_109ck1340 FIND v(dout0_109) AT=675.025n

.meas tran vdout0_110ck1340 FIND v(dout0_110) AT=675.025n

.meas tran vdout0_111ck1340 FIND v(dout0_111) AT=675.025n

.meas tran vdout0_112ck1340 FIND v(dout0_112) AT=675.025n

.meas tran vdout0_113ck1340 FIND v(dout0_113) AT=675.025n

.meas tran vdout0_114ck1340 FIND v(dout0_114) AT=675.025n

.meas tran vdout0_115ck1340 FIND v(dout0_115) AT=675.025n

.meas tran vdout0_116ck1340 FIND v(dout0_116) AT=675.025n

.meas tran vdout0_117ck1340 FIND v(dout0_117) AT=675.025n

.meas tran vdout0_118ck1340 FIND v(dout0_118) AT=675.025n

.meas tran vdout0_119ck1340 FIND v(dout0_119) AT=675.025n

.meas tran vdout0_120ck1340 FIND v(dout0_120) AT=675.025n

.meas tran vdout0_121ck1340 FIND v(dout0_121) AT=675.025n

.meas tran vdout0_122ck1340 FIND v(dout0_122) AT=675.025n

.meas tran vdout0_123ck1340 FIND v(dout0_123) AT=675.025n

.meas tran vdout0_124ck1340 FIND v(dout0_124) AT=675.025n

.meas tran vdout0_125ck1340 FIND v(dout0_125) AT=675.025n

.meas tran vdout0_126ck1340 FIND v(dout0_126) AT=675.025n

.meas tran vdout0_127ck1340 FIND v(dout0_127) AT=675.025n

.meas tran vdout0_0ck1350 FIND v(dout0_0) AT=680.025n

.meas tran vdout0_1ck1350 FIND v(dout0_1) AT=680.025n

.meas tran vdout0_2ck1350 FIND v(dout0_2) AT=680.025n

.meas tran vdout0_3ck1350 FIND v(dout0_3) AT=680.025n

.meas tran vdout0_4ck1350 FIND v(dout0_4) AT=680.025n

.meas tran vdout0_5ck1350 FIND v(dout0_5) AT=680.025n

.meas tran vdout0_6ck1350 FIND v(dout0_6) AT=680.025n

.meas tran vdout0_7ck1350 FIND v(dout0_7) AT=680.025n

.meas tran vdout0_8ck1350 FIND v(dout0_8) AT=680.025n

.meas tran vdout0_9ck1350 FIND v(dout0_9) AT=680.025n

.meas tran vdout0_10ck1350 FIND v(dout0_10) AT=680.025n

.meas tran vdout0_11ck1350 FIND v(dout0_11) AT=680.025n

.meas tran vdout0_12ck1350 FIND v(dout0_12) AT=680.025n

.meas tran vdout0_13ck1350 FIND v(dout0_13) AT=680.025n

.meas tran vdout0_14ck1350 FIND v(dout0_14) AT=680.025n

.meas tran vdout0_15ck1350 FIND v(dout0_15) AT=680.025n

.meas tran vdout0_16ck1350 FIND v(dout0_16) AT=680.025n

.meas tran vdout0_17ck1350 FIND v(dout0_17) AT=680.025n

.meas tran vdout0_18ck1350 FIND v(dout0_18) AT=680.025n

.meas tran vdout0_19ck1350 FIND v(dout0_19) AT=680.025n

.meas tran vdout0_20ck1350 FIND v(dout0_20) AT=680.025n

.meas tran vdout0_21ck1350 FIND v(dout0_21) AT=680.025n

.meas tran vdout0_22ck1350 FIND v(dout0_22) AT=680.025n

.meas tran vdout0_23ck1350 FIND v(dout0_23) AT=680.025n

.meas tran vdout0_24ck1350 FIND v(dout0_24) AT=680.025n

.meas tran vdout0_25ck1350 FIND v(dout0_25) AT=680.025n

.meas tran vdout0_26ck1350 FIND v(dout0_26) AT=680.025n

.meas tran vdout0_27ck1350 FIND v(dout0_27) AT=680.025n

.meas tran vdout0_28ck1350 FIND v(dout0_28) AT=680.025n

.meas tran vdout0_29ck1350 FIND v(dout0_29) AT=680.025n

.meas tran vdout0_30ck1350 FIND v(dout0_30) AT=680.025n

.meas tran vdout0_31ck1350 FIND v(dout0_31) AT=680.025n

.meas tran vdout0_32ck1350 FIND v(dout0_32) AT=680.025n

.meas tran vdout0_33ck1350 FIND v(dout0_33) AT=680.025n

.meas tran vdout0_34ck1350 FIND v(dout0_34) AT=680.025n

.meas tran vdout0_35ck1350 FIND v(dout0_35) AT=680.025n

.meas tran vdout0_36ck1350 FIND v(dout0_36) AT=680.025n

.meas tran vdout0_37ck1350 FIND v(dout0_37) AT=680.025n

.meas tran vdout0_38ck1350 FIND v(dout0_38) AT=680.025n

.meas tran vdout0_39ck1350 FIND v(dout0_39) AT=680.025n

.meas tran vdout0_40ck1350 FIND v(dout0_40) AT=680.025n

.meas tran vdout0_41ck1350 FIND v(dout0_41) AT=680.025n

.meas tran vdout0_42ck1350 FIND v(dout0_42) AT=680.025n

.meas tran vdout0_43ck1350 FIND v(dout0_43) AT=680.025n

.meas tran vdout0_44ck1350 FIND v(dout0_44) AT=680.025n

.meas tran vdout0_45ck1350 FIND v(dout0_45) AT=680.025n

.meas tran vdout0_46ck1350 FIND v(dout0_46) AT=680.025n

.meas tran vdout0_47ck1350 FIND v(dout0_47) AT=680.025n

.meas tran vdout0_48ck1350 FIND v(dout0_48) AT=680.025n

.meas tran vdout0_49ck1350 FIND v(dout0_49) AT=680.025n

.meas tran vdout0_50ck1350 FIND v(dout0_50) AT=680.025n

.meas tran vdout0_51ck1350 FIND v(dout0_51) AT=680.025n

.meas tran vdout0_52ck1350 FIND v(dout0_52) AT=680.025n

.meas tran vdout0_53ck1350 FIND v(dout0_53) AT=680.025n

.meas tran vdout0_54ck1350 FIND v(dout0_54) AT=680.025n

.meas tran vdout0_55ck1350 FIND v(dout0_55) AT=680.025n

.meas tran vdout0_56ck1350 FIND v(dout0_56) AT=680.025n

.meas tran vdout0_57ck1350 FIND v(dout0_57) AT=680.025n

.meas tran vdout0_58ck1350 FIND v(dout0_58) AT=680.025n

.meas tran vdout0_59ck1350 FIND v(dout0_59) AT=680.025n

.meas tran vdout0_60ck1350 FIND v(dout0_60) AT=680.025n

.meas tran vdout0_61ck1350 FIND v(dout0_61) AT=680.025n

.meas tran vdout0_62ck1350 FIND v(dout0_62) AT=680.025n

.meas tran vdout0_63ck1350 FIND v(dout0_63) AT=680.025n

.meas tran vdout0_64ck1350 FIND v(dout0_64) AT=680.025n

.meas tran vdout0_65ck1350 FIND v(dout0_65) AT=680.025n

.meas tran vdout0_66ck1350 FIND v(dout0_66) AT=680.025n

.meas tran vdout0_67ck1350 FIND v(dout0_67) AT=680.025n

.meas tran vdout0_68ck1350 FIND v(dout0_68) AT=680.025n

.meas tran vdout0_69ck1350 FIND v(dout0_69) AT=680.025n

.meas tran vdout0_70ck1350 FIND v(dout0_70) AT=680.025n

.meas tran vdout0_71ck1350 FIND v(dout0_71) AT=680.025n

.meas tran vdout0_72ck1350 FIND v(dout0_72) AT=680.025n

.meas tran vdout0_73ck1350 FIND v(dout0_73) AT=680.025n

.meas tran vdout0_74ck1350 FIND v(dout0_74) AT=680.025n

.meas tran vdout0_75ck1350 FIND v(dout0_75) AT=680.025n

.meas tran vdout0_76ck1350 FIND v(dout0_76) AT=680.025n

.meas tran vdout0_77ck1350 FIND v(dout0_77) AT=680.025n

.meas tran vdout0_78ck1350 FIND v(dout0_78) AT=680.025n

.meas tran vdout0_79ck1350 FIND v(dout0_79) AT=680.025n

.meas tran vdout0_80ck1350 FIND v(dout0_80) AT=680.025n

.meas tran vdout0_81ck1350 FIND v(dout0_81) AT=680.025n

.meas tran vdout0_82ck1350 FIND v(dout0_82) AT=680.025n

.meas tran vdout0_83ck1350 FIND v(dout0_83) AT=680.025n

.meas tran vdout0_84ck1350 FIND v(dout0_84) AT=680.025n

.meas tran vdout0_85ck1350 FIND v(dout0_85) AT=680.025n

.meas tran vdout0_86ck1350 FIND v(dout0_86) AT=680.025n

.meas tran vdout0_87ck1350 FIND v(dout0_87) AT=680.025n

.meas tran vdout0_88ck1350 FIND v(dout0_88) AT=680.025n

.meas tran vdout0_89ck1350 FIND v(dout0_89) AT=680.025n

.meas tran vdout0_90ck1350 FIND v(dout0_90) AT=680.025n

.meas tran vdout0_91ck1350 FIND v(dout0_91) AT=680.025n

.meas tran vdout0_92ck1350 FIND v(dout0_92) AT=680.025n

.meas tran vdout0_93ck1350 FIND v(dout0_93) AT=680.025n

.meas tran vdout0_94ck1350 FIND v(dout0_94) AT=680.025n

.meas tran vdout0_95ck1350 FIND v(dout0_95) AT=680.025n

.meas tran vdout0_96ck1350 FIND v(dout0_96) AT=680.025n

.meas tran vdout0_97ck1350 FIND v(dout0_97) AT=680.025n

.meas tran vdout0_98ck1350 FIND v(dout0_98) AT=680.025n

.meas tran vdout0_99ck1350 FIND v(dout0_99) AT=680.025n

.meas tran vdout0_100ck1350 FIND v(dout0_100) AT=680.025n

.meas tran vdout0_101ck1350 FIND v(dout0_101) AT=680.025n

.meas tran vdout0_102ck1350 FIND v(dout0_102) AT=680.025n

.meas tran vdout0_103ck1350 FIND v(dout0_103) AT=680.025n

.meas tran vdout0_104ck1350 FIND v(dout0_104) AT=680.025n

.meas tran vdout0_105ck1350 FIND v(dout0_105) AT=680.025n

.meas tran vdout0_106ck1350 FIND v(dout0_106) AT=680.025n

.meas tran vdout0_107ck1350 FIND v(dout0_107) AT=680.025n

.meas tran vdout0_108ck1350 FIND v(dout0_108) AT=680.025n

.meas tran vdout0_109ck1350 FIND v(dout0_109) AT=680.025n

.meas tran vdout0_110ck1350 FIND v(dout0_110) AT=680.025n

.meas tran vdout0_111ck1350 FIND v(dout0_111) AT=680.025n

.meas tran vdout0_112ck1350 FIND v(dout0_112) AT=680.025n

.meas tran vdout0_113ck1350 FIND v(dout0_113) AT=680.025n

.meas tran vdout0_114ck1350 FIND v(dout0_114) AT=680.025n

.meas tran vdout0_115ck1350 FIND v(dout0_115) AT=680.025n

.meas tran vdout0_116ck1350 FIND v(dout0_116) AT=680.025n

.meas tran vdout0_117ck1350 FIND v(dout0_117) AT=680.025n

.meas tran vdout0_118ck1350 FIND v(dout0_118) AT=680.025n

.meas tran vdout0_119ck1350 FIND v(dout0_119) AT=680.025n

.meas tran vdout0_120ck1350 FIND v(dout0_120) AT=680.025n

.meas tran vdout0_121ck1350 FIND v(dout0_121) AT=680.025n

.meas tran vdout0_122ck1350 FIND v(dout0_122) AT=680.025n

.meas tran vdout0_123ck1350 FIND v(dout0_123) AT=680.025n

.meas tran vdout0_124ck1350 FIND v(dout0_124) AT=680.025n

.meas tran vdout0_125ck1350 FIND v(dout0_125) AT=680.025n

.meas tran vdout0_126ck1350 FIND v(dout0_126) AT=680.025n

.meas tran vdout0_127ck1350 FIND v(dout0_127) AT=680.025n

.meas tran vdout0_0ck1400 FIND v(dout0_0) AT=705.025n

.meas tran vdout0_1ck1400 FIND v(dout0_1) AT=705.025n

.meas tran vdout0_2ck1400 FIND v(dout0_2) AT=705.025n

.meas tran vdout0_3ck1400 FIND v(dout0_3) AT=705.025n

.meas tran vdout0_4ck1400 FIND v(dout0_4) AT=705.025n

.meas tran vdout0_5ck1400 FIND v(dout0_5) AT=705.025n

.meas tran vdout0_6ck1400 FIND v(dout0_6) AT=705.025n

.meas tran vdout0_7ck1400 FIND v(dout0_7) AT=705.025n

.meas tran vdout0_8ck1400 FIND v(dout0_8) AT=705.025n

.meas tran vdout0_9ck1400 FIND v(dout0_9) AT=705.025n

.meas tran vdout0_10ck1400 FIND v(dout0_10) AT=705.025n

.meas tran vdout0_11ck1400 FIND v(dout0_11) AT=705.025n

.meas tran vdout0_12ck1400 FIND v(dout0_12) AT=705.025n

.meas tran vdout0_13ck1400 FIND v(dout0_13) AT=705.025n

.meas tran vdout0_14ck1400 FIND v(dout0_14) AT=705.025n

.meas tran vdout0_15ck1400 FIND v(dout0_15) AT=705.025n

.meas tran vdout0_16ck1400 FIND v(dout0_16) AT=705.025n

.meas tran vdout0_17ck1400 FIND v(dout0_17) AT=705.025n

.meas tran vdout0_18ck1400 FIND v(dout0_18) AT=705.025n

.meas tran vdout0_19ck1400 FIND v(dout0_19) AT=705.025n

.meas tran vdout0_20ck1400 FIND v(dout0_20) AT=705.025n

.meas tran vdout0_21ck1400 FIND v(dout0_21) AT=705.025n

.meas tran vdout0_22ck1400 FIND v(dout0_22) AT=705.025n

.meas tran vdout0_23ck1400 FIND v(dout0_23) AT=705.025n

.meas tran vdout0_24ck1400 FIND v(dout0_24) AT=705.025n

.meas tran vdout0_25ck1400 FIND v(dout0_25) AT=705.025n

.meas tran vdout0_26ck1400 FIND v(dout0_26) AT=705.025n

.meas tran vdout0_27ck1400 FIND v(dout0_27) AT=705.025n

.meas tran vdout0_28ck1400 FIND v(dout0_28) AT=705.025n

.meas tran vdout0_29ck1400 FIND v(dout0_29) AT=705.025n

.meas tran vdout0_30ck1400 FIND v(dout0_30) AT=705.025n

.meas tran vdout0_31ck1400 FIND v(dout0_31) AT=705.025n

.meas tran vdout0_32ck1400 FIND v(dout0_32) AT=705.025n

.meas tran vdout0_33ck1400 FIND v(dout0_33) AT=705.025n

.meas tran vdout0_34ck1400 FIND v(dout0_34) AT=705.025n

.meas tran vdout0_35ck1400 FIND v(dout0_35) AT=705.025n

.meas tran vdout0_36ck1400 FIND v(dout0_36) AT=705.025n

.meas tran vdout0_37ck1400 FIND v(dout0_37) AT=705.025n

.meas tran vdout0_38ck1400 FIND v(dout0_38) AT=705.025n

.meas tran vdout0_39ck1400 FIND v(dout0_39) AT=705.025n

.meas tran vdout0_40ck1400 FIND v(dout0_40) AT=705.025n

.meas tran vdout0_41ck1400 FIND v(dout0_41) AT=705.025n

.meas tran vdout0_42ck1400 FIND v(dout0_42) AT=705.025n

.meas tran vdout0_43ck1400 FIND v(dout0_43) AT=705.025n

.meas tran vdout0_44ck1400 FIND v(dout0_44) AT=705.025n

.meas tran vdout0_45ck1400 FIND v(dout0_45) AT=705.025n

.meas tran vdout0_46ck1400 FIND v(dout0_46) AT=705.025n

.meas tran vdout0_47ck1400 FIND v(dout0_47) AT=705.025n

.meas tran vdout0_48ck1400 FIND v(dout0_48) AT=705.025n

.meas tran vdout0_49ck1400 FIND v(dout0_49) AT=705.025n

.meas tran vdout0_50ck1400 FIND v(dout0_50) AT=705.025n

.meas tran vdout0_51ck1400 FIND v(dout0_51) AT=705.025n

.meas tran vdout0_52ck1400 FIND v(dout0_52) AT=705.025n

.meas tran vdout0_53ck1400 FIND v(dout0_53) AT=705.025n

.meas tran vdout0_54ck1400 FIND v(dout0_54) AT=705.025n

.meas tran vdout0_55ck1400 FIND v(dout0_55) AT=705.025n

.meas tran vdout0_56ck1400 FIND v(dout0_56) AT=705.025n

.meas tran vdout0_57ck1400 FIND v(dout0_57) AT=705.025n

.meas tran vdout0_58ck1400 FIND v(dout0_58) AT=705.025n

.meas tran vdout0_59ck1400 FIND v(dout0_59) AT=705.025n

.meas tran vdout0_60ck1400 FIND v(dout0_60) AT=705.025n

.meas tran vdout0_61ck1400 FIND v(dout0_61) AT=705.025n

.meas tran vdout0_62ck1400 FIND v(dout0_62) AT=705.025n

.meas tran vdout0_63ck1400 FIND v(dout0_63) AT=705.025n

.meas tran vdout0_64ck1400 FIND v(dout0_64) AT=705.025n

.meas tran vdout0_65ck1400 FIND v(dout0_65) AT=705.025n

.meas tran vdout0_66ck1400 FIND v(dout0_66) AT=705.025n

.meas tran vdout0_67ck1400 FIND v(dout0_67) AT=705.025n

.meas tran vdout0_68ck1400 FIND v(dout0_68) AT=705.025n

.meas tran vdout0_69ck1400 FIND v(dout0_69) AT=705.025n

.meas tran vdout0_70ck1400 FIND v(dout0_70) AT=705.025n

.meas tran vdout0_71ck1400 FIND v(dout0_71) AT=705.025n

.meas tran vdout0_72ck1400 FIND v(dout0_72) AT=705.025n

.meas tran vdout0_73ck1400 FIND v(dout0_73) AT=705.025n

.meas tran vdout0_74ck1400 FIND v(dout0_74) AT=705.025n

.meas tran vdout0_75ck1400 FIND v(dout0_75) AT=705.025n

.meas tran vdout0_76ck1400 FIND v(dout0_76) AT=705.025n

.meas tran vdout0_77ck1400 FIND v(dout0_77) AT=705.025n

.meas tran vdout0_78ck1400 FIND v(dout0_78) AT=705.025n

.meas tran vdout0_79ck1400 FIND v(dout0_79) AT=705.025n

.meas tran vdout0_80ck1400 FIND v(dout0_80) AT=705.025n

.meas tran vdout0_81ck1400 FIND v(dout0_81) AT=705.025n

.meas tran vdout0_82ck1400 FIND v(dout0_82) AT=705.025n

.meas tran vdout0_83ck1400 FIND v(dout0_83) AT=705.025n

.meas tran vdout0_84ck1400 FIND v(dout0_84) AT=705.025n

.meas tran vdout0_85ck1400 FIND v(dout0_85) AT=705.025n

.meas tran vdout0_86ck1400 FIND v(dout0_86) AT=705.025n

.meas tran vdout0_87ck1400 FIND v(dout0_87) AT=705.025n

.meas tran vdout0_88ck1400 FIND v(dout0_88) AT=705.025n

.meas tran vdout0_89ck1400 FIND v(dout0_89) AT=705.025n

.meas tran vdout0_90ck1400 FIND v(dout0_90) AT=705.025n

.meas tran vdout0_91ck1400 FIND v(dout0_91) AT=705.025n

.meas tran vdout0_92ck1400 FIND v(dout0_92) AT=705.025n

.meas tran vdout0_93ck1400 FIND v(dout0_93) AT=705.025n

.meas tran vdout0_94ck1400 FIND v(dout0_94) AT=705.025n

.meas tran vdout0_95ck1400 FIND v(dout0_95) AT=705.025n

.meas tran vdout0_96ck1400 FIND v(dout0_96) AT=705.025n

.meas tran vdout0_97ck1400 FIND v(dout0_97) AT=705.025n

.meas tran vdout0_98ck1400 FIND v(dout0_98) AT=705.025n

.meas tran vdout0_99ck1400 FIND v(dout0_99) AT=705.025n

.meas tran vdout0_100ck1400 FIND v(dout0_100) AT=705.025n

.meas tran vdout0_101ck1400 FIND v(dout0_101) AT=705.025n

.meas tran vdout0_102ck1400 FIND v(dout0_102) AT=705.025n

.meas tran vdout0_103ck1400 FIND v(dout0_103) AT=705.025n

.meas tran vdout0_104ck1400 FIND v(dout0_104) AT=705.025n

.meas tran vdout0_105ck1400 FIND v(dout0_105) AT=705.025n

.meas tran vdout0_106ck1400 FIND v(dout0_106) AT=705.025n

.meas tran vdout0_107ck1400 FIND v(dout0_107) AT=705.025n

.meas tran vdout0_108ck1400 FIND v(dout0_108) AT=705.025n

.meas tran vdout0_109ck1400 FIND v(dout0_109) AT=705.025n

.meas tran vdout0_110ck1400 FIND v(dout0_110) AT=705.025n

.meas tran vdout0_111ck1400 FIND v(dout0_111) AT=705.025n

.meas tran vdout0_112ck1400 FIND v(dout0_112) AT=705.025n

.meas tran vdout0_113ck1400 FIND v(dout0_113) AT=705.025n

.meas tran vdout0_114ck1400 FIND v(dout0_114) AT=705.025n

.meas tran vdout0_115ck1400 FIND v(dout0_115) AT=705.025n

.meas tran vdout0_116ck1400 FIND v(dout0_116) AT=705.025n

.meas tran vdout0_117ck1400 FIND v(dout0_117) AT=705.025n

.meas tran vdout0_118ck1400 FIND v(dout0_118) AT=705.025n

.meas tran vdout0_119ck1400 FIND v(dout0_119) AT=705.025n

.meas tran vdout0_120ck1400 FIND v(dout0_120) AT=705.025n

.meas tran vdout0_121ck1400 FIND v(dout0_121) AT=705.025n

.meas tran vdout0_122ck1400 FIND v(dout0_122) AT=705.025n

.meas tran vdout0_123ck1400 FIND v(dout0_123) AT=705.025n

.meas tran vdout0_124ck1400 FIND v(dout0_124) AT=705.025n

.meas tran vdout0_125ck1400 FIND v(dout0_125) AT=705.025n

.meas tran vdout0_126ck1400 FIND v(dout0_126) AT=705.025n

.meas tran vdout0_127ck1400 FIND v(dout0_127) AT=705.025n

.meas tran vdout0_0ck1460 FIND v(dout0_0) AT=735.025n

.meas tran vdout0_1ck1460 FIND v(dout0_1) AT=735.025n

.meas tran vdout0_2ck1460 FIND v(dout0_2) AT=735.025n

.meas tran vdout0_3ck1460 FIND v(dout0_3) AT=735.025n

.meas tran vdout0_4ck1460 FIND v(dout0_4) AT=735.025n

.meas tran vdout0_5ck1460 FIND v(dout0_5) AT=735.025n

.meas tran vdout0_6ck1460 FIND v(dout0_6) AT=735.025n

.meas tran vdout0_7ck1460 FIND v(dout0_7) AT=735.025n

.meas tran vdout0_8ck1460 FIND v(dout0_8) AT=735.025n

.meas tran vdout0_9ck1460 FIND v(dout0_9) AT=735.025n

.meas tran vdout0_10ck1460 FIND v(dout0_10) AT=735.025n

.meas tran vdout0_11ck1460 FIND v(dout0_11) AT=735.025n

.meas tran vdout0_12ck1460 FIND v(dout0_12) AT=735.025n

.meas tran vdout0_13ck1460 FIND v(dout0_13) AT=735.025n

.meas tran vdout0_14ck1460 FIND v(dout0_14) AT=735.025n

.meas tran vdout0_15ck1460 FIND v(dout0_15) AT=735.025n

.meas tran vdout0_16ck1460 FIND v(dout0_16) AT=735.025n

.meas tran vdout0_17ck1460 FIND v(dout0_17) AT=735.025n

.meas tran vdout0_18ck1460 FIND v(dout0_18) AT=735.025n

.meas tran vdout0_19ck1460 FIND v(dout0_19) AT=735.025n

.meas tran vdout0_20ck1460 FIND v(dout0_20) AT=735.025n

.meas tran vdout0_21ck1460 FIND v(dout0_21) AT=735.025n

.meas tran vdout0_22ck1460 FIND v(dout0_22) AT=735.025n

.meas tran vdout0_23ck1460 FIND v(dout0_23) AT=735.025n

.meas tran vdout0_24ck1460 FIND v(dout0_24) AT=735.025n

.meas tran vdout0_25ck1460 FIND v(dout0_25) AT=735.025n

.meas tran vdout0_26ck1460 FIND v(dout0_26) AT=735.025n

.meas tran vdout0_27ck1460 FIND v(dout0_27) AT=735.025n

.meas tran vdout0_28ck1460 FIND v(dout0_28) AT=735.025n

.meas tran vdout0_29ck1460 FIND v(dout0_29) AT=735.025n

.meas tran vdout0_30ck1460 FIND v(dout0_30) AT=735.025n

.meas tran vdout0_31ck1460 FIND v(dout0_31) AT=735.025n

.meas tran vdout0_32ck1460 FIND v(dout0_32) AT=735.025n

.meas tran vdout0_33ck1460 FIND v(dout0_33) AT=735.025n

.meas tran vdout0_34ck1460 FIND v(dout0_34) AT=735.025n

.meas tran vdout0_35ck1460 FIND v(dout0_35) AT=735.025n

.meas tran vdout0_36ck1460 FIND v(dout0_36) AT=735.025n

.meas tran vdout0_37ck1460 FIND v(dout0_37) AT=735.025n

.meas tran vdout0_38ck1460 FIND v(dout0_38) AT=735.025n

.meas tran vdout0_39ck1460 FIND v(dout0_39) AT=735.025n

.meas tran vdout0_40ck1460 FIND v(dout0_40) AT=735.025n

.meas tran vdout0_41ck1460 FIND v(dout0_41) AT=735.025n

.meas tran vdout0_42ck1460 FIND v(dout0_42) AT=735.025n

.meas tran vdout0_43ck1460 FIND v(dout0_43) AT=735.025n

.meas tran vdout0_44ck1460 FIND v(dout0_44) AT=735.025n

.meas tran vdout0_45ck1460 FIND v(dout0_45) AT=735.025n

.meas tran vdout0_46ck1460 FIND v(dout0_46) AT=735.025n

.meas tran vdout0_47ck1460 FIND v(dout0_47) AT=735.025n

.meas tran vdout0_48ck1460 FIND v(dout0_48) AT=735.025n

.meas tran vdout0_49ck1460 FIND v(dout0_49) AT=735.025n

.meas tran vdout0_50ck1460 FIND v(dout0_50) AT=735.025n

.meas tran vdout0_51ck1460 FIND v(dout0_51) AT=735.025n

.meas tran vdout0_52ck1460 FIND v(dout0_52) AT=735.025n

.meas tran vdout0_53ck1460 FIND v(dout0_53) AT=735.025n

.meas tran vdout0_54ck1460 FIND v(dout0_54) AT=735.025n

.meas tran vdout0_55ck1460 FIND v(dout0_55) AT=735.025n

.meas tran vdout0_56ck1460 FIND v(dout0_56) AT=735.025n

.meas tran vdout0_57ck1460 FIND v(dout0_57) AT=735.025n

.meas tran vdout0_58ck1460 FIND v(dout0_58) AT=735.025n

.meas tran vdout0_59ck1460 FIND v(dout0_59) AT=735.025n

.meas tran vdout0_60ck1460 FIND v(dout0_60) AT=735.025n

.meas tran vdout0_61ck1460 FIND v(dout0_61) AT=735.025n

.meas tran vdout0_62ck1460 FIND v(dout0_62) AT=735.025n

.meas tran vdout0_63ck1460 FIND v(dout0_63) AT=735.025n

.meas tran vdout0_64ck1460 FIND v(dout0_64) AT=735.025n

.meas tran vdout0_65ck1460 FIND v(dout0_65) AT=735.025n

.meas tran vdout0_66ck1460 FIND v(dout0_66) AT=735.025n

.meas tran vdout0_67ck1460 FIND v(dout0_67) AT=735.025n

.meas tran vdout0_68ck1460 FIND v(dout0_68) AT=735.025n

.meas tran vdout0_69ck1460 FIND v(dout0_69) AT=735.025n

.meas tran vdout0_70ck1460 FIND v(dout0_70) AT=735.025n

.meas tran vdout0_71ck1460 FIND v(dout0_71) AT=735.025n

.meas tran vdout0_72ck1460 FIND v(dout0_72) AT=735.025n

.meas tran vdout0_73ck1460 FIND v(dout0_73) AT=735.025n

.meas tran vdout0_74ck1460 FIND v(dout0_74) AT=735.025n

.meas tran vdout0_75ck1460 FIND v(dout0_75) AT=735.025n

.meas tran vdout0_76ck1460 FIND v(dout0_76) AT=735.025n

.meas tran vdout0_77ck1460 FIND v(dout0_77) AT=735.025n

.meas tran vdout0_78ck1460 FIND v(dout0_78) AT=735.025n

.meas tran vdout0_79ck1460 FIND v(dout0_79) AT=735.025n

.meas tran vdout0_80ck1460 FIND v(dout0_80) AT=735.025n

.meas tran vdout0_81ck1460 FIND v(dout0_81) AT=735.025n

.meas tran vdout0_82ck1460 FIND v(dout0_82) AT=735.025n

.meas tran vdout0_83ck1460 FIND v(dout0_83) AT=735.025n

.meas tran vdout0_84ck1460 FIND v(dout0_84) AT=735.025n

.meas tran vdout0_85ck1460 FIND v(dout0_85) AT=735.025n

.meas tran vdout0_86ck1460 FIND v(dout0_86) AT=735.025n

.meas tran vdout0_87ck1460 FIND v(dout0_87) AT=735.025n

.meas tran vdout0_88ck1460 FIND v(dout0_88) AT=735.025n

.meas tran vdout0_89ck1460 FIND v(dout0_89) AT=735.025n

.meas tran vdout0_90ck1460 FIND v(dout0_90) AT=735.025n

.meas tran vdout0_91ck1460 FIND v(dout0_91) AT=735.025n

.meas tran vdout0_92ck1460 FIND v(dout0_92) AT=735.025n

.meas tran vdout0_93ck1460 FIND v(dout0_93) AT=735.025n

.meas tran vdout0_94ck1460 FIND v(dout0_94) AT=735.025n

.meas tran vdout0_95ck1460 FIND v(dout0_95) AT=735.025n

.meas tran vdout0_96ck1460 FIND v(dout0_96) AT=735.025n

.meas tran vdout0_97ck1460 FIND v(dout0_97) AT=735.025n

.meas tran vdout0_98ck1460 FIND v(dout0_98) AT=735.025n

.meas tran vdout0_99ck1460 FIND v(dout0_99) AT=735.025n

.meas tran vdout0_100ck1460 FIND v(dout0_100) AT=735.025n

.meas tran vdout0_101ck1460 FIND v(dout0_101) AT=735.025n

.meas tran vdout0_102ck1460 FIND v(dout0_102) AT=735.025n

.meas tran vdout0_103ck1460 FIND v(dout0_103) AT=735.025n

.meas tran vdout0_104ck1460 FIND v(dout0_104) AT=735.025n

.meas tran vdout0_105ck1460 FIND v(dout0_105) AT=735.025n

.meas tran vdout0_106ck1460 FIND v(dout0_106) AT=735.025n

.meas tran vdout0_107ck1460 FIND v(dout0_107) AT=735.025n

.meas tran vdout0_108ck1460 FIND v(dout0_108) AT=735.025n

.meas tran vdout0_109ck1460 FIND v(dout0_109) AT=735.025n

.meas tran vdout0_110ck1460 FIND v(dout0_110) AT=735.025n

.meas tran vdout0_111ck1460 FIND v(dout0_111) AT=735.025n

.meas tran vdout0_112ck1460 FIND v(dout0_112) AT=735.025n

.meas tran vdout0_113ck1460 FIND v(dout0_113) AT=735.025n

.meas tran vdout0_114ck1460 FIND v(dout0_114) AT=735.025n

.meas tran vdout0_115ck1460 FIND v(dout0_115) AT=735.025n

.meas tran vdout0_116ck1460 FIND v(dout0_116) AT=735.025n

.meas tran vdout0_117ck1460 FIND v(dout0_117) AT=735.025n

.meas tran vdout0_118ck1460 FIND v(dout0_118) AT=735.025n

.meas tran vdout0_119ck1460 FIND v(dout0_119) AT=735.025n

.meas tran vdout0_120ck1460 FIND v(dout0_120) AT=735.025n

.meas tran vdout0_121ck1460 FIND v(dout0_121) AT=735.025n

.meas tran vdout0_122ck1460 FIND v(dout0_122) AT=735.025n

.meas tran vdout0_123ck1460 FIND v(dout0_123) AT=735.025n

.meas tran vdout0_124ck1460 FIND v(dout0_124) AT=735.025n

.meas tran vdout0_125ck1460 FIND v(dout0_125) AT=735.025n

.meas tran vdout0_126ck1460 FIND v(dout0_126) AT=735.025n

.meas tran vdout0_127ck1460 FIND v(dout0_127) AT=735.025n

.meas tran vdout0_0ck1500 FIND v(dout0_0) AT=755.025n

.meas tran vdout0_1ck1500 FIND v(dout0_1) AT=755.025n

.meas tran vdout0_2ck1500 FIND v(dout0_2) AT=755.025n

.meas tran vdout0_3ck1500 FIND v(dout0_3) AT=755.025n

.meas tran vdout0_4ck1500 FIND v(dout0_4) AT=755.025n

.meas tran vdout0_5ck1500 FIND v(dout0_5) AT=755.025n

.meas tran vdout0_6ck1500 FIND v(dout0_6) AT=755.025n

.meas tran vdout0_7ck1500 FIND v(dout0_7) AT=755.025n

.meas tran vdout0_8ck1500 FIND v(dout0_8) AT=755.025n

.meas tran vdout0_9ck1500 FIND v(dout0_9) AT=755.025n

.meas tran vdout0_10ck1500 FIND v(dout0_10) AT=755.025n

.meas tran vdout0_11ck1500 FIND v(dout0_11) AT=755.025n

.meas tran vdout0_12ck1500 FIND v(dout0_12) AT=755.025n

.meas tran vdout0_13ck1500 FIND v(dout0_13) AT=755.025n

.meas tran vdout0_14ck1500 FIND v(dout0_14) AT=755.025n

.meas tran vdout0_15ck1500 FIND v(dout0_15) AT=755.025n

.meas tran vdout0_16ck1500 FIND v(dout0_16) AT=755.025n

.meas tran vdout0_17ck1500 FIND v(dout0_17) AT=755.025n

.meas tran vdout0_18ck1500 FIND v(dout0_18) AT=755.025n

.meas tran vdout0_19ck1500 FIND v(dout0_19) AT=755.025n

.meas tran vdout0_20ck1500 FIND v(dout0_20) AT=755.025n

.meas tran vdout0_21ck1500 FIND v(dout0_21) AT=755.025n

.meas tran vdout0_22ck1500 FIND v(dout0_22) AT=755.025n

.meas tran vdout0_23ck1500 FIND v(dout0_23) AT=755.025n

.meas tran vdout0_24ck1500 FIND v(dout0_24) AT=755.025n

.meas tran vdout0_25ck1500 FIND v(dout0_25) AT=755.025n

.meas tran vdout0_26ck1500 FIND v(dout0_26) AT=755.025n

.meas tran vdout0_27ck1500 FIND v(dout0_27) AT=755.025n

.meas tran vdout0_28ck1500 FIND v(dout0_28) AT=755.025n

.meas tran vdout0_29ck1500 FIND v(dout0_29) AT=755.025n

.meas tran vdout0_30ck1500 FIND v(dout0_30) AT=755.025n

.meas tran vdout0_31ck1500 FIND v(dout0_31) AT=755.025n

.meas tran vdout0_32ck1500 FIND v(dout0_32) AT=755.025n

.meas tran vdout0_33ck1500 FIND v(dout0_33) AT=755.025n

.meas tran vdout0_34ck1500 FIND v(dout0_34) AT=755.025n

.meas tran vdout0_35ck1500 FIND v(dout0_35) AT=755.025n

.meas tran vdout0_36ck1500 FIND v(dout0_36) AT=755.025n

.meas tran vdout0_37ck1500 FIND v(dout0_37) AT=755.025n

.meas tran vdout0_38ck1500 FIND v(dout0_38) AT=755.025n

.meas tran vdout0_39ck1500 FIND v(dout0_39) AT=755.025n

.meas tran vdout0_40ck1500 FIND v(dout0_40) AT=755.025n

.meas tran vdout0_41ck1500 FIND v(dout0_41) AT=755.025n

.meas tran vdout0_42ck1500 FIND v(dout0_42) AT=755.025n

.meas tran vdout0_43ck1500 FIND v(dout0_43) AT=755.025n

.meas tran vdout0_44ck1500 FIND v(dout0_44) AT=755.025n

.meas tran vdout0_45ck1500 FIND v(dout0_45) AT=755.025n

.meas tran vdout0_46ck1500 FIND v(dout0_46) AT=755.025n

.meas tran vdout0_47ck1500 FIND v(dout0_47) AT=755.025n

.meas tran vdout0_48ck1500 FIND v(dout0_48) AT=755.025n

.meas tran vdout0_49ck1500 FIND v(dout0_49) AT=755.025n

.meas tran vdout0_50ck1500 FIND v(dout0_50) AT=755.025n

.meas tran vdout0_51ck1500 FIND v(dout0_51) AT=755.025n

.meas tran vdout0_52ck1500 FIND v(dout0_52) AT=755.025n

.meas tran vdout0_53ck1500 FIND v(dout0_53) AT=755.025n

.meas tran vdout0_54ck1500 FIND v(dout0_54) AT=755.025n

.meas tran vdout0_55ck1500 FIND v(dout0_55) AT=755.025n

.meas tran vdout0_56ck1500 FIND v(dout0_56) AT=755.025n

.meas tran vdout0_57ck1500 FIND v(dout0_57) AT=755.025n

.meas tran vdout0_58ck1500 FIND v(dout0_58) AT=755.025n

.meas tran vdout0_59ck1500 FIND v(dout0_59) AT=755.025n

.meas tran vdout0_60ck1500 FIND v(dout0_60) AT=755.025n

.meas tran vdout0_61ck1500 FIND v(dout0_61) AT=755.025n

.meas tran vdout0_62ck1500 FIND v(dout0_62) AT=755.025n

.meas tran vdout0_63ck1500 FIND v(dout0_63) AT=755.025n

.meas tran vdout0_64ck1500 FIND v(dout0_64) AT=755.025n

.meas tran vdout0_65ck1500 FIND v(dout0_65) AT=755.025n

.meas tran vdout0_66ck1500 FIND v(dout0_66) AT=755.025n

.meas tran vdout0_67ck1500 FIND v(dout0_67) AT=755.025n

.meas tran vdout0_68ck1500 FIND v(dout0_68) AT=755.025n

.meas tran vdout0_69ck1500 FIND v(dout0_69) AT=755.025n

.meas tran vdout0_70ck1500 FIND v(dout0_70) AT=755.025n

.meas tran vdout0_71ck1500 FIND v(dout0_71) AT=755.025n

.meas tran vdout0_72ck1500 FIND v(dout0_72) AT=755.025n

.meas tran vdout0_73ck1500 FIND v(dout0_73) AT=755.025n

.meas tran vdout0_74ck1500 FIND v(dout0_74) AT=755.025n

.meas tran vdout0_75ck1500 FIND v(dout0_75) AT=755.025n

.meas tran vdout0_76ck1500 FIND v(dout0_76) AT=755.025n

.meas tran vdout0_77ck1500 FIND v(dout0_77) AT=755.025n

.meas tran vdout0_78ck1500 FIND v(dout0_78) AT=755.025n

.meas tran vdout0_79ck1500 FIND v(dout0_79) AT=755.025n

.meas tran vdout0_80ck1500 FIND v(dout0_80) AT=755.025n

.meas tran vdout0_81ck1500 FIND v(dout0_81) AT=755.025n

.meas tran vdout0_82ck1500 FIND v(dout0_82) AT=755.025n

.meas tran vdout0_83ck1500 FIND v(dout0_83) AT=755.025n

.meas tran vdout0_84ck1500 FIND v(dout0_84) AT=755.025n

.meas tran vdout0_85ck1500 FIND v(dout0_85) AT=755.025n

.meas tran vdout0_86ck1500 FIND v(dout0_86) AT=755.025n

.meas tran vdout0_87ck1500 FIND v(dout0_87) AT=755.025n

.meas tran vdout0_88ck1500 FIND v(dout0_88) AT=755.025n

.meas tran vdout0_89ck1500 FIND v(dout0_89) AT=755.025n

.meas tran vdout0_90ck1500 FIND v(dout0_90) AT=755.025n

.meas tran vdout0_91ck1500 FIND v(dout0_91) AT=755.025n

.meas tran vdout0_92ck1500 FIND v(dout0_92) AT=755.025n

.meas tran vdout0_93ck1500 FIND v(dout0_93) AT=755.025n

.meas tran vdout0_94ck1500 FIND v(dout0_94) AT=755.025n

.meas tran vdout0_95ck1500 FIND v(dout0_95) AT=755.025n

.meas tran vdout0_96ck1500 FIND v(dout0_96) AT=755.025n

.meas tran vdout0_97ck1500 FIND v(dout0_97) AT=755.025n

.meas tran vdout0_98ck1500 FIND v(dout0_98) AT=755.025n

.meas tran vdout0_99ck1500 FIND v(dout0_99) AT=755.025n

.meas tran vdout0_100ck1500 FIND v(dout0_100) AT=755.025n

.meas tran vdout0_101ck1500 FIND v(dout0_101) AT=755.025n

.meas tran vdout0_102ck1500 FIND v(dout0_102) AT=755.025n

.meas tran vdout0_103ck1500 FIND v(dout0_103) AT=755.025n

.meas tran vdout0_104ck1500 FIND v(dout0_104) AT=755.025n

.meas tran vdout0_105ck1500 FIND v(dout0_105) AT=755.025n

.meas tran vdout0_106ck1500 FIND v(dout0_106) AT=755.025n

.meas tran vdout0_107ck1500 FIND v(dout0_107) AT=755.025n

.meas tran vdout0_108ck1500 FIND v(dout0_108) AT=755.025n

.meas tran vdout0_109ck1500 FIND v(dout0_109) AT=755.025n

.meas tran vdout0_110ck1500 FIND v(dout0_110) AT=755.025n

.meas tran vdout0_111ck1500 FIND v(dout0_111) AT=755.025n

.meas tran vdout0_112ck1500 FIND v(dout0_112) AT=755.025n

.meas tran vdout0_113ck1500 FIND v(dout0_113) AT=755.025n

.meas tran vdout0_114ck1500 FIND v(dout0_114) AT=755.025n

.meas tran vdout0_115ck1500 FIND v(dout0_115) AT=755.025n

.meas tran vdout0_116ck1500 FIND v(dout0_116) AT=755.025n

.meas tran vdout0_117ck1500 FIND v(dout0_117) AT=755.025n

.meas tran vdout0_118ck1500 FIND v(dout0_118) AT=755.025n

.meas tran vdout0_119ck1500 FIND v(dout0_119) AT=755.025n

.meas tran vdout0_120ck1500 FIND v(dout0_120) AT=755.025n

.meas tran vdout0_121ck1500 FIND v(dout0_121) AT=755.025n

.meas tran vdout0_122ck1500 FIND v(dout0_122) AT=755.025n

.meas tran vdout0_123ck1500 FIND v(dout0_123) AT=755.025n

.meas tran vdout0_124ck1500 FIND v(dout0_124) AT=755.025n

.meas tran vdout0_125ck1500 FIND v(dout0_125) AT=755.025n

.meas tran vdout0_126ck1500 FIND v(dout0_126) AT=755.025n

.meas tran vdout0_127ck1500 FIND v(dout0_127) AT=755.025n

.meas tran vdout0_0ck1520 FIND v(dout0_0) AT=765.025n

.meas tran vdout0_1ck1520 FIND v(dout0_1) AT=765.025n

.meas tran vdout0_2ck1520 FIND v(dout0_2) AT=765.025n

.meas tran vdout0_3ck1520 FIND v(dout0_3) AT=765.025n

.meas tran vdout0_4ck1520 FIND v(dout0_4) AT=765.025n

.meas tran vdout0_5ck1520 FIND v(dout0_5) AT=765.025n

.meas tran vdout0_6ck1520 FIND v(dout0_6) AT=765.025n

.meas tran vdout0_7ck1520 FIND v(dout0_7) AT=765.025n

.meas tran vdout0_8ck1520 FIND v(dout0_8) AT=765.025n

.meas tran vdout0_9ck1520 FIND v(dout0_9) AT=765.025n

.meas tran vdout0_10ck1520 FIND v(dout0_10) AT=765.025n

.meas tran vdout0_11ck1520 FIND v(dout0_11) AT=765.025n

.meas tran vdout0_12ck1520 FIND v(dout0_12) AT=765.025n

.meas tran vdout0_13ck1520 FIND v(dout0_13) AT=765.025n

.meas tran vdout0_14ck1520 FIND v(dout0_14) AT=765.025n

.meas tran vdout0_15ck1520 FIND v(dout0_15) AT=765.025n

.meas tran vdout0_16ck1520 FIND v(dout0_16) AT=765.025n

.meas tran vdout0_17ck1520 FIND v(dout0_17) AT=765.025n

.meas tran vdout0_18ck1520 FIND v(dout0_18) AT=765.025n

.meas tran vdout0_19ck1520 FIND v(dout0_19) AT=765.025n

.meas tran vdout0_20ck1520 FIND v(dout0_20) AT=765.025n

.meas tran vdout0_21ck1520 FIND v(dout0_21) AT=765.025n

.meas tran vdout0_22ck1520 FIND v(dout0_22) AT=765.025n

.meas tran vdout0_23ck1520 FIND v(dout0_23) AT=765.025n

.meas tran vdout0_24ck1520 FIND v(dout0_24) AT=765.025n

.meas tran vdout0_25ck1520 FIND v(dout0_25) AT=765.025n

.meas tran vdout0_26ck1520 FIND v(dout0_26) AT=765.025n

.meas tran vdout0_27ck1520 FIND v(dout0_27) AT=765.025n

.meas tran vdout0_28ck1520 FIND v(dout0_28) AT=765.025n

.meas tran vdout0_29ck1520 FIND v(dout0_29) AT=765.025n

.meas tran vdout0_30ck1520 FIND v(dout0_30) AT=765.025n

.meas tran vdout0_31ck1520 FIND v(dout0_31) AT=765.025n

.meas tran vdout0_32ck1520 FIND v(dout0_32) AT=765.025n

.meas tran vdout0_33ck1520 FIND v(dout0_33) AT=765.025n

.meas tran vdout0_34ck1520 FIND v(dout0_34) AT=765.025n

.meas tran vdout0_35ck1520 FIND v(dout0_35) AT=765.025n

.meas tran vdout0_36ck1520 FIND v(dout0_36) AT=765.025n

.meas tran vdout0_37ck1520 FIND v(dout0_37) AT=765.025n

.meas tran vdout0_38ck1520 FIND v(dout0_38) AT=765.025n

.meas tran vdout0_39ck1520 FIND v(dout0_39) AT=765.025n

.meas tran vdout0_40ck1520 FIND v(dout0_40) AT=765.025n

.meas tran vdout0_41ck1520 FIND v(dout0_41) AT=765.025n

.meas tran vdout0_42ck1520 FIND v(dout0_42) AT=765.025n

.meas tran vdout0_43ck1520 FIND v(dout0_43) AT=765.025n

.meas tran vdout0_44ck1520 FIND v(dout0_44) AT=765.025n

.meas tran vdout0_45ck1520 FIND v(dout0_45) AT=765.025n

.meas tran vdout0_46ck1520 FIND v(dout0_46) AT=765.025n

.meas tran vdout0_47ck1520 FIND v(dout0_47) AT=765.025n

.meas tran vdout0_48ck1520 FIND v(dout0_48) AT=765.025n

.meas tran vdout0_49ck1520 FIND v(dout0_49) AT=765.025n

.meas tran vdout0_50ck1520 FIND v(dout0_50) AT=765.025n

.meas tran vdout0_51ck1520 FIND v(dout0_51) AT=765.025n

.meas tran vdout0_52ck1520 FIND v(dout0_52) AT=765.025n

.meas tran vdout0_53ck1520 FIND v(dout0_53) AT=765.025n

.meas tran vdout0_54ck1520 FIND v(dout0_54) AT=765.025n

.meas tran vdout0_55ck1520 FIND v(dout0_55) AT=765.025n

.meas tran vdout0_56ck1520 FIND v(dout0_56) AT=765.025n

.meas tran vdout0_57ck1520 FIND v(dout0_57) AT=765.025n

.meas tran vdout0_58ck1520 FIND v(dout0_58) AT=765.025n

.meas tran vdout0_59ck1520 FIND v(dout0_59) AT=765.025n

.meas tran vdout0_60ck1520 FIND v(dout0_60) AT=765.025n

.meas tran vdout0_61ck1520 FIND v(dout0_61) AT=765.025n

.meas tran vdout0_62ck1520 FIND v(dout0_62) AT=765.025n

.meas tran vdout0_63ck1520 FIND v(dout0_63) AT=765.025n

.meas tran vdout0_64ck1520 FIND v(dout0_64) AT=765.025n

.meas tran vdout0_65ck1520 FIND v(dout0_65) AT=765.025n

.meas tran vdout0_66ck1520 FIND v(dout0_66) AT=765.025n

.meas tran vdout0_67ck1520 FIND v(dout0_67) AT=765.025n

.meas tran vdout0_68ck1520 FIND v(dout0_68) AT=765.025n

.meas tran vdout0_69ck1520 FIND v(dout0_69) AT=765.025n

.meas tran vdout0_70ck1520 FIND v(dout0_70) AT=765.025n

.meas tran vdout0_71ck1520 FIND v(dout0_71) AT=765.025n

.meas tran vdout0_72ck1520 FIND v(dout0_72) AT=765.025n

.meas tran vdout0_73ck1520 FIND v(dout0_73) AT=765.025n

.meas tran vdout0_74ck1520 FIND v(dout0_74) AT=765.025n

.meas tran vdout0_75ck1520 FIND v(dout0_75) AT=765.025n

.meas tran vdout0_76ck1520 FIND v(dout0_76) AT=765.025n

.meas tran vdout0_77ck1520 FIND v(dout0_77) AT=765.025n

.meas tran vdout0_78ck1520 FIND v(dout0_78) AT=765.025n

.meas tran vdout0_79ck1520 FIND v(dout0_79) AT=765.025n

.meas tran vdout0_80ck1520 FIND v(dout0_80) AT=765.025n

.meas tran vdout0_81ck1520 FIND v(dout0_81) AT=765.025n

.meas tran vdout0_82ck1520 FIND v(dout0_82) AT=765.025n

.meas tran vdout0_83ck1520 FIND v(dout0_83) AT=765.025n

.meas tran vdout0_84ck1520 FIND v(dout0_84) AT=765.025n

.meas tran vdout0_85ck1520 FIND v(dout0_85) AT=765.025n

.meas tran vdout0_86ck1520 FIND v(dout0_86) AT=765.025n

.meas tran vdout0_87ck1520 FIND v(dout0_87) AT=765.025n

.meas tran vdout0_88ck1520 FIND v(dout0_88) AT=765.025n

.meas tran vdout0_89ck1520 FIND v(dout0_89) AT=765.025n

.meas tran vdout0_90ck1520 FIND v(dout0_90) AT=765.025n

.meas tran vdout0_91ck1520 FIND v(dout0_91) AT=765.025n

.meas tran vdout0_92ck1520 FIND v(dout0_92) AT=765.025n

.meas tran vdout0_93ck1520 FIND v(dout0_93) AT=765.025n

.meas tran vdout0_94ck1520 FIND v(dout0_94) AT=765.025n

.meas tran vdout0_95ck1520 FIND v(dout0_95) AT=765.025n

.meas tran vdout0_96ck1520 FIND v(dout0_96) AT=765.025n

.meas tran vdout0_97ck1520 FIND v(dout0_97) AT=765.025n

.meas tran vdout0_98ck1520 FIND v(dout0_98) AT=765.025n

.meas tran vdout0_99ck1520 FIND v(dout0_99) AT=765.025n

.meas tran vdout0_100ck1520 FIND v(dout0_100) AT=765.025n

.meas tran vdout0_101ck1520 FIND v(dout0_101) AT=765.025n

.meas tran vdout0_102ck1520 FIND v(dout0_102) AT=765.025n

.meas tran vdout0_103ck1520 FIND v(dout0_103) AT=765.025n

.meas tran vdout0_104ck1520 FIND v(dout0_104) AT=765.025n

.meas tran vdout0_105ck1520 FIND v(dout0_105) AT=765.025n

.meas tran vdout0_106ck1520 FIND v(dout0_106) AT=765.025n

.meas tran vdout0_107ck1520 FIND v(dout0_107) AT=765.025n

.meas tran vdout0_108ck1520 FIND v(dout0_108) AT=765.025n

.meas tran vdout0_109ck1520 FIND v(dout0_109) AT=765.025n

.meas tran vdout0_110ck1520 FIND v(dout0_110) AT=765.025n

.meas tran vdout0_111ck1520 FIND v(dout0_111) AT=765.025n

.meas tran vdout0_112ck1520 FIND v(dout0_112) AT=765.025n

.meas tran vdout0_113ck1520 FIND v(dout0_113) AT=765.025n

.meas tran vdout0_114ck1520 FIND v(dout0_114) AT=765.025n

.meas tran vdout0_115ck1520 FIND v(dout0_115) AT=765.025n

.meas tran vdout0_116ck1520 FIND v(dout0_116) AT=765.025n

.meas tran vdout0_117ck1520 FIND v(dout0_117) AT=765.025n

.meas tran vdout0_118ck1520 FIND v(dout0_118) AT=765.025n

.meas tran vdout0_119ck1520 FIND v(dout0_119) AT=765.025n

.meas tran vdout0_120ck1520 FIND v(dout0_120) AT=765.025n

.meas tran vdout0_121ck1520 FIND v(dout0_121) AT=765.025n

.meas tran vdout0_122ck1520 FIND v(dout0_122) AT=765.025n

.meas tran vdout0_123ck1520 FIND v(dout0_123) AT=765.025n

.meas tran vdout0_124ck1520 FIND v(dout0_124) AT=765.025n

.meas tran vdout0_125ck1520 FIND v(dout0_125) AT=765.025n

.meas tran vdout0_126ck1520 FIND v(dout0_126) AT=765.025n

.meas tran vdout0_127ck1520 FIND v(dout0_127) AT=765.025n

.meas tran vdout0_0ck1550 FIND v(dout0_0) AT=780.025n

.meas tran vdout0_1ck1550 FIND v(dout0_1) AT=780.025n

.meas tran vdout0_2ck1550 FIND v(dout0_2) AT=780.025n

.meas tran vdout0_3ck1550 FIND v(dout0_3) AT=780.025n

.meas tran vdout0_4ck1550 FIND v(dout0_4) AT=780.025n

.meas tran vdout0_5ck1550 FIND v(dout0_5) AT=780.025n

.meas tran vdout0_6ck1550 FIND v(dout0_6) AT=780.025n

.meas tran vdout0_7ck1550 FIND v(dout0_7) AT=780.025n

.meas tran vdout0_8ck1550 FIND v(dout0_8) AT=780.025n

.meas tran vdout0_9ck1550 FIND v(dout0_9) AT=780.025n

.meas tran vdout0_10ck1550 FIND v(dout0_10) AT=780.025n

.meas tran vdout0_11ck1550 FIND v(dout0_11) AT=780.025n

.meas tran vdout0_12ck1550 FIND v(dout0_12) AT=780.025n

.meas tran vdout0_13ck1550 FIND v(dout0_13) AT=780.025n

.meas tran vdout0_14ck1550 FIND v(dout0_14) AT=780.025n

.meas tran vdout0_15ck1550 FIND v(dout0_15) AT=780.025n

.meas tran vdout0_16ck1550 FIND v(dout0_16) AT=780.025n

.meas tran vdout0_17ck1550 FIND v(dout0_17) AT=780.025n

.meas tran vdout0_18ck1550 FIND v(dout0_18) AT=780.025n

.meas tran vdout0_19ck1550 FIND v(dout0_19) AT=780.025n

.meas tran vdout0_20ck1550 FIND v(dout0_20) AT=780.025n

.meas tran vdout0_21ck1550 FIND v(dout0_21) AT=780.025n

.meas tran vdout0_22ck1550 FIND v(dout0_22) AT=780.025n

.meas tran vdout0_23ck1550 FIND v(dout0_23) AT=780.025n

.meas tran vdout0_24ck1550 FIND v(dout0_24) AT=780.025n

.meas tran vdout0_25ck1550 FIND v(dout0_25) AT=780.025n

.meas tran vdout0_26ck1550 FIND v(dout0_26) AT=780.025n

.meas tran vdout0_27ck1550 FIND v(dout0_27) AT=780.025n

.meas tran vdout0_28ck1550 FIND v(dout0_28) AT=780.025n

.meas tran vdout0_29ck1550 FIND v(dout0_29) AT=780.025n

.meas tran vdout0_30ck1550 FIND v(dout0_30) AT=780.025n

.meas tran vdout0_31ck1550 FIND v(dout0_31) AT=780.025n

.meas tran vdout0_32ck1550 FIND v(dout0_32) AT=780.025n

.meas tran vdout0_33ck1550 FIND v(dout0_33) AT=780.025n

.meas tran vdout0_34ck1550 FIND v(dout0_34) AT=780.025n

.meas tran vdout0_35ck1550 FIND v(dout0_35) AT=780.025n

.meas tran vdout0_36ck1550 FIND v(dout0_36) AT=780.025n

.meas tran vdout0_37ck1550 FIND v(dout0_37) AT=780.025n

.meas tran vdout0_38ck1550 FIND v(dout0_38) AT=780.025n

.meas tran vdout0_39ck1550 FIND v(dout0_39) AT=780.025n

.meas tran vdout0_40ck1550 FIND v(dout0_40) AT=780.025n

.meas tran vdout0_41ck1550 FIND v(dout0_41) AT=780.025n

.meas tran vdout0_42ck1550 FIND v(dout0_42) AT=780.025n

.meas tran vdout0_43ck1550 FIND v(dout0_43) AT=780.025n

.meas tran vdout0_44ck1550 FIND v(dout0_44) AT=780.025n

.meas tran vdout0_45ck1550 FIND v(dout0_45) AT=780.025n

.meas tran vdout0_46ck1550 FIND v(dout0_46) AT=780.025n

.meas tran vdout0_47ck1550 FIND v(dout0_47) AT=780.025n

.meas tran vdout0_48ck1550 FIND v(dout0_48) AT=780.025n

.meas tran vdout0_49ck1550 FIND v(dout0_49) AT=780.025n

.meas tran vdout0_50ck1550 FIND v(dout0_50) AT=780.025n

.meas tran vdout0_51ck1550 FIND v(dout0_51) AT=780.025n

.meas tran vdout0_52ck1550 FIND v(dout0_52) AT=780.025n

.meas tran vdout0_53ck1550 FIND v(dout0_53) AT=780.025n

.meas tran vdout0_54ck1550 FIND v(dout0_54) AT=780.025n

.meas tran vdout0_55ck1550 FIND v(dout0_55) AT=780.025n

.meas tran vdout0_56ck1550 FIND v(dout0_56) AT=780.025n

.meas tran vdout0_57ck1550 FIND v(dout0_57) AT=780.025n

.meas tran vdout0_58ck1550 FIND v(dout0_58) AT=780.025n

.meas tran vdout0_59ck1550 FIND v(dout0_59) AT=780.025n

.meas tran vdout0_60ck1550 FIND v(dout0_60) AT=780.025n

.meas tran vdout0_61ck1550 FIND v(dout0_61) AT=780.025n

.meas tran vdout0_62ck1550 FIND v(dout0_62) AT=780.025n

.meas tran vdout0_63ck1550 FIND v(dout0_63) AT=780.025n

.meas tran vdout0_64ck1550 FIND v(dout0_64) AT=780.025n

.meas tran vdout0_65ck1550 FIND v(dout0_65) AT=780.025n

.meas tran vdout0_66ck1550 FIND v(dout0_66) AT=780.025n

.meas tran vdout0_67ck1550 FIND v(dout0_67) AT=780.025n

.meas tran vdout0_68ck1550 FIND v(dout0_68) AT=780.025n

.meas tran vdout0_69ck1550 FIND v(dout0_69) AT=780.025n

.meas tran vdout0_70ck1550 FIND v(dout0_70) AT=780.025n

.meas tran vdout0_71ck1550 FIND v(dout0_71) AT=780.025n

.meas tran vdout0_72ck1550 FIND v(dout0_72) AT=780.025n

.meas tran vdout0_73ck1550 FIND v(dout0_73) AT=780.025n

.meas tran vdout0_74ck1550 FIND v(dout0_74) AT=780.025n

.meas tran vdout0_75ck1550 FIND v(dout0_75) AT=780.025n

.meas tran vdout0_76ck1550 FIND v(dout0_76) AT=780.025n

.meas tran vdout0_77ck1550 FIND v(dout0_77) AT=780.025n

.meas tran vdout0_78ck1550 FIND v(dout0_78) AT=780.025n

.meas tran vdout0_79ck1550 FIND v(dout0_79) AT=780.025n

.meas tran vdout0_80ck1550 FIND v(dout0_80) AT=780.025n

.meas tran vdout0_81ck1550 FIND v(dout0_81) AT=780.025n

.meas tran vdout0_82ck1550 FIND v(dout0_82) AT=780.025n

.meas tran vdout0_83ck1550 FIND v(dout0_83) AT=780.025n

.meas tran vdout0_84ck1550 FIND v(dout0_84) AT=780.025n

.meas tran vdout0_85ck1550 FIND v(dout0_85) AT=780.025n

.meas tran vdout0_86ck1550 FIND v(dout0_86) AT=780.025n

.meas tran vdout0_87ck1550 FIND v(dout0_87) AT=780.025n

.meas tran vdout0_88ck1550 FIND v(dout0_88) AT=780.025n

.meas tran vdout0_89ck1550 FIND v(dout0_89) AT=780.025n

.meas tran vdout0_90ck1550 FIND v(dout0_90) AT=780.025n

.meas tran vdout0_91ck1550 FIND v(dout0_91) AT=780.025n

.meas tran vdout0_92ck1550 FIND v(dout0_92) AT=780.025n

.meas tran vdout0_93ck1550 FIND v(dout0_93) AT=780.025n

.meas tran vdout0_94ck1550 FIND v(dout0_94) AT=780.025n

.meas tran vdout0_95ck1550 FIND v(dout0_95) AT=780.025n

.meas tran vdout0_96ck1550 FIND v(dout0_96) AT=780.025n

.meas tran vdout0_97ck1550 FIND v(dout0_97) AT=780.025n

.meas tran vdout0_98ck1550 FIND v(dout0_98) AT=780.025n

.meas tran vdout0_99ck1550 FIND v(dout0_99) AT=780.025n

.meas tran vdout0_100ck1550 FIND v(dout0_100) AT=780.025n

.meas tran vdout0_101ck1550 FIND v(dout0_101) AT=780.025n

.meas tran vdout0_102ck1550 FIND v(dout0_102) AT=780.025n

.meas tran vdout0_103ck1550 FIND v(dout0_103) AT=780.025n

.meas tran vdout0_104ck1550 FIND v(dout0_104) AT=780.025n

.meas tran vdout0_105ck1550 FIND v(dout0_105) AT=780.025n

.meas tran vdout0_106ck1550 FIND v(dout0_106) AT=780.025n

.meas tran vdout0_107ck1550 FIND v(dout0_107) AT=780.025n

.meas tran vdout0_108ck1550 FIND v(dout0_108) AT=780.025n

.meas tran vdout0_109ck1550 FIND v(dout0_109) AT=780.025n

.meas tran vdout0_110ck1550 FIND v(dout0_110) AT=780.025n

.meas tran vdout0_111ck1550 FIND v(dout0_111) AT=780.025n

.meas tran vdout0_112ck1550 FIND v(dout0_112) AT=780.025n

.meas tran vdout0_113ck1550 FIND v(dout0_113) AT=780.025n

.meas tran vdout0_114ck1550 FIND v(dout0_114) AT=780.025n

.meas tran vdout0_115ck1550 FIND v(dout0_115) AT=780.025n

.meas tran vdout0_116ck1550 FIND v(dout0_116) AT=780.025n

.meas tran vdout0_117ck1550 FIND v(dout0_117) AT=780.025n

.meas tran vdout0_118ck1550 FIND v(dout0_118) AT=780.025n

.meas tran vdout0_119ck1550 FIND v(dout0_119) AT=780.025n

.meas tran vdout0_120ck1550 FIND v(dout0_120) AT=780.025n

.meas tran vdout0_121ck1550 FIND v(dout0_121) AT=780.025n

.meas tran vdout0_122ck1550 FIND v(dout0_122) AT=780.025n

.meas tran vdout0_123ck1550 FIND v(dout0_123) AT=780.025n

.meas tran vdout0_124ck1550 FIND v(dout0_124) AT=780.025n

.meas tran vdout0_125ck1550 FIND v(dout0_125) AT=780.025n

.meas tran vdout0_126ck1550 FIND v(dout0_126) AT=780.025n

.meas tran vdout0_127ck1550 FIND v(dout0_127) AT=780.025n

.meas tran vdout0_0ck1570 FIND v(dout0_0) AT=790.025n

.meas tran vdout0_1ck1570 FIND v(dout0_1) AT=790.025n

.meas tran vdout0_2ck1570 FIND v(dout0_2) AT=790.025n

.meas tran vdout0_3ck1570 FIND v(dout0_3) AT=790.025n

.meas tran vdout0_4ck1570 FIND v(dout0_4) AT=790.025n

.meas tran vdout0_5ck1570 FIND v(dout0_5) AT=790.025n

.meas tran vdout0_6ck1570 FIND v(dout0_6) AT=790.025n

.meas tran vdout0_7ck1570 FIND v(dout0_7) AT=790.025n

.meas tran vdout0_8ck1570 FIND v(dout0_8) AT=790.025n

.meas tran vdout0_9ck1570 FIND v(dout0_9) AT=790.025n

.meas tran vdout0_10ck1570 FIND v(dout0_10) AT=790.025n

.meas tran vdout0_11ck1570 FIND v(dout0_11) AT=790.025n

.meas tran vdout0_12ck1570 FIND v(dout0_12) AT=790.025n

.meas tran vdout0_13ck1570 FIND v(dout0_13) AT=790.025n

.meas tran vdout0_14ck1570 FIND v(dout0_14) AT=790.025n

.meas tran vdout0_15ck1570 FIND v(dout0_15) AT=790.025n

.meas tran vdout0_16ck1570 FIND v(dout0_16) AT=790.025n

.meas tran vdout0_17ck1570 FIND v(dout0_17) AT=790.025n

.meas tran vdout0_18ck1570 FIND v(dout0_18) AT=790.025n

.meas tran vdout0_19ck1570 FIND v(dout0_19) AT=790.025n

.meas tran vdout0_20ck1570 FIND v(dout0_20) AT=790.025n

.meas tran vdout0_21ck1570 FIND v(dout0_21) AT=790.025n

.meas tran vdout0_22ck1570 FIND v(dout0_22) AT=790.025n

.meas tran vdout0_23ck1570 FIND v(dout0_23) AT=790.025n

.meas tran vdout0_24ck1570 FIND v(dout0_24) AT=790.025n

.meas tran vdout0_25ck1570 FIND v(dout0_25) AT=790.025n

.meas tran vdout0_26ck1570 FIND v(dout0_26) AT=790.025n

.meas tran vdout0_27ck1570 FIND v(dout0_27) AT=790.025n

.meas tran vdout0_28ck1570 FIND v(dout0_28) AT=790.025n

.meas tran vdout0_29ck1570 FIND v(dout0_29) AT=790.025n

.meas tran vdout0_30ck1570 FIND v(dout0_30) AT=790.025n

.meas tran vdout0_31ck1570 FIND v(dout0_31) AT=790.025n

.meas tran vdout0_32ck1570 FIND v(dout0_32) AT=790.025n

.meas tran vdout0_33ck1570 FIND v(dout0_33) AT=790.025n

.meas tran vdout0_34ck1570 FIND v(dout0_34) AT=790.025n

.meas tran vdout0_35ck1570 FIND v(dout0_35) AT=790.025n

.meas tran vdout0_36ck1570 FIND v(dout0_36) AT=790.025n

.meas tran vdout0_37ck1570 FIND v(dout0_37) AT=790.025n

.meas tran vdout0_38ck1570 FIND v(dout0_38) AT=790.025n

.meas tran vdout0_39ck1570 FIND v(dout0_39) AT=790.025n

.meas tran vdout0_40ck1570 FIND v(dout0_40) AT=790.025n

.meas tran vdout0_41ck1570 FIND v(dout0_41) AT=790.025n

.meas tran vdout0_42ck1570 FIND v(dout0_42) AT=790.025n

.meas tran vdout0_43ck1570 FIND v(dout0_43) AT=790.025n

.meas tran vdout0_44ck1570 FIND v(dout0_44) AT=790.025n

.meas tran vdout0_45ck1570 FIND v(dout0_45) AT=790.025n

.meas tran vdout0_46ck1570 FIND v(dout0_46) AT=790.025n

.meas tran vdout0_47ck1570 FIND v(dout0_47) AT=790.025n

.meas tran vdout0_48ck1570 FIND v(dout0_48) AT=790.025n

.meas tran vdout0_49ck1570 FIND v(dout0_49) AT=790.025n

.meas tran vdout0_50ck1570 FIND v(dout0_50) AT=790.025n

.meas tran vdout0_51ck1570 FIND v(dout0_51) AT=790.025n

.meas tran vdout0_52ck1570 FIND v(dout0_52) AT=790.025n

.meas tran vdout0_53ck1570 FIND v(dout0_53) AT=790.025n

.meas tran vdout0_54ck1570 FIND v(dout0_54) AT=790.025n

.meas tran vdout0_55ck1570 FIND v(dout0_55) AT=790.025n

.meas tran vdout0_56ck1570 FIND v(dout0_56) AT=790.025n

.meas tran vdout0_57ck1570 FIND v(dout0_57) AT=790.025n

.meas tran vdout0_58ck1570 FIND v(dout0_58) AT=790.025n

.meas tran vdout0_59ck1570 FIND v(dout0_59) AT=790.025n

.meas tran vdout0_60ck1570 FIND v(dout0_60) AT=790.025n

.meas tran vdout0_61ck1570 FIND v(dout0_61) AT=790.025n

.meas tran vdout0_62ck1570 FIND v(dout0_62) AT=790.025n

.meas tran vdout0_63ck1570 FIND v(dout0_63) AT=790.025n

.meas tran vdout0_64ck1570 FIND v(dout0_64) AT=790.025n

.meas tran vdout0_65ck1570 FIND v(dout0_65) AT=790.025n

.meas tran vdout0_66ck1570 FIND v(dout0_66) AT=790.025n

.meas tran vdout0_67ck1570 FIND v(dout0_67) AT=790.025n

.meas tran vdout0_68ck1570 FIND v(dout0_68) AT=790.025n

.meas tran vdout0_69ck1570 FIND v(dout0_69) AT=790.025n

.meas tran vdout0_70ck1570 FIND v(dout0_70) AT=790.025n

.meas tran vdout0_71ck1570 FIND v(dout0_71) AT=790.025n

.meas tran vdout0_72ck1570 FIND v(dout0_72) AT=790.025n

.meas tran vdout0_73ck1570 FIND v(dout0_73) AT=790.025n

.meas tran vdout0_74ck1570 FIND v(dout0_74) AT=790.025n

.meas tran vdout0_75ck1570 FIND v(dout0_75) AT=790.025n

.meas tran vdout0_76ck1570 FIND v(dout0_76) AT=790.025n

.meas tran vdout0_77ck1570 FIND v(dout0_77) AT=790.025n

.meas tran vdout0_78ck1570 FIND v(dout0_78) AT=790.025n

.meas tran vdout0_79ck1570 FIND v(dout0_79) AT=790.025n

.meas tran vdout0_80ck1570 FIND v(dout0_80) AT=790.025n

.meas tran vdout0_81ck1570 FIND v(dout0_81) AT=790.025n

.meas tran vdout0_82ck1570 FIND v(dout0_82) AT=790.025n

.meas tran vdout0_83ck1570 FIND v(dout0_83) AT=790.025n

.meas tran vdout0_84ck1570 FIND v(dout0_84) AT=790.025n

.meas tran vdout0_85ck1570 FIND v(dout0_85) AT=790.025n

.meas tran vdout0_86ck1570 FIND v(dout0_86) AT=790.025n

.meas tran vdout0_87ck1570 FIND v(dout0_87) AT=790.025n

.meas tran vdout0_88ck1570 FIND v(dout0_88) AT=790.025n

.meas tran vdout0_89ck1570 FIND v(dout0_89) AT=790.025n

.meas tran vdout0_90ck1570 FIND v(dout0_90) AT=790.025n

.meas tran vdout0_91ck1570 FIND v(dout0_91) AT=790.025n

.meas tran vdout0_92ck1570 FIND v(dout0_92) AT=790.025n

.meas tran vdout0_93ck1570 FIND v(dout0_93) AT=790.025n

.meas tran vdout0_94ck1570 FIND v(dout0_94) AT=790.025n

.meas tran vdout0_95ck1570 FIND v(dout0_95) AT=790.025n

.meas tran vdout0_96ck1570 FIND v(dout0_96) AT=790.025n

.meas tran vdout0_97ck1570 FIND v(dout0_97) AT=790.025n

.meas tran vdout0_98ck1570 FIND v(dout0_98) AT=790.025n

.meas tran vdout0_99ck1570 FIND v(dout0_99) AT=790.025n

.meas tran vdout0_100ck1570 FIND v(dout0_100) AT=790.025n

.meas tran vdout0_101ck1570 FIND v(dout0_101) AT=790.025n

.meas tran vdout0_102ck1570 FIND v(dout0_102) AT=790.025n

.meas tran vdout0_103ck1570 FIND v(dout0_103) AT=790.025n

.meas tran vdout0_104ck1570 FIND v(dout0_104) AT=790.025n

.meas tran vdout0_105ck1570 FIND v(dout0_105) AT=790.025n

.meas tran vdout0_106ck1570 FIND v(dout0_106) AT=790.025n

.meas tran vdout0_107ck1570 FIND v(dout0_107) AT=790.025n

.meas tran vdout0_108ck1570 FIND v(dout0_108) AT=790.025n

.meas tran vdout0_109ck1570 FIND v(dout0_109) AT=790.025n

.meas tran vdout0_110ck1570 FIND v(dout0_110) AT=790.025n

.meas tran vdout0_111ck1570 FIND v(dout0_111) AT=790.025n

.meas tran vdout0_112ck1570 FIND v(dout0_112) AT=790.025n

.meas tran vdout0_113ck1570 FIND v(dout0_113) AT=790.025n

.meas tran vdout0_114ck1570 FIND v(dout0_114) AT=790.025n

.meas tran vdout0_115ck1570 FIND v(dout0_115) AT=790.025n

.meas tran vdout0_116ck1570 FIND v(dout0_116) AT=790.025n

.meas tran vdout0_117ck1570 FIND v(dout0_117) AT=790.025n

.meas tran vdout0_118ck1570 FIND v(dout0_118) AT=790.025n

.meas tran vdout0_119ck1570 FIND v(dout0_119) AT=790.025n

.meas tran vdout0_120ck1570 FIND v(dout0_120) AT=790.025n

.meas tran vdout0_121ck1570 FIND v(dout0_121) AT=790.025n

.meas tran vdout0_122ck1570 FIND v(dout0_122) AT=790.025n

.meas tran vdout0_123ck1570 FIND v(dout0_123) AT=790.025n

.meas tran vdout0_124ck1570 FIND v(dout0_124) AT=790.025n

.meas tran vdout0_125ck1570 FIND v(dout0_125) AT=790.025n

.meas tran vdout0_126ck1570 FIND v(dout0_126) AT=790.025n

.meas tran vdout0_127ck1570 FIND v(dout0_127) AT=790.025n

.meas tran vdout0_0ck1580 FIND v(dout0_0) AT=795.025n

.meas tran vdout0_1ck1580 FIND v(dout0_1) AT=795.025n

.meas tran vdout0_2ck1580 FIND v(dout0_2) AT=795.025n

.meas tran vdout0_3ck1580 FIND v(dout0_3) AT=795.025n

.meas tran vdout0_4ck1580 FIND v(dout0_4) AT=795.025n

.meas tran vdout0_5ck1580 FIND v(dout0_5) AT=795.025n

.meas tran vdout0_6ck1580 FIND v(dout0_6) AT=795.025n

.meas tran vdout0_7ck1580 FIND v(dout0_7) AT=795.025n

.meas tran vdout0_8ck1580 FIND v(dout0_8) AT=795.025n

.meas tran vdout0_9ck1580 FIND v(dout0_9) AT=795.025n

.meas tran vdout0_10ck1580 FIND v(dout0_10) AT=795.025n

.meas tran vdout0_11ck1580 FIND v(dout0_11) AT=795.025n

.meas tran vdout0_12ck1580 FIND v(dout0_12) AT=795.025n

.meas tran vdout0_13ck1580 FIND v(dout0_13) AT=795.025n

.meas tran vdout0_14ck1580 FIND v(dout0_14) AT=795.025n

.meas tran vdout0_15ck1580 FIND v(dout0_15) AT=795.025n

.meas tran vdout0_16ck1580 FIND v(dout0_16) AT=795.025n

.meas tran vdout0_17ck1580 FIND v(dout0_17) AT=795.025n

.meas tran vdout0_18ck1580 FIND v(dout0_18) AT=795.025n

.meas tran vdout0_19ck1580 FIND v(dout0_19) AT=795.025n

.meas tran vdout0_20ck1580 FIND v(dout0_20) AT=795.025n

.meas tran vdout0_21ck1580 FIND v(dout0_21) AT=795.025n

.meas tran vdout0_22ck1580 FIND v(dout0_22) AT=795.025n

.meas tran vdout0_23ck1580 FIND v(dout0_23) AT=795.025n

.meas tran vdout0_24ck1580 FIND v(dout0_24) AT=795.025n

.meas tran vdout0_25ck1580 FIND v(dout0_25) AT=795.025n

.meas tran vdout0_26ck1580 FIND v(dout0_26) AT=795.025n

.meas tran vdout0_27ck1580 FIND v(dout0_27) AT=795.025n

.meas tran vdout0_28ck1580 FIND v(dout0_28) AT=795.025n

.meas tran vdout0_29ck1580 FIND v(dout0_29) AT=795.025n

.meas tran vdout0_30ck1580 FIND v(dout0_30) AT=795.025n

.meas tran vdout0_31ck1580 FIND v(dout0_31) AT=795.025n

.meas tran vdout0_32ck1580 FIND v(dout0_32) AT=795.025n

.meas tran vdout0_33ck1580 FIND v(dout0_33) AT=795.025n

.meas tran vdout0_34ck1580 FIND v(dout0_34) AT=795.025n

.meas tran vdout0_35ck1580 FIND v(dout0_35) AT=795.025n

.meas tran vdout0_36ck1580 FIND v(dout0_36) AT=795.025n

.meas tran vdout0_37ck1580 FIND v(dout0_37) AT=795.025n

.meas tran vdout0_38ck1580 FIND v(dout0_38) AT=795.025n

.meas tran vdout0_39ck1580 FIND v(dout0_39) AT=795.025n

.meas tran vdout0_40ck1580 FIND v(dout0_40) AT=795.025n

.meas tran vdout0_41ck1580 FIND v(dout0_41) AT=795.025n

.meas tran vdout0_42ck1580 FIND v(dout0_42) AT=795.025n

.meas tran vdout0_43ck1580 FIND v(dout0_43) AT=795.025n

.meas tran vdout0_44ck1580 FIND v(dout0_44) AT=795.025n

.meas tran vdout0_45ck1580 FIND v(dout0_45) AT=795.025n

.meas tran vdout0_46ck1580 FIND v(dout0_46) AT=795.025n

.meas tran vdout0_47ck1580 FIND v(dout0_47) AT=795.025n

.meas tran vdout0_48ck1580 FIND v(dout0_48) AT=795.025n

.meas tran vdout0_49ck1580 FIND v(dout0_49) AT=795.025n

.meas tran vdout0_50ck1580 FIND v(dout0_50) AT=795.025n

.meas tran vdout0_51ck1580 FIND v(dout0_51) AT=795.025n

.meas tran vdout0_52ck1580 FIND v(dout0_52) AT=795.025n

.meas tran vdout0_53ck1580 FIND v(dout0_53) AT=795.025n

.meas tran vdout0_54ck1580 FIND v(dout0_54) AT=795.025n

.meas tran vdout0_55ck1580 FIND v(dout0_55) AT=795.025n

.meas tran vdout0_56ck1580 FIND v(dout0_56) AT=795.025n

.meas tran vdout0_57ck1580 FIND v(dout0_57) AT=795.025n

.meas tran vdout0_58ck1580 FIND v(dout0_58) AT=795.025n

.meas tran vdout0_59ck1580 FIND v(dout0_59) AT=795.025n

.meas tran vdout0_60ck1580 FIND v(dout0_60) AT=795.025n

.meas tran vdout0_61ck1580 FIND v(dout0_61) AT=795.025n

.meas tran vdout0_62ck1580 FIND v(dout0_62) AT=795.025n

.meas tran vdout0_63ck1580 FIND v(dout0_63) AT=795.025n

.meas tran vdout0_64ck1580 FIND v(dout0_64) AT=795.025n

.meas tran vdout0_65ck1580 FIND v(dout0_65) AT=795.025n

.meas tran vdout0_66ck1580 FIND v(dout0_66) AT=795.025n

.meas tran vdout0_67ck1580 FIND v(dout0_67) AT=795.025n

.meas tran vdout0_68ck1580 FIND v(dout0_68) AT=795.025n

.meas tran vdout0_69ck1580 FIND v(dout0_69) AT=795.025n

.meas tran vdout0_70ck1580 FIND v(dout0_70) AT=795.025n

.meas tran vdout0_71ck1580 FIND v(dout0_71) AT=795.025n

.meas tran vdout0_72ck1580 FIND v(dout0_72) AT=795.025n

.meas tran vdout0_73ck1580 FIND v(dout0_73) AT=795.025n

.meas tran vdout0_74ck1580 FIND v(dout0_74) AT=795.025n

.meas tran vdout0_75ck1580 FIND v(dout0_75) AT=795.025n

.meas tran vdout0_76ck1580 FIND v(dout0_76) AT=795.025n

.meas tran vdout0_77ck1580 FIND v(dout0_77) AT=795.025n

.meas tran vdout0_78ck1580 FIND v(dout0_78) AT=795.025n

.meas tran vdout0_79ck1580 FIND v(dout0_79) AT=795.025n

.meas tran vdout0_80ck1580 FIND v(dout0_80) AT=795.025n

.meas tran vdout0_81ck1580 FIND v(dout0_81) AT=795.025n

.meas tran vdout0_82ck1580 FIND v(dout0_82) AT=795.025n

.meas tran vdout0_83ck1580 FIND v(dout0_83) AT=795.025n

.meas tran vdout0_84ck1580 FIND v(dout0_84) AT=795.025n

.meas tran vdout0_85ck1580 FIND v(dout0_85) AT=795.025n

.meas tran vdout0_86ck1580 FIND v(dout0_86) AT=795.025n

.meas tran vdout0_87ck1580 FIND v(dout0_87) AT=795.025n

.meas tran vdout0_88ck1580 FIND v(dout0_88) AT=795.025n

.meas tran vdout0_89ck1580 FIND v(dout0_89) AT=795.025n

.meas tran vdout0_90ck1580 FIND v(dout0_90) AT=795.025n

.meas tran vdout0_91ck1580 FIND v(dout0_91) AT=795.025n

.meas tran vdout0_92ck1580 FIND v(dout0_92) AT=795.025n

.meas tran vdout0_93ck1580 FIND v(dout0_93) AT=795.025n

.meas tran vdout0_94ck1580 FIND v(dout0_94) AT=795.025n

.meas tran vdout0_95ck1580 FIND v(dout0_95) AT=795.025n

.meas tran vdout0_96ck1580 FIND v(dout0_96) AT=795.025n

.meas tran vdout0_97ck1580 FIND v(dout0_97) AT=795.025n

.meas tran vdout0_98ck1580 FIND v(dout0_98) AT=795.025n

.meas tran vdout0_99ck1580 FIND v(dout0_99) AT=795.025n

.meas tran vdout0_100ck1580 FIND v(dout0_100) AT=795.025n

.meas tran vdout0_101ck1580 FIND v(dout0_101) AT=795.025n

.meas tran vdout0_102ck1580 FIND v(dout0_102) AT=795.025n

.meas tran vdout0_103ck1580 FIND v(dout0_103) AT=795.025n

.meas tran vdout0_104ck1580 FIND v(dout0_104) AT=795.025n

.meas tran vdout0_105ck1580 FIND v(dout0_105) AT=795.025n

.meas tran vdout0_106ck1580 FIND v(dout0_106) AT=795.025n

.meas tran vdout0_107ck1580 FIND v(dout0_107) AT=795.025n

.meas tran vdout0_108ck1580 FIND v(dout0_108) AT=795.025n

.meas tran vdout0_109ck1580 FIND v(dout0_109) AT=795.025n

.meas tran vdout0_110ck1580 FIND v(dout0_110) AT=795.025n

.meas tran vdout0_111ck1580 FIND v(dout0_111) AT=795.025n

.meas tran vdout0_112ck1580 FIND v(dout0_112) AT=795.025n

.meas tran vdout0_113ck1580 FIND v(dout0_113) AT=795.025n

.meas tran vdout0_114ck1580 FIND v(dout0_114) AT=795.025n

.meas tran vdout0_115ck1580 FIND v(dout0_115) AT=795.025n

.meas tran vdout0_116ck1580 FIND v(dout0_116) AT=795.025n

.meas tran vdout0_117ck1580 FIND v(dout0_117) AT=795.025n

.meas tran vdout0_118ck1580 FIND v(dout0_118) AT=795.025n

.meas tran vdout0_119ck1580 FIND v(dout0_119) AT=795.025n

.meas tran vdout0_120ck1580 FIND v(dout0_120) AT=795.025n

.meas tran vdout0_121ck1580 FIND v(dout0_121) AT=795.025n

.meas tran vdout0_122ck1580 FIND v(dout0_122) AT=795.025n

.meas tran vdout0_123ck1580 FIND v(dout0_123) AT=795.025n

.meas tran vdout0_124ck1580 FIND v(dout0_124) AT=795.025n

.meas tran vdout0_125ck1580 FIND v(dout0_125) AT=795.025n

.meas tran vdout0_126ck1580 FIND v(dout0_126) AT=795.025n

.meas tran vdout0_127ck1580 FIND v(dout0_127) AT=795.025n

.meas tran vdout0_0ck1590 FIND v(dout0_0) AT=800.025n

.meas tran vdout0_1ck1590 FIND v(dout0_1) AT=800.025n

.meas tran vdout0_2ck1590 FIND v(dout0_2) AT=800.025n

.meas tran vdout0_3ck1590 FIND v(dout0_3) AT=800.025n

.meas tran vdout0_4ck1590 FIND v(dout0_4) AT=800.025n

.meas tran vdout0_5ck1590 FIND v(dout0_5) AT=800.025n

.meas tran vdout0_6ck1590 FIND v(dout0_6) AT=800.025n

.meas tran vdout0_7ck1590 FIND v(dout0_7) AT=800.025n

.meas tran vdout0_8ck1590 FIND v(dout0_8) AT=800.025n

.meas tran vdout0_9ck1590 FIND v(dout0_9) AT=800.025n

.meas tran vdout0_10ck1590 FIND v(dout0_10) AT=800.025n

.meas tran vdout0_11ck1590 FIND v(dout0_11) AT=800.025n

.meas tran vdout0_12ck1590 FIND v(dout0_12) AT=800.025n

.meas tran vdout0_13ck1590 FIND v(dout0_13) AT=800.025n

.meas tran vdout0_14ck1590 FIND v(dout0_14) AT=800.025n

.meas tran vdout0_15ck1590 FIND v(dout0_15) AT=800.025n

.meas tran vdout0_16ck1590 FIND v(dout0_16) AT=800.025n

.meas tran vdout0_17ck1590 FIND v(dout0_17) AT=800.025n

.meas tran vdout0_18ck1590 FIND v(dout0_18) AT=800.025n

.meas tran vdout0_19ck1590 FIND v(dout0_19) AT=800.025n

.meas tran vdout0_20ck1590 FIND v(dout0_20) AT=800.025n

.meas tran vdout0_21ck1590 FIND v(dout0_21) AT=800.025n

.meas tran vdout0_22ck1590 FIND v(dout0_22) AT=800.025n

.meas tran vdout0_23ck1590 FIND v(dout0_23) AT=800.025n

.meas tran vdout0_24ck1590 FIND v(dout0_24) AT=800.025n

.meas tran vdout0_25ck1590 FIND v(dout0_25) AT=800.025n

.meas tran vdout0_26ck1590 FIND v(dout0_26) AT=800.025n

.meas tran vdout0_27ck1590 FIND v(dout0_27) AT=800.025n

.meas tran vdout0_28ck1590 FIND v(dout0_28) AT=800.025n

.meas tran vdout0_29ck1590 FIND v(dout0_29) AT=800.025n

.meas tran vdout0_30ck1590 FIND v(dout0_30) AT=800.025n

.meas tran vdout0_31ck1590 FIND v(dout0_31) AT=800.025n

.meas tran vdout0_32ck1590 FIND v(dout0_32) AT=800.025n

.meas tran vdout0_33ck1590 FIND v(dout0_33) AT=800.025n

.meas tran vdout0_34ck1590 FIND v(dout0_34) AT=800.025n

.meas tran vdout0_35ck1590 FIND v(dout0_35) AT=800.025n

.meas tran vdout0_36ck1590 FIND v(dout0_36) AT=800.025n

.meas tran vdout0_37ck1590 FIND v(dout0_37) AT=800.025n

.meas tran vdout0_38ck1590 FIND v(dout0_38) AT=800.025n

.meas tran vdout0_39ck1590 FIND v(dout0_39) AT=800.025n

.meas tran vdout0_40ck1590 FIND v(dout0_40) AT=800.025n

.meas tran vdout0_41ck1590 FIND v(dout0_41) AT=800.025n

.meas tran vdout0_42ck1590 FIND v(dout0_42) AT=800.025n

.meas tran vdout0_43ck1590 FIND v(dout0_43) AT=800.025n

.meas tran vdout0_44ck1590 FIND v(dout0_44) AT=800.025n

.meas tran vdout0_45ck1590 FIND v(dout0_45) AT=800.025n

.meas tran vdout0_46ck1590 FIND v(dout0_46) AT=800.025n

.meas tran vdout0_47ck1590 FIND v(dout0_47) AT=800.025n

.meas tran vdout0_48ck1590 FIND v(dout0_48) AT=800.025n

.meas tran vdout0_49ck1590 FIND v(dout0_49) AT=800.025n

.meas tran vdout0_50ck1590 FIND v(dout0_50) AT=800.025n

.meas tran vdout0_51ck1590 FIND v(dout0_51) AT=800.025n

.meas tran vdout0_52ck1590 FIND v(dout0_52) AT=800.025n

.meas tran vdout0_53ck1590 FIND v(dout0_53) AT=800.025n

.meas tran vdout0_54ck1590 FIND v(dout0_54) AT=800.025n

.meas tran vdout0_55ck1590 FIND v(dout0_55) AT=800.025n

.meas tran vdout0_56ck1590 FIND v(dout0_56) AT=800.025n

.meas tran vdout0_57ck1590 FIND v(dout0_57) AT=800.025n

.meas tran vdout0_58ck1590 FIND v(dout0_58) AT=800.025n

.meas tran vdout0_59ck1590 FIND v(dout0_59) AT=800.025n

.meas tran vdout0_60ck1590 FIND v(dout0_60) AT=800.025n

.meas tran vdout0_61ck1590 FIND v(dout0_61) AT=800.025n

.meas tran vdout0_62ck1590 FIND v(dout0_62) AT=800.025n

.meas tran vdout0_63ck1590 FIND v(dout0_63) AT=800.025n

.meas tran vdout0_64ck1590 FIND v(dout0_64) AT=800.025n

.meas tran vdout0_65ck1590 FIND v(dout0_65) AT=800.025n

.meas tran vdout0_66ck1590 FIND v(dout0_66) AT=800.025n

.meas tran vdout0_67ck1590 FIND v(dout0_67) AT=800.025n

.meas tran vdout0_68ck1590 FIND v(dout0_68) AT=800.025n

.meas tran vdout0_69ck1590 FIND v(dout0_69) AT=800.025n

.meas tran vdout0_70ck1590 FIND v(dout0_70) AT=800.025n

.meas tran vdout0_71ck1590 FIND v(dout0_71) AT=800.025n

.meas tran vdout0_72ck1590 FIND v(dout0_72) AT=800.025n

.meas tran vdout0_73ck1590 FIND v(dout0_73) AT=800.025n

.meas tran vdout0_74ck1590 FIND v(dout0_74) AT=800.025n

.meas tran vdout0_75ck1590 FIND v(dout0_75) AT=800.025n

.meas tran vdout0_76ck1590 FIND v(dout0_76) AT=800.025n

.meas tran vdout0_77ck1590 FIND v(dout0_77) AT=800.025n

.meas tran vdout0_78ck1590 FIND v(dout0_78) AT=800.025n

.meas tran vdout0_79ck1590 FIND v(dout0_79) AT=800.025n

.meas tran vdout0_80ck1590 FIND v(dout0_80) AT=800.025n

.meas tran vdout0_81ck1590 FIND v(dout0_81) AT=800.025n

.meas tran vdout0_82ck1590 FIND v(dout0_82) AT=800.025n

.meas tran vdout0_83ck1590 FIND v(dout0_83) AT=800.025n

.meas tran vdout0_84ck1590 FIND v(dout0_84) AT=800.025n

.meas tran vdout0_85ck1590 FIND v(dout0_85) AT=800.025n

.meas tran vdout0_86ck1590 FIND v(dout0_86) AT=800.025n

.meas tran vdout0_87ck1590 FIND v(dout0_87) AT=800.025n

.meas tran vdout0_88ck1590 FIND v(dout0_88) AT=800.025n

.meas tran vdout0_89ck1590 FIND v(dout0_89) AT=800.025n

.meas tran vdout0_90ck1590 FIND v(dout0_90) AT=800.025n

.meas tran vdout0_91ck1590 FIND v(dout0_91) AT=800.025n

.meas tran vdout0_92ck1590 FIND v(dout0_92) AT=800.025n

.meas tran vdout0_93ck1590 FIND v(dout0_93) AT=800.025n

.meas tran vdout0_94ck1590 FIND v(dout0_94) AT=800.025n

.meas tran vdout0_95ck1590 FIND v(dout0_95) AT=800.025n

.meas tran vdout0_96ck1590 FIND v(dout0_96) AT=800.025n

.meas tran vdout0_97ck1590 FIND v(dout0_97) AT=800.025n

.meas tran vdout0_98ck1590 FIND v(dout0_98) AT=800.025n

.meas tran vdout0_99ck1590 FIND v(dout0_99) AT=800.025n

.meas tran vdout0_100ck1590 FIND v(dout0_100) AT=800.025n

.meas tran vdout0_101ck1590 FIND v(dout0_101) AT=800.025n

.meas tran vdout0_102ck1590 FIND v(dout0_102) AT=800.025n

.meas tran vdout0_103ck1590 FIND v(dout0_103) AT=800.025n

.meas tran vdout0_104ck1590 FIND v(dout0_104) AT=800.025n

.meas tran vdout0_105ck1590 FIND v(dout0_105) AT=800.025n

.meas tran vdout0_106ck1590 FIND v(dout0_106) AT=800.025n

.meas tran vdout0_107ck1590 FIND v(dout0_107) AT=800.025n

.meas tran vdout0_108ck1590 FIND v(dout0_108) AT=800.025n

.meas tran vdout0_109ck1590 FIND v(dout0_109) AT=800.025n

.meas tran vdout0_110ck1590 FIND v(dout0_110) AT=800.025n

.meas tran vdout0_111ck1590 FIND v(dout0_111) AT=800.025n

.meas tran vdout0_112ck1590 FIND v(dout0_112) AT=800.025n

.meas tran vdout0_113ck1590 FIND v(dout0_113) AT=800.025n

.meas tran vdout0_114ck1590 FIND v(dout0_114) AT=800.025n

.meas tran vdout0_115ck1590 FIND v(dout0_115) AT=800.025n

.meas tran vdout0_116ck1590 FIND v(dout0_116) AT=800.025n

.meas tran vdout0_117ck1590 FIND v(dout0_117) AT=800.025n

.meas tran vdout0_118ck1590 FIND v(dout0_118) AT=800.025n

.meas tran vdout0_119ck1590 FIND v(dout0_119) AT=800.025n

.meas tran vdout0_120ck1590 FIND v(dout0_120) AT=800.025n

.meas tran vdout0_121ck1590 FIND v(dout0_121) AT=800.025n

.meas tran vdout0_122ck1590 FIND v(dout0_122) AT=800.025n

.meas tran vdout0_123ck1590 FIND v(dout0_123) AT=800.025n

.meas tran vdout0_124ck1590 FIND v(dout0_124) AT=800.025n

.meas tran vdout0_125ck1590 FIND v(dout0_125) AT=800.025n

.meas tran vdout0_126ck1590 FIND v(dout0_126) AT=800.025n

.meas tran vdout0_127ck1590 FIND v(dout0_127) AT=800.025n

.meas tran vdout0_0ck1600 FIND v(dout0_0) AT=805.025n

.meas tran vdout0_1ck1600 FIND v(dout0_1) AT=805.025n

.meas tran vdout0_2ck1600 FIND v(dout0_2) AT=805.025n

.meas tran vdout0_3ck1600 FIND v(dout0_3) AT=805.025n

.meas tran vdout0_4ck1600 FIND v(dout0_4) AT=805.025n

.meas tran vdout0_5ck1600 FIND v(dout0_5) AT=805.025n

.meas tran vdout0_6ck1600 FIND v(dout0_6) AT=805.025n

.meas tran vdout0_7ck1600 FIND v(dout0_7) AT=805.025n

.meas tran vdout0_8ck1600 FIND v(dout0_8) AT=805.025n

.meas tran vdout0_9ck1600 FIND v(dout0_9) AT=805.025n

.meas tran vdout0_10ck1600 FIND v(dout0_10) AT=805.025n

.meas tran vdout0_11ck1600 FIND v(dout0_11) AT=805.025n

.meas tran vdout0_12ck1600 FIND v(dout0_12) AT=805.025n

.meas tran vdout0_13ck1600 FIND v(dout0_13) AT=805.025n

.meas tran vdout0_14ck1600 FIND v(dout0_14) AT=805.025n

.meas tran vdout0_15ck1600 FIND v(dout0_15) AT=805.025n

.meas tran vdout0_16ck1600 FIND v(dout0_16) AT=805.025n

.meas tran vdout0_17ck1600 FIND v(dout0_17) AT=805.025n

.meas tran vdout0_18ck1600 FIND v(dout0_18) AT=805.025n

.meas tran vdout0_19ck1600 FIND v(dout0_19) AT=805.025n

.meas tran vdout0_20ck1600 FIND v(dout0_20) AT=805.025n

.meas tran vdout0_21ck1600 FIND v(dout0_21) AT=805.025n

.meas tran vdout0_22ck1600 FIND v(dout0_22) AT=805.025n

.meas tran vdout0_23ck1600 FIND v(dout0_23) AT=805.025n

.meas tran vdout0_24ck1600 FIND v(dout0_24) AT=805.025n

.meas tran vdout0_25ck1600 FIND v(dout0_25) AT=805.025n

.meas tran vdout0_26ck1600 FIND v(dout0_26) AT=805.025n

.meas tran vdout0_27ck1600 FIND v(dout0_27) AT=805.025n

.meas tran vdout0_28ck1600 FIND v(dout0_28) AT=805.025n

.meas tran vdout0_29ck1600 FIND v(dout0_29) AT=805.025n

.meas tran vdout0_30ck1600 FIND v(dout0_30) AT=805.025n

.meas tran vdout0_31ck1600 FIND v(dout0_31) AT=805.025n

.meas tran vdout0_32ck1600 FIND v(dout0_32) AT=805.025n

.meas tran vdout0_33ck1600 FIND v(dout0_33) AT=805.025n

.meas tran vdout0_34ck1600 FIND v(dout0_34) AT=805.025n

.meas tran vdout0_35ck1600 FIND v(dout0_35) AT=805.025n

.meas tran vdout0_36ck1600 FIND v(dout0_36) AT=805.025n

.meas tran vdout0_37ck1600 FIND v(dout0_37) AT=805.025n

.meas tran vdout0_38ck1600 FIND v(dout0_38) AT=805.025n

.meas tran vdout0_39ck1600 FIND v(dout0_39) AT=805.025n

.meas tran vdout0_40ck1600 FIND v(dout0_40) AT=805.025n

.meas tran vdout0_41ck1600 FIND v(dout0_41) AT=805.025n

.meas tran vdout0_42ck1600 FIND v(dout0_42) AT=805.025n

.meas tran vdout0_43ck1600 FIND v(dout0_43) AT=805.025n

.meas tran vdout0_44ck1600 FIND v(dout0_44) AT=805.025n

.meas tran vdout0_45ck1600 FIND v(dout0_45) AT=805.025n

.meas tran vdout0_46ck1600 FIND v(dout0_46) AT=805.025n

.meas tran vdout0_47ck1600 FIND v(dout0_47) AT=805.025n

.meas tran vdout0_48ck1600 FIND v(dout0_48) AT=805.025n

.meas tran vdout0_49ck1600 FIND v(dout0_49) AT=805.025n

.meas tran vdout0_50ck1600 FIND v(dout0_50) AT=805.025n

.meas tran vdout0_51ck1600 FIND v(dout0_51) AT=805.025n

.meas tran vdout0_52ck1600 FIND v(dout0_52) AT=805.025n

.meas tran vdout0_53ck1600 FIND v(dout0_53) AT=805.025n

.meas tran vdout0_54ck1600 FIND v(dout0_54) AT=805.025n

.meas tran vdout0_55ck1600 FIND v(dout0_55) AT=805.025n

.meas tran vdout0_56ck1600 FIND v(dout0_56) AT=805.025n

.meas tran vdout0_57ck1600 FIND v(dout0_57) AT=805.025n

.meas tran vdout0_58ck1600 FIND v(dout0_58) AT=805.025n

.meas tran vdout0_59ck1600 FIND v(dout0_59) AT=805.025n

.meas tran vdout0_60ck1600 FIND v(dout0_60) AT=805.025n

.meas tran vdout0_61ck1600 FIND v(dout0_61) AT=805.025n

.meas tran vdout0_62ck1600 FIND v(dout0_62) AT=805.025n

.meas tran vdout0_63ck1600 FIND v(dout0_63) AT=805.025n

.meas tran vdout0_64ck1600 FIND v(dout0_64) AT=805.025n

.meas tran vdout0_65ck1600 FIND v(dout0_65) AT=805.025n

.meas tran vdout0_66ck1600 FIND v(dout0_66) AT=805.025n

.meas tran vdout0_67ck1600 FIND v(dout0_67) AT=805.025n

.meas tran vdout0_68ck1600 FIND v(dout0_68) AT=805.025n

.meas tran vdout0_69ck1600 FIND v(dout0_69) AT=805.025n

.meas tran vdout0_70ck1600 FIND v(dout0_70) AT=805.025n

.meas tran vdout0_71ck1600 FIND v(dout0_71) AT=805.025n

.meas tran vdout0_72ck1600 FIND v(dout0_72) AT=805.025n

.meas tran vdout0_73ck1600 FIND v(dout0_73) AT=805.025n

.meas tran vdout0_74ck1600 FIND v(dout0_74) AT=805.025n

.meas tran vdout0_75ck1600 FIND v(dout0_75) AT=805.025n

.meas tran vdout0_76ck1600 FIND v(dout0_76) AT=805.025n

.meas tran vdout0_77ck1600 FIND v(dout0_77) AT=805.025n

.meas tran vdout0_78ck1600 FIND v(dout0_78) AT=805.025n

.meas tran vdout0_79ck1600 FIND v(dout0_79) AT=805.025n

.meas tran vdout0_80ck1600 FIND v(dout0_80) AT=805.025n

.meas tran vdout0_81ck1600 FIND v(dout0_81) AT=805.025n

.meas tran vdout0_82ck1600 FIND v(dout0_82) AT=805.025n

.meas tran vdout0_83ck1600 FIND v(dout0_83) AT=805.025n

.meas tran vdout0_84ck1600 FIND v(dout0_84) AT=805.025n

.meas tran vdout0_85ck1600 FIND v(dout0_85) AT=805.025n

.meas tran vdout0_86ck1600 FIND v(dout0_86) AT=805.025n

.meas tran vdout0_87ck1600 FIND v(dout0_87) AT=805.025n

.meas tran vdout0_88ck1600 FIND v(dout0_88) AT=805.025n

.meas tran vdout0_89ck1600 FIND v(dout0_89) AT=805.025n

.meas tran vdout0_90ck1600 FIND v(dout0_90) AT=805.025n

.meas tran vdout0_91ck1600 FIND v(dout0_91) AT=805.025n

.meas tran vdout0_92ck1600 FIND v(dout0_92) AT=805.025n

.meas tran vdout0_93ck1600 FIND v(dout0_93) AT=805.025n

.meas tran vdout0_94ck1600 FIND v(dout0_94) AT=805.025n

.meas tran vdout0_95ck1600 FIND v(dout0_95) AT=805.025n

.meas tran vdout0_96ck1600 FIND v(dout0_96) AT=805.025n

.meas tran vdout0_97ck1600 FIND v(dout0_97) AT=805.025n

.meas tran vdout0_98ck1600 FIND v(dout0_98) AT=805.025n

.meas tran vdout0_99ck1600 FIND v(dout0_99) AT=805.025n

.meas tran vdout0_100ck1600 FIND v(dout0_100) AT=805.025n

.meas tran vdout0_101ck1600 FIND v(dout0_101) AT=805.025n

.meas tran vdout0_102ck1600 FIND v(dout0_102) AT=805.025n

.meas tran vdout0_103ck1600 FIND v(dout0_103) AT=805.025n

.meas tran vdout0_104ck1600 FIND v(dout0_104) AT=805.025n

.meas tran vdout0_105ck1600 FIND v(dout0_105) AT=805.025n

.meas tran vdout0_106ck1600 FIND v(dout0_106) AT=805.025n

.meas tran vdout0_107ck1600 FIND v(dout0_107) AT=805.025n

.meas tran vdout0_108ck1600 FIND v(dout0_108) AT=805.025n

.meas tran vdout0_109ck1600 FIND v(dout0_109) AT=805.025n

.meas tran vdout0_110ck1600 FIND v(dout0_110) AT=805.025n

.meas tran vdout0_111ck1600 FIND v(dout0_111) AT=805.025n

.meas tran vdout0_112ck1600 FIND v(dout0_112) AT=805.025n

.meas tran vdout0_113ck1600 FIND v(dout0_113) AT=805.025n

.meas tran vdout0_114ck1600 FIND v(dout0_114) AT=805.025n

.meas tran vdout0_115ck1600 FIND v(dout0_115) AT=805.025n

.meas tran vdout0_116ck1600 FIND v(dout0_116) AT=805.025n

.meas tran vdout0_117ck1600 FIND v(dout0_117) AT=805.025n

.meas tran vdout0_118ck1600 FIND v(dout0_118) AT=805.025n

.meas tran vdout0_119ck1600 FIND v(dout0_119) AT=805.025n

.meas tran vdout0_120ck1600 FIND v(dout0_120) AT=805.025n

.meas tran vdout0_121ck1600 FIND v(dout0_121) AT=805.025n

.meas tran vdout0_122ck1600 FIND v(dout0_122) AT=805.025n

.meas tran vdout0_123ck1600 FIND v(dout0_123) AT=805.025n

.meas tran vdout0_124ck1600 FIND v(dout0_124) AT=805.025n

.meas tran vdout0_125ck1600 FIND v(dout0_125) AT=805.025n

.meas tran vdout0_126ck1600 FIND v(dout0_126) AT=805.025n

.meas tran vdout0_127ck1600 FIND v(dout0_127) AT=805.025n

.meas tran vdout0_0ck1610 FIND v(dout0_0) AT=810.025n

.meas tran vdout0_1ck1610 FIND v(dout0_1) AT=810.025n

.meas tran vdout0_2ck1610 FIND v(dout0_2) AT=810.025n

.meas tran vdout0_3ck1610 FIND v(dout0_3) AT=810.025n

.meas tran vdout0_4ck1610 FIND v(dout0_4) AT=810.025n

.meas tran vdout0_5ck1610 FIND v(dout0_5) AT=810.025n

.meas tran vdout0_6ck1610 FIND v(dout0_6) AT=810.025n

.meas tran vdout0_7ck1610 FIND v(dout0_7) AT=810.025n

.meas tran vdout0_8ck1610 FIND v(dout0_8) AT=810.025n

.meas tran vdout0_9ck1610 FIND v(dout0_9) AT=810.025n

.meas tran vdout0_10ck1610 FIND v(dout0_10) AT=810.025n

.meas tran vdout0_11ck1610 FIND v(dout0_11) AT=810.025n

.meas tran vdout0_12ck1610 FIND v(dout0_12) AT=810.025n

.meas tran vdout0_13ck1610 FIND v(dout0_13) AT=810.025n

.meas tran vdout0_14ck1610 FIND v(dout0_14) AT=810.025n

.meas tran vdout0_15ck1610 FIND v(dout0_15) AT=810.025n

.meas tran vdout0_16ck1610 FIND v(dout0_16) AT=810.025n

.meas tran vdout0_17ck1610 FIND v(dout0_17) AT=810.025n

.meas tran vdout0_18ck1610 FIND v(dout0_18) AT=810.025n

.meas tran vdout0_19ck1610 FIND v(dout0_19) AT=810.025n

.meas tran vdout0_20ck1610 FIND v(dout0_20) AT=810.025n

.meas tran vdout0_21ck1610 FIND v(dout0_21) AT=810.025n

.meas tran vdout0_22ck1610 FIND v(dout0_22) AT=810.025n

.meas tran vdout0_23ck1610 FIND v(dout0_23) AT=810.025n

.meas tran vdout0_24ck1610 FIND v(dout0_24) AT=810.025n

.meas tran vdout0_25ck1610 FIND v(dout0_25) AT=810.025n

.meas tran vdout0_26ck1610 FIND v(dout0_26) AT=810.025n

.meas tran vdout0_27ck1610 FIND v(dout0_27) AT=810.025n

.meas tran vdout0_28ck1610 FIND v(dout0_28) AT=810.025n

.meas tran vdout0_29ck1610 FIND v(dout0_29) AT=810.025n

.meas tran vdout0_30ck1610 FIND v(dout0_30) AT=810.025n

.meas tran vdout0_31ck1610 FIND v(dout0_31) AT=810.025n

.meas tran vdout0_32ck1610 FIND v(dout0_32) AT=810.025n

.meas tran vdout0_33ck1610 FIND v(dout0_33) AT=810.025n

.meas tran vdout0_34ck1610 FIND v(dout0_34) AT=810.025n

.meas tran vdout0_35ck1610 FIND v(dout0_35) AT=810.025n

.meas tran vdout0_36ck1610 FIND v(dout0_36) AT=810.025n

.meas tran vdout0_37ck1610 FIND v(dout0_37) AT=810.025n

.meas tran vdout0_38ck1610 FIND v(dout0_38) AT=810.025n

.meas tran vdout0_39ck1610 FIND v(dout0_39) AT=810.025n

.meas tran vdout0_40ck1610 FIND v(dout0_40) AT=810.025n

.meas tran vdout0_41ck1610 FIND v(dout0_41) AT=810.025n

.meas tran vdout0_42ck1610 FIND v(dout0_42) AT=810.025n

.meas tran vdout0_43ck1610 FIND v(dout0_43) AT=810.025n

.meas tran vdout0_44ck1610 FIND v(dout0_44) AT=810.025n

.meas tran vdout0_45ck1610 FIND v(dout0_45) AT=810.025n

.meas tran vdout0_46ck1610 FIND v(dout0_46) AT=810.025n

.meas tran vdout0_47ck1610 FIND v(dout0_47) AT=810.025n

.meas tran vdout0_48ck1610 FIND v(dout0_48) AT=810.025n

.meas tran vdout0_49ck1610 FIND v(dout0_49) AT=810.025n

.meas tran vdout0_50ck1610 FIND v(dout0_50) AT=810.025n

.meas tran vdout0_51ck1610 FIND v(dout0_51) AT=810.025n

.meas tran vdout0_52ck1610 FIND v(dout0_52) AT=810.025n

.meas tran vdout0_53ck1610 FIND v(dout0_53) AT=810.025n

.meas tran vdout0_54ck1610 FIND v(dout0_54) AT=810.025n

.meas tran vdout0_55ck1610 FIND v(dout0_55) AT=810.025n

.meas tran vdout0_56ck1610 FIND v(dout0_56) AT=810.025n

.meas tran vdout0_57ck1610 FIND v(dout0_57) AT=810.025n

.meas tran vdout0_58ck1610 FIND v(dout0_58) AT=810.025n

.meas tran vdout0_59ck1610 FIND v(dout0_59) AT=810.025n

.meas tran vdout0_60ck1610 FIND v(dout0_60) AT=810.025n

.meas tran vdout0_61ck1610 FIND v(dout0_61) AT=810.025n

.meas tran vdout0_62ck1610 FIND v(dout0_62) AT=810.025n

.meas tran vdout0_63ck1610 FIND v(dout0_63) AT=810.025n

.meas tran vdout0_64ck1610 FIND v(dout0_64) AT=810.025n

.meas tran vdout0_65ck1610 FIND v(dout0_65) AT=810.025n

.meas tran vdout0_66ck1610 FIND v(dout0_66) AT=810.025n

.meas tran vdout0_67ck1610 FIND v(dout0_67) AT=810.025n

.meas tran vdout0_68ck1610 FIND v(dout0_68) AT=810.025n

.meas tran vdout0_69ck1610 FIND v(dout0_69) AT=810.025n

.meas tran vdout0_70ck1610 FIND v(dout0_70) AT=810.025n

.meas tran vdout0_71ck1610 FIND v(dout0_71) AT=810.025n

.meas tran vdout0_72ck1610 FIND v(dout0_72) AT=810.025n

.meas tran vdout0_73ck1610 FIND v(dout0_73) AT=810.025n

.meas tran vdout0_74ck1610 FIND v(dout0_74) AT=810.025n

.meas tran vdout0_75ck1610 FIND v(dout0_75) AT=810.025n

.meas tran vdout0_76ck1610 FIND v(dout0_76) AT=810.025n

.meas tran vdout0_77ck1610 FIND v(dout0_77) AT=810.025n

.meas tran vdout0_78ck1610 FIND v(dout0_78) AT=810.025n

.meas tran vdout0_79ck1610 FIND v(dout0_79) AT=810.025n

.meas tran vdout0_80ck1610 FIND v(dout0_80) AT=810.025n

.meas tran vdout0_81ck1610 FIND v(dout0_81) AT=810.025n

.meas tran vdout0_82ck1610 FIND v(dout0_82) AT=810.025n

.meas tran vdout0_83ck1610 FIND v(dout0_83) AT=810.025n

.meas tran vdout0_84ck1610 FIND v(dout0_84) AT=810.025n

.meas tran vdout0_85ck1610 FIND v(dout0_85) AT=810.025n

.meas tran vdout0_86ck1610 FIND v(dout0_86) AT=810.025n

.meas tran vdout0_87ck1610 FIND v(dout0_87) AT=810.025n

.meas tran vdout0_88ck1610 FIND v(dout0_88) AT=810.025n

.meas tran vdout0_89ck1610 FIND v(dout0_89) AT=810.025n

.meas tran vdout0_90ck1610 FIND v(dout0_90) AT=810.025n

.meas tran vdout0_91ck1610 FIND v(dout0_91) AT=810.025n

.meas tran vdout0_92ck1610 FIND v(dout0_92) AT=810.025n

.meas tran vdout0_93ck1610 FIND v(dout0_93) AT=810.025n

.meas tran vdout0_94ck1610 FIND v(dout0_94) AT=810.025n

.meas tran vdout0_95ck1610 FIND v(dout0_95) AT=810.025n

.meas tran vdout0_96ck1610 FIND v(dout0_96) AT=810.025n

.meas tran vdout0_97ck1610 FIND v(dout0_97) AT=810.025n

.meas tran vdout0_98ck1610 FIND v(dout0_98) AT=810.025n

.meas tran vdout0_99ck1610 FIND v(dout0_99) AT=810.025n

.meas tran vdout0_100ck1610 FIND v(dout0_100) AT=810.025n

.meas tran vdout0_101ck1610 FIND v(dout0_101) AT=810.025n

.meas tran vdout0_102ck1610 FIND v(dout0_102) AT=810.025n

.meas tran vdout0_103ck1610 FIND v(dout0_103) AT=810.025n

.meas tran vdout0_104ck1610 FIND v(dout0_104) AT=810.025n

.meas tran vdout0_105ck1610 FIND v(dout0_105) AT=810.025n

.meas tran vdout0_106ck1610 FIND v(dout0_106) AT=810.025n

.meas tran vdout0_107ck1610 FIND v(dout0_107) AT=810.025n

.meas tran vdout0_108ck1610 FIND v(dout0_108) AT=810.025n

.meas tran vdout0_109ck1610 FIND v(dout0_109) AT=810.025n

.meas tran vdout0_110ck1610 FIND v(dout0_110) AT=810.025n

.meas tran vdout0_111ck1610 FIND v(dout0_111) AT=810.025n

.meas tran vdout0_112ck1610 FIND v(dout0_112) AT=810.025n

.meas tran vdout0_113ck1610 FIND v(dout0_113) AT=810.025n

.meas tran vdout0_114ck1610 FIND v(dout0_114) AT=810.025n

.meas tran vdout0_115ck1610 FIND v(dout0_115) AT=810.025n

.meas tran vdout0_116ck1610 FIND v(dout0_116) AT=810.025n

.meas tran vdout0_117ck1610 FIND v(dout0_117) AT=810.025n

.meas tran vdout0_118ck1610 FIND v(dout0_118) AT=810.025n

.meas tran vdout0_119ck1610 FIND v(dout0_119) AT=810.025n

.meas tran vdout0_120ck1610 FIND v(dout0_120) AT=810.025n

.meas tran vdout0_121ck1610 FIND v(dout0_121) AT=810.025n

.meas tran vdout0_122ck1610 FIND v(dout0_122) AT=810.025n

.meas tran vdout0_123ck1610 FIND v(dout0_123) AT=810.025n

.meas tran vdout0_124ck1610 FIND v(dout0_124) AT=810.025n

.meas tran vdout0_125ck1610 FIND v(dout0_125) AT=810.025n

.meas tran vdout0_126ck1610 FIND v(dout0_126) AT=810.025n

.meas tran vdout0_127ck1610 FIND v(dout0_127) AT=810.025n

.meas tran vdout0_0ck1660 FIND v(dout0_0) AT=835.025n

.meas tran vdout0_1ck1660 FIND v(dout0_1) AT=835.025n

.meas tran vdout0_2ck1660 FIND v(dout0_2) AT=835.025n

.meas tran vdout0_3ck1660 FIND v(dout0_3) AT=835.025n

.meas tran vdout0_4ck1660 FIND v(dout0_4) AT=835.025n

.meas tran vdout0_5ck1660 FIND v(dout0_5) AT=835.025n

.meas tran vdout0_6ck1660 FIND v(dout0_6) AT=835.025n

.meas tran vdout0_7ck1660 FIND v(dout0_7) AT=835.025n

.meas tran vdout0_8ck1660 FIND v(dout0_8) AT=835.025n

.meas tran vdout0_9ck1660 FIND v(dout0_9) AT=835.025n

.meas tran vdout0_10ck1660 FIND v(dout0_10) AT=835.025n

.meas tran vdout0_11ck1660 FIND v(dout0_11) AT=835.025n

.meas tran vdout0_12ck1660 FIND v(dout0_12) AT=835.025n

.meas tran vdout0_13ck1660 FIND v(dout0_13) AT=835.025n

.meas tran vdout0_14ck1660 FIND v(dout0_14) AT=835.025n

.meas tran vdout0_15ck1660 FIND v(dout0_15) AT=835.025n

.meas tran vdout0_16ck1660 FIND v(dout0_16) AT=835.025n

.meas tran vdout0_17ck1660 FIND v(dout0_17) AT=835.025n

.meas tran vdout0_18ck1660 FIND v(dout0_18) AT=835.025n

.meas tran vdout0_19ck1660 FIND v(dout0_19) AT=835.025n

.meas tran vdout0_20ck1660 FIND v(dout0_20) AT=835.025n

.meas tran vdout0_21ck1660 FIND v(dout0_21) AT=835.025n

.meas tran vdout0_22ck1660 FIND v(dout0_22) AT=835.025n

.meas tran vdout0_23ck1660 FIND v(dout0_23) AT=835.025n

.meas tran vdout0_24ck1660 FIND v(dout0_24) AT=835.025n

.meas tran vdout0_25ck1660 FIND v(dout0_25) AT=835.025n

.meas tran vdout0_26ck1660 FIND v(dout0_26) AT=835.025n

.meas tran vdout0_27ck1660 FIND v(dout0_27) AT=835.025n

.meas tran vdout0_28ck1660 FIND v(dout0_28) AT=835.025n

.meas tran vdout0_29ck1660 FIND v(dout0_29) AT=835.025n

.meas tran vdout0_30ck1660 FIND v(dout0_30) AT=835.025n

.meas tran vdout0_31ck1660 FIND v(dout0_31) AT=835.025n

.meas tran vdout0_32ck1660 FIND v(dout0_32) AT=835.025n

.meas tran vdout0_33ck1660 FIND v(dout0_33) AT=835.025n

.meas tran vdout0_34ck1660 FIND v(dout0_34) AT=835.025n

.meas tran vdout0_35ck1660 FIND v(dout0_35) AT=835.025n

.meas tran vdout0_36ck1660 FIND v(dout0_36) AT=835.025n

.meas tran vdout0_37ck1660 FIND v(dout0_37) AT=835.025n

.meas tran vdout0_38ck1660 FIND v(dout0_38) AT=835.025n

.meas tran vdout0_39ck1660 FIND v(dout0_39) AT=835.025n

.meas tran vdout0_40ck1660 FIND v(dout0_40) AT=835.025n

.meas tran vdout0_41ck1660 FIND v(dout0_41) AT=835.025n

.meas tran vdout0_42ck1660 FIND v(dout0_42) AT=835.025n

.meas tran vdout0_43ck1660 FIND v(dout0_43) AT=835.025n

.meas tran vdout0_44ck1660 FIND v(dout0_44) AT=835.025n

.meas tran vdout0_45ck1660 FIND v(dout0_45) AT=835.025n

.meas tran vdout0_46ck1660 FIND v(dout0_46) AT=835.025n

.meas tran vdout0_47ck1660 FIND v(dout0_47) AT=835.025n

.meas tran vdout0_48ck1660 FIND v(dout0_48) AT=835.025n

.meas tran vdout0_49ck1660 FIND v(dout0_49) AT=835.025n

.meas tran vdout0_50ck1660 FIND v(dout0_50) AT=835.025n

.meas tran vdout0_51ck1660 FIND v(dout0_51) AT=835.025n

.meas tran vdout0_52ck1660 FIND v(dout0_52) AT=835.025n

.meas tran vdout0_53ck1660 FIND v(dout0_53) AT=835.025n

.meas tran vdout0_54ck1660 FIND v(dout0_54) AT=835.025n

.meas tran vdout0_55ck1660 FIND v(dout0_55) AT=835.025n

.meas tran vdout0_56ck1660 FIND v(dout0_56) AT=835.025n

.meas tran vdout0_57ck1660 FIND v(dout0_57) AT=835.025n

.meas tran vdout0_58ck1660 FIND v(dout0_58) AT=835.025n

.meas tran vdout0_59ck1660 FIND v(dout0_59) AT=835.025n

.meas tran vdout0_60ck1660 FIND v(dout0_60) AT=835.025n

.meas tran vdout0_61ck1660 FIND v(dout0_61) AT=835.025n

.meas tran vdout0_62ck1660 FIND v(dout0_62) AT=835.025n

.meas tran vdout0_63ck1660 FIND v(dout0_63) AT=835.025n

.meas tran vdout0_64ck1660 FIND v(dout0_64) AT=835.025n

.meas tran vdout0_65ck1660 FIND v(dout0_65) AT=835.025n

.meas tran vdout0_66ck1660 FIND v(dout0_66) AT=835.025n

.meas tran vdout0_67ck1660 FIND v(dout0_67) AT=835.025n

.meas tran vdout0_68ck1660 FIND v(dout0_68) AT=835.025n

.meas tran vdout0_69ck1660 FIND v(dout0_69) AT=835.025n

.meas tran vdout0_70ck1660 FIND v(dout0_70) AT=835.025n

.meas tran vdout0_71ck1660 FIND v(dout0_71) AT=835.025n

.meas tran vdout0_72ck1660 FIND v(dout0_72) AT=835.025n

.meas tran vdout0_73ck1660 FIND v(dout0_73) AT=835.025n

.meas tran vdout0_74ck1660 FIND v(dout0_74) AT=835.025n

.meas tran vdout0_75ck1660 FIND v(dout0_75) AT=835.025n

.meas tran vdout0_76ck1660 FIND v(dout0_76) AT=835.025n

.meas tran vdout0_77ck1660 FIND v(dout0_77) AT=835.025n

.meas tran vdout0_78ck1660 FIND v(dout0_78) AT=835.025n

.meas tran vdout0_79ck1660 FIND v(dout0_79) AT=835.025n

.meas tran vdout0_80ck1660 FIND v(dout0_80) AT=835.025n

.meas tran vdout0_81ck1660 FIND v(dout0_81) AT=835.025n

.meas tran vdout0_82ck1660 FIND v(dout0_82) AT=835.025n

.meas tran vdout0_83ck1660 FIND v(dout0_83) AT=835.025n

.meas tran vdout0_84ck1660 FIND v(dout0_84) AT=835.025n

.meas tran vdout0_85ck1660 FIND v(dout0_85) AT=835.025n

.meas tran vdout0_86ck1660 FIND v(dout0_86) AT=835.025n

.meas tran vdout0_87ck1660 FIND v(dout0_87) AT=835.025n

.meas tran vdout0_88ck1660 FIND v(dout0_88) AT=835.025n

.meas tran vdout0_89ck1660 FIND v(dout0_89) AT=835.025n

.meas tran vdout0_90ck1660 FIND v(dout0_90) AT=835.025n

.meas tran vdout0_91ck1660 FIND v(dout0_91) AT=835.025n

.meas tran vdout0_92ck1660 FIND v(dout0_92) AT=835.025n

.meas tran vdout0_93ck1660 FIND v(dout0_93) AT=835.025n

.meas tran vdout0_94ck1660 FIND v(dout0_94) AT=835.025n

.meas tran vdout0_95ck1660 FIND v(dout0_95) AT=835.025n

.meas tran vdout0_96ck1660 FIND v(dout0_96) AT=835.025n

.meas tran vdout0_97ck1660 FIND v(dout0_97) AT=835.025n

.meas tran vdout0_98ck1660 FIND v(dout0_98) AT=835.025n

.meas tran vdout0_99ck1660 FIND v(dout0_99) AT=835.025n

.meas tran vdout0_100ck1660 FIND v(dout0_100) AT=835.025n

.meas tran vdout0_101ck1660 FIND v(dout0_101) AT=835.025n

.meas tran vdout0_102ck1660 FIND v(dout0_102) AT=835.025n

.meas tran vdout0_103ck1660 FIND v(dout0_103) AT=835.025n

.meas tran vdout0_104ck1660 FIND v(dout0_104) AT=835.025n

.meas tran vdout0_105ck1660 FIND v(dout0_105) AT=835.025n

.meas tran vdout0_106ck1660 FIND v(dout0_106) AT=835.025n

.meas tran vdout0_107ck1660 FIND v(dout0_107) AT=835.025n

.meas tran vdout0_108ck1660 FIND v(dout0_108) AT=835.025n

.meas tran vdout0_109ck1660 FIND v(dout0_109) AT=835.025n

.meas tran vdout0_110ck1660 FIND v(dout0_110) AT=835.025n

.meas tran vdout0_111ck1660 FIND v(dout0_111) AT=835.025n

.meas tran vdout0_112ck1660 FIND v(dout0_112) AT=835.025n

.meas tran vdout0_113ck1660 FIND v(dout0_113) AT=835.025n

.meas tran vdout0_114ck1660 FIND v(dout0_114) AT=835.025n

.meas tran vdout0_115ck1660 FIND v(dout0_115) AT=835.025n

.meas tran vdout0_116ck1660 FIND v(dout0_116) AT=835.025n

.meas tran vdout0_117ck1660 FIND v(dout0_117) AT=835.025n

.meas tran vdout0_118ck1660 FIND v(dout0_118) AT=835.025n

.meas tran vdout0_119ck1660 FIND v(dout0_119) AT=835.025n

.meas tran vdout0_120ck1660 FIND v(dout0_120) AT=835.025n

.meas tran vdout0_121ck1660 FIND v(dout0_121) AT=835.025n

.meas tran vdout0_122ck1660 FIND v(dout0_122) AT=835.025n

.meas tran vdout0_123ck1660 FIND v(dout0_123) AT=835.025n

.meas tran vdout0_124ck1660 FIND v(dout0_124) AT=835.025n

.meas tran vdout0_125ck1660 FIND v(dout0_125) AT=835.025n

.meas tran vdout0_126ck1660 FIND v(dout0_126) AT=835.025n

.meas tran vdout0_127ck1660 FIND v(dout0_127) AT=835.025n

.meas tran vdout0_0ck1670 FIND v(dout0_0) AT=840.025n

.meas tran vdout0_1ck1670 FIND v(dout0_1) AT=840.025n

.meas tran vdout0_2ck1670 FIND v(dout0_2) AT=840.025n

.meas tran vdout0_3ck1670 FIND v(dout0_3) AT=840.025n

.meas tran vdout0_4ck1670 FIND v(dout0_4) AT=840.025n

.meas tran vdout0_5ck1670 FIND v(dout0_5) AT=840.025n

.meas tran vdout0_6ck1670 FIND v(dout0_6) AT=840.025n

.meas tran vdout0_7ck1670 FIND v(dout0_7) AT=840.025n

.meas tran vdout0_8ck1670 FIND v(dout0_8) AT=840.025n

.meas tran vdout0_9ck1670 FIND v(dout0_9) AT=840.025n

.meas tran vdout0_10ck1670 FIND v(dout0_10) AT=840.025n

.meas tran vdout0_11ck1670 FIND v(dout0_11) AT=840.025n

.meas tran vdout0_12ck1670 FIND v(dout0_12) AT=840.025n

.meas tran vdout0_13ck1670 FIND v(dout0_13) AT=840.025n

.meas tran vdout0_14ck1670 FIND v(dout0_14) AT=840.025n

.meas tran vdout0_15ck1670 FIND v(dout0_15) AT=840.025n

.meas tran vdout0_16ck1670 FIND v(dout0_16) AT=840.025n

.meas tran vdout0_17ck1670 FIND v(dout0_17) AT=840.025n

.meas tran vdout0_18ck1670 FIND v(dout0_18) AT=840.025n

.meas tran vdout0_19ck1670 FIND v(dout0_19) AT=840.025n

.meas tran vdout0_20ck1670 FIND v(dout0_20) AT=840.025n

.meas tran vdout0_21ck1670 FIND v(dout0_21) AT=840.025n

.meas tran vdout0_22ck1670 FIND v(dout0_22) AT=840.025n

.meas tran vdout0_23ck1670 FIND v(dout0_23) AT=840.025n

.meas tran vdout0_24ck1670 FIND v(dout0_24) AT=840.025n

.meas tran vdout0_25ck1670 FIND v(dout0_25) AT=840.025n

.meas tran vdout0_26ck1670 FIND v(dout0_26) AT=840.025n

.meas tran vdout0_27ck1670 FIND v(dout0_27) AT=840.025n

.meas tran vdout0_28ck1670 FIND v(dout0_28) AT=840.025n

.meas tran vdout0_29ck1670 FIND v(dout0_29) AT=840.025n

.meas tran vdout0_30ck1670 FIND v(dout0_30) AT=840.025n

.meas tran vdout0_31ck1670 FIND v(dout0_31) AT=840.025n

.meas tran vdout0_32ck1670 FIND v(dout0_32) AT=840.025n

.meas tran vdout0_33ck1670 FIND v(dout0_33) AT=840.025n

.meas tran vdout0_34ck1670 FIND v(dout0_34) AT=840.025n

.meas tran vdout0_35ck1670 FIND v(dout0_35) AT=840.025n

.meas tran vdout0_36ck1670 FIND v(dout0_36) AT=840.025n

.meas tran vdout0_37ck1670 FIND v(dout0_37) AT=840.025n

.meas tran vdout0_38ck1670 FIND v(dout0_38) AT=840.025n

.meas tran vdout0_39ck1670 FIND v(dout0_39) AT=840.025n

.meas tran vdout0_40ck1670 FIND v(dout0_40) AT=840.025n

.meas tran vdout0_41ck1670 FIND v(dout0_41) AT=840.025n

.meas tran vdout0_42ck1670 FIND v(dout0_42) AT=840.025n

.meas tran vdout0_43ck1670 FIND v(dout0_43) AT=840.025n

.meas tran vdout0_44ck1670 FIND v(dout0_44) AT=840.025n

.meas tran vdout0_45ck1670 FIND v(dout0_45) AT=840.025n

.meas tran vdout0_46ck1670 FIND v(dout0_46) AT=840.025n

.meas tran vdout0_47ck1670 FIND v(dout0_47) AT=840.025n

.meas tran vdout0_48ck1670 FIND v(dout0_48) AT=840.025n

.meas tran vdout0_49ck1670 FIND v(dout0_49) AT=840.025n

.meas tran vdout0_50ck1670 FIND v(dout0_50) AT=840.025n

.meas tran vdout0_51ck1670 FIND v(dout0_51) AT=840.025n

.meas tran vdout0_52ck1670 FIND v(dout0_52) AT=840.025n

.meas tran vdout0_53ck1670 FIND v(dout0_53) AT=840.025n

.meas tran vdout0_54ck1670 FIND v(dout0_54) AT=840.025n

.meas tran vdout0_55ck1670 FIND v(dout0_55) AT=840.025n

.meas tran vdout0_56ck1670 FIND v(dout0_56) AT=840.025n

.meas tran vdout0_57ck1670 FIND v(dout0_57) AT=840.025n

.meas tran vdout0_58ck1670 FIND v(dout0_58) AT=840.025n

.meas tran vdout0_59ck1670 FIND v(dout0_59) AT=840.025n

.meas tran vdout0_60ck1670 FIND v(dout0_60) AT=840.025n

.meas tran vdout0_61ck1670 FIND v(dout0_61) AT=840.025n

.meas tran vdout0_62ck1670 FIND v(dout0_62) AT=840.025n

.meas tran vdout0_63ck1670 FIND v(dout0_63) AT=840.025n

.meas tran vdout0_64ck1670 FIND v(dout0_64) AT=840.025n

.meas tran vdout0_65ck1670 FIND v(dout0_65) AT=840.025n

.meas tran vdout0_66ck1670 FIND v(dout0_66) AT=840.025n

.meas tran vdout0_67ck1670 FIND v(dout0_67) AT=840.025n

.meas tran vdout0_68ck1670 FIND v(dout0_68) AT=840.025n

.meas tran vdout0_69ck1670 FIND v(dout0_69) AT=840.025n

.meas tran vdout0_70ck1670 FIND v(dout0_70) AT=840.025n

.meas tran vdout0_71ck1670 FIND v(dout0_71) AT=840.025n

.meas tran vdout0_72ck1670 FIND v(dout0_72) AT=840.025n

.meas tran vdout0_73ck1670 FIND v(dout0_73) AT=840.025n

.meas tran vdout0_74ck1670 FIND v(dout0_74) AT=840.025n

.meas tran vdout0_75ck1670 FIND v(dout0_75) AT=840.025n

.meas tran vdout0_76ck1670 FIND v(dout0_76) AT=840.025n

.meas tran vdout0_77ck1670 FIND v(dout0_77) AT=840.025n

.meas tran vdout0_78ck1670 FIND v(dout0_78) AT=840.025n

.meas tran vdout0_79ck1670 FIND v(dout0_79) AT=840.025n

.meas tran vdout0_80ck1670 FIND v(dout0_80) AT=840.025n

.meas tran vdout0_81ck1670 FIND v(dout0_81) AT=840.025n

.meas tran vdout0_82ck1670 FIND v(dout0_82) AT=840.025n

.meas tran vdout0_83ck1670 FIND v(dout0_83) AT=840.025n

.meas tran vdout0_84ck1670 FIND v(dout0_84) AT=840.025n

.meas tran vdout0_85ck1670 FIND v(dout0_85) AT=840.025n

.meas tran vdout0_86ck1670 FIND v(dout0_86) AT=840.025n

.meas tran vdout0_87ck1670 FIND v(dout0_87) AT=840.025n

.meas tran vdout0_88ck1670 FIND v(dout0_88) AT=840.025n

.meas tran vdout0_89ck1670 FIND v(dout0_89) AT=840.025n

.meas tran vdout0_90ck1670 FIND v(dout0_90) AT=840.025n

.meas tran vdout0_91ck1670 FIND v(dout0_91) AT=840.025n

.meas tran vdout0_92ck1670 FIND v(dout0_92) AT=840.025n

.meas tran vdout0_93ck1670 FIND v(dout0_93) AT=840.025n

.meas tran vdout0_94ck1670 FIND v(dout0_94) AT=840.025n

.meas tran vdout0_95ck1670 FIND v(dout0_95) AT=840.025n

.meas tran vdout0_96ck1670 FIND v(dout0_96) AT=840.025n

.meas tran vdout0_97ck1670 FIND v(dout0_97) AT=840.025n

.meas tran vdout0_98ck1670 FIND v(dout0_98) AT=840.025n

.meas tran vdout0_99ck1670 FIND v(dout0_99) AT=840.025n

.meas tran vdout0_100ck1670 FIND v(dout0_100) AT=840.025n

.meas tran vdout0_101ck1670 FIND v(dout0_101) AT=840.025n

.meas tran vdout0_102ck1670 FIND v(dout0_102) AT=840.025n

.meas tran vdout0_103ck1670 FIND v(dout0_103) AT=840.025n

.meas tran vdout0_104ck1670 FIND v(dout0_104) AT=840.025n

.meas tran vdout0_105ck1670 FIND v(dout0_105) AT=840.025n

.meas tran vdout0_106ck1670 FIND v(dout0_106) AT=840.025n

.meas tran vdout0_107ck1670 FIND v(dout0_107) AT=840.025n

.meas tran vdout0_108ck1670 FIND v(dout0_108) AT=840.025n

.meas tran vdout0_109ck1670 FIND v(dout0_109) AT=840.025n

.meas tran vdout0_110ck1670 FIND v(dout0_110) AT=840.025n

.meas tran vdout0_111ck1670 FIND v(dout0_111) AT=840.025n

.meas tran vdout0_112ck1670 FIND v(dout0_112) AT=840.025n

.meas tran vdout0_113ck1670 FIND v(dout0_113) AT=840.025n

.meas tran vdout0_114ck1670 FIND v(dout0_114) AT=840.025n

.meas tran vdout0_115ck1670 FIND v(dout0_115) AT=840.025n

.meas tran vdout0_116ck1670 FIND v(dout0_116) AT=840.025n

.meas tran vdout0_117ck1670 FIND v(dout0_117) AT=840.025n

.meas tran vdout0_118ck1670 FIND v(dout0_118) AT=840.025n

.meas tran vdout0_119ck1670 FIND v(dout0_119) AT=840.025n

.meas tran vdout0_120ck1670 FIND v(dout0_120) AT=840.025n

.meas tran vdout0_121ck1670 FIND v(dout0_121) AT=840.025n

.meas tran vdout0_122ck1670 FIND v(dout0_122) AT=840.025n

.meas tran vdout0_123ck1670 FIND v(dout0_123) AT=840.025n

.meas tran vdout0_124ck1670 FIND v(dout0_124) AT=840.025n

.meas tran vdout0_125ck1670 FIND v(dout0_125) AT=840.025n

.meas tran vdout0_126ck1670 FIND v(dout0_126) AT=840.025n

.meas tran vdout0_127ck1670 FIND v(dout0_127) AT=840.025n

.meas tran vdout0_0ck1680 FIND v(dout0_0) AT=845.025n

.meas tran vdout0_1ck1680 FIND v(dout0_1) AT=845.025n

.meas tran vdout0_2ck1680 FIND v(dout0_2) AT=845.025n

.meas tran vdout0_3ck1680 FIND v(dout0_3) AT=845.025n

.meas tran vdout0_4ck1680 FIND v(dout0_4) AT=845.025n

.meas tran vdout0_5ck1680 FIND v(dout0_5) AT=845.025n

.meas tran vdout0_6ck1680 FIND v(dout0_6) AT=845.025n

.meas tran vdout0_7ck1680 FIND v(dout0_7) AT=845.025n

.meas tran vdout0_8ck1680 FIND v(dout0_8) AT=845.025n

.meas tran vdout0_9ck1680 FIND v(dout0_9) AT=845.025n

.meas tran vdout0_10ck1680 FIND v(dout0_10) AT=845.025n

.meas tran vdout0_11ck1680 FIND v(dout0_11) AT=845.025n

.meas tran vdout0_12ck1680 FIND v(dout0_12) AT=845.025n

.meas tran vdout0_13ck1680 FIND v(dout0_13) AT=845.025n

.meas tran vdout0_14ck1680 FIND v(dout0_14) AT=845.025n

.meas tran vdout0_15ck1680 FIND v(dout0_15) AT=845.025n

.meas tran vdout0_16ck1680 FIND v(dout0_16) AT=845.025n

.meas tran vdout0_17ck1680 FIND v(dout0_17) AT=845.025n

.meas tran vdout0_18ck1680 FIND v(dout0_18) AT=845.025n

.meas tran vdout0_19ck1680 FIND v(dout0_19) AT=845.025n

.meas tran vdout0_20ck1680 FIND v(dout0_20) AT=845.025n

.meas tran vdout0_21ck1680 FIND v(dout0_21) AT=845.025n

.meas tran vdout0_22ck1680 FIND v(dout0_22) AT=845.025n

.meas tran vdout0_23ck1680 FIND v(dout0_23) AT=845.025n

.meas tran vdout0_24ck1680 FIND v(dout0_24) AT=845.025n

.meas tran vdout0_25ck1680 FIND v(dout0_25) AT=845.025n

.meas tran vdout0_26ck1680 FIND v(dout0_26) AT=845.025n

.meas tran vdout0_27ck1680 FIND v(dout0_27) AT=845.025n

.meas tran vdout0_28ck1680 FIND v(dout0_28) AT=845.025n

.meas tran vdout0_29ck1680 FIND v(dout0_29) AT=845.025n

.meas tran vdout0_30ck1680 FIND v(dout0_30) AT=845.025n

.meas tran vdout0_31ck1680 FIND v(dout0_31) AT=845.025n

.meas tran vdout0_32ck1680 FIND v(dout0_32) AT=845.025n

.meas tran vdout0_33ck1680 FIND v(dout0_33) AT=845.025n

.meas tran vdout0_34ck1680 FIND v(dout0_34) AT=845.025n

.meas tran vdout0_35ck1680 FIND v(dout0_35) AT=845.025n

.meas tran vdout0_36ck1680 FIND v(dout0_36) AT=845.025n

.meas tran vdout0_37ck1680 FIND v(dout0_37) AT=845.025n

.meas tran vdout0_38ck1680 FIND v(dout0_38) AT=845.025n

.meas tran vdout0_39ck1680 FIND v(dout0_39) AT=845.025n

.meas tran vdout0_40ck1680 FIND v(dout0_40) AT=845.025n

.meas tran vdout0_41ck1680 FIND v(dout0_41) AT=845.025n

.meas tran vdout0_42ck1680 FIND v(dout0_42) AT=845.025n

.meas tran vdout0_43ck1680 FIND v(dout0_43) AT=845.025n

.meas tran vdout0_44ck1680 FIND v(dout0_44) AT=845.025n

.meas tran vdout0_45ck1680 FIND v(dout0_45) AT=845.025n

.meas tran vdout0_46ck1680 FIND v(dout0_46) AT=845.025n

.meas tran vdout0_47ck1680 FIND v(dout0_47) AT=845.025n

.meas tran vdout0_48ck1680 FIND v(dout0_48) AT=845.025n

.meas tran vdout0_49ck1680 FIND v(dout0_49) AT=845.025n

.meas tran vdout0_50ck1680 FIND v(dout0_50) AT=845.025n

.meas tran vdout0_51ck1680 FIND v(dout0_51) AT=845.025n

.meas tran vdout0_52ck1680 FIND v(dout0_52) AT=845.025n

.meas tran vdout0_53ck1680 FIND v(dout0_53) AT=845.025n

.meas tran vdout0_54ck1680 FIND v(dout0_54) AT=845.025n

.meas tran vdout0_55ck1680 FIND v(dout0_55) AT=845.025n

.meas tran vdout0_56ck1680 FIND v(dout0_56) AT=845.025n

.meas tran vdout0_57ck1680 FIND v(dout0_57) AT=845.025n

.meas tran vdout0_58ck1680 FIND v(dout0_58) AT=845.025n

.meas tran vdout0_59ck1680 FIND v(dout0_59) AT=845.025n

.meas tran vdout0_60ck1680 FIND v(dout0_60) AT=845.025n

.meas tran vdout0_61ck1680 FIND v(dout0_61) AT=845.025n

.meas tran vdout0_62ck1680 FIND v(dout0_62) AT=845.025n

.meas tran vdout0_63ck1680 FIND v(dout0_63) AT=845.025n

.meas tran vdout0_64ck1680 FIND v(dout0_64) AT=845.025n

.meas tran vdout0_65ck1680 FIND v(dout0_65) AT=845.025n

.meas tran vdout0_66ck1680 FIND v(dout0_66) AT=845.025n

.meas tran vdout0_67ck1680 FIND v(dout0_67) AT=845.025n

.meas tran vdout0_68ck1680 FIND v(dout0_68) AT=845.025n

.meas tran vdout0_69ck1680 FIND v(dout0_69) AT=845.025n

.meas tran vdout0_70ck1680 FIND v(dout0_70) AT=845.025n

.meas tran vdout0_71ck1680 FIND v(dout0_71) AT=845.025n

.meas tran vdout0_72ck1680 FIND v(dout0_72) AT=845.025n

.meas tran vdout0_73ck1680 FIND v(dout0_73) AT=845.025n

.meas tran vdout0_74ck1680 FIND v(dout0_74) AT=845.025n

.meas tran vdout0_75ck1680 FIND v(dout0_75) AT=845.025n

.meas tran vdout0_76ck1680 FIND v(dout0_76) AT=845.025n

.meas tran vdout0_77ck1680 FIND v(dout0_77) AT=845.025n

.meas tran vdout0_78ck1680 FIND v(dout0_78) AT=845.025n

.meas tran vdout0_79ck1680 FIND v(dout0_79) AT=845.025n

.meas tran vdout0_80ck1680 FIND v(dout0_80) AT=845.025n

.meas tran vdout0_81ck1680 FIND v(dout0_81) AT=845.025n

.meas tran vdout0_82ck1680 FIND v(dout0_82) AT=845.025n

.meas tran vdout0_83ck1680 FIND v(dout0_83) AT=845.025n

.meas tran vdout0_84ck1680 FIND v(dout0_84) AT=845.025n

.meas tran vdout0_85ck1680 FIND v(dout0_85) AT=845.025n

.meas tran vdout0_86ck1680 FIND v(dout0_86) AT=845.025n

.meas tran vdout0_87ck1680 FIND v(dout0_87) AT=845.025n

.meas tran vdout0_88ck1680 FIND v(dout0_88) AT=845.025n

.meas tran vdout0_89ck1680 FIND v(dout0_89) AT=845.025n

.meas tran vdout0_90ck1680 FIND v(dout0_90) AT=845.025n

.meas tran vdout0_91ck1680 FIND v(dout0_91) AT=845.025n

.meas tran vdout0_92ck1680 FIND v(dout0_92) AT=845.025n

.meas tran vdout0_93ck1680 FIND v(dout0_93) AT=845.025n

.meas tran vdout0_94ck1680 FIND v(dout0_94) AT=845.025n

.meas tran vdout0_95ck1680 FIND v(dout0_95) AT=845.025n

.meas tran vdout0_96ck1680 FIND v(dout0_96) AT=845.025n

.meas tran vdout0_97ck1680 FIND v(dout0_97) AT=845.025n

.meas tran vdout0_98ck1680 FIND v(dout0_98) AT=845.025n

.meas tran vdout0_99ck1680 FIND v(dout0_99) AT=845.025n

.meas tran vdout0_100ck1680 FIND v(dout0_100) AT=845.025n

.meas tran vdout0_101ck1680 FIND v(dout0_101) AT=845.025n

.meas tran vdout0_102ck1680 FIND v(dout0_102) AT=845.025n

.meas tran vdout0_103ck1680 FIND v(dout0_103) AT=845.025n

.meas tran vdout0_104ck1680 FIND v(dout0_104) AT=845.025n

.meas tran vdout0_105ck1680 FIND v(dout0_105) AT=845.025n

.meas tran vdout0_106ck1680 FIND v(dout0_106) AT=845.025n

.meas tran vdout0_107ck1680 FIND v(dout0_107) AT=845.025n

.meas tran vdout0_108ck1680 FIND v(dout0_108) AT=845.025n

.meas tran vdout0_109ck1680 FIND v(dout0_109) AT=845.025n

.meas tran vdout0_110ck1680 FIND v(dout0_110) AT=845.025n

.meas tran vdout0_111ck1680 FIND v(dout0_111) AT=845.025n

.meas tran vdout0_112ck1680 FIND v(dout0_112) AT=845.025n

.meas tran vdout0_113ck1680 FIND v(dout0_113) AT=845.025n

.meas tran vdout0_114ck1680 FIND v(dout0_114) AT=845.025n

.meas tran vdout0_115ck1680 FIND v(dout0_115) AT=845.025n

.meas tran vdout0_116ck1680 FIND v(dout0_116) AT=845.025n

.meas tran vdout0_117ck1680 FIND v(dout0_117) AT=845.025n

.meas tran vdout0_118ck1680 FIND v(dout0_118) AT=845.025n

.meas tran vdout0_119ck1680 FIND v(dout0_119) AT=845.025n

.meas tran vdout0_120ck1680 FIND v(dout0_120) AT=845.025n

.meas tran vdout0_121ck1680 FIND v(dout0_121) AT=845.025n

.meas tran vdout0_122ck1680 FIND v(dout0_122) AT=845.025n

.meas tran vdout0_123ck1680 FIND v(dout0_123) AT=845.025n

.meas tran vdout0_124ck1680 FIND v(dout0_124) AT=845.025n

.meas tran vdout0_125ck1680 FIND v(dout0_125) AT=845.025n

.meas tran vdout0_126ck1680 FIND v(dout0_126) AT=845.025n

.meas tran vdout0_127ck1680 FIND v(dout0_127) AT=845.025n

.meas tran vdout0_0ck1780 FIND v(dout0_0) AT=895.025n

.meas tran vdout0_1ck1780 FIND v(dout0_1) AT=895.025n

.meas tran vdout0_2ck1780 FIND v(dout0_2) AT=895.025n

.meas tran vdout0_3ck1780 FIND v(dout0_3) AT=895.025n

.meas tran vdout0_4ck1780 FIND v(dout0_4) AT=895.025n

.meas tran vdout0_5ck1780 FIND v(dout0_5) AT=895.025n

.meas tran vdout0_6ck1780 FIND v(dout0_6) AT=895.025n

.meas tran vdout0_7ck1780 FIND v(dout0_7) AT=895.025n

.meas tran vdout0_8ck1780 FIND v(dout0_8) AT=895.025n

.meas tran vdout0_9ck1780 FIND v(dout0_9) AT=895.025n

.meas tran vdout0_10ck1780 FIND v(dout0_10) AT=895.025n

.meas tran vdout0_11ck1780 FIND v(dout0_11) AT=895.025n

.meas tran vdout0_12ck1780 FIND v(dout0_12) AT=895.025n

.meas tran vdout0_13ck1780 FIND v(dout0_13) AT=895.025n

.meas tran vdout0_14ck1780 FIND v(dout0_14) AT=895.025n

.meas tran vdout0_15ck1780 FIND v(dout0_15) AT=895.025n

.meas tran vdout0_16ck1780 FIND v(dout0_16) AT=895.025n

.meas tran vdout0_17ck1780 FIND v(dout0_17) AT=895.025n

.meas tran vdout0_18ck1780 FIND v(dout0_18) AT=895.025n

.meas tran vdout0_19ck1780 FIND v(dout0_19) AT=895.025n

.meas tran vdout0_20ck1780 FIND v(dout0_20) AT=895.025n

.meas tran vdout0_21ck1780 FIND v(dout0_21) AT=895.025n

.meas tran vdout0_22ck1780 FIND v(dout0_22) AT=895.025n

.meas tran vdout0_23ck1780 FIND v(dout0_23) AT=895.025n

.meas tran vdout0_24ck1780 FIND v(dout0_24) AT=895.025n

.meas tran vdout0_25ck1780 FIND v(dout0_25) AT=895.025n

.meas tran vdout0_26ck1780 FIND v(dout0_26) AT=895.025n

.meas tran vdout0_27ck1780 FIND v(dout0_27) AT=895.025n

.meas tran vdout0_28ck1780 FIND v(dout0_28) AT=895.025n

.meas tran vdout0_29ck1780 FIND v(dout0_29) AT=895.025n

.meas tran vdout0_30ck1780 FIND v(dout0_30) AT=895.025n

.meas tran vdout0_31ck1780 FIND v(dout0_31) AT=895.025n

.meas tran vdout0_32ck1780 FIND v(dout0_32) AT=895.025n

.meas tran vdout0_33ck1780 FIND v(dout0_33) AT=895.025n

.meas tran vdout0_34ck1780 FIND v(dout0_34) AT=895.025n

.meas tran vdout0_35ck1780 FIND v(dout0_35) AT=895.025n

.meas tran vdout0_36ck1780 FIND v(dout0_36) AT=895.025n

.meas tran vdout0_37ck1780 FIND v(dout0_37) AT=895.025n

.meas tran vdout0_38ck1780 FIND v(dout0_38) AT=895.025n

.meas tran vdout0_39ck1780 FIND v(dout0_39) AT=895.025n

.meas tran vdout0_40ck1780 FIND v(dout0_40) AT=895.025n

.meas tran vdout0_41ck1780 FIND v(dout0_41) AT=895.025n

.meas tran vdout0_42ck1780 FIND v(dout0_42) AT=895.025n

.meas tran vdout0_43ck1780 FIND v(dout0_43) AT=895.025n

.meas tran vdout0_44ck1780 FIND v(dout0_44) AT=895.025n

.meas tran vdout0_45ck1780 FIND v(dout0_45) AT=895.025n

.meas tran vdout0_46ck1780 FIND v(dout0_46) AT=895.025n

.meas tran vdout0_47ck1780 FIND v(dout0_47) AT=895.025n

.meas tran vdout0_48ck1780 FIND v(dout0_48) AT=895.025n

.meas tran vdout0_49ck1780 FIND v(dout0_49) AT=895.025n

.meas tran vdout0_50ck1780 FIND v(dout0_50) AT=895.025n

.meas tran vdout0_51ck1780 FIND v(dout0_51) AT=895.025n

.meas tran vdout0_52ck1780 FIND v(dout0_52) AT=895.025n

.meas tran vdout0_53ck1780 FIND v(dout0_53) AT=895.025n

.meas tran vdout0_54ck1780 FIND v(dout0_54) AT=895.025n

.meas tran vdout0_55ck1780 FIND v(dout0_55) AT=895.025n

.meas tran vdout0_56ck1780 FIND v(dout0_56) AT=895.025n

.meas tran vdout0_57ck1780 FIND v(dout0_57) AT=895.025n

.meas tran vdout0_58ck1780 FIND v(dout0_58) AT=895.025n

.meas tran vdout0_59ck1780 FIND v(dout0_59) AT=895.025n

.meas tran vdout0_60ck1780 FIND v(dout0_60) AT=895.025n

.meas tran vdout0_61ck1780 FIND v(dout0_61) AT=895.025n

.meas tran vdout0_62ck1780 FIND v(dout0_62) AT=895.025n

.meas tran vdout0_63ck1780 FIND v(dout0_63) AT=895.025n

.meas tran vdout0_64ck1780 FIND v(dout0_64) AT=895.025n

.meas tran vdout0_65ck1780 FIND v(dout0_65) AT=895.025n

.meas tran vdout0_66ck1780 FIND v(dout0_66) AT=895.025n

.meas tran vdout0_67ck1780 FIND v(dout0_67) AT=895.025n

.meas tran vdout0_68ck1780 FIND v(dout0_68) AT=895.025n

.meas tran vdout0_69ck1780 FIND v(dout0_69) AT=895.025n

.meas tran vdout0_70ck1780 FIND v(dout0_70) AT=895.025n

.meas tran vdout0_71ck1780 FIND v(dout0_71) AT=895.025n

.meas tran vdout0_72ck1780 FIND v(dout0_72) AT=895.025n

.meas tran vdout0_73ck1780 FIND v(dout0_73) AT=895.025n

.meas tran vdout0_74ck1780 FIND v(dout0_74) AT=895.025n

.meas tran vdout0_75ck1780 FIND v(dout0_75) AT=895.025n

.meas tran vdout0_76ck1780 FIND v(dout0_76) AT=895.025n

.meas tran vdout0_77ck1780 FIND v(dout0_77) AT=895.025n

.meas tran vdout0_78ck1780 FIND v(dout0_78) AT=895.025n

.meas tran vdout0_79ck1780 FIND v(dout0_79) AT=895.025n

.meas tran vdout0_80ck1780 FIND v(dout0_80) AT=895.025n

.meas tran vdout0_81ck1780 FIND v(dout0_81) AT=895.025n

.meas tran vdout0_82ck1780 FIND v(dout0_82) AT=895.025n

.meas tran vdout0_83ck1780 FIND v(dout0_83) AT=895.025n

.meas tran vdout0_84ck1780 FIND v(dout0_84) AT=895.025n

.meas tran vdout0_85ck1780 FIND v(dout0_85) AT=895.025n

.meas tran vdout0_86ck1780 FIND v(dout0_86) AT=895.025n

.meas tran vdout0_87ck1780 FIND v(dout0_87) AT=895.025n

.meas tran vdout0_88ck1780 FIND v(dout0_88) AT=895.025n

.meas tran vdout0_89ck1780 FIND v(dout0_89) AT=895.025n

.meas tran vdout0_90ck1780 FIND v(dout0_90) AT=895.025n

.meas tran vdout0_91ck1780 FIND v(dout0_91) AT=895.025n

.meas tran vdout0_92ck1780 FIND v(dout0_92) AT=895.025n

.meas tran vdout0_93ck1780 FIND v(dout0_93) AT=895.025n

.meas tran vdout0_94ck1780 FIND v(dout0_94) AT=895.025n

.meas tran vdout0_95ck1780 FIND v(dout0_95) AT=895.025n

.meas tran vdout0_96ck1780 FIND v(dout0_96) AT=895.025n

.meas tran vdout0_97ck1780 FIND v(dout0_97) AT=895.025n

.meas tran vdout0_98ck1780 FIND v(dout0_98) AT=895.025n

.meas tran vdout0_99ck1780 FIND v(dout0_99) AT=895.025n

.meas tran vdout0_100ck1780 FIND v(dout0_100) AT=895.025n

.meas tran vdout0_101ck1780 FIND v(dout0_101) AT=895.025n

.meas tran vdout0_102ck1780 FIND v(dout0_102) AT=895.025n

.meas tran vdout0_103ck1780 FIND v(dout0_103) AT=895.025n

.meas tran vdout0_104ck1780 FIND v(dout0_104) AT=895.025n

.meas tran vdout0_105ck1780 FIND v(dout0_105) AT=895.025n

.meas tran vdout0_106ck1780 FIND v(dout0_106) AT=895.025n

.meas tran vdout0_107ck1780 FIND v(dout0_107) AT=895.025n

.meas tran vdout0_108ck1780 FIND v(dout0_108) AT=895.025n

.meas tran vdout0_109ck1780 FIND v(dout0_109) AT=895.025n

.meas tran vdout0_110ck1780 FIND v(dout0_110) AT=895.025n

.meas tran vdout0_111ck1780 FIND v(dout0_111) AT=895.025n

.meas tran vdout0_112ck1780 FIND v(dout0_112) AT=895.025n

.meas tran vdout0_113ck1780 FIND v(dout0_113) AT=895.025n

.meas tran vdout0_114ck1780 FIND v(dout0_114) AT=895.025n

.meas tran vdout0_115ck1780 FIND v(dout0_115) AT=895.025n

.meas tran vdout0_116ck1780 FIND v(dout0_116) AT=895.025n

.meas tran vdout0_117ck1780 FIND v(dout0_117) AT=895.025n

.meas tran vdout0_118ck1780 FIND v(dout0_118) AT=895.025n

.meas tran vdout0_119ck1780 FIND v(dout0_119) AT=895.025n

.meas tran vdout0_120ck1780 FIND v(dout0_120) AT=895.025n

.meas tran vdout0_121ck1780 FIND v(dout0_121) AT=895.025n

.meas tran vdout0_122ck1780 FIND v(dout0_122) AT=895.025n

.meas tran vdout0_123ck1780 FIND v(dout0_123) AT=895.025n

.meas tran vdout0_124ck1780 FIND v(dout0_124) AT=895.025n

.meas tran vdout0_125ck1780 FIND v(dout0_125) AT=895.025n

.meas tran vdout0_126ck1780 FIND v(dout0_126) AT=895.025n

.meas tran vdout0_127ck1780 FIND v(dout0_127) AT=895.025n

.meas tran vdout0_0ck1830 FIND v(dout0_0) AT=920.025n

.meas tran vdout0_1ck1830 FIND v(dout0_1) AT=920.025n

.meas tran vdout0_2ck1830 FIND v(dout0_2) AT=920.025n

.meas tran vdout0_3ck1830 FIND v(dout0_3) AT=920.025n

.meas tran vdout0_4ck1830 FIND v(dout0_4) AT=920.025n

.meas tran vdout0_5ck1830 FIND v(dout0_5) AT=920.025n

.meas tran vdout0_6ck1830 FIND v(dout0_6) AT=920.025n

.meas tran vdout0_7ck1830 FIND v(dout0_7) AT=920.025n

.meas tran vdout0_8ck1830 FIND v(dout0_8) AT=920.025n

.meas tran vdout0_9ck1830 FIND v(dout0_9) AT=920.025n

.meas tran vdout0_10ck1830 FIND v(dout0_10) AT=920.025n

.meas tran vdout0_11ck1830 FIND v(dout0_11) AT=920.025n

.meas tran vdout0_12ck1830 FIND v(dout0_12) AT=920.025n

.meas tran vdout0_13ck1830 FIND v(dout0_13) AT=920.025n

.meas tran vdout0_14ck1830 FIND v(dout0_14) AT=920.025n

.meas tran vdout0_15ck1830 FIND v(dout0_15) AT=920.025n

.meas tran vdout0_16ck1830 FIND v(dout0_16) AT=920.025n

.meas tran vdout0_17ck1830 FIND v(dout0_17) AT=920.025n

.meas tran vdout0_18ck1830 FIND v(dout0_18) AT=920.025n

.meas tran vdout0_19ck1830 FIND v(dout0_19) AT=920.025n

.meas tran vdout0_20ck1830 FIND v(dout0_20) AT=920.025n

.meas tran vdout0_21ck1830 FIND v(dout0_21) AT=920.025n

.meas tran vdout0_22ck1830 FIND v(dout0_22) AT=920.025n

.meas tran vdout0_23ck1830 FIND v(dout0_23) AT=920.025n

.meas tran vdout0_24ck1830 FIND v(dout0_24) AT=920.025n

.meas tran vdout0_25ck1830 FIND v(dout0_25) AT=920.025n

.meas tran vdout0_26ck1830 FIND v(dout0_26) AT=920.025n

.meas tran vdout0_27ck1830 FIND v(dout0_27) AT=920.025n

.meas tran vdout0_28ck1830 FIND v(dout0_28) AT=920.025n

.meas tran vdout0_29ck1830 FIND v(dout0_29) AT=920.025n

.meas tran vdout0_30ck1830 FIND v(dout0_30) AT=920.025n

.meas tran vdout0_31ck1830 FIND v(dout0_31) AT=920.025n

.meas tran vdout0_32ck1830 FIND v(dout0_32) AT=920.025n

.meas tran vdout0_33ck1830 FIND v(dout0_33) AT=920.025n

.meas tran vdout0_34ck1830 FIND v(dout0_34) AT=920.025n

.meas tran vdout0_35ck1830 FIND v(dout0_35) AT=920.025n

.meas tran vdout0_36ck1830 FIND v(dout0_36) AT=920.025n

.meas tran vdout0_37ck1830 FIND v(dout0_37) AT=920.025n

.meas tran vdout0_38ck1830 FIND v(dout0_38) AT=920.025n

.meas tran vdout0_39ck1830 FIND v(dout0_39) AT=920.025n

.meas tran vdout0_40ck1830 FIND v(dout0_40) AT=920.025n

.meas tran vdout0_41ck1830 FIND v(dout0_41) AT=920.025n

.meas tran vdout0_42ck1830 FIND v(dout0_42) AT=920.025n

.meas tran vdout0_43ck1830 FIND v(dout0_43) AT=920.025n

.meas tran vdout0_44ck1830 FIND v(dout0_44) AT=920.025n

.meas tran vdout0_45ck1830 FIND v(dout0_45) AT=920.025n

.meas tran vdout0_46ck1830 FIND v(dout0_46) AT=920.025n

.meas tran vdout0_47ck1830 FIND v(dout0_47) AT=920.025n

.meas tran vdout0_48ck1830 FIND v(dout0_48) AT=920.025n

.meas tran vdout0_49ck1830 FIND v(dout0_49) AT=920.025n

.meas tran vdout0_50ck1830 FIND v(dout0_50) AT=920.025n

.meas tran vdout0_51ck1830 FIND v(dout0_51) AT=920.025n

.meas tran vdout0_52ck1830 FIND v(dout0_52) AT=920.025n

.meas tran vdout0_53ck1830 FIND v(dout0_53) AT=920.025n

.meas tran vdout0_54ck1830 FIND v(dout0_54) AT=920.025n

.meas tran vdout0_55ck1830 FIND v(dout0_55) AT=920.025n

.meas tran vdout0_56ck1830 FIND v(dout0_56) AT=920.025n

.meas tran vdout0_57ck1830 FIND v(dout0_57) AT=920.025n

.meas tran vdout0_58ck1830 FIND v(dout0_58) AT=920.025n

.meas tran vdout0_59ck1830 FIND v(dout0_59) AT=920.025n

.meas tran vdout0_60ck1830 FIND v(dout0_60) AT=920.025n

.meas tran vdout0_61ck1830 FIND v(dout0_61) AT=920.025n

.meas tran vdout0_62ck1830 FIND v(dout0_62) AT=920.025n

.meas tran vdout0_63ck1830 FIND v(dout0_63) AT=920.025n

.meas tran vdout0_64ck1830 FIND v(dout0_64) AT=920.025n

.meas tran vdout0_65ck1830 FIND v(dout0_65) AT=920.025n

.meas tran vdout0_66ck1830 FIND v(dout0_66) AT=920.025n

.meas tran vdout0_67ck1830 FIND v(dout0_67) AT=920.025n

.meas tran vdout0_68ck1830 FIND v(dout0_68) AT=920.025n

.meas tran vdout0_69ck1830 FIND v(dout0_69) AT=920.025n

.meas tran vdout0_70ck1830 FIND v(dout0_70) AT=920.025n

.meas tran vdout0_71ck1830 FIND v(dout0_71) AT=920.025n

.meas tran vdout0_72ck1830 FIND v(dout0_72) AT=920.025n

.meas tran vdout0_73ck1830 FIND v(dout0_73) AT=920.025n

.meas tran vdout0_74ck1830 FIND v(dout0_74) AT=920.025n

.meas tran vdout0_75ck1830 FIND v(dout0_75) AT=920.025n

.meas tran vdout0_76ck1830 FIND v(dout0_76) AT=920.025n

.meas tran vdout0_77ck1830 FIND v(dout0_77) AT=920.025n

.meas tran vdout0_78ck1830 FIND v(dout0_78) AT=920.025n

.meas tran vdout0_79ck1830 FIND v(dout0_79) AT=920.025n

.meas tran vdout0_80ck1830 FIND v(dout0_80) AT=920.025n

.meas tran vdout0_81ck1830 FIND v(dout0_81) AT=920.025n

.meas tran vdout0_82ck1830 FIND v(dout0_82) AT=920.025n

.meas tran vdout0_83ck1830 FIND v(dout0_83) AT=920.025n

.meas tran vdout0_84ck1830 FIND v(dout0_84) AT=920.025n

.meas tran vdout0_85ck1830 FIND v(dout0_85) AT=920.025n

.meas tran vdout0_86ck1830 FIND v(dout0_86) AT=920.025n

.meas tran vdout0_87ck1830 FIND v(dout0_87) AT=920.025n

.meas tran vdout0_88ck1830 FIND v(dout0_88) AT=920.025n

.meas tran vdout0_89ck1830 FIND v(dout0_89) AT=920.025n

.meas tran vdout0_90ck1830 FIND v(dout0_90) AT=920.025n

.meas tran vdout0_91ck1830 FIND v(dout0_91) AT=920.025n

.meas tran vdout0_92ck1830 FIND v(dout0_92) AT=920.025n

.meas tran vdout0_93ck1830 FIND v(dout0_93) AT=920.025n

.meas tran vdout0_94ck1830 FIND v(dout0_94) AT=920.025n

.meas tran vdout0_95ck1830 FIND v(dout0_95) AT=920.025n

.meas tran vdout0_96ck1830 FIND v(dout0_96) AT=920.025n

.meas tran vdout0_97ck1830 FIND v(dout0_97) AT=920.025n

.meas tran vdout0_98ck1830 FIND v(dout0_98) AT=920.025n

.meas tran vdout0_99ck1830 FIND v(dout0_99) AT=920.025n

.meas tran vdout0_100ck1830 FIND v(dout0_100) AT=920.025n

.meas tran vdout0_101ck1830 FIND v(dout0_101) AT=920.025n

.meas tran vdout0_102ck1830 FIND v(dout0_102) AT=920.025n

.meas tran vdout0_103ck1830 FIND v(dout0_103) AT=920.025n

.meas tran vdout0_104ck1830 FIND v(dout0_104) AT=920.025n

.meas tran vdout0_105ck1830 FIND v(dout0_105) AT=920.025n

.meas tran vdout0_106ck1830 FIND v(dout0_106) AT=920.025n

.meas tran vdout0_107ck1830 FIND v(dout0_107) AT=920.025n

.meas tran vdout0_108ck1830 FIND v(dout0_108) AT=920.025n

.meas tran vdout0_109ck1830 FIND v(dout0_109) AT=920.025n

.meas tran vdout0_110ck1830 FIND v(dout0_110) AT=920.025n

.meas tran vdout0_111ck1830 FIND v(dout0_111) AT=920.025n

.meas tran vdout0_112ck1830 FIND v(dout0_112) AT=920.025n

.meas tran vdout0_113ck1830 FIND v(dout0_113) AT=920.025n

.meas tran vdout0_114ck1830 FIND v(dout0_114) AT=920.025n

.meas tran vdout0_115ck1830 FIND v(dout0_115) AT=920.025n

.meas tran vdout0_116ck1830 FIND v(dout0_116) AT=920.025n

.meas tran vdout0_117ck1830 FIND v(dout0_117) AT=920.025n

.meas tran vdout0_118ck1830 FIND v(dout0_118) AT=920.025n

.meas tran vdout0_119ck1830 FIND v(dout0_119) AT=920.025n

.meas tran vdout0_120ck1830 FIND v(dout0_120) AT=920.025n

.meas tran vdout0_121ck1830 FIND v(dout0_121) AT=920.025n

.meas tran vdout0_122ck1830 FIND v(dout0_122) AT=920.025n

.meas tran vdout0_123ck1830 FIND v(dout0_123) AT=920.025n

.meas tran vdout0_124ck1830 FIND v(dout0_124) AT=920.025n

.meas tran vdout0_125ck1830 FIND v(dout0_125) AT=920.025n

.meas tran vdout0_126ck1830 FIND v(dout0_126) AT=920.025n

.meas tran vdout0_127ck1830 FIND v(dout0_127) AT=920.025n

.meas tran vdout0_0ck1850 FIND v(dout0_0) AT=930.025n

.meas tran vdout0_1ck1850 FIND v(dout0_1) AT=930.025n

.meas tran vdout0_2ck1850 FIND v(dout0_2) AT=930.025n

.meas tran vdout0_3ck1850 FIND v(dout0_3) AT=930.025n

.meas tran vdout0_4ck1850 FIND v(dout0_4) AT=930.025n

.meas tran vdout0_5ck1850 FIND v(dout0_5) AT=930.025n

.meas tran vdout0_6ck1850 FIND v(dout0_6) AT=930.025n

.meas tran vdout0_7ck1850 FIND v(dout0_7) AT=930.025n

.meas tran vdout0_8ck1850 FIND v(dout0_8) AT=930.025n

.meas tran vdout0_9ck1850 FIND v(dout0_9) AT=930.025n

.meas tran vdout0_10ck1850 FIND v(dout0_10) AT=930.025n

.meas tran vdout0_11ck1850 FIND v(dout0_11) AT=930.025n

.meas tran vdout0_12ck1850 FIND v(dout0_12) AT=930.025n

.meas tran vdout0_13ck1850 FIND v(dout0_13) AT=930.025n

.meas tran vdout0_14ck1850 FIND v(dout0_14) AT=930.025n

.meas tran vdout0_15ck1850 FIND v(dout0_15) AT=930.025n

.meas tran vdout0_16ck1850 FIND v(dout0_16) AT=930.025n

.meas tran vdout0_17ck1850 FIND v(dout0_17) AT=930.025n

.meas tran vdout0_18ck1850 FIND v(dout0_18) AT=930.025n

.meas tran vdout0_19ck1850 FIND v(dout0_19) AT=930.025n

.meas tran vdout0_20ck1850 FIND v(dout0_20) AT=930.025n

.meas tran vdout0_21ck1850 FIND v(dout0_21) AT=930.025n

.meas tran vdout0_22ck1850 FIND v(dout0_22) AT=930.025n

.meas tran vdout0_23ck1850 FIND v(dout0_23) AT=930.025n

.meas tran vdout0_24ck1850 FIND v(dout0_24) AT=930.025n

.meas tran vdout0_25ck1850 FIND v(dout0_25) AT=930.025n

.meas tran vdout0_26ck1850 FIND v(dout0_26) AT=930.025n

.meas tran vdout0_27ck1850 FIND v(dout0_27) AT=930.025n

.meas tran vdout0_28ck1850 FIND v(dout0_28) AT=930.025n

.meas tran vdout0_29ck1850 FIND v(dout0_29) AT=930.025n

.meas tran vdout0_30ck1850 FIND v(dout0_30) AT=930.025n

.meas tran vdout0_31ck1850 FIND v(dout0_31) AT=930.025n

.meas tran vdout0_32ck1850 FIND v(dout0_32) AT=930.025n

.meas tran vdout0_33ck1850 FIND v(dout0_33) AT=930.025n

.meas tran vdout0_34ck1850 FIND v(dout0_34) AT=930.025n

.meas tran vdout0_35ck1850 FIND v(dout0_35) AT=930.025n

.meas tran vdout0_36ck1850 FIND v(dout0_36) AT=930.025n

.meas tran vdout0_37ck1850 FIND v(dout0_37) AT=930.025n

.meas tran vdout0_38ck1850 FIND v(dout0_38) AT=930.025n

.meas tran vdout0_39ck1850 FIND v(dout0_39) AT=930.025n

.meas tran vdout0_40ck1850 FIND v(dout0_40) AT=930.025n

.meas tran vdout0_41ck1850 FIND v(dout0_41) AT=930.025n

.meas tran vdout0_42ck1850 FIND v(dout0_42) AT=930.025n

.meas tran vdout0_43ck1850 FIND v(dout0_43) AT=930.025n

.meas tran vdout0_44ck1850 FIND v(dout0_44) AT=930.025n

.meas tran vdout0_45ck1850 FIND v(dout0_45) AT=930.025n

.meas tran vdout0_46ck1850 FIND v(dout0_46) AT=930.025n

.meas tran vdout0_47ck1850 FIND v(dout0_47) AT=930.025n

.meas tran vdout0_48ck1850 FIND v(dout0_48) AT=930.025n

.meas tran vdout0_49ck1850 FIND v(dout0_49) AT=930.025n

.meas tran vdout0_50ck1850 FIND v(dout0_50) AT=930.025n

.meas tran vdout0_51ck1850 FIND v(dout0_51) AT=930.025n

.meas tran vdout0_52ck1850 FIND v(dout0_52) AT=930.025n

.meas tran vdout0_53ck1850 FIND v(dout0_53) AT=930.025n

.meas tran vdout0_54ck1850 FIND v(dout0_54) AT=930.025n

.meas tran vdout0_55ck1850 FIND v(dout0_55) AT=930.025n

.meas tran vdout0_56ck1850 FIND v(dout0_56) AT=930.025n

.meas tran vdout0_57ck1850 FIND v(dout0_57) AT=930.025n

.meas tran vdout0_58ck1850 FIND v(dout0_58) AT=930.025n

.meas tran vdout0_59ck1850 FIND v(dout0_59) AT=930.025n

.meas tran vdout0_60ck1850 FIND v(dout0_60) AT=930.025n

.meas tran vdout0_61ck1850 FIND v(dout0_61) AT=930.025n

.meas tran vdout0_62ck1850 FIND v(dout0_62) AT=930.025n

.meas tran vdout0_63ck1850 FIND v(dout0_63) AT=930.025n

.meas tran vdout0_64ck1850 FIND v(dout0_64) AT=930.025n

.meas tran vdout0_65ck1850 FIND v(dout0_65) AT=930.025n

.meas tran vdout0_66ck1850 FIND v(dout0_66) AT=930.025n

.meas tran vdout0_67ck1850 FIND v(dout0_67) AT=930.025n

.meas tran vdout0_68ck1850 FIND v(dout0_68) AT=930.025n

.meas tran vdout0_69ck1850 FIND v(dout0_69) AT=930.025n

.meas tran vdout0_70ck1850 FIND v(dout0_70) AT=930.025n

.meas tran vdout0_71ck1850 FIND v(dout0_71) AT=930.025n

.meas tran vdout0_72ck1850 FIND v(dout0_72) AT=930.025n

.meas tran vdout0_73ck1850 FIND v(dout0_73) AT=930.025n

.meas tran vdout0_74ck1850 FIND v(dout0_74) AT=930.025n

.meas tran vdout0_75ck1850 FIND v(dout0_75) AT=930.025n

.meas tran vdout0_76ck1850 FIND v(dout0_76) AT=930.025n

.meas tran vdout0_77ck1850 FIND v(dout0_77) AT=930.025n

.meas tran vdout0_78ck1850 FIND v(dout0_78) AT=930.025n

.meas tran vdout0_79ck1850 FIND v(dout0_79) AT=930.025n

.meas tran vdout0_80ck1850 FIND v(dout0_80) AT=930.025n

.meas tran vdout0_81ck1850 FIND v(dout0_81) AT=930.025n

.meas tran vdout0_82ck1850 FIND v(dout0_82) AT=930.025n

.meas tran vdout0_83ck1850 FIND v(dout0_83) AT=930.025n

.meas tran vdout0_84ck1850 FIND v(dout0_84) AT=930.025n

.meas tran vdout0_85ck1850 FIND v(dout0_85) AT=930.025n

.meas tran vdout0_86ck1850 FIND v(dout0_86) AT=930.025n

.meas tran vdout0_87ck1850 FIND v(dout0_87) AT=930.025n

.meas tran vdout0_88ck1850 FIND v(dout0_88) AT=930.025n

.meas tran vdout0_89ck1850 FIND v(dout0_89) AT=930.025n

.meas tran vdout0_90ck1850 FIND v(dout0_90) AT=930.025n

.meas tran vdout0_91ck1850 FIND v(dout0_91) AT=930.025n

.meas tran vdout0_92ck1850 FIND v(dout0_92) AT=930.025n

.meas tran vdout0_93ck1850 FIND v(dout0_93) AT=930.025n

.meas tran vdout0_94ck1850 FIND v(dout0_94) AT=930.025n

.meas tran vdout0_95ck1850 FIND v(dout0_95) AT=930.025n

.meas tran vdout0_96ck1850 FIND v(dout0_96) AT=930.025n

.meas tran vdout0_97ck1850 FIND v(dout0_97) AT=930.025n

.meas tran vdout0_98ck1850 FIND v(dout0_98) AT=930.025n

.meas tran vdout0_99ck1850 FIND v(dout0_99) AT=930.025n

.meas tran vdout0_100ck1850 FIND v(dout0_100) AT=930.025n

.meas tran vdout0_101ck1850 FIND v(dout0_101) AT=930.025n

.meas tran vdout0_102ck1850 FIND v(dout0_102) AT=930.025n

.meas tran vdout0_103ck1850 FIND v(dout0_103) AT=930.025n

.meas tran vdout0_104ck1850 FIND v(dout0_104) AT=930.025n

.meas tran vdout0_105ck1850 FIND v(dout0_105) AT=930.025n

.meas tran vdout0_106ck1850 FIND v(dout0_106) AT=930.025n

.meas tran vdout0_107ck1850 FIND v(dout0_107) AT=930.025n

.meas tran vdout0_108ck1850 FIND v(dout0_108) AT=930.025n

.meas tran vdout0_109ck1850 FIND v(dout0_109) AT=930.025n

.meas tran vdout0_110ck1850 FIND v(dout0_110) AT=930.025n

.meas tran vdout0_111ck1850 FIND v(dout0_111) AT=930.025n

.meas tran vdout0_112ck1850 FIND v(dout0_112) AT=930.025n

.meas tran vdout0_113ck1850 FIND v(dout0_113) AT=930.025n

.meas tran vdout0_114ck1850 FIND v(dout0_114) AT=930.025n

.meas tran vdout0_115ck1850 FIND v(dout0_115) AT=930.025n

.meas tran vdout0_116ck1850 FIND v(dout0_116) AT=930.025n

.meas tran vdout0_117ck1850 FIND v(dout0_117) AT=930.025n

.meas tran vdout0_118ck1850 FIND v(dout0_118) AT=930.025n

.meas tran vdout0_119ck1850 FIND v(dout0_119) AT=930.025n

.meas tran vdout0_120ck1850 FIND v(dout0_120) AT=930.025n

.meas tran vdout0_121ck1850 FIND v(dout0_121) AT=930.025n

.meas tran vdout0_122ck1850 FIND v(dout0_122) AT=930.025n

.meas tran vdout0_123ck1850 FIND v(dout0_123) AT=930.025n

.meas tran vdout0_124ck1850 FIND v(dout0_124) AT=930.025n

.meas tran vdout0_125ck1850 FIND v(dout0_125) AT=930.025n

.meas tran vdout0_126ck1850 FIND v(dout0_126) AT=930.025n

.meas tran vdout0_127ck1850 FIND v(dout0_127) AT=930.025n

.meas tran vdout0_0ck1870 FIND v(dout0_0) AT=940.025n

.meas tran vdout0_1ck1870 FIND v(dout0_1) AT=940.025n

.meas tran vdout0_2ck1870 FIND v(dout0_2) AT=940.025n

.meas tran vdout0_3ck1870 FIND v(dout0_3) AT=940.025n

.meas tran vdout0_4ck1870 FIND v(dout0_4) AT=940.025n

.meas tran vdout0_5ck1870 FIND v(dout0_5) AT=940.025n

.meas tran vdout0_6ck1870 FIND v(dout0_6) AT=940.025n

.meas tran vdout0_7ck1870 FIND v(dout0_7) AT=940.025n

.meas tran vdout0_8ck1870 FIND v(dout0_8) AT=940.025n

.meas tran vdout0_9ck1870 FIND v(dout0_9) AT=940.025n

.meas tran vdout0_10ck1870 FIND v(dout0_10) AT=940.025n

.meas tran vdout0_11ck1870 FIND v(dout0_11) AT=940.025n

.meas tran vdout0_12ck1870 FIND v(dout0_12) AT=940.025n

.meas tran vdout0_13ck1870 FIND v(dout0_13) AT=940.025n

.meas tran vdout0_14ck1870 FIND v(dout0_14) AT=940.025n

.meas tran vdout0_15ck1870 FIND v(dout0_15) AT=940.025n

.meas tran vdout0_16ck1870 FIND v(dout0_16) AT=940.025n

.meas tran vdout0_17ck1870 FIND v(dout0_17) AT=940.025n

.meas tran vdout0_18ck1870 FIND v(dout0_18) AT=940.025n

.meas tran vdout0_19ck1870 FIND v(dout0_19) AT=940.025n

.meas tran vdout0_20ck1870 FIND v(dout0_20) AT=940.025n

.meas tran vdout0_21ck1870 FIND v(dout0_21) AT=940.025n

.meas tran vdout0_22ck1870 FIND v(dout0_22) AT=940.025n

.meas tran vdout0_23ck1870 FIND v(dout0_23) AT=940.025n

.meas tran vdout0_24ck1870 FIND v(dout0_24) AT=940.025n

.meas tran vdout0_25ck1870 FIND v(dout0_25) AT=940.025n

.meas tran vdout0_26ck1870 FIND v(dout0_26) AT=940.025n

.meas tran vdout0_27ck1870 FIND v(dout0_27) AT=940.025n

.meas tran vdout0_28ck1870 FIND v(dout0_28) AT=940.025n

.meas tran vdout0_29ck1870 FIND v(dout0_29) AT=940.025n

.meas tran vdout0_30ck1870 FIND v(dout0_30) AT=940.025n

.meas tran vdout0_31ck1870 FIND v(dout0_31) AT=940.025n

.meas tran vdout0_32ck1870 FIND v(dout0_32) AT=940.025n

.meas tran vdout0_33ck1870 FIND v(dout0_33) AT=940.025n

.meas tran vdout0_34ck1870 FIND v(dout0_34) AT=940.025n

.meas tran vdout0_35ck1870 FIND v(dout0_35) AT=940.025n

.meas tran vdout0_36ck1870 FIND v(dout0_36) AT=940.025n

.meas tran vdout0_37ck1870 FIND v(dout0_37) AT=940.025n

.meas tran vdout0_38ck1870 FIND v(dout0_38) AT=940.025n

.meas tran vdout0_39ck1870 FIND v(dout0_39) AT=940.025n

.meas tran vdout0_40ck1870 FIND v(dout0_40) AT=940.025n

.meas tran vdout0_41ck1870 FIND v(dout0_41) AT=940.025n

.meas tran vdout0_42ck1870 FIND v(dout0_42) AT=940.025n

.meas tran vdout0_43ck1870 FIND v(dout0_43) AT=940.025n

.meas tran vdout0_44ck1870 FIND v(dout0_44) AT=940.025n

.meas tran vdout0_45ck1870 FIND v(dout0_45) AT=940.025n

.meas tran vdout0_46ck1870 FIND v(dout0_46) AT=940.025n

.meas tran vdout0_47ck1870 FIND v(dout0_47) AT=940.025n

.meas tran vdout0_48ck1870 FIND v(dout0_48) AT=940.025n

.meas tran vdout0_49ck1870 FIND v(dout0_49) AT=940.025n

.meas tran vdout0_50ck1870 FIND v(dout0_50) AT=940.025n

.meas tran vdout0_51ck1870 FIND v(dout0_51) AT=940.025n

.meas tran vdout0_52ck1870 FIND v(dout0_52) AT=940.025n

.meas tran vdout0_53ck1870 FIND v(dout0_53) AT=940.025n

.meas tran vdout0_54ck1870 FIND v(dout0_54) AT=940.025n

.meas tran vdout0_55ck1870 FIND v(dout0_55) AT=940.025n

.meas tran vdout0_56ck1870 FIND v(dout0_56) AT=940.025n

.meas tran vdout0_57ck1870 FIND v(dout0_57) AT=940.025n

.meas tran vdout0_58ck1870 FIND v(dout0_58) AT=940.025n

.meas tran vdout0_59ck1870 FIND v(dout0_59) AT=940.025n

.meas tran vdout0_60ck1870 FIND v(dout0_60) AT=940.025n

.meas tran vdout0_61ck1870 FIND v(dout0_61) AT=940.025n

.meas tran vdout0_62ck1870 FIND v(dout0_62) AT=940.025n

.meas tran vdout0_63ck1870 FIND v(dout0_63) AT=940.025n

.meas tran vdout0_64ck1870 FIND v(dout0_64) AT=940.025n

.meas tran vdout0_65ck1870 FIND v(dout0_65) AT=940.025n

.meas tran vdout0_66ck1870 FIND v(dout0_66) AT=940.025n

.meas tran vdout0_67ck1870 FIND v(dout0_67) AT=940.025n

.meas tran vdout0_68ck1870 FIND v(dout0_68) AT=940.025n

.meas tran vdout0_69ck1870 FIND v(dout0_69) AT=940.025n

.meas tran vdout0_70ck1870 FIND v(dout0_70) AT=940.025n

.meas tran vdout0_71ck1870 FIND v(dout0_71) AT=940.025n

.meas tran vdout0_72ck1870 FIND v(dout0_72) AT=940.025n

.meas tran vdout0_73ck1870 FIND v(dout0_73) AT=940.025n

.meas tran vdout0_74ck1870 FIND v(dout0_74) AT=940.025n

.meas tran vdout0_75ck1870 FIND v(dout0_75) AT=940.025n

.meas tran vdout0_76ck1870 FIND v(dout0_76) AT=940.025n

.meas tran vdout0_77ck1870 FIND v(dout0_77) AT=940.025n

.meas tran vdout0_78ck1870 FIND v(dout0_78) AT=940.025n

.meas tran vdout0_79ck1870 FIND v(dout0_79) AT=940.025n

.meas tran vdout0_80ck1870 FIND v(dout0_80) AT=940.025n

.meas tran vdout0_81ck1870 FIND v(dout0_81) AT=940.025n

.meas tran vdout0_82ck1870 FIND v(dout0_82) AT=940.025n

.meas tran vdout0_83ck1870 FIND v(dout0_83) AT=940.025n

.meas tran vdout0_84ck1870 FIND v(dout0_84) AT=940.025n

.meas tran vdout0_85ck1870 FIND v(dout0_85) AT=940.025n

.meas tran vdout0_86ck1870 FIND v(dout0_86) AT=940.025n

.meas tran vdout0_87ck1870 FIND v(dout0_87) AT=940.025n

.meas tran vdout0_88ck1870 FIND v(dout0_88) AT=940.025n

.meas tran vdout0_89ck1870 FIND v(dout0_89) AT=940.025n

.meas tran vdout0_90ck1870 FIND v(dout0_90) AT=940.025n

.meas tran vdout0_91ck1870 FIND v(dout0_91) AT=940.025n

.meas tran vdout0_92ck1870 FIND v(dout0_92) AT=940.025n

.meas tran vdout0_93ck1870 FIND v(dout0_93) AT=940.025n

.meas tran vdout0_94ck1870 FIND v(dout0_94) AT=940.025n

.meas tran vdout0_95ck1870 FIND v(dout0_95) AT=940.025n

.meas tran vdout0_96ck1870 FIND v(dout0_96) AT=940.025n

.meas tran vdout0_97ck1870 FIND v(dout0_97) AT=940.025n

.meas tran vdout0_98ck1870 FIND v(dout0_98) AT=940.025n

.meas tran vdout0_99ck1870 FIND v(dout0_99) AT=940.025n

.meas tran vdout0_100ck1870 FIND v(dout0_100) AT=940.025n

.meas tran vdout0_101ck1870 FIND v(dout0_101) AT=940.025n

.meas tran vdout0_102ck1870 FIND v(dout0_102) AT=940.025n

.meas tran vdout0_103ck1870 FIND v(dout0_103) AT=940.025n

.meas tran vdout0_104ck1870 FIND v(dout0_104) AT=940.025n

.meas tran vdout0_105ck1870 FIND v(dout0_105) AT=940.025n

.meas tran vdout0_106ck1870 FIND v(dout0_106) AT=940.025n

.meas tran vdout0_107ck1870 FIND v(dout0_107) AT=940.025n

.meas tran vdout0_108ck1870 FIND v(dout0_108) AT=940.025n

.meas tran vdout0_109ck1870 FIND v(dout0_109) AT=940.025n

.meas tran vdout0_110ck1870 FIND v(dout0_110) AT=940.025n

.meas tran vdout0_111ck1870 FIND v(dout0_111) AT=940.025n

.meas tran vdout0_112ck1870 FIND v(dout0_112) AT=940.025n

.meas tran vdout0_113ck1870 FIND v(dout0_113) AT=940.025n

.meas tran vdout0_114ck1870 FIND v(dout0_114) AT=940.025n

.meas tran vdout0_115ck1870 FIND v(dout0_115) AT=940.025n

.meas tran vdout0_116ck1870 FIND v(dout0_116) AT=940.025n

.meas tran vdout0_117ck1870 FIND v(dout0_117) AT=940.025n

.meas tran vdout0_118ck1870 FIND v(dout0_118) AT=940.025n

.meas tran vdout0_119ck1870 FIND v(dout0_119) AT=940.025n

.meas tran vdout0_120ck1870 FIND v(dout0_120) AT=940.025n

.meas tran vdout0_121ck1870 FIND v(dout0_121) AT=940.025n

.meas tran vdout0_122ck1870 FIND v(dout0_122) AT=940.025n

.meas tran vdout0_123ck1870 FIND v(dout0_123) AT=940.025n

.meas tran vdout0_124ck1870 FIND v(dout0_124) AT=940.025n

.meas tran vdout0_125ck1870 FIND v(dout0_125) AT=940.025n

.meas tran vdout0_126ck1870 FIND v(dout0_126) AT=940.025n

.meas tran vdout0_127ck1870 FIND v(dout0_127) AT=940.025n

.meas tran vdout0_0ck1880 FIND v(dout0_0) AT=945.025n

.meas tran vdout0_1ck1880 FIND v(dout0_1) AT=945.025n

.meas tran vdout0_2ck1880 FIND v(dout0_2) AT=945.025n

.meas tran vdout0_3ck1880 FIND v(dout0_3) AT=945.025n

.meas tran vdout0_4ck1880 FIND v(dout0_4) AT=945.025n

.meas tran vdout0_5ck1880 FIND v(dout0_5) AT=945.025n

.meas tran vdout0_6ck1880 FIND v(dout0_6) AT=945.025n

.meas tran vdout0_7ck1880 FIND v(dout0_7) AT=945.025n

.meas tran vdout0_8ck1880 FIND v(dout0_8) AT=945.025n

.meas tran vdout0_9ck1880 FIND v(dout0_9) AT=945.025n

.meas tran vdout0_10ck1880 FIND v(dout0_10) AT=945.025n

.meas tran vdout0_11ck1880 FIND v(dout0_11) AT=945.025n

.meas tran vdout0_12ck1880 FIND v(dout0_12) AT=945.025n

.meas tran vdout0_13ck1880 FIND v(dout0_13) AT=945.025n

.meas tran vdout0_14ck1880 FIND v(dout0_14) AT=945.025n

.meas tran vdout0_15ck1880 FIND v(dout0_15) AT=945.025n

.meas tran vdout0_16ck1880 FIND v(dout0_16) AT=945.025n

.meas tran vdout0_17ck1880 FIND v(dout0_17) AT=945.025n

.meas tran vdout0_18ck1880 FIND v(dout0_18) AT=945.025n

.meas tran vdout0_19ck1880 FIND v(dout0_19) AT=945.025n

.meas tran vdout0_20ck1880 FIND v(dout0_20) AT=945.025n

.meas tran vdout0_21ck1880 FIND v(dout0_21) AT=945.025n

.meas tran vdout0_22ck1880 FIND v(dout0_22) AT=945.025n

.meas tran vdout0_23ck1880 FIND v(dout0_23) AT=945.025n

.meas tran vdout0_24ck1880 FIND v(dout0_24) AT=945.025n

.meas tran vdout0_25ck1880 FIND v(dout0_25) AT=945.025n

.meas tran vdout0_26ck1880 FIND v(dout0_26) AT=945.025n

.meas tran vdout0_27ck1880 FIND v(dout0_27) AT=945.025n

.meas tran vdout0_28ck1880 FIND v(dout0_28) AT=945.025n

.meas tran vdout0_29ck1880 FIND v(dout0_29) AT=945.025n

.meas tran vdout0_30ck1880 FIND v(dout0_30) AT=945.025n

.meas tran vdout0_31ck1880 FIND v(dout0_31) AT=945.025n

.meas tran vdout0_32ck1880 FIND v(dout0_32) AT=945.025n

.meas tran vdout0_33ck1880 FIND v(dout0_33) AT=945.025n

.meas tran vdout0_34ck1880 FIND v(dout0_34) AT=945.025n

.meas tran vdout0_35ck1880 FIND v(dout0_35) AT=945.025n

.meas tran vdout0_36ck1880 FIND v(dout0_36) AT=945.025n

.meas tran vdout0_37ck1880 FIND v(dout0_37) AT=945.025n

.meas tran vdout0_38ck1880 FIND v(dout0_38) AT=945.025n

.meas tran vdout0_39ck1880 FIND v(dout0_39) AT=945.025n

.meas tran vdout0_40ck1880 FIND v(dout0_40) AT=945.025n

.meas tran vdout0_41ck1880 FIND v(dout0_41) AT=945.025n

.meas tran vdout0_42ck1880 FIND v(dout0_42) AT=945.025n

.meas tran vdout0_43ck1880 FIND v(dout0_43) AT=945.025n

.meas tran vdout0_44ck1880 FIND v(dout0_44) AT=945.025n

.meas tran vdout0_45ck1880 FIND v(dout0_45) AT=945.025n

.meas tran vdout0_46ck1880 FIND v(dout0_46) AT=945.025n

.meas tran vdout0_47ck1880 FIND v(dout0_47) AT=945.025n

.meas tran vdout0_48ck1880 FIND v(dout0_48) AT=945.025n

.meas tran vdout0_49ck1880 FIND v(dout0_49) AT=945.025n

.meas tran vdout0_50ck1880 FIND v(dout0_50) AT=945.025n

.meas tran vdout0_51ck1880 FIND v(dout0_51) AT=945.025n

.meas tran vdout0_52ck1880 FIND v(dout0_52) AT=945.025n

.meas tran vdout0_53ck1880 FIND v(dout0_53) AT=945.025n

.meas tran vdout0_54ck1880 FIND v(dout0_54) AT=945.025n

.meas tran vdout0_55ck1880 FIND v(dout0_55) AT=945.025n

.meas tran vdout0_56ck1880 FIND v(dout0_56) AT=945.025n

.meas tran vdout0_57ck1880 FIND v(dout0_57) AT=945.025n

.meas tran vdout0_58ck1880 FIND v(dout0_58) AT=945.025n

.meas tran vdout0_59ck1880 FIND v(dout0_59) AT=945.025n

.meas tran vdout0_60ck1880 FIND v(dout0_60) AT=945.025n

.meas tran vdout0_61ck1880 FIND v(dout0_61) AT=945.025n

.meas tran vdout0_62ck1880 FIND v(dout0_62) AT=945.025n

.meas tran vdout0_63ck1880 FIND v(dout0_63) AT=945.025n

.meas tran vdout0_64ck1880 FIND v(dout0_64) AT=945.025n

.meas tran vdout0_65ck1880 FIND v(dout0_65) AT=945.025n

.meas tran vdout0_66ck1880 FIND v(dout0_66) AT=945.025n

.meas tran vdout0_67ck1880 FIND v(dout0_67) AT=945.025n

.meas tran vdout0_68ck1880 FIND v(dout0_68) AT=945.025n

.meas tran vdout0_69ck1880 FIND v(dout0_69) AT=945.025n

.meas tran vdout0_70ck1880 FIND v(dout0_70) AT=945.025n

.meas tran vdout0_71ck1880 FIND v(dout0_71) AT=945.025n

.meas tran vdout0_72ck1880 FIND v(dout0_72) AT=945.025n

.meas tran vdout0_73ck1880 FIND v(dout0_73) AT=945.025n

.meas tran vdout0_74ck1880 FIND v(dout0_74) AT=945.025n

.meas tran vdout0_75ck1880 FIND v(dout0_75) AT=945.025n

.meas tran vdout0_76ck1880 FIND v(dout0_76) AT=945.025n

.meas tran vdout0_77ck1880 FIND v(dout0_77) AT=945.025n

.meas tran vdout0_78ck1880 FIND v(dout0_78) AT=945.025n

.meas tran vdout0_79ck1880 FIND v(dout0_79) AT=945.025n

.meas tran vdout0_80ck1880 FIND v(dout0_80) AT=945.025n

.meas tran vdout0_81ck1880 FIND v(dout0_81) AT=945.025n

.meas tran vdout0_82ck1880 FIND v(dout0_82) AT=945.025n

.meas tran vdout0_83ck1880 FIND v(dout0_83) AT=945.025n

.meas tran vdout0_84ck1880 FIND v(dout0_84) AT=945.025n

.meas tran vdout0_85ck1880 FIND v(dout0_85) AT=945.025n

.meas tran vdout0_86ck1880 FIND v(dout0_86) AT=945.025n

.meas tran vdout0_87ck1880 FIND v(dout0_87) AT=945.025n

.meas tran vdout0_88ck1880 FIND v(dout0_88) AT=945.025n

.meas tran vdout0_89ck1880 FIND v(dout0_89) AT=945.025n

.meas tran vdout0_90ck1880 FIND v(dout0_90) AT=945.025n

.meas tran vdout0_91ck1880 FIND v(dout0_91) AT=945.025n

.meas tran vdout0_92ck1880 FIND v(dout0_92) AT=945.025n

.meas tran vdout0_93ck1880 FIND v(dout0_93) AT=945.025n

.meas tran vdout0_94ck1880 FIND v(dout0_94) AT=945.025n

.meas tran vdout0_95ck1880 FIND v(dout0_95) AT=945.025n

.meas tran vdout0_96ck1880 FIND v(dout0_96) AT=945.025n

.meas tran vdout0_97ck1880 FIND v(dout0_97) AT=945.025n

.meas tran vdout0_98ck1880 FIND v(dout0_98) AT=945.025n

.meas tran vdout0_99ck1880 FIND v(dout0_99) AT=945.025n

.meas tran vdout0_100ck1880 FIND v(dout0_100) AT=945.025n

.meas tran vdout0_101ck1880 FIND v(dout0_101) AT=945.025n

.meas tran vdout0_102ck1880 FIND v(dout0_102) AT=945.025n

.meas tran vdout0_103ck1880 FIND v(dout0_103) AT=945.025n

.meas tran vdout0_104ck1880 FIND v(dout0_104) AT=945.025n

.meas tran vdout0_105ck1880 FIND v(dout0_105) AT=945.025n

.meas tran vdout0_106ck1880 FIND v(dout0_106) AT=945.025n

.meas tran vdout0_107ck1880 FIND v(dout0_107) AT=945.025n

.meas tran vdout0_108ck1880 FIND v(dout0_108) AT=945.025n

.meas tran vdout0_109ck1880 FIND v(dout0_109) AT=945.025n

.meas tran vdout0_110ck1880 FIND v(dout0_110) AT=945.025n

.meas tran vdout0_111ck1880 FIND v(dout0_111) AT=945.025n

.meas tran vdout0_112ck1880 FIND v(dout0_112) AT=945.025n

.meas tran vdout0_113ck1880 FIND v(dout0_113) AT=945.025n

.meas tran vdout0_114ck1880 FIND v(dout0_114) AT=945.025n

.meas tran vdout0_115ck1880 FIND v(dout0_115) AT=945.025n

.meas tran vdout0_116ck1880 FIND v(dout0_116) AT=945.025n

.meas tran vdout0_117ck1880 FIND v(dout0_117) AT=945.025n

.meas tran vdout0_118ck1880 FIND v(dout0_118) AT=945.025n

.meas tran vdout0_119ck1880 FIND v(dout0_119) AT=945.025n

.meas tran vdout0_120ck1880 FIND v(dout0_120) AT=945.025n

.meas tran vdout0_121ck1880 FIND v(dout0_121) AT=945.025n

.meas tran vdout0_122ck1880 FIND v(dout0_122) AT=945.025n

.meas tran vdout0_123ck1880 FIND v(dout0_123) AT=945.025n

.meas tran vdout0_124ck1880 FIND v(dout0_124) AT=945.025n

.meas tran vdout0_125ck1880 FIND v(dout0_125) AT=945.025n

.meas tran vdout0_126ck1880 FIND v(dout0_126) AT=945.025n

.meas tran vdout0_127ck1880 FIND v(dout0_127) AT=945.025n

.meas tran vdout0_0ck1900 FIND v(dout0_0) AT=955.025n

.meas tran vdout0_1ck1900 FIND v(dout0_1) AT=955.025n

.meas tran vdout0_2ck1900 FIND v(dout0_2) AT=955.025n

.meas tran vdout0_3ck1900 FIND v(dout0_3) AT=955.025n

.meas tran vdout0_4ck1900 FIND v(dout0_4) AT=955.025n

.meas tran vdout0_5ck1900 FIND v(dout0_5) AT=955.025n

.meas tran vdout0_6ck1900 FIND v(dout0_6) AT=955.025n

.meas tran vdout0_7ck1900 FIND v(dout0_7) AT=955.025n

.meas tran vdout0_8ck1900 FIND v(dout0_8) AT=955.025n

.meas tran vdout0_9ck1900 FIND v(dout0_9) AT=955.025n

.meas tran vdout0_10ck1900 FIND v(dout0_10) AT=955.025n

.meas tran vdout0_11ck1900 FIND v(dout0_11) AT=955.025n

.meas tran vdout0_12ck1900 FIND v(dout0_12) AT=955.025n

.meas tran vdout0_13ck1900 FIND v(dout0_13) AT=955.025n

.meas tran vdout0_14ck1900 FIND v(dout0_14) AT=955.025n

.meas tran vdout0_15ck1900 FIND v(dout0_15) AT=955.025n

.meas tran vdout0_16ck1900 FIND v(dout0_16) AT=955.025n

.meas tran vdout0_17ck1900 FIND v(dout0_17) AT=955.025n

.meas tran vdout0_18ck1900 FIND v(dout0_18) AT=955.025n

.meas tran vdout0_19ck1900 FIND v(dout0_19) AT=955.025n

.meas tran vdout0_20ck1900 FIND v(dout0_20) AT=955.025n

.meas tran vdout0_21ck1900 FIND v(dout0_21) AT=955.025n

.meas tran vdout0_22ck1900 FIND v(dout0_22) AT=955.025n

.meas tran vdout0_23ck1900 FIND v(dout0_23) AT=955.025n

.meas tran vdout0_24ck1900 FIND v(dout0_24) AT=955.025n

.meas tran vdout0_25ck1900 FIND v(dout0_25) AT=955.025n

.meas tran vdout0_26ck1900 FIND v(dout0_26) AT=955.025n

.meas tran vdout0_27ck1900 FIND v(dout0_27) AT=955.025n

.meas tran vdout0_28ck1900 FIND v(dout0_28) AT=955.025n

.meas tran vdout0_29ck1900 FIND v(dout0_29) AT=955.025n

.meas tran vdout0_30ck1900 FIND v(dout0_30) AT=955.025n

.meas tran vdout0_31ck1900 FIND v(dout0_31) AT=955.025n

.meas tran vdout0_32ck1900 FIND v(dout0_32) AT=955.025n

.meas tran vdout0_33ck1900 FIND v(dout0_33) AT=955.025n

.meas tran vdout0_34ck1900 FIND v(dout0_34) AT=955.025n

.meas tran vdout0_35ck1900 FIND v(dout0_35) AT=955.025n

.meas tran vdout0_36ck1900 FIND v(dout0_36) AT=955.025n

.meas tran vdout0_37ck1900 FIND v(dout0_37) AT=955.025n

.meas tran vdout0_38ck1900 FIND v(dout0_38) AT=955.025n

.meas tran vdout0_39ck1900 FIND v(dout0_39) AT=955.025n

.meas tran vdout0_40ck1900 FIND v(dout0_40) AT=955.025n

.meas tran vdout0_41ck1900 FIND v(dout0_41) AT=955.025n

.meas tran vdout0_42ck1900 FIND v(dout0_42) AT=955.025n

.meas tran vdout0_43ck1900 FIND v(dout0_43) AT=955.025n

.meas tran vdout0_44ck1900 FIND v(dout0_44) AT=955.025n

.meas tran vdout0_45ck1900 FIND v(dout0_45) AT=955.025n

.meas tran vdout0_46ck1900 FIND v(dout0_46) AT=955.025n

.meas tran vdout0_47ck1900 FIND v(dout0_47) AT=955.025n

.meas tran vdout0_48ck1900 FIND v(dout0_48) AT=955.025n

.meas tran vdout0_49ck1900 FIND v(dout0_49) AT=955.025n

.meas tran vdout0_50ck1900 FIND v(dout0_50) AT=955.025n

.meas tran vdout0_51ck1900 FIND v(dout0_51) AT=955.025n

.meas tran vdout0_52ck1900 FIND v(dout0_52) AT=955.025n

.meas tran vdout0_53ck1900 FIND v(dout0_53) AT=955.025n

.meas tran vdout0_54ck1900 FIND v(dout0_54) AT=955.025n

.meas tran vdout0_55ck1900 FIND v(dout0_55) AT=955.025n

.meas tran vdout0_56ck1900 FIND v(dout0_56) AT=955.025n

.meas tran vdout0_57ck1900 FIND v(dout0_57) AT=955.025n

.meas tran vdout0_58ck1900 FIND v(dout0_58) AT=955.025n

.meas tran vdout0_59ck1900 FIND v(dout0_59) AT=955.025n

.meas tran vdout0_60ck1900 FIND v(dout0_60) AT=955.025n

.meas tran vdout0_61ck1900 FIND v(dout0_61) AT=955.025n

.meas tran vdout0_62ck1900 FIND v(dout0_62) AT=955.025n

.meas tran vdout0_63ck1900 FIND v(dout0_63) AT=955.025n

.meas tran vdout0_64ck1900 FIND v(dout0_64) AT=955.025n

.meas tran vdout0_65ck1900 FIND v(dout0_65) AT=955.025n

.meas tran vdout0_66ck1900 FIND v(dout0_66) AT=955.025n

.meas tran vdout0_67ck1900 FIND v(dout0_67) AT=955.025n

.meas tran vdout0_68ck1900 FIND v(dout0_68) AT=955.025n

.meas tran vdout0_69ck1900 FIND v(dout0_69) AT=955.025n

.meas tran vdout0_70ck1900 FIND v(dout0_70) AT=955.025n

.meas tran vdout0_71ck1900 FIND v(dout0_71) AT=955.025n

.meas tran vdout0_72ck1900 FIND v(dout0_72) AT=955.025n

.meas tran vdout0_73ck1900 FIND v(dout0_73) AT=955.025n

.meas tran vdout0_74ck1900 FIND v(dout0_74) AT=955.025n

.meas tran vdout0_75ck1900 FIND v(dout0_75) AT=955.025n

.meas tran vdout0_76ck1900 FIND v(dout0_76) AT=955.025n

.meas tran vdout0_77ck1900 FIND v(dout0_77) AT=955.025n

.meas tran vdout0_78ck1900 FIND v(dout0_78) AT=955.025n

.meas tran vdout0_79ck1900 FIND v(dout0_79) AT=955.025n

.meas tran vdout0_80ck1900 FIND v(dout0_80) AT=955.025n

.meas tran vdout0_81ck1900 FIND v(dout0_81) AT=955.025n

.meas tran vdout0_82ck1900 FIND v(dout0_82) AT=955.025n

.meas tran vdout0_83ck1900 FIND v(dout0_83) AT=955.025n

.meas tran vdout0_84ck1900 FIND v(dout0_84) AT=955.025n

.meas tran vdout0_85ck1900 FIND v(dout0_85) AT=955.025n

.meas tran vdout0_86ck1900 FIND v(dout0_86) AT=955.025n

.meas tran vdout0_87ck1900 FIND v(dout0_87) AT=955.025n

.meas tran vdout0_88ck1900 FIND v(dout0_88) AT=955.025n

.meas tran vdout0_89ck1900 FIND v(dout0_89) AT=955.025n

.meas tran vdout0_90ck1900 FIND v(dout0_90) AT=955.025n

.meas tran vdout0_91ck1900 FIND v(dout0_91) AT=955.025n

.meas tran vdout0_92ck1900 FIND v(dout0_92) AT=955.025n

.meas tran vdout0_93ck1900 FIND v(dout0_93) AT=955.025n

.meas tran vdout0_94ck1900 FIND v(dout0_94) AT=955.025n

.meas tran vdout0_95ck1900 FIND v(dout0_95) AT=955.025n

.meas tran vdout0_96ck1900 FIND v(dout0_96) AT=955.025n

.meas tran vdout0_97ck1900 FIND v(dout0_97) AT=955.025n

.meas tran vdout0_98ck1900 FIND v(dout0_98) AT=955.025n

.meas tran vdout0_99ck1900 FIND v(dout0_99) AT=955.025n

.meas tran vdout0_100ck1900 FIND v(dout0_100) AT=955.025n

.meas tran vdout0_101ck1900 FIND v(dout0_101) AT=955.025n

.meas tran vdout0_102ck1900 FIND v(dout0_102) AT=955.025n

.meas tran vdout0_103ck1900 FIND v(dout0_103) AT=955.025n

.meas tran vdout0_104ck1900 FIND v(dout0_104) AT=955.025n

.meas tran vdout0_105ck1900 FIND v(dout0_105) AT=955.025n

.meas tran vdout0_106ck1900 FIND v(dout0_106) AT=955.025n

.meas tran vdout0_107ck1900 FIND v(dout0_107) AT=955.025n

.meas tran vdout0_108ck1900 FIND v(dout0_108) AT=955.025n

.meas tran vdout0_109ck1900 FIND v(dout0_109) AT=955.025n

.meas tran vdout0_110ck1900 FIND v(dout0_110) AT=955.025n

.meas tran vdout0_111ck1900 FIND v(dout0_111) AT=955.025n

.meas tran vdout0_112ck1900 FIND v(dout0_112) AT=955.025n

.meas tran vdout0_113ck1900 FIND v(dout0_113) AT=955.025n

.meas tran vdout0_114ck1900 FIND v(dout0_114) AT=955.025n

.meas tran vdout0_115ck1900 FIND v(dout0_115) AT=955.025n

.meas tran vdout0_116ck1900 FIND v(dout0_116) AT=955.025n

.meas tran vdout0_117ck1900 FIND v(dout0_117) AT=955.025n

.meas tran vdout0_118ck1900 FIND v(dout0_118) AT=955.025n

.meas tran vdout0_119ck1900 FIND v(dout0_119) AT=955.025n

.meas tran vdout0_120ck1900 FIND v(dout0_120) AT=955.025n

.meas tran vdout0_121ck1900 FIND v(dout0_121) AT=955.025n

.meas tran vdout0_122ck1900 FIND v(dout0_122) AT=955.025n

.meas tran vdout0_123ck1900 FIND v(dout0_123) AT=955.025n

.meas tran vdout0_124ck1900 FIND v(dout0_124) AT=955.025n

.meas tran vdout0_125ck1900 FIND v(dout0_125) AT=955.025n

.meas tran vdout0_126ck1900 FIND v(dout0_126) AT=955.025n

.meas tran vdout0_127ck1900 FIND v(dout0_127) AT=955.025n

.meas tran vdout0_0ck1920 FIND v(dout0_0) AT=965.025n

.meas tran vdout0_1ck1920 FIND v(dout0_1) AT=965.025n

.meas tran vdout0_2ck1920 FIND v(dout0_2) AT=965.025n

.meas tran vdout0_3ck1920 FIND v(dout0_3) AT=965.025n

.meas tran vdout0_4ck1920 FIND v(dout0_4) AT=965.025n

.meas tran vdout0_5ck1920 FIND v(dout0_5) AT=965.025n

.meas tran vdout0_6ck1920 FIND v(dout0_6) AT=965.025n

.meas tran vdout0_7ck1920 FIND v(dout0_7) AT=965.025n

.meas tran vdout0_8ck1920 FIND v(dout0_8) AT=965.025n

.meas tran vdout0_9ck1920 FIND v(dout0_9) AT=965.025n

.meas tran vdout0_10ck1920 FIND v(dout0_10) AT=965.025n

.meas tran vdout0_11ck1920 FIND v(dout0_11) AT=965.025n

.meas tran vdout0_12ck1920 FIND v(dout0_12) AT=965.025n

.meas tran vdout0_13ck1920 FIND v(dout0_13) AT=965.025n

.meas tran vdout0_14ck1920 FIND v(dout0_14) AT=965.025n

.meas tran vdout0_15ck1920 FIND v(dout0_15) AT=965.025n

.meas tran vdout0_16ck1920 FIND v(dout0_16) AT=965.025n

.meas tran vdout0_17ck1920 FIND v(dout0_17) AT=965.025n

.meas tran vdout0_18ck1920 FIND v(dout0_18) AT=965.025n

.meas tran vdout0_19ck1920 FIND v(dout0_19) AT=965.025n

.meas tran vdout0_20ck1920 FIND v(dout0_20) AT=965.025n

.meas tran vdout0_21ck1920 FIND v(dout0_21) AT=965.025n

.meas tran vdout0_22ck1920 FIND v(dout0_22) AT=965.025n

.meas tran vdout0_23ck1920 FIND v(dout0_23) AT=965.025n

.meas tran vdout0_24ck1920 FIND v(dout0_24) AT=965.025n

.meas tran vdout0_25ck1920 FIND v(dout0_25) AT=965.025n

.meas tran vdout0_26ck1920 FIND v(dout0_26) AT=965.025n

.meas tran vdout0_27ck1920 FIND v(dout0_27) AT=965.025n

.meas tran vdout0_28ck1920 FIND v(dout0_28) AT=965.025n

.meas tran vdout0_29ck1920 FIND v(dout0_29) AT=965.025n

.meas tran vdout0_30ck1920 FIND v(dout0_30) AT=965.025n

.meas tran vdout0_31ck1920 FIND v(dout0_31) AT=965.025n

.meas tran vdout0_32ck1920 FIND v(dout0_32) AT=965.025n

.meas tran vdout0_33ck1920 FIND v(dout0_33) AT=965.025n

.meas tran vdout0_34ck1920 FIND v(dout0_34) AT=965.025n

.meas tran vdout0_35ck1920 FIND v(dout0_35) AT=965.025n

.meas tran vdout0_36ck1920 FIND v(dout0_36) AT=965.025n

.meas tran vdout0_37ck1920 FIND v(dout0_37) AT=965.025n

.meas tran vdout0_38ck1920 FIND v(dout0_38) AT=965.025n

.meas tran vdout0_39ck1920 FIND v(dout0_39) AT=965.025n

.meas tran vdout0_40ck1920 FIND v(dout0_40) AT=965.025n

.meas tran vdout0_41ck1920 FIND v(dout0_41) AT=965.025n

.meas tran vdout0_42ck1920 FIND v(dout0_42) AT=965.025n

.meas tran vdout0_43ck1920 FIND v(dout0_43) AT=965.025n

.meas tran vdout0_44ck1920 FIND v(dout0_44) AT=965.025n

.meas tran vdout0_45ck1920 FIND v(dout0_45) AT=965.025n

.meas tran vdout0_46ck1920 FIND v(dout0_46) AT=965.025n

.meas tran vdout0_47ck1920 FIND v(dout0_47) AT=965.025n

.meas tran vdout0_48ck1920 FIND v(dout0_48) AT=965.025n

.meas tran vdout0_49ck1920 FIND v(dout0_49) AT=965.025n

.meas tran vdout0_50ck1920 FIND v(dout0_50) AT=965.025n

.meas tran vdout0_51ck1920 FIND v(dout0_51) AT=965.025n

.meas tran vdout0_52ck1920 FIND v(dout0_52) AT=965.025n

.meas tran vdout0_53ck1920 FIND v(dout0_53) AT=965.025n

.meas tran vdout0_54ck1920 FIND v(dout0_54) AT=965.025n

.meas tran vdout0_55ck1920 FIND v(dout0_55) AT=965.025n

.meas tran vdout0_56ck1920 FIND v(dout0_56) AT=965.025n

.meas tran vdout0_57ck1920 FIND v(dout0_57) AT=965.025n

.meas tran vdout0_58ck1920 FIND v(dout0_58) AT=965.025n

.meas tran vdout0_59ck1920 FIND v(dout0_59) AT=965.025n

.meas tran vdout0_60ck1920 FIND v(dout0_60) AT=965.025n

.meas tran vdout0_61ck1920 FIND v(dout0_61) AT=965.025n

.meas tran vdout0_62ck1920 FIND v(dout0_62) AT=965.025n

.meas tran vdout0_63ck1920 FIND v(dout0_63) AT=965.025n

.meas tran vdout0_64ck1920 FIND v(dout0_64) AT=965.025n

.meas tran vdout0_65ck1920 FIND v(dout0_65) AT=965.025n

.meas tran vdout0_66ck1920 FIND v(dout0_66) AT=965.025n

.meas tran vdout0_67ck1920 FIND v(dout0_67) AT=965.025n

.meas tran vdout0_68ck1920 FIND v(dout0_68) AT=965.025n

.meas tran vdout0_69ck1920 FIND v(dout0_69) AT=965.025n

.meas tran vdout0_70ck1920 FIND v(dout0_70) AT=965.025n

.meas tran vdout0_71ck1920 FIND v(dout0_71) AT=965.025n

.meas tran vdout0_72ck1920 FIND v(dout0_72) AT=965.025n

.meas tran vdout0_73ck1920 FIND v(dout0_73) AT=965.025n

.meas tran vdout0_74ck1920 FIND v(dout0_74) AT=965.025n

.meas tran vdout0_75ck1920 FIND v(dout0_75) AT=965.025n

.meas tran vdout0_76ck1920 FIND v(dout0_76) AT=965.025n

.meas tran vdout0_77ck1920 FIND v(dout0_77) AT=965.025n

.meas tran vdout0_78ck1920 FIND v(dout0_78) AT=965.025n

.meas tran vdout0_79ck1920 FIND v(dout0_79) AT=965.025n

.meas tran vdout0_80ck1920 FIND v(dout0_80) AT=965.025n

.meas tran vdout0_81ck1920 FIND v(dout0_81) AT=965.025n

.meas tran vdout0_82ck1920 FIND v(dout0_82) AT=965.025n

.meas tran vdout0_83ck1920 FIND v(dout0_83) AT=965.025n

.meas tran vdout0_84ck1920 FIND v(dout0_84) AT=965.025n

.meas tran vdout0_85ck1920 FIND v(dout0_85) AT=965.025n

.meas tran vdout0_86ck1920 FIND v(dout0_86) AT=965.025n

.meas tran vdout0_87ck1920 FIND v(dout0_87) AT=965.025n

.meas tran vdout0_88ck1920 FIND v(dout0_88) AT=965.025n

.meas tran vdout0_89ck1920 FIND v(dout0_89) AT=965.025n

.meas tran vdout0_90ck1920 FIND v(dout0_90) AT=965.025n

.meas tran vdout0_91ck1920 FIND v(dout0_91) AT=965.025n

.meas tran vdout0_92ck1920 FIND v(dout0_92) AT=965.025n

.meas tran vdout0_93ck1920 FIND v(dout0_93) AT=965.025n

.meas tran vdout0_94ck1920 FIND v(dout0_94) AT=965.025n

.meas tran vdout0_95ck1920 FIND v(dout0_95) AT=965.025n

.meas tran vdout0_96ck1920 FIND v(dout0_96) AT=965.025n

.meas tran vdout0_97ck1920 FIND v(dout0_97) AT=965.025n

.meas tran vdout0_98ck1920 FIND v(dout0_98) AT=965.025n

.meas tran vdout0_99ck1920 FIND v(dout0_99) AT=965.025n

.meas tran vdout0_100ck1920 FIND v(dout0_100) AT=965.025n

.meas tran vdout0_101ck1920 FIND v(dout0_101) AT=965.025n

.meas tran vdout0_102ck1920 FIND v(dout0_102) AT=965.025n

.meas tran vdout0_103ck1920 FIND v(dout0_103) AT=965.025n

.meas tran vdout0_104ck1920 FIND v(dout0_104) AT=965.025n

.meas tran vdout0_105ck1920 FIND v(dout0_105) AT=965.025n

.meas tran vdout0_106ck1920 FIND v(dout0_106) AT=965.025n

.meas tran vdout0_107ck1920 FIND v(dout0_107) AT=965.025n

.meas tran vdout0_108ck1920 FIND v(dout0_108) AT=965.025n

.meas tran vdout0_109ck1920 FIND v(dout0_109) AT=965.025n

.meas tran vdout0_110ck1920 FIND v(dout0_110) AT=965.025n

.meas tran vdout0_111ck1920 FIND v(dout0_111) AT=965.025n

.meas tran vdout0_112ck1920 FIND v(dout0_112) AT=965.025n

.meas tran vdout0_113ck1920 FIND v(dout0_113) AT=965.025n

.meas tran vdout0_114ck1920 FIND v(dout0_114) AT=965.025n

.meas tran vdout0_115ck1920 FIND v(dout0_115) AT=965.025n

.meas tran vdout0_116ck1920 FIND v(dout0_116) AT=965.025n

.meas tran vdout0_117ck1920 FIND v(dout0_117) AT=965.025n

.meas tran vdout0_118ck1920 FIND v(dout0_118) AT=965.025n

.meas tran vdout0_119ck1920 FIND v(dout0_119) AT=965.025n

.meas tran vdout0_120ck1920 FIND v(dout0_120) AT=965.025n

.meas tran vdout0_121ck1920 FIND v(dout0_121) AT=965.025n

.meas tran vdout0_122ck1920 FIND v(dout0_122) AT=965.025n

.meas tran vdout0_123ck1920 FIND v(dout0_123) AT=965.025n

.meas tran vdout0_124ck1920 FIND v(dout0_124) AT=965.025n

.meas tran vdout0_125ck1920 FIND v(dout0_125) AT=965.025n

.meas tran vdout0_126ck1920 FIND v(dout0_126) AT=965.025n

.meas tran vdout0_127ck1920 FIND v(dout0_127) AT=965.025n

.meas tran vdout0_0ck1980 FIND v(dout0_0) AT=995.025n

.meas tran vdout0_1ck1980 FIND v(dout0_1) AT=995.025n

.meas tran vdout0_2ck1980 FIND v(dout0_2) AT=995.025n

.meas tran vdout0_3ck1980 FIND v(dout0_3) AT=995.025n

.meas tran vdout0_4ck1980 FIND v(dout0_4) AT=995.025n

.meas tran vdout0_5ck1980 FIND v(dout0_5) AT=995.025n

.meas tran vdout0_6ck1980 FIND v(dout0_6) AT=995.025n

.meas tran vdout0_7ck1980 FIND v(dout0_7) AT=995.025n

.meas tran vdout0_8ck1980 FIND v(dout0_8) AT=995.025n

.meas tran vdout0_9ck1980 FIND v(dout0_9) AT=995.025n

.meas tran vdout0_10ck1980 FIND v(dout0_10) AT=995.025n

.meas tran vdout0_11ck1980 FIND v(dout0_11) AT=995.025n

.meas tran vdout0_12ck1980 FIND v(dout0_12) AT=995.025n

.meas tran vdout0_13ck1980 FIND v(dout0_13) AT=995.025n

.meas tran vdout0_14ck1980 FIND v(dout0_14) AT=995.025n

.meas tran vdout0_15ck1980 FIND v(dout0_15) AT=995.025n

.meas tran vdout0_16ck1980 FIND v(dout0_16) AT=995.025n

.meas tran vdout0_17ck1980 FIND v(dout0_17) AT=995.025n

.meas tran vdout0_18ck1980 FIND v(dout0_18) AT=995.025n

.meas tran vdout0_19ck1980 FIND v(dout0_19) AT=995.025n

.meas tran vdout0_20ck1980 FIND v(dout0_20) AT=995.025n

.meas tran vdout0_21ck1980 FIND v(dout0_21) AT=995.025n

.meas tran vdout0_22ck1980 FIND v(dout0_22) AT=995.025n

.meas tran vdout0_23ck1980 FIND v(dout0_23) AT=995.025n

.meas tran vdout0_24ck1980 FIND v(dout0_24) AT=995.025n

.meas tran vdout0_25ck1980 FIND v(dout0_25) AT=995.025n

.meas tran vdout0_26ck1980 FIND v(dout0_26) AT=995.025n

.meas tran vdout0_27ck1980 FIND v(dout0_27) AT=995.025n

.meas tran vdout0_28ck1980 FIND v(dout0_28) AT=995.025n

.meas tran vdout0_29ck1980 FIND v(dout0_29) AT=995.025n

.meas tran vdout0_30ck1980 FIND v(dout0_30) AT=995.025n

.meas tran vdout0_31ck1980 FIND v(dout0_31) AT=995.025n

.meas tran vdout0_32ck1980 FIND v(dout0_32) AT=995.025n

.meas tran vdout0_33ck1980 FIND v(dout0_33) AT=995.025n

.meas tran vdout0_34ck1980 FIND v(dout0_34) AT=995.025n

.meas tran vdout0_35ck1980 FIND v(dout0_35) AT=995.025n

.meas tran vdout0_36ck1980 FIND v(dout0_36) AT=995.025n

.meas tran vdout0_37ck1980 FIND v(dout0_37) AT=995.025n

.meas tran vdout0_38ck1980 FIND v(dout0_38) AT=995.025n

.meas tran vdout0_39ck1980 FIND v(dout0_39) AT=995.025n

.meas tran vdout0_40ck1980 FIND v(dout0_40) AT=995.025n

.meas tran vdout0_41ck1980 FIND v(dout0_41) AT=995.025n

.meas tran vdout0_42ck1980 FIND v(dout0_42) AT=995.025n

.meas tran vdout0_43ck1980 FIND v(dout0_43) AT=995.025n

.meas tran vdout0_44ck1980 FIND v(dout0_44) AT=995.025n

.meas tran vdout0_45ck1980 FIND v(dout0_45) AT=995.025n

.meas tran vdout0_46ck1980 FIND v(dout0_46) AT=995.025n

.meas tran vdout0_47ck1980 FIND v(dout0_47) AT=995.025n

.meas tran vdout0_48ck1980 FIND v(dout0_48) AT=995.025n

.meas tran vdout0_49ck1980 FIND v(dout0_49) AT=995.025n

.meas tran vdout0_50ck1980 FIND v(dout0_50) AT=995.025n

.meas tran vdout0_51ck1980 FIND v(dout0_51) AT=995.025n

.meas tran vdout0_52ck1980 FIND v(dout0_52) AT=995.025n

.meas tran vdout0_53ck1980 FIND v(dout0_53) AT=995.025n

.meas tran vdout0_54ck1980 FIND v(dout0_54) AT=995.025n

.meas tran vdout0_55ck1980 FIND v(dout0_55) AT=995.025n

.meas tran vdout0_56ck1980 FIND v(dout0_56) AT=995.025n

.meas tran vdout0_57ck1980 FIND v(dout0_57) AT=995.025n

.meas tran vdout0_58ck1980 FIND v(dout0_58) AT=995.025n

.meas tran vdout0_59ck1980 FIND v(dout0_59) AT=995.025n

.meas tran vdout0_60ck1980 FIND v(dout0_60) AT=995.025n

.meas tran vdout0_61ck1980 FIND v(dout0_61) AT=995.025n

.meas tran vdout0_62ck1980 FIND v(dout0_62) AT=995.025n

.meas tran vdout0_63ck1980 FIND v(dout0_63) AT=995.025n

.meas tran vdout0_64ck1980 FIND v(dout0_64) AT=995.025n

.meas tran vdout0_65ck1980 FIND v(dout0_65) AT=995.025n

.meas tran vdout0_66ck1980 FIND v(dout0_66) AT=995.025n

.meas tran vdout0_67ck1980 FIND v(dout0_67) AT=995.025n

.meas tran vdout0_68ck1980 FIND v(dout0_68) AT=995.025n

.meas tran vdout0_69ck1980 FIND v(dout0_69) AT=995.025n

.meas tran vdout0_70ck1980 FIND v(dout0_70) AT=995.025n

.meas tran vdout0_71ck1980 FIND v(dout0_71) AT=995.025n

.meas tran vdout0_72ck1980 FIND v(dout0_72) AT=995.025n

.meas tran vdout0_73ck1980 FIND v(dout0_73) AT=995.025n

.meas tran vdout0_74ck1980 FIND v(dout0_74) AT=995.025n

.meas tran vdout0_75ck1980 FIND v(dout0_75) AT=995.025n

.meas tran vdout0_76ck1980 FIND v(dout0_76) AT=995.025n

.meas tran vdout0_77ck1980 FIND v(dout0_77) AT=995.025n

.meas tran vdout0_78ck1980 FIND v(dout0_78) AT=995.025n

.meas tran vdout0_79ck1980 FIND v(dout0_79) AT=995.025n

.meas tran vdout0_80ck1980 FIND v(dout0_80) AT=995.025n

.meas tran vdout0_81ck1980 FIND v(dout0_81) AT=995.025n

.meas tran vdout0_82ck1980 FIND v(dout0_82) AT=995.025n

.meas tran vdout0_83ck1980 FIND v(dout0_83) AT=995.025n

.meas tran vdout0_84ck1980 FIND v(dout0_84) AT=995.025n

.meas tran vdout0_85ck1980 FIND v(dout0_85) AT=995.025n

.meas tran vdout0_86ck1980 FIND v(dout0_86) AT=995.025n

.meas tran vdout0_87ck1980 FIND v(dout0_87) AT=995.025n

.meas tran vdout0_88ck1980 FIND v(dout0_88) AT=995.025n

.meas tran vdout0_89ck1980 FIND v(dout0_89) AT=995.025n

.meas tran vdout0_90ck1980 FIND v(dout0_90) AT=995.025n

.meas tran vdout0_91ck1980 FIND v(dout0_91) AT=995.025n

.meas tran vdout0_92ck1980 FIND v(dout0_92) AT=995.025n

.meas tran vdout0_93ck1980 FIND v(dout0_93) AT=995.025n

.meas tran vdout0_94ck1980 FIND v(dout0_94) AT=995.025n

.meas tran vdout0_95ck1980 FIND v(dout0_95) AT=995.025n

.meas tran vdout0_96ck1980 FIND v(dout0_96) AT=995.025n

.meas tran vdout0_97ck1980 FIND v(dout0_97) AT=995.025n

.meas tran vdout0_98ck1980 FIND v(dout0_98) AT=995.025n

.meas tran vdout0_99ck1980 FIND v(dout0_99) AT=995.025n

.meas tran vdout0_100ck1980 FIND v(dout0_100) AT=995.025n

.meas tran vdout0_101ck1980 FIND v(dout0_101) AT=995.025n

.meas tran vdout0_102ck1980 FIND v(dout0_102) AT=995.025n

.meas tran vdout0_103ck1980 FIND v(dout0_103) AT=995.025n

.meas tran vdout0_104ck1980 FIND v(dout0_104) AT=995.025n

.meas tran vdout0_105ck1980 FIND v(dout0_105) AT=995.025n

.meas tran vdout0_106ck1980 FIND v(dout0_106) AT=995.025n

.meas tran vdout0_107ck1980 FIND v(dout0_107) AT=995.025n

.meas tran vdout0_108ck1980 FIND v(dout0_108) AT=995.025n

.meas tran vdout0_109ck1980 FIND v(dout0_109) AT=995.025n

.meas tran vdout0_110ck1980 FIND v(dout0_110) AT=995.025n

.meas tran vdout0_111ck1980 FIND v(dout0_111) AT=995.025n

.meas tran vdout0_112ck1980 FIND v(dout0_112) AT=995.025n

.meas tran vdout0_113ck1980 FIND v(dout0_113) AT=995.025n

.meas tran vdout0_114ck1980 FIND v(dout0_114) AT=995.025n

.meas tran vdout0_115ck1980 FIND v(dout0_115) AT=995.025n

.meas tran vdout0_116ck1980 FIND v(dout0_116) AT=995.025n

.meas tran vdout0_117ck1980 FIND v(dout0_117) AT=995.025n

.meas tran vdout0_118ck1980 FIND v(dout0_118) AT=995.025n

.meas tran vdout0_119ck1980 FIND v(dout0_119) AT=995.025n

.meas tran vdout0_120ck1980 FIND v(dout0_120) AT=995.025n

.meas tran vdout0_121ck1980 FIND v(dout0_121) AT=995.025n

.meas tran vdout0_122ck1980 FIND v(dout0_122) AT=995.025n

.meas tran vdout0_123ck1980 FIND v(dout0_123) AT=995.025n

.meas tran vdout0_124ck1980 FIND v(dout0_124) AT=995.025n

.meas tran vdout0_125ck1980 FIND v(dout0_125) AT=995.025n

.meas tran vdout0_126ck1980 FIND v(dout0_126) AT=995.025n

.meas tran vdout0_127ck1980 FIND v(dout0_127) AT=995.025n

.meas tran vdout0_0ck2000 FIND v(dout0_0) AT=1005.025n

.meas tran vdout0_1ck2000 FIND v(dout0_1) AT=1005.025n

.meas tran vdout0_2ck2000 FIND v(dout0_2) AT=1005.025n

.meas tran vdout0_3ck2000 FIND v(dout0_3) AT=1005.025n

.meas tran vdout0_4ck2000 FIND v(dout0_4) AT=1005.025n

.meas tran vdout0_5ck2000 FIND v(dout0_5) AT=1005.025n

.meas tran vdout0_6ck2000 FIND v(dout0_6) AT=1005.025n

.meas tran vdout0_7ck2000 FIND v(dout0_7) AT=1005.025n

.meas tran vdout0_8ck2000 FIND v(dout0_8) AT=1005.025n

.meas tran vdout0_9ck2000 FIND v(dout0_9) AT=1005.025n

.meas tran vdout0_10ck2000 FIND v(dout0_10) AT=1005.025n

.meas tran vdout0_11ck2000 FIND v(dout0_11) AT=1005.025n

.meas tran vdout0_12ck2000 FIND v(dout0_12) AT=1005.025n

.meas tran vdout0_13ck2000 FIND v(dout0_13) AT=1005.025n

.meas tran vdout0_14ck2000 FIND v(dout0_14) AT=1005.025n

.meas tran vdout0_15ck2000 FIND v(dout0_15) AT=1005.025n

.meas tran vdout0_16ck2000 FIND v(dout0_16) AT=1005.025n

.meas tran vdout0_17ck2000 FIND v(dout0_17) AT=1005.025n

.meas tran vdout0_18ck2000 FIND v(dout0_18) AT=1005.025n

.meas tran vdout0_19ck2000 FIND v(dout0_19) AT=1005.025n

.meas tran vdout0_20ck2000 FIND v(dout0_20) AT=1005.025n

.meas tran vdout0_21ck2000 FIND v(dout0_21) AT=1005.025n

.meas tran vdout0_22ck2000 FIND v(dout0_22) AT=1005.025n

.meas tran vdout0_23ck2000 FIND v(dout0_23) AT=1005.025n

.meas tran vdout0_24ck2000 FIND v(dout0_24) AT=1005.025n

.meas tran vdout0_25ck2000 FIND v(dout0_25) AT=1005.025n

.meas tran vdout0_26ck2000 FIND v(dout0_26) AT=1005.025n

.meas tran vdout0_27ck2000 FIND v(dout0_27) AT=1005.025n

.meas tran vdout0_28ck2000 FIND v(dout0_28) AT=1005.025n

.meas tran vdout0_29ck2000 FIND v(dout0_29) AT=1005.025n

.meas tran vdout0_30ck2000 FIND v(dout0_30) AT=1005.025n

.meas tran vdout0_31ck2000 FIND v(dout0_31) AT=1005.025n

.meas tran vdout0_32ck2000 FIND v(dout0_32) AT=1005.025n

.meas tran vdout0_33ck2000 FIND v(dout0_33) AT=1005.025n

.meas tran vdout0_34ck2000 FIND v(dout0_34) AT=1005.025n

.meas tran vdout0_35ck2000 FIND v(dout0_35) AT=1005.025n

.meas tran vdout0_36ck2000 FIND v(dout0_36) AT=1005.025n

.meas tran vdout0_37ck2000 FIND v(dout0_37) AT=1005.025n

.meas tran vdout0_38ck2000 FIND v(dout0_38) AT=1005.025n

.meas tran vdout0_39ck2000 FIND v(dout0_39) AT=1005.025n

.meas tran vdout0_40ck2000 FIND v(dout0_40) AT=1005.025n

.meas tran vdout0_41ck2000 FIND v(dout0_41) AT=1005.025n

.meas tran vdout0_42ck2000 FIND v(dout0_42) AT=1005.025n

.meas tran vdout0_43ck2000 FIND v(dout0_43) AT=1005.025n

.meas tran vdout0_44ck2000 FIND v(dout0_44) AT=1005.025n

.meas tran vdout0_45ck2000 FIND v(dout0_45) AT=1005.025n

.meas tran vdout0_46ck2000 FIND v(dout0_46) AT=1005.025n

.meas tran vdout0_47ck2000 FIND v(dout0_47) AT=1005.025n

.meas tran vdout0_48ck2000 FIND v(dout0_48) AT=1005.025n

.meas tran vdout0_49ck2000 FIND v(dout0_49) AT=1005.025n

.meas tran vdout0_50ck2000 FIND v(dout0_50) AT=1005.025n

.meas tran vdout0_51ck2000 FIND v(dout0_51) AT=1005.025n

.meas tran vdout0_52ck2000 FIND v(dout0_52) AT=1005.025n

.meas tran vdout0_53ck2000 FIND v(dout0_53) AT=1005.025n

.meas tran vdout0_54ck2000 FIND v(dout0_54) AT=1005.025n

.meas tran vdout0_55ck2000 FIND v(dout0_55) AT=1005.025n

.meas tran vdout0_56ck2000 FIND v(dout0_56) AT=1005.025n

.meas tran vdout0_57ck2000 FIND v(dout0_57) AT=1005.025n

.meas tran vdout0_58ck2000 FIND v(dout0_58) AT=1005.025n

.meas tran vdout0_59ck2000 FIND v(dout0_59) AT=1005.025n

.meas tran vdout0_60ck2000 FIND v(dout0_60) AT=1005.025n

.meas tran vdout0_61ck2000 FIND v(dout0_61) AT=1005.025n

.meas tran vdout0_62ck2000 FIND v(dout0_62) AT=1005.025n

.meas tran vdout0_63ck2000 FIND v(dout0_63) AT=1005.025n

.meas tran vdout0_64ck2000 FIND v(dout0_64) AT=1005.025n

.meas tran vdout0_65ck2000 FIND v(dout0_65) AT=1005.025n

.meas tran vdout0_66ck2000 FIND v(dout0_66) AT=1005.025n

.meas tran vdout0_67ck2000 FIND v(dout0_67) AT=1005.025n

.meas tran vdout0_68ck2000 FIND v(dout0_68) AT=1005.025n

.meas tran vdout0_69ck2000 FIND v(dout0_69) AT=1005.025n

.meas tran vdout0_70ck2000 FIND v(dout0_70) AT=1005.025n

.meas tran vdout0_71ck2000 FIND v(dout0_71) AT=1005.025n

.meas tran vdout0_72ck2000 FIND v(dout0_72) AT=1005.025n

.meas tran vdout0_73ck2000 FIND v(dout0_73) AT=1005.025n

.meas tran vdout0_74ck2000 FIND v(dout0_74) AT=1005.025n

.meas tran vdout0_75ck2000 FIND v(dout0_75) AT=1005.025n

.meas tran vdout0_76ck2000 FIND v(dout0_76) AT=1005.025n

.meas tran vdout0_77ck2000 FIND v(dout0_77) AT=1005.025n

.meas tran vdout0_78ck2000 FIND v(dout0_78) AT=1005.025n

.meas tran vdout0_79ck2000 FIND v(dout0_79) AT=1005.025n

.meas tran vdout0_80ck2000 FIND v(dout0_80) AT=1005.025n

.meas tran vdout0_81ck2000 FIND v(dout0_81) AT=1005.025n

.meas tran vdout0_82ck2000 FIND v(dout0_82) AT=1005.025n

.meas tran vdout0_83ck2000 FIND v(dout0_83) AT=1005.025n

.meas tran vdout0_84ck2000 FIND v(dout0_84) AT=1005.025n

.meas tran vdout0_85ck2000 FIND v(dout0_85) AT=1005.025n

.meas tran vdout0_86ck2000 FIND v(dout0_86) AT=1005.025n

.meas tran vdout0_87ck2000 FIND v(dout0_87) AT=1005.025n

.meas tran vdout0_88ck2000 FIND v(dout0_88) AT=1005.025n

.meas tran vdout0_89ck2000 FIND v(dout0_89) AT=1005.025n

.meas tran vdout0_90ck2000 FIND v(dout0_90) AT=1005.025n

.meas tran vdout0_91ck2000 FIND v(dout0_91) AT=1005.025n

.meas tran vdout0_92ck2000 FIND v(dout0_92) AT=1005.025n

.meas tran vdout0_93ck2000 FIND v(dout0_93) AT=1005.025n

.meas tran vdout0_94ck2000 FIND v(dout0_94) AT=1005.025n

.meas tran vdout0_95ck2000 FIND v(dout0_95) AT=1005.025n

.meas tran vdout0_96ck2000 FIND v(dout0_96) AT=1005.025n

.meas tran vdout0_97ck2000 FIND v(dout0_97) AT=1005.025n

.meas tran vdout0_98ck2000 FIND v(dout0_98) AT=1005.025n

.meas tran vdout0_99ck2000 FIND v(dout0_99) AT=1005.025n

.meas tran vdout0_100ck2000 FIND v(dout0_100) AT=1005.025n

.meas tran vdout0_101ck2000 FIND v(dout0_101) AT=1005.025n

.meas tran vdout0_102ck2000 FIND v(dout0_102) AT=1005.025n

.meas tran vdout0_103ck2000 FIND v(dout0_103) AT=1005.025n

.meas tran vdout0_104ck2000 FIND v(dout0_104) AT=1005.025n

.meas tran vdout0_105ck2000 FIND v(dout0_105) AT=1005.025n

.meas tran vdout0_106ck2000 FIND v(dout0_106) AT=1005.025n

.meas tran vdout0_107ck2000 FIND v(dout0_107) AT=1005.025n

.meas tran vdout0_108ck2000 FIND v(dout0_108) AT=1005.025n

.meas tran vdout0_109ck2000 FIND v(dout0_109) AT=1005.025n

.meas tran vdout0_110ck2000 FIND v(dout0_110) AT=1005.025n

.meas tran vdout0_111ck2000 FIND v(dout0_111) AT=1005.025n

.meas tran vdout0_112ck2000 FIND v(dout0_112) AT=1005.025n

.meas tran vdout0_113ck2000 FIND v(dout0_113) AT=1005.025n

.meas tran vdout0_114ck2000 FIND v(dout0_114) AT=1005.025n

.meas tran vdout0_115ck2000 FIND v(dout0_115) AT=1005.025n

.meas tran vdout0_116ck2000 FIND v(dout0_116) AT=1005.025n

.meas tran vdout0_117ck2000 FIND v(dout0_117) AT=1005.025n

.meas tran vdout0_118ck2000 FIND v(dout0_118) AT=1005.025n

.meas tran vdout0_119ck2000 FIND v(dout0_119) AT=1005.025n

.meas tran vdout0_120ck2000 FIND v(dout0_120) AT=1005.025n

.meas tran vdout0_121ck2000 FIND v(dout0_121) AT=1005.025n

.meas tran vdout0_122ck2000 FIND v(dout0_122) AT=1005.025n

.meas tran vdout0_123ck2000 FIND v(dout0_123) AT=1005.025n

.meas tran vdout0_124ck2000 FIND v(dout0_124) AT=1005.025n

.meas tran vdout0_125ck2000 FIND v(dout0_125) AT=1005.025n

.meas tran vdout0_126ck2000 FIND v(dout0_126) AT=1005.025n

.meas tran vdout0_127ck2000 FIND v(dout0_127) AT=1005.025n

.meas tran vdout0_0ck2030 FIND v(dout0_0) AT=1020.025n

.meas tran vdout0_1ck2030 FIND v(dout0_1) AT=1020.025n

.meas tran vdout0_2ck2030 FIND v(dout0_2) AT=1020.025n

.meas tran vdout0_3ck2030 FIND v(dout0_3) AT=1020.025n

.meas tran vdout0_4ck2030 FIND v(dout0_4) AT=1020.025n

.meas tran vdout0_5ck2030 FIND v(dout0_5) AT=1020.025n

.meas tran vdout0_6ck2030 FIND v(dout0_6) AT=1020.025n

.meas tran vdout0_7ck2030 FIND v(dout0_7) AT=1020.025n

.meas tran vdout0_8ck2030 FIND v(dout0_8) AT=1020.025n

.meas tran vdout0_9ck2030 FIND v(dout0_9) AT=1020.025n

.meas tran vdout0_10ck2030 FIND v(dout0_10) AT=1020.025n

.meas tran vdout0_11ck2030 FIND v(dout0_11) AT=1020.025n

.meas tran vdout0_12ck2030 FIND v(dout0_12) AT=1020.025n

.meas tran vdout0_13ck2030 FIND v(dout0_13) AT=1020.025n

.meas tran vdout0_14ck2030 FIND v(dout0_14) AT=1020.025n

.meas tran vdout0_15ck2030 FIND v(dout0_15) AT=1020.025n

.meas tran vdout0_16ck2030 FIND v(dout0_16) AT=1020.025n

.meas tran vdout0_17ck2030 FIND v(dout0_17) AT=1020.025n

.meas tran vdout0_18ck2030 FIND v(dout0_18) AT=1020.025n

.meas tran vdout0_19ck2030 FIND v(dout0_19) AT=1020.025n

.meas tran vdout0_20ck2030 FIND v(dout0_20) AT=1020.025n

.meas tran vdout0_21ck2030 FIND v(dout0_21) AT=1020.025n

.meas tran vdout0_22ck2030 FIND v(dout0_22) AT=1020.025n

.meas tran vdout0_23ck2030 FIND v(dout0_23) AT=1020.025n

.meas tran vdout0_24ck2030 FIND v(dout0_24) AT=1020.025n

.meas tran vdout0_25ck2030 FIND v(dout0_25) AT=1020.025n

.meas tran vdout0_26ck2030 FIND v(dout0_26) AT=1020.025n

.meas tran vdout0_27ck2030 FIND v(dout0_27) AT=1020.025n

.meas tran vdout0_28ck2030 FIND v(dout0_28) AT=1020.025n

.meas tran vdout0_29ck2030 FIND v(dout0_29) AT=1020.025n

.meas tran vdout0_30ck2030 FIND v(dout0_30) AT=1020.025n

.meas tran vdout0_31ck2030 FIND v(dout0_31) AT=1020.025n

.meas tran vdout0_32ck2030 FIND v(dout0_32) AT=1020.025n

.meas tran vdout0_33ck2030 FIND v(dout0_33) AT=1020.025n

.meas tran vdout0_34ck2030 FIND v(dout0_34) AT=1020.025n

.meas tran vdout0_35ck2030 FIND v(dout0_35) AT=1020.025n

.meas tran vdout0_36ck2030 FIND v(dout0_36) AT=1020.025n

.meas tran vdout0_37ck2030 FIND v(dout0_37) AT=1020.025n

.meas tran vdout0_38ck2030 FIND v(dout0_38) AT=1020.025n

.meas tran vdout0_39ck2030 FIND v(dout0_39) AT=1020.025n

.meas tran vdout0_40ck2030 FIND v(dout0_40) AT=1020.025n

.meas tran vdout0_41ck2030 FIND v(dout0_41) AT=1020.025n

.meas tran vdout0_42ck2030 FIND v(dout0_42) AT=1020.025n

.meas tran vdout0_43ck2030 FIND v(dout0_43) AT=1020.025n

.meas tran vdout0_44ck2030 FIND v(dout0_44) AT=1020.025n

.meas tran vdout0_45ck2030 FIND v(dout0_45) AT=1020.025n

.meas tran vdout0_46ck2030 FIND v(dout0_46) AT=1020.025n

.meas tran vdout0_47ck2030 FIND v(dout0_47) AT=1020.025n

.meas tran vdout0_48ck2030 FIND v(dout0_48) AT=1020.025n

.meas tran vdout0_49ck2030 FIND v(dout0_49) AT=1020.025n

.meas tran vdout0_50ck2030 FIND v(dout0_50) AT=1020.025n

.meas tran vdout0_51ck2030 FIND v(dout0_51) AT=1020.025n

.meas tran vdout0_52ck2030 FIND v(dout0_52) AT=1020.025n

.meas tran vdout0_53ck2030 FIND v(dout0_53) AT=1020.025n

.meas tran vdout0_54ck2030 FIND v(dout0_54) AT=1020.025n

.meas tran vdout0_55ck2030 FIND v(dout0_55) AT=1020.025n

.meas tran vdout0_56ck2030 FIND v(dout0_56) AT=1020.025n

.meas tran vdout0_57ck2030 FIND v(dout0_57) AT=1020.025n

.meas tran vdout0_58ck2030 FIND v(dout0_58) AT=1020.025n

.meas tran vdout0_59ck2030 FIND v(dout0_59) AT=1020.025n

.meas tran vdout0_60ck2030 FIND v(dout0_60) AT=1020.025n

.meas tran vdout0_61ck2030 FIND v(dout0_61) AT=1020.025n

.meas tran vdout0_62ck2030 FIND v(dout0_62) AT=1020.025n

.meas tran vdout0_63ck2030 FIND v(dout0_63) AT=1020.025n

.meas tran vdout0_64ck2030 FIND v(dout0_64) AT=1020.025n

.meas tran vdout0_65ck2030 FIND v(dout0_65) AT=1020.025n

.meas tran vdout0_66ck2030 FIND v(dout0_66) AT=1020.025n

.meas tran vdout0_67ck2030 FIND v(dout0_67) AT=1020.025n

.meas tran vdout0_68ck2030 FIND v(dout0_68) AT=1020.025n

.meas tran vdout0_69ck2030 FIND v(dout0_69) AT=1020.025n

.meas tran vdout0_70ck2030 FIND v(dout0_70) AT=1020.025n

.meas tran vdout0_71ck2030 FIND v(dout0_71) AT=1020.025n

.meas tran vdout0_72ck2030 FIND v(dout0_72) AT=1020.025n

.meas tran vdout0_73ck2030 FIND v(dout0_73) AT=1020.025n

.meas tran vdout0_74ck2030 FIND v(dout0_74) AT=1020.025n

.meas tran vdout0_75ck2030 FIND v(dout0_75) AT=1020.025n

.meas tran vdout0_76ck2030 FIND v(dout0_76) AT=1020.025n

.meas tran vdout0_77ck2030 FIND v(dout0_77) AT=1020.025n

.meas tran vdout0_78ck2030 FIND v(dout0_78) AT=1020.025n

.meas tran vdout0_79ck2030 FIND v(dout0_79) AT=1020.025n

.meas tran vdout0_80ck2030 FIND v(dout0_80) AT=1020.025n

.meas tran vdout0_81ck2030 FIND v(dout0_81) AT=1020.025n

.meas tran vdout0_82ck2030 FIND v(dout0_82) AT=1020.025n

.meas tran vdout0_83ck2030 FIND v(dout0_83) AT=1020.025n

.meas tran vdout0_84ck2030 FIND v(dout0_84) AT=1020.025n

.meas tran vdout0_85ck2030 FIND v(dout0_85) AT=1020.025n

.meas tran vdout0_86ck2030 FIND v(dout0_86) AT=1020.025n

.meas tran vdout0_87ck2030 FIND v(dout0_87) AT=1020.025n

.meas tran vdout0_88ck2030 FIND v(dout0_88) AT=1020.025n

.meas tran vdout0_89ck2030 FIND v(dout0_89) AT=1020.025n

.meas tran vdout0_90ck2030 FIND v(dout0_90) AT=1020.025n

.meas tran vdout0_91ck2030 FIND v(dout0_91) AT=1020.025n

.meas tran vdout0_92ck2030 FIND v(dout0_92) AT=1020.025n

.meas tran vdout0_93ck2030 FIND v(dout0_93) AT=1020.025n

.meas tran vdout0_94ck2030 FIND v(dout0_94) AT=1020.025n

.meas tran vdout0_95ck2030 FIND v(dout0_95) AT=1020.025n

.meas tran vdout0_96ck2030 FIND v(dout0_96) AT=1020.025n

.meas tran vdout0_97ck2030 FIND v(dout0_97) AT=1020.025n

.meas tran vdout0_98ck2030 FIND v(dout0_98) AT=1020.025n

.meas tran vdout0_99ck2030 FIND v(dout0_99) AT=1020.025n

.meas tran vdout0_100ck2030 FIND v(dout0_100) AT=1020.025n

.meas tran vdout0_101ck2030 FIND v(dout0_101) AT=1020.025n

.meas tran vdout0_102ck2030 FIND v(dout0_102) AT=1020.025n

.meas tran vdout0_103ck2030 FIND v(dout0_103) AT=1020.025n

.meas tran vdout0_104ck2030 FIND v(dout0_104) AT=1020.025n

.meas tran vdout0_105ck2030 FIND v(dout0_105) AT=1020.025n

.meas tran vdout0_106ck2030 FIND v(dout0_106) AT=1020.025n

.meas tran vdout0_107ck2030 FIND v(dout0_107) AT=1020.025n

.meas tran vdout0_108ck2030 FIND v(dout0_108) AT=1020.025n

.meas tran vdout0_109ck2030 FIND v(dout0_109) AT=1020.025n

.meas tran vdout0_110ck2030 FIND v(dout0_110) AT=1020.025n

.meas tran vdout0_111ck2030 FIND v(dout0_111) AT=1020.025n

.meas tran vdout0_112ck2030 FIND v(dout0_112) AT=1020.025n

.meas tran vdout0_113ck2030 FIND v(dout0_113) AT=1020.025n

.meas tran vdout0_114ck2030 FIND v(dout0_114) AT=1020.025n

.meas tran vdout0_115ck2030 FIND v(dout0_115) AT=1020.025n

.meas tran vdout0_116ck2030 FIND v(dout0_116) AT=1020.025n

.meas tran vdout0_117ck2030 FIND v(dout0_117) AT=1020.025n

.meas tran vdout0_118ck2030 FIND v(dout0_118) AT=1020.025n

.meas tran vdout0_119ck2030 FIND v(dout0_119) AT=1020.025n

.meas tran vdout0_120ck2030 FIND v(dout0_120) AT=1020.025n

.meas tran vdout0_121ck2030 FIND v(dout0_121) AT=1020.025n

.meas tran vdout0_122ck2030 FIND v(dout0_122) AT=1020.025n

.meas tran vdout0_123ck2030 FIND v(dout0_123) AT=1020.025n

.meas tran vdout0_124ck2030 FIND v(dout0_124) AT=1020.025n

.meas tran vdout0_125ck2030 FIND v(dout0_125) AT=1020.025n

.meas tran vdout0_126ck2030 FIND v(dout0_126) AT=1020.025n

.meas tran vdout0_127ck2030 FIND v(dout0_127) AT=1020.025n

.meas tran vdout0_0ck2040 FIND v(dout0_0) AT=1025.025n

.meas tran vdout0_1ck2040 FIND v(dout0_1) AT=1025.025n

.meas tran vdout0_2ck2040 FIND v(dout0_2) AT=1025.025n

.meas tran vdout0_3ck2040 FIND v(dout0_3) AT=1025.025n

.meas tran vdout0_4ck2040 FIND v(dout0_4) AT=1025.025n

.meas tran vdout0_5ck2040 FIND v(dout0_5) AT=1025.025n

.meas tran vdout0_6ck2040 FIND v(dout0_6) AT=1025.025n

.meas tran vdout0_7ck2040 FIND v(dout0_7) AT=1025.025n

.meas tran vdout0_8ck2040 FIND v(dout0_8) AT=1025.025n

.meas tran vdout0_9ck2040 FIND v(dout0_9) AT=1025.025n

.meas tran vdout0_10ck2040 FIND v(dout0_10) AT=1025.025n

.meas tran vdout0_11ck2040 FIND v(dout0_11) AT=1025.025n

.meas tran vdout0_12ck2040 FIND v(dout0_12) AT=1025.025n

.meas tran vdout0_13ck2040 FIND v(dout0_13) AT=1025.025n

.meas tran vdout0_14ck2040 FIND v(dout0_14) AT=1025.025n

.meas tran vdout0_15ck2040 FIND v(dout0_15) AT=1025.025n

.meas tran vdout0_16ck2040 FIND v(dout0_16) AT=1025.025n

.meas tran vdout0_17ck2040 FIND v(dout0_17) AT=1025.025n

.meas tran vdout0_18ck2040 FIND v(dout0_18) AT=1025.025n

.meas tran vdout0_19ck2040 FIND v(dout0_19) AT=1025.025n

.meas tran vdout0_20ck2040 FIND v(dout0_20) AT=1025.025n

.meas tran vdout0_21ck2040 FIND v(dout0_21) AT=1025.025n

.meas tran vdout0_22ck2040 FIND v(dout0_22) AT=1025.025n

.meas tran vdout0_23ck2040 FIND v(dout0_23) AT=1025.025n

.meas tran vdout0_24ck2040 FIND v(dout0_24) AT=1025.025n

.meas tran vdout0_25ck2040 FIND v(dout0_25) AT=1025.025n

.meas tran vdout0_26ck2040 FIND v(dout0_26) AT=1025.025n

.meas tran vdout0_27ck2040 FIND v(dout0_27) AT=1025.025n

.meas tran vdout0_28ck2040 FIND v(dout0_28) AT=1025.025n

.meas tran vdout0_29ck2040 FIND v(dout0_29) AT=1025.025n

.meas tran vdout0_30ck2040 FIND v(dout0_30) AT=1025.025n

.meas tran vdout0_31ck2040 FIND v(dout0_31) AT=1025.025n

.meas tran vdout0_32ck2040 FIND v(dout0_32) AT=1025.025n

.meas tran vdout0_33ck2040 FIND v(dout0_33) AT=1025.025n

.meas tran vdout0_34ck2040 FIND v(dout0_34) AT=1025.025n

.meas tran vdout0_35ck2040 FIND v(dout0_35) AT=1025.025n

.meas tran vdout0_36ck2040 FIND v(dout0_36) AT=1025.025n

.meas tran vdout0_37ck2040 FIND v(dout0_37) AT=1025.025n

.meas tran vdout0_38ck2040 FIND v(dout0_38) AT=1025.025n

.meas tran vdout0_39ck2040 FIND v(dout0_39) AT=1025.025n

.meas tran vdout0_40ck2040 FIND v(dout0_40) AT=1025.025n

.meas tran vdout0_41ck2040 FIND v(dout0_41) AT=1025.025n

.meas tran vdout0_42ck2040 FIND v(dout0_42) AT=1025.025n

.meas tran vdout0_43ck2040 FIND v(dout0_43) AT=1025.025n

.meas tran vdout0_44ck2040 FIND v(dout0_44) AT=1025.025n

.meas tran vdout0_45ck2040 FIND v(dout0_45) AT=1025.025n

.meas tran vdout0_46ck2040 FIND v(dout0_46) AT=1025.025n

.meas tran vdout0_47ck2040 FIND v(dout0_47) AT=1025.025n

.meas tran vdout0_48ck2040 FIND v(dout0_48) AT=1025.025n

.meas tran vdout0_49ck2040 FIND v(dout0_49) AT=1025.025n

.meas tran vdout0_50ck2040 FIND v(dout0_50) AT=1025.025n

.meas tran vdout0_51ck2040 FIND v(dout0_51) AT=1025.025n

.meas tran vdout0_52ck2040 FIND v(dout0_52) AT=1025.025n

.meas tran vdout0_53ck2040 FIND v(dout0_53) AT=1025.025n

.meas tran vdout0_54ck2040 FIND v(dout0_54) AT=1025.025n

.meas tran vdout0_55ck2040 FIND v(dout0_55) AT=1025.025n

.meas tran vdout0_56ck2040 FIND v(dout0_56) AT=1025.025n

.meas tran vdout0_57ck2040 FIND v(dout0_57) AT=1025.025n

.meas tran vdout0_58ck2040 FIND v(dout0_58) AT=1025.025n

.meas tran vdout0_59ck2040 FIND v(dout0_59) AT=1025.025n

.meas tran vdout0_60ck2040 FIND v(dout0_60) AT=1025.025n

.meas tran vdout0_61ck2040 FIND v(dout0_61) AT=1025.025n

.meas tran vdout0_62ck2040 FIND v(dout0_62) AT=1025.025n

.meas tran vdout0_63ck2040 FIND v(dout0_63) AT=1025.025n

.meas tran vdout0_64ck2040 FIND v(dout0_64) AT=1025.025n

.meas tran vdout0_65ck2040 FIND v(dout0_65) AT=1025.025n

.meas tran vdout0_66ck2040 FIND v(dout0_66) AT=1025.025n

.meas tran vdout0_67ck2040 FIND v(dout0_67) AT=1025.025n

.meas tran vdout0_68ck2040 FIND v(dout0_68) AT=1025.025n

.meas tran vdout0_69ck2040 FIND v(dout0_69) AT=1025.025n

.meas tran vdout0_70ck2040 FIND v(dout0_70) AT=1025.025n

.meas tran vdout0_71ck2040 FIND v(dout0_71) AT=1025.025n

.meas tran vdout0_72ck2040 FIND v(dout0_72) AT=1025.025n

.meas tran vdout0_73ck2040 FIND v(dout0_73) AT=1025.025n

.meas tran vdout0_74ck2040 FIND v(dout0_74) AT=1025.025n

.meas tran vdout0_75ck2040 FIND v(dout0_75) AT=1025.025n

.meas tran vdout0_76ck2040 FIND v(dout0_76) AT=1025.025n

.meas tran vdout0_77ck2040 FIND v(dout0_77) AT=1025.025n

.meas tran vdout0_78ck2040 FIND v(dout0_78) AT=1025.025n

.meas tran vdout0_79ck2040 FIND v(dout0_79) AT=1025.025n

.meas tran vdout0_80ck2040 FIND v(dout0_80) AT=1025.025n

.meas tran vdout0_81ck2040 FIND v(dout0_81) AT=1025.025n

.meas tran vdout0_82ck2040 FIND v(dout0_82) AT=1025.025n

.meas tran vdout0_83ck2040 FIND v(dout0_83) AT=1025.025n

.meas tran vdout0_84ck2040 FIND v(dout0_84) AT=1025.025n

.meas tran vdout0_85ck2040 FIND v(dout0_85) AT=1025.025n

.meas tran vdout0_86ck2040 FIND v(dout0_86) AT=1025.025n

.meas tran vdout0_87ck2040 FIND v(dout0_87) AT=1025.025n

.meas tran vdout0_88ck2040 FIND v(dout0_88) AT=1025.025n

.meas tran vdout0_89ck2040 FIND v(dout0_89) AT=1025.025n

.meas tran vdout0_90ck2040 FIND v(dout0_90) AT=1025.025n

.meas tran vdout0_91ck2040 FIND v(dout0_91) AT=1025.025n

.meas tran vdout0_92ck2040 FIND v(dout0_92) AT=1025.025n

.meas tran vdout0_93ck2040 FIND v(dout0_93) AT=1025.025n

.meas tran vdout0_94ck2040 FIND v(dout0_94) AT=1025.025n

.meas tran vdout0_95ck2040 FIND v(dout0_95) AT=1025.025n

.meas tran vdout0_96ck2040 FIND v(dout0_96) AT=1025.025n

.meas tran vdout0_97ck2040 FIND v(dout0_97) AT=1025.025n

.meas tran vdout0_98ck2040 FIND v(dout0_98) AT=1025.025n

.meas tran vdout0_99ck2040 FIND v(dout0_99) AT=1025.025n

.meas tran vdout0_100ck2040 FIND v(dout0_100) AT=1025.025n

.meas tran vdout0_101ck2040 FIND v(dout0_101) AT=1025.025n

.meas tran vdout0_102ck2040 FIND v(dout0_102) AT=1025.025n

.meas tran vdout0_103ck2040 FIND v(dout0_103) AT=1025.025n

.meas tran vdout0_104ck2040 FIND v(dout0_104) AT=1025.025n

.meas tran vdout0_105ck2040 FIND v(dout0_105) AT=1025.025n

.meas tran vdout0_106ck2040 FIND v(dout0_106) AT=1025.025n

.meas tran vdout0_107ck2040 FIND v(dout0_107) AT=1025.025n

.meas tran vdout0_108ck2040 FIND v(dout0_108) AT=1025.025n

.meas tran vdout0_109ck2040 FIND v(dout0_109) AT=1025.025n

.meas tran vdout0_110ck2040 FIND v(dout0_110) AT=1025.025n

.meas tran vdout0_111ck2040 FIND v(dout0_111) AT=1025.025n

.meas tran vdout0_112ck2040 FIND v(dout0_112) AT=1025.025n

.meas tran vdout0_113ck2040 FIND v(dout0_113) AT=1025.025n

.meas tran vdout0_114ck2040 FIND v(dout0_114) AT=1025.025n

.meas tran vdout0_115ck2040 FIND v(dout0_115) AT=1025.025n

.meas tran vdout0_116ck2040 FIND v(dout0_116) AT=1025.025n

.meas tran vdout0_117ck2040 FIND v(dout0_117) AT=1025.025n

.meas tran vdout0_118ck2040 FIND v(dout0_118) AT=1025.025n

.meas tran vdout0_119ck2040 FIND v(dout0_119) AT=1025.025n

.meas tran vdout0_120ck2040 FIND v(dout0_120) AT=1025.025n

.meas tran vdout0_121ck2040 FIND v(dout0_121) AT=1025.025n

.meas tran vdout0_122ck2040 FIND v(dout0_122) AT=1025.025n

.meas tran vdout0_123ck2040 FIND v(dout0_123) AT=1025.025n

.meas tran vdout0_124ck2040 FIND v(dout0_124) AT=1025.025n

.meas tran vdout0_125ck2040 FIND v(dout0_125) AT=1025.025n

.meas tran vdout0_126ck2040 FIND v(dout0_126) AT=1025.025n

.meas tran vdout0_127ck2040 FIND v(dout0_127) AT=1025.025n

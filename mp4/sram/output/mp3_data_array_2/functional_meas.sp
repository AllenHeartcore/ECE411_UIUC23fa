.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_0ck90 FIND v(dout0_0) AT=50.025n

.meas tran vdout0_1ck90 FIND v(dout0_1) AT=50.025n

.meas tran vdout0_2ck90 FIND v(dout0_2) AT=50.025n

.meas tran vdout0_3ck90 FIND v(dout0_3) AT=50.025n

.meas tran vdout0_4ck90 FIND v(dout0_4) AT=50.025n

.meas tran vdout0_5ck90 FIND v(dout0_5) AT=50.025n

.meas tran vdout0_6ck90 FIND v(dout0_6) AT=50.025n

.meas tran vdout0_7ck90 FIND v(dout0_7) AT=50.025n

.meas tran vdout0_8ck90 FIND v(dout0_8) AT=50.025n

.meas tran vdout0_9ck90 FIND v(dout0_9) AT=50.025n

.meas tran vdout0_10ck90 FIND v(dout0_10) AT=50.025n

.meas tran vdout0_11ck90 FIND v(dout0_11) AT=50.025n

.meas tran vdout0_12ck90 FIND v(dout0_12) AT=50.025n

.meas tran vdout0_13ck90 FIND v(dout0_13) AT=50.025n

.meas tran vdout0_14ck90 FIND v(dout0_14) AT=50.025n

.meas tran vdout0_15ck90 FIND v(dout0_15) AT=50.025n

.meas tran vdout0_16ck90 FIND v(dout0_16) AT=50.025n

.meas tran vdout0_17ck90 FIND v(dout0_17) AT=50.025n

.meas tran vdout0_18ck90 FIND v(dout0_18) AT=50.025n

.meas tran vdout0_19ck90 FIND v(dout0_19) AT=50.025n

.meas tran vdout0_20ck90 FIND v(dout0_20) AT=50.025n

.meas tran vdout0_21ck90 FIND v(dout0_21) AT=50.025n

.meas tran vdout0_22ck90 FIND v(dout0_22) AT=50.025n

.meas tran vdout0_23ck90 FIND v(dout0_23) AT=50.025n

.meas tran vdout0_24ck90 FIND v(dout0_24) AT=50.025n

.meas tran vdout0_25ck90 FIND v(dout0_25) AT=50.025n

.meas tran vdout0_26ck90 FIND v(dout0_26) AT=50.025n

.meas tran vdout0_27ck90 FIND v(dout0_27) AT=50.025n

.meas tran vdout0_28ck90 FIND v(dout0_28) AT=50.025n

.meas tran vdout0_29ck90 FIND v(dout0_29) AT=50.025n

.meas tran vdout0_30ck90 FIND v(dout0_30) AT=50.025n

.meas tran vdout0_31ck90 FIND v(dout0_31) AT=50.025n

.meas tran vdout0_32ck90 FIND v(dout0_32) AT=50.025n

.meas tran vdout0_33ck90 FIND v(dout0_33) AT=50.025n

.meas tran vdout0_34ck90 FIND v(dout0_34) AT=50.025n

.meas tran vdout0_35ck90 FIND v(dout0_35) AT=50.025n

.meas tran vdout0_36ck90 FIND v(dout0_36) AT=50.025n

.meas tran vdout0_37ck90 FIND v(dout0_37) AT=50.025n

.meas tran vdout0_38ck90 FIND v(dout0_38) AT=50.025n

.meas tran vdout0_39ck90 FIND v(dout0_39) AT=50.025n

.meas tran vdout0_40ck90 FIND v(dout0_40) AT=50.025n

.meas tran vdout0_41ck90 FIND v(dout0_41) AT=50.025n

.meas tran vdout0_42ck90 FIND v(dout0_42) AT=50.025n

.meas tran vdout0_43ck90 FIND v(dout0_43) AT=50.025n

.meas tran vdout0_44ck90 FIND v(dout0_44) AT=50.025n

.meas tran vdout0_45ck90 FIND v(dout0_45) AT=50.025n

.meas tran vdout0_46ck90 FIND v(dout0_46) AT=50.025n

.meas tran vdout0_47ck90 FIND v(dout0_47) AT=50.025n

.meas tran vdout0_48ck90 FIND v(dout0_48) AT=50.025n

.meas tran vdout0_49ck90 FIND v(dout0_49) AT=50.025n

.meas tran vdout0_50ck90 FIND v(dout0_50) AT=50.025n

.meas tran vdout0_51ck90 FIND v(dout0_51) AT=50.025n

.meas tran vdout0_52ck90 FIND v(dout0_52) AT=50.025n

.meas tran vdout0_53ck90 FIND v(dout0_53) AT=50.025n

.meas tran vdout0_54ck90 FIND v(dout0_54) AT=50.025n

.meas tran vdout0_55ck90 FIND v(dout0_55) AT=50.025n

.meas tran vdout0_56ck90 FIND v(dout0_56) AT=50.025n

.meas tran vdout0_57ck90 FIND v(dout0_57) AT=50.025n

.meas tran vdout0_58ck90 FIND v(dout0_58) AT=50.025n

.meas tran vdout0_59ck90 FIND v(dout0_59) AT=50.025n

.meas tran vdout0_60ck90 FIND v(dout0_60) AT=50.025n

.meas tran vdout0_61ck90 FIND v(dout0_61) AT=50.025n

.meas tran vdout0_62ck90 FIND v(dout0_62) AT=50.025n

.meas tran vdout0_63ck90 FIND v(dout0_63) AT=50.025n

.meas tran vdout0_64ck90 FIND v(dout0_64) AT=50.025n

.meas tran vdout0_65ck90 FIND v(dout0_65) AT=50.025n

.meas tran vdout0_66ck90 FIND v(dout0_66) AT=50.025n

.meas tran vdout0_67ck90 FIND v(dout0_67) AT=50.025n

.meas tran vdout0_68ck90 FIND v(dout0_68) AT=50.025n

.meas tran vdout0_69ck90 FIND v(dout0_69) AT=50.025n

.meas tran vdout0_70ck90 FIND v(dout0_70) AT=50.025n

.meas tran vdout0_71ck90 FIND v(dout0_71) AT=50.025n

.meas tran vdout0_72ck90 FIND v(dout0_72) AT=50.025n

.meas tran vdout0_73ck90 FIND v(dout0_73) AT=50.025n

.meas tran vdout0_74ck90 FIND v(dout0_74) AT=50.025n

.meas tran vdout0_75ck90 FIND v(dout0_75) AT=50.025n

.meas tran vdout0_76ck90 FIND v(dout0_76) AT=50.025n

.meas tran vdout0_77ck90 FIND v(dout0_77) AT=50.025n

.meas tran vdout0_78ck90 FIND v(dout0_78) AT=50.025n

.meas tran vdout0_79ck90 FIND v(dout0_79) AT=50.025n

.meas tran vdout0_80ck90 FIND v(dout0_80) AT=50.025n

.meas tran vdout0_81ck90 FIND v(dout0_81) AT=50.025n

.meas tran vdout0_82ck90 FIND v(dout0_82) AT=50.025n

.meas tran vdout0_83ck90 FIND v(dout0_83) AT=50.025n

.meas tran vdout0_84ck90 FIND v(dout0_84) AT=50.025n

.meas tran vdout0_85ck90 FIND v(dout0_85) AT=50.025n

.meas tran vdout0_86ck90 FIND v(dout0_86) AT=50.025n

.meas tran vdout0_87ck90 FIND v(dout0_87) AT=50.025n

.meas tran vdout0_88ck90 FIND v(dout0_88) AT=50.025n

.meas tran vdout0_89ck90 FIND v(dout0_89) AT=50.025n

.meas tran vdout0_90ck90 FIND v(dout0_90) AT=50.025n

.meas tran vdout0_91ck90 FIND v(dout0_91) AT=50.025n

.meas tran vdout0_92ck90 FIND v(dout0_92) AT=50.025n

.meas tran vdout0_93ck90 FIND v(dout0_93) AT=50.025n

.meas tran vdout0_94ck90 FIND v(dout0_94) AT=50.025n

.meas tran vdout0_95ck90 FIND v(dout0_95) AT=50.025n

.meas tran vdout0_96ck90 FIND v(dout0_96) AT=50.025n

.meas tran vdout0_97ck90 FIND v(dout0_97) AT=50.025n

.meas tran vdout0_98ck90 FIND v(dout0_98) AT=50.025n

.meas tran vdout0_99ck90 FIND v(dout0_99) AT=50.025n

.meas tran vdout0_100ck90 FIND v(dout0_100) AT=50.025n

.meas tran vdout0_101ck90 FIND v(dout0_101) AT=50.025n

.meas tran vdout0_102ck90 FIND v(dout0_102) AT=50.025n

.meas tran vdout0_103ck90 FIND v(dout0_103) AT=50.025n

.meas tran vdout0_104ck90 FIND v(dout0_104) AT=50.025n

.meas tran vdout0_105ck90 FIND v(dout0_105) AT=50.025n

.meas tran vdout0_106ck90 FIND v(dout0_106) AT=50.025n

.meas tran vdout0_107ck90 FIND v(dout0_107) AT=50.025n

.meas tran vdout0_108ck90 FIND v(dout0_108) AT=50.025n

.meas tran vdout0_109ck90 FIND v(dout0_109) AT=50.025n

.meas tran vdout0_110ck90 FIND v(dout0_110) AT=50.025n

.meas tran vdout0_111ck90 FIND v(dout0_111) AT=50.025n

.meas tran vdout0_112ck90 FIND v(dout0_112) AT=50.025n

.meas tran vdout0_113ck90 FIND v(dout0_113) AT=50.025n

.meas tran vdout0_114ck90 FIND v(dout0_114) AT=50.025n

.meas tran vdout0_115ck90 FIND v(dout0_115) AT=50.025n

.meas tran vdout0_116ck90 FIND v(dout0_116) AT=50.025n

.meas tran vdout0_117ck90 FIND v(dout0_117) AT=50.025n

.meas tran vdout0_118ck90 FIND v(dout0_118) AT=50.025n

.meas tran vdout0_119ck90 FIND v(dout0_119) AT=50.025n

.meas tran vdout0_120ck90 FIND v(dout0_120) AT=50.025n

.meas tran vdout0_121ck90 FIND v(dout0_121) AT=50.025n

.meas tran vdout0_122ck90 FIND v(dout0_122) AT=50.025n

.meas tran vdout0_123ck90 FIND v(dout0_123) AT=50.025n

.meas tran vdout0_124ck90 FIND v(dout0_124) AT=50.025n

.meas tran vdout0_125ck90 FIND v(dout0_125) AT=50.025n

.meas tran vdout0_126ck90 FIND v(dout0_126) AT=50.025n

.meas tran vdout0_127ck90 FIND v(dout0_127) AT=50.025n

.meas tran vdout0_0ck100 FIND v(dout0_0) AT=55.025n

.meas tran vdout0_1ck100 FIND v(dout0_1) AT=55.025n

.meas tran vdout0_2ck100 FIND v(dout0_2) AT=55.025n

.meas tran vdout0_3ck100 FIND v(dout0_3) AT=55.025n

.meas tran vdout0_4ck100 FIND v(dout0_4) AT=55.025n

.meas tran vdout0_5ck100 FIND v(dout0_5) AT=55.025n

.meas tran vdout0_6ck100 FIND v(dout0_6) AT=55.025n

.meas tran vdout0_7ck100 FIND v(dout0_7) AT=55.025n

.meas tran vdout0_8ck100 FIND v(dout0_8) AT=55.025n

.meas tran vdout0_9ck100 FIND v(dout0_9) AT=55.025n

.meas tran vdout0_10ck100 FIND v(dout0_10) AT=55.025n

.meas tran vdout0_11ck100 FIND v(dout0_11) AT=55.025n

.meas tran vdout0_12ck100 FIND v(dout0_12) AT=55.025n

.meas tran vdout0_13ck100 FIND v(dout0_13) AT=55.025n

.meas tran vdout0_14ck100 FIND v(dout0_14) AT=55.025n

.meas tran vdout0_15ck100 FIND v(dout0_15) AT=55.025n

.meas tran vdout0_16ck100 FIND v(dout0_16) AT=55.025n

.meas tran vdout0_17ck100 FIND v(dout0_17) AT=55.025n

.meas tran vdout0_18ck100 FIND v(dout0_18) AT=55.025n

.meas tran vdout0_19ck100 FIND v(dout0_19) AT=55.025n

.meas tran vdout0_20ck100 FIND v(dout0_20) AT=55.025n

.meas tran vdout0_21ck100 FIND v(dout0_21) AT=55.025n

.meas tran vdout0_22ck100 FIND v(dout0_22) AT=55.025n

.meas tran vdout0_23ck100 FIND v(dout0_23) AT=55.025n

.meas tran vdout0_24ck100 FIND v(dout0_24) AT=55.025n

.meas tran vdout0_25ck100 FIND v(dout0_25) AT=55.025n

.meas tran vdout0_26ck100 FIND v(dout0_26) AT=55.025n

.meas tran vdout0_27ck100 FIND v(dout0_27) AT=55.025n

.meas tran vdout0_28ck100 FIND v(dout0_28) AT=55.025n

.meas tran vdout0_29ck100 FIND v(dout0_29) AT=55.025n

.meas tran vdout0_30ck100 FIND v(dout0_30) AT=55.025n

.meas tran vdout0_31ck100 FIND v(dout0_31) AT=55.025n

.meas tran vdout0_32ck100 FIND v(dout0_32) AT=55.025n

.meas tran vdout0_33ck100 FIND v(dout0_33) AT=55.025n

.meas tran vdout0_34ck100 FIND v(dout0_34) AT=55.025n

.meas tran vdout0_35ck100 FIND v(dout0_35) AT=55.025n

.meas tran vdout0_36ck100 FIND v(dout0_36) AT=55.025n

.meas tran vdout0_37ck100 FIND v(dout0_37) AT=55.025n

.meas tran vdout0_38ck100 FIND v(dout0_38) AT=55.025n

.meas tran vdout0_39ck100 FIND v(dout0_39) AT=55.025n

.meas tran vdout0_40ck100 FIND v(dout0_40) AT=55.025n

.meas tran vdout0_41ck100 FIND v(dout0_41) AT=55.025n

.meas tran vdout0_42ck100 FIND v(dout0_42) AT=55.025n

.meas tran vdout0_43ck100 FIND v(dout0_43) AT=55.025n

.meas tran vdout0_44ck100 FIND v(dout0_44) AT=55.025n

.meas tran vdout0_45ck100 FIND v(dout0_45) AT=55.025n

.meas tran vdout0_46ck100 FIND v(dout0_46) AT=55.025n

.meas tran vdout0_47ck100 FIND v(dout0_47) AT=55.025n

.meas tran vdout0_48ck100 FIND v(dout0_48) AT=55.025n

.meas tran vdout0_49ck100 FIND v(dout0_49) AT=55.025n

.meas tran vdout0_50ck100 FIND v(dout0_50) AT=55.025n

.meas tran vdout0_51ck100 FIND v(dout0_51) AT=55.025n

.meas tran vdout0_52ck100 FIND v(dout0_52) AT=55.025n

.meas tran vdout0_53ck100 FIND v(dout0_53) AT=55.025n

.meas tran vdout0_54ck100 FIND v(dout0_54) AT=55.025n

.meas tran vdout0_55ck100 FIND v(dout0_55) AT=55.025n

.meas tran vdout0_56ck100 FIND v(dout0_56) AT=55.025n

.meas tran vdout0_57ck100 FIND v(dout0_57) AT=55.025n

.meas tran vdout0_58ck100 FIND v(dout0_58) AT=55.025n

.meas tran vdout0_59ck100 FIND v(dout0_59) AT=55.025n

.meas tran vdout0_60ck100 FIND v(dout0_60) AT=55.025n

.meas tran vdout0_61ck100 FIND v(dout0_61) AT=55.025n

.meas tran vdout0_62ck100 FIND v(dout0_62) AT=55.025n

.meas tran vdout0_63ck100 FIND v(dout0_63) AT=55.025n

.meas tran vdout0_64ck100 FIND v(dout0_64) AT=55.025n

.meas tran vdout0_65ck100 FIND v(dout0_65) AT=55.025n

.meas tran vdout0_66ck100 FIND v(dout0_66) AT=55.025n

.meas tran vdout0_67ck100 FIND v(dout0_67) AT=55.025n

.meas tran vdout0_68ck100 FIND v(dout0_68) AT=55.025n

.meas tran vdout0_69ck100 FIND v(dout0_69) AT=55.025n

.meas tran vdout0_70ck100 FIND v(dout0_70) AT=55.025n

.meas tran vdout0_71ck100 FIND v(dout0_71) AT=55.025n

.meas tran vdout0_72ck100 FIND v(dout0_72) AT=55.025n

.meas tran vdout0_73ck100 FIND v(dout0_73) AT=55.025n

.meas tran vdout0_74ck100 FIND v(dout0_74) AT=55.025n

.meas tran vdout0_75ck100 FIND v(dout0_75) AT=55.025n

.meas tran vdout0_76ck100 FIND v(dout0_76) AT=55.025n

.meas tran vdout0_77ck100 FIND v(dout0_77) AT=55.025n

.meas tran vdout0_78ck100 FIND v(dout0_78) AT=55.025n

.meas tran vdout0_79ck100 FIND v(dout0_79) AT=55.025n

.meas tran vdout0_80ck100 FIND v(dout0_80) AT=55.025n

.meas tran vdout0_81ck100 FIND v(dout0_81) AT=55.025n

.meas tran vdout0_82ck100 FIND v(dout0_82) AT=55.025n

.meas tran vdout0_83ck100 FIND v(dout0_83) AT=55.025n

.meas tran vdout0_84ck100 FIND v(dout0_84) AT=55.025n

.meas tran vdout0_85ck100 FIND v(dout0_85) AT=55.025n

.meas tran vdout0_86ck100 FIND v(dout0_86) AT=55.025n

.meas tran vdout0_87ck100 FIND v(dout0_87) AT=55.025n

.meas tran vdout0_88ck100 FIND v(dout0_88) AT=55.025n

.meas tran vdout0_89ck100 FIND v(dout0_89) AT=55.025n

.meas tran vdout0_90ck100 FIND v(dout0_90) AT=55.025n

.meas tran vdout0_91ck100 FIND v(dout0_91) AT=55.025n

.meas tran vdout0_92ck100 FIND v(dout0_92) AT=55.025n

.meas tran vdout0_93ck100 FIND v(dout0_93) AT=55.025n

.meas tran vdout0_94ck100 FIND v(dout0_94) AT=55.025n

.meas tran vdout0_95ck100 FIND v(dout0_95) AT=55.025n

.meas tran vdout0_96ck100 FIND v(dout0_96) AT=55.025n

.meas tran vdout0_97ck100 FIND v(dout0_97) AT=55.025n

.meas tran vdout0_98ck100 FIND v(dout0_98) AT=55.025n

.meas tran vdout0_99ck100 FIND v(dout0_99) AT=55.025n

.meas tran vdout0_100ck100 FIND v(dout0_100) AT=55.025n

.meas tran vdout0_101ck100 FIND v(dout0_101) AT=55.025n

.meas tran vdout0_102ck100 FIND v(dout0_102) AT=55.025n

.meas tran vdout0_103ck100 FIND v(dout0_103) AT=55.025n

.meas tran vdout0_104ck100 FIND v(dout0_104) AT=55.025n

.meas tran vdout0_105ck100 FIND v(dout0_105) AT=55.025n

.meas tran vdout0_106ck100 FIND v(dout0_106) AT=55.025n

.meas tran vdout0_107ck100 FIND v(dout0_107) AT=55.025n

.meas tran vdout0_108ck100 FIND v(dout0_108) AT=55.025n

.meas tran vdout0_109ck100 FIND v(dout0_109) AT=55.025n

.meas tran vdout0_110ck100 FIND v(dout0_110) AT=55.025n

.meas tran vdout0_111ck100 FIND v(dout0_111) AT=55.025n

.meas tran vdout0_112ck100 FIND v(dout0_112) AT=55.025n

.meas tran vdout0_113ck100 FIND v(dout0_113) AT=55.025n

.meas tran vdout0_114ck100 FIND v(dout0_114) AT=55.025n

.meas tran vdout0_115ck100 FIND v(dout0_115) AT=55.025n

.meas tran vdout0_116ck100 FIND v(dout0_116) AT=55.025n

.meas tran vdout0_117ck100 FIND v(dout0_117) AT=55.025n

.meas tran vdout0_118ck100 FIND v(dout0_118) AT=55.025n

.meas tran vdout0_119ck100 FIND v(dout0_119) AT=55.025n

.meas tran vdout0_120ck100 FIND v(dout0_120) AT=55.025n

.meas tran vdout0_121ck100 FIND v(dout0_121) AT=55.025n

.meas tran vdout0_122ck100 FIND v(dout0_122) AT=55.025n

.meas tran vdout0_123ck100 FIND v(dout0_123) AT=55.025n

.meas tran vdout0_124ck100 FIND v(dout0_124) AT=55.025n

.meas tran vdout0_125ck100 FIND v(dout0_125) AT=55.025n

.meas tran vdout0_126ck100 FIND v(dout0_126) AT=55.025n

.meas tran vdout0_127ck100 FIND v(dout0_127) AT=55.025n

.meas tran vdout0_0ck120 FIND v(dout0_0) AT=65.025n

.meas tran vdout0_1ck120 FIND v(dout0_1) AT=65.025n

.meas tran vdout0_2ck120 FIND v(dout0_2) AT=65.025n

.meas tran vdout0_3ck120 FIND v(dout0_3) AT=65.025n

.meas tran vdout0_4ck120 FIND v(dout0_4) AT=65.025n

.meas tran vdout0_5ck120 FIND v(dout0_5) AT=65.025n

.meas tran vdout0_6ck120 FIND v(dout0_6) AT=65.025n

.meas tran vdout0_7ck120 FIND v(dout0_7) AT=65.025n

.meas tran vdout0_8ck120 FIND v(dout0_8) AT=65.025n

.meas tran vdout0_9ck120 FIND v(dout0_9) AT=65.025n

.meas tran vdout0_10ck120 FIND v(dout0_10) AT=65.025n

.meas tran vdout0_11ck120 FIND v(dout0_11) AT=65.025n

.meas tran vdout0_12ck120 FIND v(dout0_12) AT=65.025n

.meas tran vdout0_13ck120 FIND v(dout0_13) AT=65.025n

.meas tran vdout0_14ck120 FIND v(dout0_14) AT=65.025n

.meas tran vdout0_15ck120 FIND v(dout0_15) AT=65.025n

.meas tran vdout0_16ck120 FIND v(dout0_16) AT=65.025n

.meas tran vdout0_17ck120 FIND v(dout0_17) AT=65.025n

.meas tran vdout0_18ck120 FIND v(dout0_18) AT=65.025n

.meas tran vdout0_19ck120 FIND v(dout0_19) AT=65.025n

.meas tran vdout0_20ck120 FIND v(dout0_20) AT=65.025n

.meas tran vdout0_21ck120 FIND v(dout0_21) AT=65.025n

.meas tran vdout0_22ck120 FIND v(dout0_22) AT=65.025n

.meas tran vdout0_23ck120 FIND v(dout0_23) AT=65.025n

.meas tran vdout0_24ck120 FIND v(dout0_24) AT=65.025n

.meas tran vdout0_25ck120 FIND v(dout0_25) AT=65.025n

.meas tran vdout0_26ck120 FIND v(dout0_26) AT=65.025n

.meas tran vdout0_27ck120 FIND v(dout0_27) AT=65.025n

.meas tran vdout0_28ck120 FIND v(dout0_28) AT=65.025n

.meas tran vdout0_29ck120 FIND v(dout0_29) AT=65.025n

.meas tran vdout0_30ck120 FIND v(dout0_30) AT=65.025n

.meas tran vdout0_31ck120 FIND v(dout0_31) AT=65.025n

.meas tran vdout0_32ck120 FIND v(dout0_32) AT=65.025n

.meas tran vdout0_33ck120 FIND v(dout0_33) AT=65.025n

.meas tran vdout0_34ck120 FIND v(dout0_34) AT=65.025n

.meas tran vdout0_35ck120 FIND v(dout0_35) AT=65.025n

.meas tran vdout0_36ck120 FIND v(dout0_36) AT=65.025n

.meas tran vdout0_37ck120 FIND v(dout0_37) AT=65.025n

.meas tran vdout0_38ck120 FIND v(dout0_38) AT=65.025n

.meas tran vdout0_39ck120 FIND v(dout0_39) AT=65.025n

.meas tran vdout0_40ck120 FIND v(dout0_40) AT=65.025n

.meas tran vdout0_41ck120 FIND v(dout0_41) AT=65.025n

.meas tran vdout0_42ck120 FIND v(dout0_42) AT=65.025n

.meas tran vdout0_43ck120 FIND v(dout0_43) AT=65.025n

.meas tran vdout0_44ck120 FIND v(dout0_44) AT=65.025n

.meas tran vdout0_45ck120 FIND v(dout0_45) AT=65.025n

.meas tran vdout0_46ck120 FIND v(dout0_46) AT=65.025n

.meas tran vdout0_47ck120 FIND v(dout0_47) AT=65.025n

.meas tran vdout0_48ck120 FIND v(dout0_48) AT=65.025n

.meas tran vdout0_49ck120 FIND v(dout0_49) AT=65.025n

.meas tran vdout0_50ck120 FIND v(dout0_50) AT=65.025n

.meas tran vdout0_51ck120 FIND v(dout0_51) AT=65.025n

.meas tran vdout0_52ck120 FIND v(dout0_52) AT=65.025n

.meas tran vdout0_53ck120 FIND v(dout0_53) AT=65.025n

.meas tran vdout0_54ck120 FIND v(dout0_54) AT=65.025n

.meas tran vdout0_55ck120 FIND v(dout0_55) AT=65.025n

.meas tran vdout0_56ck120 FIND v(dout0_56) AT=65.025n

.meas tran vdout0_57ck120 FIND v(dout0_57) AT=65.025n

.meas tran vdout0_58ck120 FIND v(dout0_58) AT=65.025n

.meas tran vdout0_59ck120 FIND v(dout0_59) AT=65.025n

.meas tran vdout0_60ck120 FIND v(dout0_60) AT=65.025n

.meas tran vdout0_61ck120 FIND v(dout0_61) AT=65.025n

.meas tran vdout0_62ck120 FIND v(dout0_62) AT=65.025n

.meas tran vdout0_63ck120 FIND v(dout0_63) AT=65.025n

.meas tran vdout0_64ck120 FIND v(dout0_64) AT=65.025n

.meas tran vdout0_65ck120 FIND v(dout0_65) AT=65.025n

.meas tran vdout0_66ck120 FIND v(dout0_66) AT=65.025n

.meas tran vdout0_67ck120 FIND v(dout0_67) AT=65.025n

.meas tran vdout0_68ck120 FIND v(dout0_68) AT=65.025n

.meas tran vdout0_69ck120 FIND v(dout0_69) AT=65.025n

.meas tran vdout0_70ck120 FIND v(dout0_70) AT=65.025n

.meas tran vdout0_71ck120 FIND v(dout0_71) AT=65.025n

.meas tran vdout0_72ck120 FIND v(dout0_72) AT=65.025n

.meas tran vdout0_73ck120 FIND v(dout0_73) AT=65.025n

.meas tran vdout0_74ck120 FIND v(dout0_74) AT=65.025n

.meas tran vdout0_75ck120 FIND v(dout0_75) AT=65.025n

.meas tran vdout0_76ck120 FIND v(dout0_76) AT=65.025n

.meas tran vdout0_77ck120 FIND v(dout0_77) AT=65.025n

.meas tran vdout0_78ck120 FIND v(dout0_78) AT=65.025n

.meas tran vdout0_79ck120 FIND v(dout0_79) AT=65.025n

.meas tran vdout0_80ck120 FIND v(dout0_80) AT=65.025n

.meas tran vdout0_81ck120 FIND v(dout0_81) AT=65.025n

.meas tran vdout0_82ck120 FIND v(dout0_82) AT=65.025n

.meas tran vdout0_83ck120 FIND v(dout0_83) AT=65.025n

.meas tran vdout0_84ck120 FIND v(dout0_84) AT=65.025n

.meas tran vdout0_85ck120 FIND v(dout0_85) AT=65.025n

.meas tran vdout0_86ck120 FIND v(dout0_86) AT=65.025n

.meas tran vdout0_87ck120 FIND v(dout0_87) AT=65.025n

.meas tran vdout0_88ck120 FIND v(dout0_88) AT=65.025n

.meas tran vdout0_89ck120 FIND v(dout0_89) AT=65.025n

.meas tran vdout0_90ck120 FIND v(dout0_90) AT=65.025n

.meas tran vdout0_91ck120 FIND v(dout0_91) AT=65.025n

.meas tran vdout0_92ck120 FIND v(dout0_92) AT=65.025n

.meas tran vdout0_93ck120 FIND v(dout0_93) AT=65.025n

.meas tran vdout0_94ck120 FIND v(dout0_94) AT=65.025n

.meas tran vdout0_95ck120 FIND v(dout0_95) AT=65.025n

.meas tran vdout0_96ck120 FIND v(dout0_96) AT=65.025n

.meas tran vdout0_97ck120 FIND v(dout0_97) AT=65.025n

.meas tran vdout0_98ck120 FIND v(dout0_98) AT=65.025n

.meas tran vdout0_99ck120 FIND v(dout0_99) AT=65.025n

.meas tran vdout0_100ck120 FIND v(dout0_100) AT=65.025n

.meas tran vdout0_101ck120 FIND v(dout0_101) AT=65.025n

.meas tran vdout0_102ck120 FIND v(dout0_102) AT=65.025n

.meas tran vdout0_103ck120 FIND v(dout0_103) AT=65.025n

.meas tran vdout0_104ck120 FIND v(dout0_104) AT=65.025n

.meas tran vdout0_105ck120 FIND v(dout0_105) AT=65.025n

.meas tran vdout0_106ck120 FIND v(dout0_106) AT=65.025n

.meas tran vdout0_107ck120 FIND v(dout0_107) AT=65.025n

.meas tran vdout0_108ck120 FIND v(dout0_108) AT=65.025n

.meas tran vdout0_109ck120 FIND v(dout0_109) AT=65.025n

.meas tran vdout0_110ck120 FIND v(dout0_110) AT=65.025n

.meas tran vdout0_111ck120 FIND v(dout0_111) AT=65.025n

.meas tran vdout0_112ck120 FIND v(dout0_112) AT=65.025n

.meas tran vdout0_113ck120 FIND v(dout0_113) AT=65.025n

.meas tran vdout0_114ck120 FIND v(dout0_114) AT=65.025n

.meas tran vdout0_115ck120 FIND v(dout0_115) AT=65.025n

.meas tran vdout0_116ck120 FIND v(dout0_116) AT=65.025n

.meas tran vdout0_117ck120 FIND v(dout0_117) AT=65.025n

.meas tran vdout0_118ck120 FIND v(dout0_118) AT=65.025n

.meas tran vdout0_119ck120 FIND v(dout0_119) AT=65.025n

.meas tran vdout0_120ck120 FIND v(dout0_120) AT=65.025n

.meas tran vdout0_121ck120 FIND v(dout0_121) AT=65.025n

.meas tran vdout0_122ck120 FIND v(dout0_122) AT=65.025n

.meas tran vdout0_123ck120 FIND v(dout0_123) AT=65.025n

.meas tran vdout0_124ck120 FIND v(dout0_124) AT=65.025n

.meas tran vdout0_125ck120 FIND v(dout0_125) AT=65.025n

.meas tran vdout0_126ck120 FIND v(dout0_126) AT=65.025n

.meas tran vdout0_127ck120 FIND v(dout0_127) AT=65.025n

.meas tran vdout0_0ck130 FIND v(dout0_0) AT=70.025n

.meas tran vdout0_1ck130 FIND v(dout0_1) AT=70.025n

.meas tran vdout0_2ck130 FIND v(dout0_2) AT=70.025n

.meas tran vdout0_3ck130 FIND v(dout0_3) AT=70.025n

.meas tran vdout0_4ck130 FIND v(dout0_4) AT=70.025n

.meas tran vdout0_5ck130 FIND v(dout0_5) AT=70.025n

.meas tran vdout0_6ck130 FIND v(dout0_6) AT=70.025n

.meas tran vdout0_7ck130 FIND v(dout0_7) AT=70.025n

.meas tran vdout0_8ck130 FIND v(dout0_8) AT=70.025n

.meas tran vdout0_9ck130 FIND v(dout0_9) AT=70.025n

.meas tran vdout0_10ck130 FIND v(dout0_10) AT=70.025n

.meas tran vdout0_11ck130 FIND v(dout0_11) AT=70.025n

.meas tran vdout0_12ck130 FIND v(dout0_12) AT=70.025n

.meas tran vdout0_13ck130 FIND v(dout0_13) AT=70.025n

.meas tran vdout0_14ck130 FIND v(dout0_14) AT=70.025n

.meas tran vdout0_15ck130 FIND v(dout0_15) AT=70.025n

.meas tran vdout0_16ck130 FIND v(dout0_16) AT=70.025n

.meas tran vdout0_17ck130 FIND v(dout0_17) AT=70.025n

.meas tran vdout0_18ck130 FIND v(dout0_18) AT=70.025n

.meas tran vdout0_19ck130 FIND v(dout0_19) AT=70.025n

.meas tran vdout0_20ck130 FIND v(dout0_20) AT=70.025n

.meas tran vdout0_21ck130 FIND v(dout0_21) AT=70.025n

.meas tran vdout0_22ck130 FIND v(dout0_22) AT=70.025n

.meas tran vdout0_23ck130 FIND v(dout0_23) AT=70.025n

.meas tran vdout0_24ck130 FIND v(dout0_24) AT=70.025n

.meas tran vdout0_25ck130 FIND v(dout0_25) AT=70.025n

.meas tran vdout0_26ck130 FIND v(dout0_26) AT=70.025n

.meas tran vdout0_27ck130 FIND v(dout0_27) AT=70.025n

.meas tran vdout0_28ck130 FIND v(dout0_28) AT=70.025n

.meas tran vdout0_29ck130 FIND v(dout0_29) AT=70.025n

.meas tran vdout0_30ck130 FIND v(dout0_30) AT=70.025n

.meas tran vdout0_31ck130 FIND v(dout0_31) AT=70.025n

.meas tran vdout0_32ck130 FIND v(dout0_32) AT=70.025n

.meas tran vdout0_33ck130 FIND v(dout0_33) AT=70.025n

.meas tran vdout0_34ck130 FIND v(dout0_34) AT=70.025n

.meas tran vdout0_35ck130 FIND v(dout0_35) AT=70.025n

.meas tran vdout0_36ck130 FIND v(dout0_36) AT=70.025n

.meas tran vdout0_37ck130 FIND v(dout0_37) AT=70.025n

.meas tran vdout0_38ck130 FIND v(dout0_38) AT=70.025n

.meas tran vdout0_39ck130 FIND v(dout0_39) AT=70.025n

.meas tran vdout0_40ck130 FIND v(dout0_40) AT=70.025n

.meas tran vdout0_41ck130 FIND v(dout0_41) AT=70.025n

.meas tran vdout0_42ck130 FIND v(dout0_42) AT=70.025n

.meas tran vdout0_43ck130 FIND v(dout0_43) AT=70.025n

.meas tran vdout0_44ck130 FIND v(dout0_44) AT=70.025n

.meas tran vdout0_45ck130 FIND v(dout0_45) AT=70.025n

.meas tran vdout0_46ck130 FIND v(dout0_46) AT=70.025n

.meas tran vdout0_47ck130 FIND v(dout0_47) AT=70.025n

.meas tran vdout0_48ck130 FIND v(dout0_48) AT=70.025n

.meas tran vdout0_49ck130 FIND v(dout0_49) AT=70.025n

.meas tran vdout0_50ck130 FIND v(dout0_50) AT=70.025n

.meas tran vdout0_51ck130 FIND v(dout0_51) AT=70.025n

.meas tran vdout0_52ck130 FIND v(dout0_52) AT=70.025n

.meas tran vdout0_53ck130 FIND v(dout0_53) AT=70.025n

.meas tran vdout0_54ck130 FIND v(dout0_54) AT=70.025n

.meas tran vdout0_55ck130 FIND v(dout0_55) AT=70.025n

.meas tran vdout0_56ck130 FIND v(dout0_56) AT=70.025n

.meas tran vdout0_57ck130 FIND v(dout0_57) AT=70.025n

.meas tran vdout0_58ck130 FIND v(dout0_58) AT=70.025n

.meas tran vdout0_59ck130 FIND v(dout0_59) AT=70.025n

.meas tran vdout0_60ck130 FIND v(dout0_60) AT=70.025n

.meas tran vdout0_61ck130 FIND v(dout0_61) AT=70.025n

.meas tran vdout0_62ck130 FIND v(dout0_62) AT=70.025n

.meas tran vdout0_63ck130 FIND v(dout0_63) AT=70.025n

.meas tran vdout0_64ck130 FIND v(dout0_64) AT=70.025n

.meas tran vdout0_65ck130 FIND v(dout0_65) AT=70.025n

.meas tran vdout0_66ck130 FIND v(dout0_66) AT=70.025n

.meas tran vdout0_67ck130 FIND v(dout0_67) AT=70.025n

.meas tran vdout0_68ck130 FIND v(dout0_68) AT=70.025n

.meas tran vdout0_69ck130 FIND v(dout0_69) AT=70.025n

.meas tran vdout0_70ck130 FIND v(dout0_70) AT=70.025n

.meas tran vdout0_71ck130 FIND v(dout0_71) AT=70.025n

.meas tran vdout0_72ck130 FIND v(dout0_72) AT=70.025n

.meas tran vdout0_73ck130 FIND v(dout0_73) AT=70.025n

.meas tran vdout0_74ck130 FIND v(dout0_74) AT=70.025n

.meas tran vdout0_75ck130 FIND v(dout0_75) AT=70.025n

.meas tran vdout0_76ck130 FIND v(dout0_76) AT=70.025n

.meas tran vdout0_77ck130 FIND v(dout0_77) AT=70.025n

.meas tran vdout0_78ck130 FIND v(dout0_78) AT=70.025n

.meas tran vdout0_79ck130 FIND v(dout0_79) AT=70.025n

.meas tran vdout0_80ck130 FIND v(dout0_80) AT=70.025n

.meas tran vdout0_81ck130 FIND v(dout0_81) AT=70.025n

.meas tran vdout0_82ck130 FIND v(dout0_82) AT=70.025n

.meas tran vdout0_83ck130 FIND v(dout0_83) AT=70.025n

.meas tran vdout0_84ck130 FIND v(dout0_84) AT=70.025n

.meas tran vdout0_85ck130 FIND v(dout0_85) AT=70.025n

.meas tran vdout0_86ck130 FIND v(dout0_86) AT=70.025n

.meas tran vdout0_87ck130 FIND v(dout0_87) AT=70.025n

.meas tran vdout0_88ck130 FIND v(dout0_88) AT=70.025n

.meas tran vdout0_89ck130 FIND v(dout0_89) AT=70.025n

.meas tran vdout0_90ck130 FIND v(dout0_90) AT=70.025n

.meas tran vdout0_91ck130 FIND v(dout0_91) AT=70.025n

.meas tran vdout0_92ck130 FIND v(dout0_92) AT=70.025n

.meas tran vdout0_93ck130 FIND v(dout0_93) AT=70.025n

.meas tran vdout0_94ck130 FIND v(dout0_94) AT=70.025n

.meas tran vdout0_95ck130 FIND v(dout0_95) AT=70.025n

.meas tran vdout0_96ck130 FIND v(dout0_96) AT=70.025n

.meas tran vdout0_97ck130 FIND v(dout0_97) AT=70.025n

.meas tran vdout0_98ck130 FIND v(dout0_98) AT=70.025n

.meas tran vdout0_99ck130 FIND v(dout0_99) AT=70.025n

.meas tran vdout0_100ck130 FIND v(dout0_100) AT=70.025n

.meas tran vdout0_101ck130 FIND v(dout0_101) AT=70.025n

.meas tran vdout0_102ck130 FIND v(dout0_102) AT=70.025n

.meas tran vdout0_103ck130 FIND v(dout0_103) AT=70.025n

.meas tran vdout0_104ck130 FIND v(dout0_104) AT=70.025n

.meas tran vdout0_105ck130 FIND v(dout0_105) AT=70.025n

.meas tran vdout0_106ck130 FIND v(dout0_106) AT=70.025n

.meas tran vdout0_107ck130 FIND v(dout0_107) AT=70.025n

.meas tran vdout0_108ck130 FIND v(dout0_108) AT=70.025n

.meas tran vdout0_109ck130 FIND v(dout0_109) AT=70.025n

.meas tran vdout0_110ck130 FIND v(dout0_110) AT=70.025n

.meas tran vdout0_111ck130 FIND v(dout0_111) AT=70.025n

.meas tran vdout0_112ck130 FIND v(dout0_112) AT=70.025n

.meas tran vdout0_113ck130 FIND v(dout0_113) AT=70.025n

.meas tran vdout0_114ck130 FIND v(dout0_114) AT=70.025n

.meas tran vdout0_115ck130 FIND v(dout0_115) AT=70.025n

.meas tran vdout0_116ck130 FIND v(dout0_116) AT=70.025n

.meas tran vdout0_117ck130 FIND v(dout0_117) AT=70.025n

.meas tran vdout0_118ck130 FIND v(dout0_118) AT=70.025n

.meas tran vdout0_119ck130 FIND v(dout0_119) AT=70.025n

.meas tran vdout0_120ck130 FIND v(dout0_120) AT=70.025n

.meas tran vdout0_121ck130 FIND v(dout0_121) AT=70.025n

.meas tran vdout0_122ck130 FIND v(dout0_122) AT=70.025n

.meas tran vdout0_123ck130 FIND v(dout0_123) AT=70.025n

.meas tran vdout0_124ck130 FIND v(dout0_124) AT=70.025n

.meas tran vdout0_125ck130 FIND v(dout0_125) AT=70.025n

.meas tran vdout0_126ck130 FIND v(dout0_126) AT=70.025n

.meas tran vdout0_127ck130 FIND v(dout0_127) AT=70.025n

.meas tran vdout0_0ck140 FIND v(dout0_0) AT=75.025n

.meas tran vdout0_1ck140 FIND v(dout0_1) AT=75.025n

.meas tran vdout0_2ck140 FIND v(dout0_2) AT=75.025n

.meas tran vdout0_3ck140 FIND v(dout0_3) AT=75.025n

.meas tran vdout0_4ck140 FIND v(dout0_4) AT=75.025n

.meas tran vdout0_5ck140 FIND v(dout0_5) AT=75.025n

.meas tran vdout0_6ck140 FIND v(dout0_6) AT=75.025n

.meas tran vdout0_7ck140 FIND v(dout0_7) AT=75.025n

.meas tran vdout0_8ck140 FIND v(dout0_8) AT=75.025n

.meas tran vdout0_9ck140 FIND v(dout0_9) AT=75.025n

.meas tran vdout0_10ck140 FIND v(dout0_10) AT=75.025n

.meas tran vdout0_11ck140 FIND v(dout0_11) AT=75.025n

.meas tran vdout0_12ck140 FIND v(dout0_12) AT=75.025n

.meas tran vdout0_13ck140 FIND v(dout0_13) AT=75.025n

.meas tran vdout0_14ck140 FIND v(dout0_14) AT=75.025n

.meas tran vdout0_15ck140 FIND v(dout0_15) AT=75.025n

.meas tran vdout0_16ck140 FIND v(dout0_16) AT=75.025n

.meas tran vdout0_17ck140 FIND v(dout0_17) AT=75.025n

.meas tran vdout0_18ck140 FIND v(dout0_18) AT=75.025n

.meas tran vdout0_19ck140 FIND v(dout0_19) AT=75.025n

.meas tran vdout0_20ck140 FIND v(dout0_20) AT=75.025n

.meas tran vdout0_21ck140 FIND v(dout0_21) AT=75.025n

.meas tran vdout0_22ck140 FIND v(dout0_22) AT=75.025n

.meas tran vdout0_23ck140 FIND v(dout0_23) AT=75.025n

.meas tran vdout0_24ck140 FIND v(dout0_24) AT=75.025n

.meas tran vdout0_25ck140 FIND v(dout0_25) AT=75.025n

.meas tran vdout0_26ck140 FIND v(dout0_26) AT=75.025n

.meas tran vdout0_27ck140 FIND v(dout0_27) AT=75.025n

.meas tran vdout0_28ck140 FIND v(dout0_28) AT=75.025n

.meas tran vdout0_29ck140 FIND v(dout0_29) AT=75.025n

.meas tran vdout0_30ck140 FIND v(dout0_30) AT=75.025n

.meas tran vdout0_31ck140 FIND v(dout0_31) AT=75.025n

.meas tran vdout0_32ck140 FIND v(dout0_32) AT=75.025n

.meas tran vdout0_33ck140 FIND v(dout0_33) AT=75.025n

.meas tran vdout0_34ck140 FIND v(dout0_34) AT=75.025n

.meas tran vdout0_35ck140 FIND v(dout0_35) AT=75.025n

.meas tran vdout0_36ck140 FIND v(dout0_36) AT=75.025n

.meas tran vdout0_37ck140 FIND v(dout0_37) AT=75.025n

.meas tran vdout0_38ck140 FIND v(dout0_38) AT=75.025n

.meas tran vdout0_39ck140 FIND v(dout0_39) AT=75.025n

.meas tran vdout0_40ck140 FIND v(dout0_40) AT=75.025n

.meas tran vdout0_41ck140 FIND v(dout0_41) AT=75.025n

.meas tran vdout0_42ck140 FIND v(dout0_42) AT=75.025n

.meas tran vdout0_43ck140 FIND v(dout0_43) AT=75.025n

.meas tran vdout0_44ck140 FIND v(dout0_44) AT=75.025n

.meas tran vdout0_45ck140 FIND v(dout0_45) AT=75.025n

.meas tran vdout0_46ck140 FIND v(dout0_46) AT=75.025n

.meas tran vdout0_47ck140 FIND v(dout0_47) AT=75.025n

.meas tran vdout0_48ck140 FIND v(dout0_48) AT=75.025n

.meas tran vdout0_49ck140 FIND v(dout0_49) AT=75.025n

.meas tran vdout0_50ck140 FIND v(dout0_50) AT=75.025n

.meas tran vdout0_51ck140 FIND v(dout0_51) AT=75.025n

.meas tran vdout0_52ck140 FIND v(dout0_52) AT=75.025n

.meas tran vdout0_53ck140 FIND v(dout0_53) AT=75.025n

.meas tran vdout0_54ck140 FIND v(dout0_54) AT=75.025n

.meas tran vdout0_55ck140 FIND v(dout0_55) AT=75.025n

.meas tran vdout0_56ck140 FIND v(dout0_56) AT=75.025n

.meas tran vdout0_57ck140 FIND v(dout0_57) AT=75.025n

.meas tran vdout0_58ck140 FIND v(dout0_58) AT=75.025n

.meas tran vdout0_59ck140 FIND v(dout0_59) AT=75.025n

.meas tran vdout0_60ck140 FIND v(dout0_60) AT=75.025n

.meas tran vdout0_61ck140 FIND v(dout0_61) AT=75.025n

.meas tran vdout0_62ck140 FIND v(dout0_62) AT=75.025n

.meas tran vdout0_63ck140 FIND v(dout0_63) AT=75.025n

.meas tran vdout0_64ck140 FIND v(dout0_64) AT=75.025n

.meas tran vdout0_65ck140 FIND v(dout0_65) AT=75.025n

.meas tran vdout0_66ck140 FIND v(dout0_66) AT=75.025n

.meas tran vdout0_67ck140 FIND v(dout0_67) AT=75.025n

.meas tran vdout0_68ck140 FIND v(dout0_68) AT=75.025n

.meas tran vdout0_69ck140 FIND v(dout0_69) AT=75.025n

.meas tran vdout0_70ck140 FIND v(dout0_70) AT=75.025n

.meas tran vdout0_71ck140 FIND v(dout0_71) AT=75.025n

.meas tran vdout0_72ck140 FIND v(dout0_72) AT=75.025n

.meas tran vdout0_73ck140 FIND v(dout0_73) AT=75.025n

.meas tran vdout0_74ck140 FIND v(dout0_74) AT=75.025n

.meas tran vdout0_75ck140 FIND v(dout0_75) AT=75.025n

.meas tran vdout0_76ck140 FIND v(dout0_76) AT=75.025n

.meas tran vdout0_77ck140 FIND v(dout0_77) AT=75.025n

.meas tran vdout0_78ck140 FIND v(dout0_78) AT=75.025n

.meas tran vdout0_79ck140 FIND v(dout0_79) AT=75.025n

.meas tran vdout0_80ck140 FIND v(dout0_80) AT=75.025n

.meas tran vdout0_81ck140 FIND v(dout0_81) AT=75.025n

.meas tran vdout0_82ck140 FIND v(dout0_82) AT=75.025n

.meas tran vdout0_83ck140 FIND v(dout0_83) AT=75.025n

.meas tran vdout0_84ck140 FIND v(dout0_84) AT=75.025n

.meas tran vdout0_85ck140 FIND v(dout0_85) AT=75.025n

.meas tran vdout0_86ck140 FIND v(dout0_86) AT=75.025n

.meas tran vdout0_87ck140 FIND v(dout0_87) AT=75.025n

.meas tran vdout0_88ck140 FIND v(dout0_88) AT=75.025n

.meas tran vdout0_89ck140 FIND v(dout0_89) AT=75.025n

.meas tran vdout0_90ck140 FIND v(dout0_90) AT=75.025n

.meas tran vdout0_91ck140 FIND v(dout0_91) AT=75.025n

.meas tran vdout0_92ck140 FIND v(dout0_92) AT=75.025n

.meas tran vdout0_93ck140 FIND v(dout0_93) AT=75.025n

.meas tran vdout0_94ck140 FIND v(dout0_94) AT=75.025n

.meas tran vdout0_95ck140 FIND v(dout0_95) AT=75.025n

.meas tran vdout0_96ck140 FIND v(dout0_96) AT=75.025n

.meas tran vdout0_97ck140 FIND v(dout0_97) AT=75.025n

.meas tran vdout0_98ck140 FIND v(dout0_98) AT=75.025n

.meas tran vdout0_99ck140 FIND v(dout0_99) AT=75.025n

.meas tran vdout0_100ck140 FIND v(dout0_100) AT=75.025n

.meas tran vdout0_101ck140 FIND v(dout0_101) AT=75.025n

.meas tran vdout0_102ck140 FIND v(dout0_102) AT=75.025n

.meas tran vdout0_103ck140 FIND v(dout0_103) AT=75.025n

.meas tran vdout0_104ck140 FIND v(dout0_104) AT=75.025n

.meas tran vdout0_105ck140 FIND v(dout0_105) AT=75.025n

.meas tran vdout0_106ck140 FIND v(dout0_106) AT=75.025n

.meas tran vdout0_107ck140 FIND v(dout0_107) AT=75.025n

.meas tran vdout0_108ck140 FIND v(dout0_108) AT=75.025n

.meas tran vdout0_109ck140 FIND v(dout0_109) AT=75.025n

.meas tran vdout0_110ck140 FIND v(dout0_110) AT=75.025n

.meas tran vdout0_111ck140 FIND v(dout0_111) AT=75.025n

.meas tran vdout0_112ck140 FIND v(dout0_112) AT=75.025n

.meas tran vdout0_113ck140 FIND v(dout0_113) AT=75.025n

.meas tran vdout0_114ck140 FIND v(dout0_114) AT=75.025n

.meas tran vdout0_115ck140 FIND v(dout0_115) AT=75.025n

.meas tran vdout0_116ck140 FIND v(dout0_116) AT=75.025n

.meas tran vdout0_117ck140 FIND v(dout0_117) AT=75.025n

.meas tran vdout0_118ck140 FIND v(dout0_118) AT=75.025n

.meas tran vdout0_119ck140 FIND v(dout0_119) AT=75.025n

.meas tran vdout0_120ck140 FIND v(dout0_120) AT=75.025n

.meas tran vdout0_121ck140 FIND v(dout0_121) AT=75.025n

.meas tran vdout0_122ck140 FIND v(dout0_122) AT=75.025n

.meas tran vdout0_123ck140 FIND v(dout0_123) AT=75.025n

.meas tran vdout0_124ck140 FIND v(dout0_124) AT=75.025n

.meas tran vdout0_125ck140 FIND v(dout0_125) AT=75.025n

.meas tran vdout0_126ck140 FIND v(dout0_126) AT=75.025n

.meas tran vdout0_127ck140 FIND v(dout0_127) AT=75.025n

.meas tran vdout0_0ck160 FIND v(dout0_0) AT=85.025n

.meas tran vdout0_1ck160 FIND v(dout0_1) AT=85.025n

.meas tran vdout0_2ck160 FIND v(dout0_2) AT=85.025n

.meas tran vdout0_3ck160 FIND v(dout0_3) AT=85.025n

.meas tran vdout0_4ck160 FIND v(dout0_4) AT=85.025n

.meas tran vdout0_5ck160 FIND v(dout0_5) AT=85.025n

.meas tran vdout0_6ck160 FIND v(dout0_6) AT=85.025n

.meas tran vdout0_7ck160 FIND v(dout0_7) AT=85.025n

.meas tran vdout0_8ck160 FIND v(dout0_8) AT=85.025n

.meas tran vdout0_9ck160 FIND v(dout0_9) AT=85.025n

.meas tran vdout0_10ck160 FIND v(dout0_10) AT=85.025n

.meas tran vdout0_11ck160 FIND v(dout0_11) AT=85.025n

.meas tran vdout0_12ck160 FIND v(dout0_12) AT=85.025n

.meas tran vdout0_13ck160 FIND v(dout0_13) AT=85.025n

.meas tran vdout0_14ck160 FIND v(dout0_14) AT=85.025n

.meas tran vdout0_15ck160 FIND v(dout0_15) AT=85.025n

.meas tran vdout0_16ck160 FIND v(dout0_16) AT=85.025n

.meas tran vdout0_17ck160 FIND v(dout0_17) AT=85.025n

.meas tran vdout0_18ck160 FIND v(dout0_18) AT=85.025n

.meas tran vdout0_19ck160 FIND v(dout0_19) AT=85.025n

.meas tran vdout0_20ck160 FIND v(dout0_20) AT=85.025n

.meas tran vdout0_21ck160 FIND v(dout0_21) AT=85.025n

.meas tran vdout0_22ck160 FIND v(dout0_22) AT=85.025n

.meas tran vdout0_23ck160 FIND v(dout0_23) AT=85.025n

.meas tran vdout0_24ck160 FIND v(dout0_24) AT=85.025n

.meas tran vdout0_25ck160 FIND v(dout0_25) AT=85.025n

.meas tran vdout0_26ck160 FIND v(dout0_26) AT=85.025n

.meas tran vdout0_27ck160 FIND v(dout0_27) AT=85.025n

.meas tran vdout0_28ck160 FIND v(dout0_28) AT=85.025n

.meas tran vdout0_29ck160 FIND v(dout0_29) AT=85.025n

.meas tran vdout0_30ck160 FIND v(dout0_30) AT=85.025n

.meas tran vdout0_31ck160 FIND v(dout0_31) AT=85.025n

.meas tran vdout0_32ck160 FIND v(dout0_32) AT=85.025n

.meas tran vdout0_33ck160 FIND v(dout0_33) AT=85.025n

.meas tran vdout0_34ck160 FIND v(dout0_34) AT=85.025n

.meas tran vdout0_35ck160 FIND v(dout0_35) AT=85.025n

.meas tran vdout0_36ck160 FIND v(dout0_36) AT=85.025n

.meas tran vdout0_37ck160 FIND v(dout0_37) AT=85.025n

.meas tran vdout0_38ck160 FIND v(dout0_38) AT=85.025n

.meas tran vdout0_39ck160 FIND v(dout0_39) AT=85.025n

.meas tran vdout0_40ck160 FIND v(dout0_40) AT=85.025n

.meas tran vdout0_41ck160 FIND v(dout0_41) AT=85.025n

.meas tran vdout0_42ck160 FIND v(dout0_42) AT=85.025n

.meas tran vdout0_43ck160 FIND v(dout0_43) AT=85.025n

.meas tran vdout0_44ck160 FIND v(dout0_44) AT=85.025n

.meas tran vdout0_45ck160 FIND v(dout0_45) AT=85.025n

.meas tran vdout0_46ck160 FIND v(dout0_46) AT=85.025n

.meas tran vdout0_47ck160 FIND v(dout0_47) AT=85.025n

.meas tran vdout0_48ck160 FIND v(dout0_48) AT=85.025n

.meas tran vdout0_49ck160 FIND v(dout0_49) AT=85.025n

.meas tran vdout0_50ck160 FIND v(dout0_50) AT=85.025n

.meas tran vdout0_51ck160 FIND v(dout0_51) AT=85.025n

.meas tran vdout0_52ck160 FIND v(dout0_52) AT=85.025n

.meas tran vdout0_53ck160 FIND v(dout0_53) AT=85.025n

.meas tran vdout0_54ck160 FIND v(dout0_54) AT=85.025n

.meas tran vdout0_55ck160 FIND v(dout0_55) AT=85.025n

.meas tran vdout0_56ck160 FIND v(dout0_56) AT=85.025n

.meas tran vdout0_57ck160 FIND v(dout0_57) AT=85.025n

.meas tran vdout0_58ck160 FIND v(dout0_58) AT=85.025n

.meas tran vdout0_59ck160 FIND v(dout0_59) AT=85.025n

.meas tran vdout0_60ck160 FIND v(dout0_60) AT=85.025n

.meas tran vdout0_61ck160 FIND v(dout0_61) AT=85.025n

.meas tran vdout0_62ck160 FIND v(dout0_62) AT=85.025n

.meas tran vdout0_63ck160 FIND v(dout0_63) AT=85.025n

.meas tran vdout0_64ck160 FIND v(dout0_64) AT=85.025n

.meas tran vdout0_65ck160 FIND v(dout0_65) AT=85.025n

.meas tran vdout0_66ck160 FIND v(dout0_66) AT=85.025n

.meas tran vdout0_67ck160 FIND v(dout0_67) AT=85.025n

.meas tran vdout0_68ck160 FIND v(dout0_68) AT=85.025n

.meas tran vdout0_69ck160 FIND v(dout0_69) AT=85.025n

.meas tran vdout0_70ck160 FIND v(dout0_70) AT=85.025n

.meas tran vdout0_71ck160 FIND v(dout0_71) AT=85.025n

.meas tran vdout0_72ck160 FIND v(dout0_72) AT=85.025n

.meas tran vdout0_73ck160 FIND v(dout0_73) AT=85.025n

.meas tran vdout0_74ck160 FIND v(dout0_74) AT=85.025n

.meas tran vdout0_75ck160 FIND v(dout0_75) AT=85.025n

.meas tran vdout0_76ck160 FIND v(dout0_76) AT=85.025n

.meas tran vdout0_77ck160 FIND v(dout0_77) AT=85.025n

.meas tran vdout0_78ck160 FIND v(dout0_78) AT=85.025n

.meas tran vdout0_79ck160 FIND v(dout0_79) AT=85.025n

.meas tran vdout0_80ck160 FIND v(dout0_80) AT=85.025n

.meas tran vdout0_81ck160 FIND v(dout0_81) AT=85.025n

.meas tran vdout0_82ck160 FIND v(dout0_82) AT=85.025n

.meas tran vdout0_83ck160 FIND v(dout0_83) AT=85.025n

.meas tran vdout0_84ck160 FIND v(dout0_84) AT=85.025n

.meas tran vdout0_85ck160 FIND v(dout0_85) AT=85.025n

.meas tran vdout0_86ck160 FIND v(dout0_86) AT=85.025n

.meas tran vdout0_87ck160 FIND v(dout0_87) AT=85.025n

.meas tran vdout0_88ck160 FIND v(dout0_88) AT=85.025n

.meas tran vdout0_89ck160 FIND v(dout0_89) AT=85.025n

.meas tran vdout0_90ck160 FIND v(dout0_90) AT=85.025n

.meas tran vdout0_91ck160 FIND v(dout0_91) AT=85.025n

.meas tran vdout0_92ck160 FIND v(dout0_92) AT=85.025n

.meas tran vdout0_93ck160 FIND v(dout0_93) AT=85.025n

.meas tran vdout0_94ck160 FIND v(dout0_94) AT=85.025n

.meas tran vdout0_95ck160 FIND v(dout0_95) AT=85.025n

.meas tran vdout0_96ck160 FIND v(dout0_96) AT=85.025n

.meas tran vdout0_97ck160 FIND v(dout0_97) AT=85.025n

.meas tran vdout0_98ck160 FIND v(dout0_98) AT=85.025n

.meas tran vdout0_99ck160 FIND v(dout0_99) AT=85.025n

.meas tran vdout0_100ck160 FIND v(dout0_100) AT=85.025n

.meas tran vdout0_101ck160 FIND v(dout0_101) AT=85.025n

.meas tran vdout0_102ck160 FIND v(dout0_102) AT=85.025n

.meas tran vdout0_103ck160 FIND v(dout0_103) AT=85.025n

.meas tran vdout0_104ck160 FIND v(dout0_104) AT=85.025n

.meas tran vdout0_105ck160 FIND v(dout0_105) AT=85.025n

.meas tran vdout0_106ck160 FIND v(dout0_106) AT=85.025n

.meas tran vdout0_107ck160 FIND v(dout0_107) AT=85.025n

.meas tran vdout0_108ck160 FIND v(dout0_108) AT=85.025n

.meas tran vdout0_109ck160 FIND v(dout0_109) AT=85.025n

.meas tran vdout0_110ck160 FIND v(dout0_110) AT=85.025n

.meas tran vdout0_111ck160 FIND v(dout0_111) AT=85.025n

.meas tran vdout0_112ck160 FIND v(dout0_112) AT=85.025n

.meas tran vdout0_113ck160 FIND v(dout0_113) AT=85.025n

.meas tran vdout0_114ck160 FIND v(dout0_114) AT=85.025n

.meas tran vdout0_115ck160 FIND v(dout0_115) AT=85.025n

.meas tran vdout0_116ck160 FIND v(dout0_116) AT=85.025n

.meas tran vdout0_117ck160 FIND v(dout0_117) AT=85.025n

.meas tran vdout0_118ck160 FIND v(dout0_118) AT=85.025n

.meas tran vdout0_119ck160 FIND v(dout0_119) AT=85.025n

.meas tran vdout0_120ck160 FIND v(dout0_120) AT=85.025n

.meas tran vdout0_121ck160 FIND v(dout0_121) AT=85.025n

.meas tran vdout0_122ck160 FIND v(dout0_122) AT=85.025n

.meas tran vdout0_123ck160 FIND v(dout0_123) AT=85.025n

.meas tran vdout0_124ck160 FIND v(dout0_124) AT=85.025n

.meas tran vdout0_125ck160 FIND v(dout0_125) AT=85.025n

.meas tran vdout0_126ck160 FIND v(dout0_126) AT=85.025n

.meas tran vdout0_127ck160 FIND v(dout0_127) AT=85.025n

.meas tran vdout0_0ck180 FIND v(dout0_0) AT=95.025n

.meas tran vdout0_1ck180 FIND v(dout0_1) AT=95.025n

.meas tran vdout0_2ck180 FIND v(dout0_2) AT=95.025n

.meas tran vdout0_3ck180 FIND v(dout0_3) AT=95.025n

.meas tran vdout0_4ck180 FIND v(dout0_4) AT=95.025n

.meas tran vdout0_5ck180 FIND v(dout0_5) AT=95.025n

.meas tran vdout0_6ck180 FIND v(dout0_6) AT=95.025n

.meas tran vdout0_7ck180 FIND v(dout0_7) AT=95.025n

.meas tran vdout0_8ck180 FIND v(dout0_8) AT=95.025n

.meas tran vdout0_9ck180 FIND v(dout0_9) AT=95.025n

.meas tran vdout0_10ck180 FIND v(dout0_10) AT=95.025n

.meas tran vdout0_11ck180 FIND v(dout0_11) AT=95.025n

.meas tran vdout0_12ck180 FIND v(dout0_12) AT=95.025n

.meas tran vdout0_13ck180 FIND v(dout0_13) AT=95.025n

.meas tran vdout0_14ck180 FIND v(dout0_14) AT=95.025n

.meas tran vdout0_15ck180 FIND v(dout0_15) AT=95.025n

.meas tran vdout0_16ck180 FIND v(dout0_16) AT=95.025n

.meas tran vdout0_17ck180 FIND v(dout0_17) AT=95.025n

.meas tran vdout0_18ck180 FIND v(dout0_18) AT=95.025n

.meas tran vdout0_19ck180 FIND v(dout0_19) AT=95.025n

.meas tran vdout0_20ck180 FIND v(dout0_20) AT=95.025n

.meas tran vdout0_21ck180 FIND v(dout0_21) AT=95.025n

.meas tran vdout0_22ck180 FIND v(dout0_22) AT=95.025n

.meas tran vdout0_23ck180 FIND v(dout0_23) AT=95.025n

.meas tran vdout0_24ck180 FIND v(dout0_24) AT=95.025n

.meas tran vdout0_25ck180 FIND v(dout0_25) AT=95.025n

.meas tran vdout0_26ck180 FIND v(dout0_26) AT=95.025n

.meas tran vdout0_27ck180 FIND v(dout0_27) AT=95.025n

.meas tran vdout0_28ck180 FIND v(dout0_28) AT=95.025n

.meas tran vdout0_29ck180 FIND v(dout0_29) AT=95.025n

.meas tran vdout0_30ck180 FIND v(dout0_30) AT=95.025n

.meas tran vdout0_31ck180 FIND v(dout0_31) AT=95.025n

.meas tran vdout0_32ck180 FIND v(dout0_32) AT=95.025n

.meas tran vdout0_33ck180 FIND v(dout0_33) AT=95.025n

.meas tran vdout0_34ck180 FIND v(dout0_34) AT=95.025n

.meas tran vdout0_35ck180 FIND v(dout0_35) AT=95.025n

.meas tran vdout0_36ck180 FIND v(dout0_36) AT=95.025n

.meas tran vdout0_37ck180 FIND v(dout0_37) AT=95.025n

.meas tran vdout0_38ck180 FIND v(dout0_38) AT=95.025n

.meas tran vdout0_39ck180 FIND v(dout0_39) AT=95.025n

.meas tran vdout0_40ck180 FIND v(dout0_40) AT=95.025n

.meas tran vdout0_41ck180 FIND v(dout0_41) AT=95.025n

.meas tran vdout0_42ck180 FIND v(dout0_42) AT=95.025n

.meas tran vdout0_43ck180 FIND v(dout0_43) AT=95.025n

.meas tran vdout0_44ck180 FIND v(dout0_44) AT=95.025n

.meas tran vdout0_45ck180 FIND v(dout0_45) AT=95.025n

.meas tran vdout0_46ck180 FIND v(dout0_46) AT=95.025n

.meas tran vdout0_47ck180 FIND v(dout0_47) AT=95.025n

.meas tran vdout0_48ck180 FIND v(dout0_48) AT=95.025n

.meas tran vdout0_49ck180 FIND v(dout0_49) AT=95.025n

.meas tran vdout0_50ck180 FIND v(dout0_50) AT=95.025n

.meas tran vdout0_51ck180 FIND v(dout0_51) AT=95.025n

.meas tran vdout0_52ck180 FIND v(dout0_52) AT=95.025n

.meas tran vdout0_53ck180 FIND v(dout0_53) AT=95.025n

.meas tran vdout0_54ck180 FIND v(dout0_54) AT=95.025n

.meas tran vdout0_55ck180 FIND v(dout0_55) AT=95.025n

.meas tran vdout0_56ck180 FIND v(dout0_56) AT=95.025n

.meas tran vdout0_57ck180 FIND v(dout0_57) AT=95.025n

.meas tran vdout0_58ck180 FIND v(dout0_58) AT=95.025n

.meas tran vdout0_59ck180 FIND v(dout0_59) AT=95.025n

.meas tran vdout0_60ck180 FIND v(dout0_60) AT=95.025n

.meas tran vdout0_61ck180 FIND v(dout0_61) AT=95.025n

.meas tran vdout0_62ck180 FIND v(dout0_62) AT=95.025n

.meas tran vdout0_63ck180 FIND v(dout0_63) AT=95.025n

.meas tran vdout0_64ck180 FIND v(dout0_64) AT=95.025n

.meas tran vdout0_65ck180 FIND v(dout0_65) AT=95.025n

.meas tran vdout0_66ck180 FIND v(dout0_66) AT=95.025n

.meas tran vdout0_67ck180 FIND v(dout0_67) AT=95.025n

.meas tran vdout0_68ck180 FIND v(dout0_68) AT=95.025n

.meas tran vdout0_69ck180 FIND v(dout0_69) AT=95.025n

.meas tran vdout0_70ck180 FIND v(dout0_70) AT=95.025n

.meas tran vdout0_71ck180 FIND v(dout0_71) AT=95.025n

.meas tran vdout0_72ck180 FIND v(dout0_72) AT=95.025n

.meas tran vdout0_73ck180 FIND v(dout0_73) AT=95.025n

.meas tran vdout0_74ck180 FIND v(dout0_74) AT=95.025n

.meas tran vdout0_75ck180 FIND v(dout0_75) AT=95.025n

.meas tran vdout0_76ck180 FIND v(dout0_76) AT=95.025n

.meas tran vdout0_77ck180 FIND v(dout0_77) AT=95.025n

.meas tran vdout0_78ck180 FIND v(dout0_78) AT=95.025n

.meas tran vdout0_79ck180 FIND v(dout0_79) AT=95.025n

.meas tran vdout0_80ck180 FIND v(dout0_80) AT=95.025n

.meas tran vdout0_81ck180 FIND v(dout0_81) AT=95.025n

.meas tran vdout0_82ck180 FIND v(dout0_82) AT=95.025n

.meas tran vdout0_83ck180 FIND v(dout0_83) AT=95.025n

.meas tran vdout0_84ck180 FIND v(dout0_84) AT=95.025n

.meas tran vdout0_85ck180 FIND v(dout0_85) AT=95.025n

.meas tran vdout0_86ck180 FIND v(dout0_86) AT=95.025n

.meas tran vdout0_87ck180 FIND v(dout0_87) AT=95.025n

.meas tran vdout0_88ck180 FIND v(dout0_88) AT=95.025n

.meas tran vdout0_89ck180 FIND v(dout0_89) AT=95.025n

.meas tran vdout0_90ck180 FIND v(dout0_90) AT=95.025n

.meas tran vdout0_91ck180 FIND v(dout0_91) AT=95.025n

.meas tran vdout0_92ck180 FIND v(dout0_92) AT=95.025n

.meas tran vdout0_93ck180 FIND v(dout0_93) AT=95.025n

.meas tran vdout0_94ck180 FIND v(dout0_94) AT=95.025n

.meas tran vdout0_95ck180 FIND v(dout0_95) AT=95.025n

.meas tran vdout0_96ck180 FIND v(dout0_96) AT=95.025n

.meas tran vdout0_97ck180 FIND v(dout0_97) AT=95.025n

.meas tran vdout0_98ck180 FIND v(dout0_98) AT=95.025n

.meas tran vdout0_99ck180 FIND v(dout0_99) AT=95.025n

.meas tran vdout0_100ck180 FIND v(dout0_100) AT=95.025n

.meas tran vdout0_101ck180 FIND v(dout0_101) AT=95.025n

.meas tran vdout0_102ck180 FIND v(dout0_102) AT=95.025n

.meas tran vdout0_103ck180 FIND v(dout0_103) AT=95.025n

.meas tran vdout0_104ck180 FIND v(dout0_104) AT=95.025n

.meas tran vdout0_105ck180 FIND v(dout0_105) AT=95.025n

.meas tran vdout0_106ck180 FIND v(dout0_106) AT=95.025n

.meas tran vdout0_107ck180 FIND v(dout0_107) AT=95.025n

.meas tran vdout0_108ck180 FIND v(dout0_108) AT=95.025n

.meas tran vdout0_109ck180 FIND v(dout0_109) AT=95.025n

.meas tran vdout0_110ck180 FIND v(dout0_110) AT=95.025n

.meas tran vdout0_111ck180 FIND v(dout0_111) AT=95.025n

.meas tran vdout0_112ck180 FIND v(dout0_112) AT=95.025n

.meas tran vdout0_113ck180 FIND v(dout0_113) AT=95.025n

.meas tran vdout0_114ck180 FIND v(dout0_114) AT=95.025n

.meas tran vdout0_115ck180 FIND v(dout0_115) AT=95.025n

.meas tran vdout0_116ck180 FIND v(dout0_116) AT=95.025n

.meas tran vdout0_117ck180 FIND v(dout0_117) AT=95.025n

.meas tran vdout0_118ck180 FIND v(dout0_118) AT=95.025n

.meas tran vdout0_119ck180 FIND v(dout0_119) AT=95.025n

.meas tran vdout0_120ck180 FIND v(dout0_120) AT=95.025n

.meas tran vdout0_121ck180 FIND v(dout0_121) AT=95.025n

.meas tran vdout0_122ck180 FIND v(dout0_122) AT=95.025n

.meas tran vdout0_123ck180 FIND v(dout0_123) AT=95.025n

.meas tran vdout0_124ck180 FIND v(dout0_124) AT=95.025n

.meas tran vdout0_125ck180 FIND v(dout0_125) AT=95.025n

.meas tran vdout0_126ck180 FIND v(dout0_126) AT=95.025n

.meas tran vdout0_127ck180 FIND v(dout0_127) AT=95.025n

.meas tran vdout0_0ck190 FIND v(dout0_0) AT=100.025n

.meas tran vdout0_1ck190 FIND v(dout0_1) AT=100.025n

.meas tran vdout0_2ck190 FIND v(dout0_2) AT=100.025n

.meas tran vdout0_3ck190 FIND v(dout0_3) AT=100.025n

.meas tran vdout0_4ck190 FIND v(dout0_4) AT=100.025n

.meas tran vdout0_5ck190 FIND v(dout0_5) AT=100.025n

.meas tran vdout0_6ck190 FIND v(dout0_6) AT=100.025n

.meas tran vdout0_7ck190 FIND v(dout0_7) AT=100.025n

.meas tran vdout0_8ck190 FIND v(dout0_8) AT=100.025n

.meas tran vdout0_9ck190 FIND v(dout0_9) AT=100.025n

.meas tran vdout0_10ck190 FIND v(dout0_10) AT=100.025n

.meas tran vdout0_11ck190 FIND v(dout0_11) AT=100.025n

.meas tran vdout0_12ck190 FIND v(dout0_12) AT=100.025n

.meas tran vdout0_13ck190 FIND v(dout0_13) AT=100.025n

.meas tran vdout0_14ck190 FIND v(dout0_14) AT=100.025n

.meas tran vdout0_15ck190 FIND v(dout0_15) AT=100.025n

.meas tran vdout0_16ck190 FIND v(dout0_16) AT=100.025n

.meas tran vdout0_17ck190 FIND v(dout0_17) AT=100.025n

.meas tran vdout0_18ck190 FIND v(dout0_18) AT=100.025n

.meas tran vdout0_19ck190 FIND v(dout0_19) AT=100.025n

.meas tran vdout0_20ck190 FIND v(dout0_20) AT=100.025n

.meas tran vdout0_21ck190 FIND v(dout0_21) AT=100.025n

.meas tran vdout0_22ck190 FIND v(dout0_22) AT=100.025n

.meas tran vdout0_23ck190 FIND v(dout0_23) AT=100.025n

.meas tran vdout0_24ck190 FIND v(dout0_24) AT=100.025n

.meas tran vdout0_25ck190 FIND v(dout0_25) AT=100.025n

.meas tran vdout0_26ck190 FIND v(dout0_26) AT=100.025n

.meas tran vdout0_27ck190 FIND v(dout0_27) AT=100.025n

.meas tran vdout0_28ck190 FIND v(dout0_28) AT=100.025n

.meas tran vdout0_29ck190 FIND v(dout0_29) AT=100.025n

.meas tran vdout0_30ck190 FIND v(dout0_30) AT=100.025n

.meas tran vdout0_31ck190 FIND v(dout0_31) AT=100.025n

.meas tran vdout0_32ck190 FIND v(dout0_32) AT=100.025n

.meas tran vdout0_33ck190 FIND v(dout0_33) AT=100.025n

.meas tran vdout0_34ck190 FIND v(dout0_34) AT=100.025n

.meas tran vdout0_35ck190 FIND v(dout0_35) AT=100.025n

.meas tran vdout0_36ck190 FIND v(dout0_36) AT=100.025n

.meas tran vdout0_37ck190 FIND v(dout0_37) AT=100.025n

.meas tran vdout0_38ck190 FIND v(dout0_38) AT=100.025n

.meas tran vdout0_39ck190 FIND v(dout0_39) AT=100.025n

.meas tran vdout0_40ck190 FIND v(dout0_40) AT=100.025n

.meas tran vdout0_41ck190 FIND v(dout0_41) AT=100.025n

.meas tran vdout0_42ck190 FIND v(dout0_42) AT=100.025n

.meas tran vdout0_43ck190 FIND v(dout0_43) AT=100.025n

.meas tran vdout0_44ck190 FIND v(dout0_44) AT=100.025n

.meas tran vdout0_45ck190 FIND v(dout0_45) AT=100.025n

.meas tran vdout0_46ck190 FIND v(dout0_46) AT=100.025n

.meas tran vdout0_47ck190 FIND v(dout0_47) AT=100.025n

.meas tran vdout0_48ck190 FIND v(dout0_48) AT=100.025n

.meas tran vdout0_49ck190 FIND v(dout0_49) AT=100.025n

.meas tran vdout0_50ck190 FIND v(dout0_50) AT=100.025n

.meas tran vdout0_51ck190 FIND v(dout0_51) AT=100.025n

.meas tran vdout0_52ck190 FIND v(dout0_52) AT=100.025n

.meas tran vdout0_53ck190 FIND v(dout0_53) AT=100.025n

.meas tran vdout0_54ck190 FIND v(dout0_54) AT=100.025n

.meas tran vdout0_55ck190 FIND v(dout0_55) AT=100.025n

.meas tran vdout0_56ck190 FIND v(dout0_56) AT=100.025n

.meas tran vdout0_57ck190 FIND v(dout0_57) AT=100.025n

.meas tran vdout0_58ck190 FIND v(dout0_58) AT=100.025n

.meas tran vdout0_59ck190 FIND v(dout0_59) AT=100.025n

.meas tran vdout0_60ck190 FIND v(dout0_60) AT=100.025n

.meas tran vdout0_61ck190 FIND v(dout0_61) AT=100.025n

.meas tran vdout0_62ck190 FIND v(dout0_62) AT=100.025n

.meas tran vdout0_63ck190 FIND v(dout0_63) AT=100.025n

.meas tran vdout0_64ck190 FIND v(dout0_64) AT=100.025n

.meas tran vdout0_65ck190 FIND v(dout0_65) AT=100.025n

.meas tran vdout0_66ck190 FIND v(dout0_66) AT=100.025n

.meas tran vdout0_67ck190 FIND v(dout0_67) AT=100.025n

.meas tran vdout0_68ck190 FIND v(dout0_68) AT=100.025n

.meas tran vdout0_69ck190 FIND v(dout0_69) AT=100.025n

.meas tran vdout0_70ck190 FIND v(dout0_70) AT=100.025n

.meas tran vdout0_71ck190 FIND v(dout0_71) AT=100.025n

.meas tran vdout0_72ck190 FIND v(dout0_72) AT=100.025n

.meas tran vdout0_73ck190 FIND v(dout0_73) AT=100.025n

.meas tran vdout0_74ck190 FIND v(dout0_74) AT=100.025n

.meas tran vdout0_75ck190 FIND v(dout0_75) AT=100.025n

.meas tran vdout0_76ck190 FIND v(dout0_76) AT=100.025n

.meas tran vdout0_77ck190 FIND v(dout0_77) AT=100.025n

.meas tran vdout0_78ck190 FIND v(dout0_78) AT=100.025n

.meas tran vdout0_79ck190 FIND v(dout0_79) AT=100.025n

.meas tran vdout0_80ck190 FIND v(dout0_80) AT=100.025n

.meas tran vdout0_81ck190 FIND v(dout0_81) AT=100.025n

.meas tran vdout0_82ck190 FIND v(dout0_82) AT=100.025n

.meas tran vdout0_83ck190 FIND v(dout0_83) AT=100.025n

.meas tran vdout0_84ck190 FIND v(dout0_84) AT=100.025n

.meas tran vdout0_85ck190 FIND v(dout0_85) AT=100.025n

.meas tran vdout0_86ck190 FIND v(dout0_86) AT=100.025n

.meas tran vdout0_87ck190 FIND v(dout0_87) AT=100.025n

.meas tran vdout0_88ck190 FIND v(dout0_88) AT=100.025n

.meas tran vdout0_89ck190 FIND v(dout0_89) AT=100.025n

.meas tran vdout0_90ck190 FIND v(dout0_90) AT=100.025n

.meas tran vdout0_91ck190 FIND v(dout0_91) AT=100.025n

.meas tran vdout0_92ck190 FIND v(dout0_92) AT=100.025n

.meas tran vdout0_93ck190 FIND v(dout0_93) AT=100.025n

.meas tran vdout0_94ck190 FIND v(dout0_94) AT=100.025n

.meas tran vdout0_95ck190 FIND v(dout0_95) AT=100.025n

.meas tran vdout0_96ck190 FIND v(dout0_96) AT=100.025n

.meas tran vdout0_97ck190 FIND v(dout0_97) AT=100.025n

.meas tran vdout0_98ck190 FIND v(dout0_98) AT=100.025n

.meas tran vdout0_99ck190 FIND v(dout0_99) AT=100.025n

.meas tran vdout0_100ck190 FIND v(dout0_100) AT=100.025n

.meas tran vdout0_101ck190 FIND v(dout0_101) AT=100.025n

.meas tran vdout0_102ck190 FIND v(dout0_102) AT=100.025n

.meas tran vdout0_103ck190 FIND v(dout0_103) AT=100.025n

.meas tran vdout0_104ck190 FIND v(dout0_104) AT=100.025n

.meas tran vdout0_105ck190 FIND v(dout0_105) AT=100.025n

.meas tran vdout0_106ck190 FIND v(dout0_106) AT=100.025n

.meas tran vdout0_107ck190 FIND v(dout0_107) AT=100.025n

.meas tran vdout0_108ck190 FIND v(dout0_108) AT=100.025n

.meas tran vdout0_109ck190 FIND v(dout0_109) AT=100.025n

.meas tran vdout0_110ck190 FIND v(dout0_110) AT=100.025n

.meas tran vdout0_111ck190 FIND v(dout0_111) AT=100.025n

.meas tran vdout0_112ck190 FIND v(dout0_112) AT=100.025n

.meas tran vdout0_113ck190 FIND v(dout0_113) AT=100.025n

.meas tran vdout0_114ck190 FIND v(dout0_114) AT=100.025n

.meas tran vdout0_115ck190 FIND v(dout0_115) AT=100.025n

.meas tran vdout0_116ck190 FIND v(dout0_116) AT=100.025n

.meas tran vdout0_117ck190 FIND v(dout0_117) AT=100.025n

.meas tran vdout0_118ck190 FIND v(dout0_118) AT=100.025n

.meas tran vdout0_119ck190 FIND v(dout0_119) AT=100.025n

.meas tran vdout0_120ck190 FIND v(dout0_120) AT=100.025n

.meas tran vdout0_121ck190 FIND v(dout0_121) AT=100.025n

.meas tran vdout0_122ck190 FIND v(dout0_122) AT=100.025n

.meas tran vdout0_123ck190 FIND v(dout0_123) AT=100.025n

.meas tran vdout0_124ck190 FIND v(dout0_124) AT=100.025n

.meas tran vdout0_125ck190 FIND v(dout0_125) AT=100.025n

.meas tran vdout0_126ck190 FIND v(dout0_126) AT=100.025n

.meas tran vdout0_127ck190 FIND v(dout0_127) AT=100.025n

.meas tran vdout0_0ck290 FIND v(dout0_0) AT=150.025n

.meas tran vdout0_1ck290 FIND v(dout0_1) AT=150.025n

.meas tran vdout0_2ck290 FIND v(dout0_2) AT=150.025n

.meas tran vdout0_3ck290 FIND v(dout0_3) AT=150.025n

.meas tran vdout0_4ck290 FIND v(dout0_4) AT=150.025n

.meas tran vdout0_5ck290 FIND v(dout0_5) AT=150.025n

.meas tran vdout0_6ck290 FIND v(dout0_6) AT=150.025n

.meas tran vdout0_7ck290 FIND v(dout0_7) AT=150.025n

.meas tran vdout0_8ck290 FIND v(dout0_8) AT=150.025n

.meas tran vdout0_9ck290 FIND v(dout0_9) AT=150.025n

.meas tran vdout0_10ck290 FIND v(dout0_10) AT=150.025n

.meas tran vdout0_11ck290 FIND v(dout0_11) AT=150.025n

.meas tran vdout0_12ck290 FIND v(dout0_12) AT=150.025n

.meas tran vdout0_13ck290 FIND v(dout0_13) AT=150.025n

.meas tran vdout0_14ck290 FIND v(dout0_14) AT=150.025n

.meas tran vdout0_15ck290 FIND v(dout0_15) AT=150.025n

.meas tran vdout0_16ck290 FIND v(dout0_16) AT=150.025n

.meas tran vdout0_17ck290 FIND v(dout0_17) AT=150.025n

.meas tran vdout0_18ck290 FIND v(dout0_18) AT=150.025n

.meas tran vdout0_19ck290 FIND v(dout0_19) AT=150.025n

.meas tran vdout0_20ck290 FIND v(dout0_20) AT=150.025n

.meas tran vdout0_21ck290 FIND v(dout0_21) AT=150.025n

.meas tran vdout0_22ck290 FIND v(dout0_22) AT=150.025n

.meas tran vdout0_23ck290 FIND v(dout0_23) AT=150.025n

.meas tran vdout0_24ck290 FIND v(dout0_24) AT=150.025n

.meas tran vdout0_25ck290 FIND v(dout0_25) AT=150.025n

.meas tran vdout0_26ck290 FIND v(dout0_26) AT=150.025n

.meas tran vdout0_27ck290 FIND v(dout0_27) AT=150.025n

.meas tran vdout0_28ck290 FIND v(dout0_28) AT=150.025n

.meas tran vdout0_29ck290 FIND v(dout0_29) AT=150.025n

.meas tran vdout0_30ck290 FIND v(dout0_30) AT=150.025n

.meas tran vdout0_31ck290 FIND v(dout0_31) AT=150.025n

.meas tran vdout0_32ck290 FIND v(dout0_32) AT=150.025n

.meas tran vdout0_33ck290 FIND v(dout0_33) AT=150.025n

.meas tran vdout0_34ck290 FIND v(dout0_34) AT=150.025n

.meas tran vdout0_35ck290 FIND v(dout0_35) AT=150.025n

.meas tran vdout0_36ck290 FIND v(dout0_36) AT=150.025n

.meas tran vdout0_37ck290 FIND v(dout0_37) AT=150.025n

.meas tran vdout0_38ck290 FIND v(dout0_38) AT=150.025n

.meas tran vdout0_39ck290 FIND v(dout0_39) AT=150.025n

.meas tran vdout0_40ck290 FIND v(dout0_40) AT=150.025n

.meas tran vdout0_41ck290 FIND v(dout0_41) AT=150.025n

.meas tran vdout0_42ck290 FIND v(dout0_42) AT=150.025n

.meas tran vdout0_43ck290 FIND v(dout0_43) AT=150.025n

.meas tran vdout0_44ck290 FIND v(dout0_44) AT=150.025n

.meas tran vdout0_45ck290 FIND v(dout0_45) AT=150.025n

.meas tran vdout0_46ck290 FIND v(dout0_46) AT=150.025n

.meas tran vdout0_47ck290 FIND v(dout0_47) AT=150.025n

.meas tran vdout0_48ck290 FIND v(dout0_48) AT=150.025n

.meas tran vdout0_49ck290 FIND v(dout0_49) AT=150.025n

.meas tran vdout0_50ck290 FIND v(dout0_50) AT=150.025n

.meas tran vdout0_51ck290 FIND v(dout0_51) AT=150.025n

.meas tran vdout0_52ck290 FIND v(dout0_52) AT=150.025n

.meas tran vdout0_53ck290 FIND v(dout0_53) AT=150.025n

.meas tran vdout0_54ck290 FIND v(dout0_54) AT=150.025n

.meas tran vdout0_55ck290 FIND v(dout0_55) AT=150.025n

.meas tran vdout0_56ck290 FIND v(dout0_56) AT=150.025n

.meas tran vdout0_57ck290 FIND v(dout0_57) AT=150.025n

.meas tran vdout0_58ck290 FIND v(dout0_58) AT=150.025n

.meas tran vdout0_59ck290 FIND v(dout0_59) AT=150.025n

.meas tran vdout0_60ck290 FIND v(dout0_60) AT=150.025n

.meas tran vdout0_61ck290 FIND v(dout0_61) AT=150.025n

.meas tran vdout0_62ck290 FIND v(dout0_62) AT=150.025n

.meas tran vdout0_63ck290 FIND v(dout0_63) AT=150.025n

.meas tran vdout0_64ck290 FIND v(dout0_64) AT=150.025n

.meas tran vdout0_65ck290 FIND v(dout0_65) AT=150.025n

.meas tran vdout0_66ck290 FIND v(dout0_66) AT=150.025n

.meas tran vdout0_67ck290 FIND v(dout0_67) AT=150.025n

.meas tran vdout0_68ck290 FIND v(dout0_68) AT=150.025n

.meas tran vdout0_69ck290 FIND v(dout0_69) AT=150.025n

.meas tran vdout0_70ck290 FIND v(dout0_70) AT=150.025n

.meas tran vdout0_71ck290 FIND v(dout0_71) AT=150.025n

.meas tran vdout0_72ck290 FIND v(dout0_72) AT=150.025n

.meas tran vdout0_73ck290 FIND v(dout0_73) AT=150.025n

.meas tran vdout0_74ck290 FIND v(dout0_74) AT=150.025n

.meas tran vdout0_75ck290 FIND v(dout0_75) AT=150.025n

.meas tran vdout0_76ck290 FIND v(dout0_76) AT=150.025n

.meas tran vdout0_77ck290 FIND v(dout0_77) AT=150.025n

.meas tran vdout0_78ck290 FIND v(dout0_78) AT=150.025n

.meas tran vdout0_79ck290 FIND v(dout0_79) AT=150.025n

.meas tran vdout0_80ck290 FIND v(dout0_80) AT=150.025n

.meas tran vdout0_81ck290 FIND v(dout0_81) AT=150.025n

.meas tran vdout0_82ck290 FIND v(dout0_82) AT=150.025n

.meas tran vdout0_83ck290 FIND v(dout0_83) AT=150.025n

.meas tran vdout0_84ck290 FIND v(dout0_84) AT=150.025n

.meas tran vdout0_85ck290 FIND v(dout0_85) AT=150.025n

.meas tran vdout0_86ck290 FIND v(dout0_86) AT=150.025n

.meas tran vdout0_87ck290 FIND v(dout0_87) AT=150.025n

.meas tran vdout0_88ck290 FIND v(dout0_88) AT=150.025n

.meas tran vdout0_89ck290 FIND v(dout0_89) AT=150.025n

.meas tran vdout0_90ck290 FIND v(dout0_90) AT=150.025n

.meas tran vdout0_91ck290 FIND v(dout0_91) AT=150.025n

.meas tran vdout0_92ck290 FIND v(dout0_92) AT=150.025n

.meas tran vdout0_93ck290 FIND v(dout0_93) AT=150.025n

.meas tran vdout0_94ck290 FIND v(dout0_94) AT=150.025n

.meas tran vdout0_95ck290 FIND v(dout0_95) AT=150.025n

.meas tran vdout0_96ck290 FIND v(dout0_96) AT=150.025n

.meas tran vdout0_97ck290 FIND v(dout0_97) AT=150.025n

.meas tran vdout0_98ck290 FIND v(dout0_98) AT=150.025n

.meas tran vdout0_99ck290 FIND v(dout0_99) AT=150.025n

.meas tran vdout0_100ck290 FIND v(dout0_100) AT=150.025n

.meas tran vdout0_101ck290 FIND v(dout0_101) AT=150.025n

.meas tran vdout0_102ck290 FIND v(dout0_102) AT=150.025n

.meas tran vdout0_103ck290 FIND v(dout0_103) AT=150.025n

.meas tran vdout0_104ck290 FIND v(dout0_104) AT=150.025n

.meas tran vdout0_105ck290 FIND v(dout0_105) AT=150.025n

.meas tran vdout0_106ck290 FIND v(dout0_106) AT=150.025n

.meas tran vdout0_107ck290 FIND v(dout0_107) AT=150.025n

.meas tran vdout0_108ck290 FIND v(dout0_108) AT=150.025n

.meas tran vdout0_109ck290 FIND v(dout0_109) AT=150.025n

.meas tran vdout0_110ck290 FIND v(dout0_110) AT=150.025n

.meas tran vdout0_111ck290 FIND v(dout0_111) AT=150.025n

.meas tran vdout0_112ck290 FIND v(dout0_112) AT=150.025n

.meas tran vdout0_113ck290 FIND v(dout0_113) AT=150.025n

.meas tran vdout0_114ck290 FIND v(dout0_114) AT=150.025n

.meas tran vdout0_115ck290 FIND v(dout0_115) AT=150.025n

.meas tran vdout0_116ck290 FIND v(dout0_116) AT=150.025n

.meas tran vdout0_117ck290 FIND v(dout0_117) AT=150.025n

.meas tran vdout0_118ck290 FIND v(dout0_118) AT=150.025n

.meas tran vdout0_119ck290 FIND v(dout0_119) AT=150.025n

.meas tran vdout0_120ck290 FIND v(dout0_120) AT=150.025n

.meas tran vdout0_121ck290 FIND v(dout0_121) AT=150.025n

.meas tran vdout0_122ck290 FIND v(dout0_122) AT=150.025n

.meas tran vdout0_123ck290 FIND v(dout0_123) AT=150.025n

.meas tran vdout0_124ck290 FIND v(dout0_124) AT=150.025n

.meas tran vdout0_125ck290 FIND v(dout0_125) AT=150.025n

.meas tran vdout0_126ck290 FIND v(dout0_126) AT=150.025n

.meas tran vdout0_127ck290 FIND v(dout0_127) AT=150.025n

.meas tran vdout0_0ck300 FIND v(dout0_0) AT=155.025n

.meas tran vdout0_1ck300 FIND v(dout0_1) AT=155.025n

.meas tran vdout0_2ck300 FIND v(dout0_2) AT=155.025n

.meas tran vdout0_3ck300 FIND v(dout0_3) AT=155.025n

.meas tran vdout0_4ck300 FIND v(dout0_4) AT=155.025n

.meas tran vdout0_5ck300 FIND v(dout0_5) AT=155.025n

.meas tran vdout0_6ck300 FIND v(dout0_6) AT=155.025n

.meas tran vdout0_7ck300 FIND v(dout0_7) AT=155.025n

.meas tran vdout0_8ck300 FIND v(dout0_8) AT=155.025n

.meas tran vdout0_9ck300 FIND v(dout0_9) AT=155.025n

.meas tran vdout0_10ck300 FIND v(dout0_10) AT=155.025n

.meas tran vdout0_11ck300 FIND v(dout0_11) AT=155.025n

.meas tran vdout0_12ck300 FIND v(dout0_12) AT=155.025n

.meas tran vdout0_13ck300 FIND v(dout0_13) AT=155.025n

.meas tran vdout0_14ck300 FIND v(dout0_14) AT=155.025n

.meas tran vdout0_15ck300 FIND v(dout0_15) AT=155.025n

.meas tran vdout0_16ck300 FIND v(dout0_16) AT=155.025n

.meas tran vdout0_17ck300 FIND v(dout0_17) AT=155.025n

.meas tran vdout0_18ck300 FIND v(dout0_18) AT=155.025n

.meas tran vdout0_19ck300 FIND v(dout0_19) AT=155.025n

.meas tran vdout0_20ck300 FIND v(dout0_20) AT=155.025n

.meas tran vdout0_21ck300 FIND v(dout0_21) AT=155.025n

.meas tran vdout0_22ck300 FIND v(dout0_22) AT=155.025n

.meas tran vdout0_23ck300 FIND v(dout0_23) AT=155.025n

.meas tran vdout0_24ck300 FIND v(dout0_24) AT=155.025n

.meas tran vdout0_25ck300 FIND v(dout0_25) AT=155.025n

.meas tran vdout0_26ck300 FIND v(dout0_26) AT=155.025n

.meas tran vdout0_27ck300 FIND v(dout0_27) AT=155.025n

.meas tran vdout0_28ck300 FIND v(dout0_28) AT=155.025n

.meas tran vdout0_29ck300 FIND v(dout0_29) AT=155.025n

.meas tran vdout0_30ck300 FIND v(dout0_30) AT=155.025n

.meas tran vdout0_31ck300 FIND v(dout0_31) AT=155.025n

.meas tran vdout0_32ck300 FIND v(dout0_32) AT=155.025n

.meas tran vdout0_33ck300 FIND v(dout0_33) AT=155.025n

.meas tran vdout0_34ck300 FIND v(dout0_34) AT=155.025n

.meas tran vdout0_35ck300 FIND v(dout0_35) AT=155.025n

.meas tran vdout0_36ck300 FIND v(dout0_36) AT=155.025n

.meas tran vdout0_37ck300 FIND v(dout0_37) AT=155.025n

.meas tran vdout0_38ck300 FIND v(dout0_38) AT=155.025n

.meas tran vdout0_39ck300 FIND v(dout0_39) AT=155.025n

.meas tran vdout0_40ck300 FIND v(dout0_40) AT=155.025n

.meas tran vdout0_41ck300 FIND v(dout0_41) AT=155.025n

.meas tran vdout0_42ck300 FIND v(dout0_42) AT=155.025n

.meas tran vdout0_43ck300 FIND v(dout0_43) AT=155.025n

.meas tran vdout0_44ck300 FIND v(dout0_44) AT=155.025n

.meas tran vdout0_45ck300 FIND v(dout0_45) AT=155.025n

.meas tran vdout0_46ck300 FIND v(dout0_46) AT=155.025n

.meas tran vdout0_47ck300 FIND v(dout0_47) AT=155.025n

.meas tran vdout0_48ck300 FIND v(dout0_48) AT=155.025n

.meas tran vdout0_49ck300 FIND v(dout0_49) AT=155.025n

.meas tran vdout0_50ck300 FIND v(dout0_50) AT=155.025n

.meas tran vdout0_51ck300 FIND v(dout0_51) AT=155.025n

.meas tran vdout0_52ck300 FIND v(dout0_52) AT=155.025n

.meas tran vdout0_53ck300 FIND v(dout0_53) AT=155.025n

.meas tran vdout0_54ck300 FIND v(dout0_54) AT=155.025n

.meas tran vdout0_55ck300 FIND v(dout0_55) AT=155.025n

.meas tran vdout0_56ck300 FIND v(dout0_56) AT=155.025n

.meas tran vdout0_57ck300 FIND v(dout0_57) AT=155.025n

.meas tran vdout0_58ck300 FIND v(dout0_58) AT=155.025n

.meas tran vdout0_59ck300 FIND v(dout0_59) AT=155.025n

.meas tran vdout0_60ck300 FIND v(dout0_60) AT=155.025n

.meas tran vdout0_61ck300 FIND v(dout0_61) AT=155.025n

.meas tran vdout0_62ck300 FIND v(dout0_62) AT=155.025n

.meas tran vdout0_63ck300 FIND v(dout0_63) AT=155.025n

.meas tran vdout0_64ck300 FIND v(dout0_64) AT=155.025n

.meas tran vdout0_65ck300 FIND v(dout0_65) AT=155.025n

.meas tran vdout0_66ck300 FIND v(dout0_66) AT=155.025n

.meas tran vdout0_67ck300 FIND v(dout0_67) AT=155.025n

.meas tran vdout0_68ck300 FIND v(dout0_68) AT=155.025n

.meas tran vdout0_69ck300 FIND v(dout0_69) AT=155.025n

.meas tran vdout0_70ck300 FIND v(dout0_70) AT=155.025n

.meas tran vdout0_71ck300 FIND v(dout0_71) AT=155.025n

.meas tran vdout0_72ck300 FIND v(dout0_72) AT=155.025n

.meas tran vdout0_73ck300 FIND v(dout0_73) AT=155.025n

.meas tran vdout0_74ck300 FIND v(dout0_74) AT=155.025n

.meas tran vdout0_75ck300 FIND v(dout0_75) AT=155.025n

.meas tran vdout0_76ck300 FIND v(dout0_76) AT=155.025n

.meas tran vdout0_77ck300 FIND v(dout0_77) AT=155.025n

.meas tran vdout0_78ck300 FIND v(dout0_78) AT=155.025n

.meas tran vdout0_79ck300 FIND v(dout0_79) AT=155.025n

.meas tran vdout0_80ck300 FIND v(dout0_80) AT=155.025n

.meas tran vdout0_81ck300 FIND v(dout0_81) AT=155.025n

.meas tran vdout0_82ck300 FIND v(dout0_82) AT=155.025n

.meas tran vdout0_83ck300 FIND v(dout0_83) AT=155.025n

.meas tran vdout0_84ck300 FIND v(dout0_84) AT=155.025n

.meas tran vdout0_85ck300 FIND v(dout0_85) AT=155.025n

.meas tran vdout0_86ck300 FIND v(dout0_86) AT=155.025n

.meas tran vdout0_87ck300 FIND v(dout0_87) AT=155.025n

.meas tran vdout0_88ck300 FIND v(dout0_88) AT=155.025n

.meas tran vdout0_89ck300 FIND v(dout0_89) AT=155.025n

.meas tran vdout0_90ck300 FIND v(dout0_90) AT=155.025n

.meas tran vdout0_91ck300 FIND v(dout0_91) AT=155.025n

.meas tran vdout0_92ck300 FIND v(dout0_92) AT=155.025n

.meas tran vdout0_93ck300 FIND v(dout0_93) AT=155.025n

.meas tran vdout0_94ck300 FIND v(dout0_94) AT=155.025n

.meas tran vdout0_95ck300 FIND v(dout0_95) AT=155.025n

.meas tran vdout0_96ck300 FIND v(dout0_96) AT=155.025n

.meas tran vdout0_97ck300 FIND v(dout0_97) AT=155.025n

.meas tran vdout0_98ck300 FIND v(dout0_98) AT=155.025n

.meas tran vdout0_99ck300 FIND v(dout0_99) AT=155.025n

.meas tran vdout0_100ck300 FIND v(dout0_100) AT=155.025n

.meas tran vdout0_101ck300 FIND v(dout0_101) AT=155.025n

.meas tran vdout0_102ck300 FIND v(dout0_102) AT=155.025n

.meas tran vdout0_103ck300 FIND v(dout0_103) AT=155.025n

.meas tran vdout0_104ck300 FIND v(dout0_104) AT=155.025n

.meas tran vdout0_105ck300 FIND v(dout0_105) AT=155.025n

.meas tran vdout0_106ck300 FIND v(dout0_106) AT=155.025n

.meas tran vdout0_107ck300 FIND v(dout0_107) AT=155.025n

.meas tran vdout0_108ck300 FIND v(dout0_108) AT=155.025n

.meas tran vdout0_109ck300 FIND v(dout0_109) AT=155.025n

.meas tran vdout0_110ck300 FIND v(dout0_110) AT=155.025n

.meas tran vdout0_111ck300 FIND v(dout0_111) AT=155.025n

.meas tran vdout0_112ck300 FIND v(dout0_112) AT=155.025n

.meas tran vdout0_113ck300 FIND v(dout0_113) AT=155.025n

.meas tran vdout0_114ck300 FIND v(dout0_114) AT=155.025n

.meas tran vdout0_115ck300 FIND v(dout0_115) AT=155.025n

.meas tran vdout0_116ck300 FIND v(dout0_116) AT=155.025n

.meas tran vdout0_117ck300 FIND v(dout0_117) AT=155.025n

.meas tran vdout0_118ck300 FIND v(dout0_118) AT=155.025n

.meas tran vdout0_119ck300 FIND v(dout0_119) AT=155.025n

.meas tran vdout0_120ck300 FIND v(dout0_120) AT=155.025n

.meas tran vdout0_121ck300 FIND v(dout0_121) AT=155.025n

.meas tran vdout0_122ck300 FIND v(dout0_122) AT=155.025n

.meas tran vdout0_123ck300 FIND v(dout0_123) AT=155.025n

.meas tran vdout0_124ck300 FIND v(dout0_124) AT=155.025n

.meas tran vdout0_125ck300 FIND v(dout0_125) AT=155.025n

.meas tran vdout0_126ck300 FIND v(dout0_126) AT=155.025n

.meas tran vdout0_127ck300 FIND v(dout0_127) AT=155.025n

.meas tran vdout0_0ck330 FIND v(dout0_0) AT=170.025n

.meas tran vdout0_1ck330 FIND v(dout0_1) AT=170.025n

.meas tran vdout0_2ck330 FIND v(dout0_2) AT=170.025n

.meas tran vdout0_3ck330 FIND v(dout0_3) AT=170.025n

.meas tran vdout0_4ck330 FIND v(dout0_4) AT=170.025n

.meas tran vdout0_5ck330 FIND v(dout0_5) AT=170.025n

.meas tran vdout0_6ck330 FIND v(dout0_6) AT=170.025n

.meas tran vdout0_7ck330 FIND v(dout0_7) AT=170.025n

.meas tran vdout0_8ck330 FIND v(dout0_8) AT=170.025n

.meas tran vdout0_9ck330 FIND v(dout0_9) AT=170.025n

.meas tran vdout0_10ck330 FIND v(dout0_10) AT=170.025n

.meas tran vdout0_11ck330 FIND v(dout0_11) AT=170.025n

.meas tran vdout0_12ck330 FIND v(dout0_12) AT=170.025n

.meas tran vdout0_13ck330 FIND v(dout0_13) AT=170.025n

.meas tran vdout0_14ck330 FIND v(dout0_14) AT=170.025n

.meas tran vdout0_15ck330 FIND v(dout0_15) AT=170.025n

.meas tran vdout0_16ck330 FIND v(dout0_16) AT=170.025n

.meas tran vdout0_17ck330 FIND v(dout0_17) AT=170.025n

.meas tran vdout0_18ck330 FIND v(dout0_18) AT=170.025n

.meas tran vdout0_19ck330 FIND v(dout0_19) AT=170.025n

.meas tran vdout0_20ck330 FIND v(dout0_20) AT=170.025n

.meas tran vdout0_21ck330 FIND v(dout0_21) AT=170.025n

.meas tran vdout0_22ck330 FIND v(dout0_22) AT=170.025n

.meas tran vdout0_23ck330 FIND v(dout0_23) AT=170.025n

.meas tran vdout0_24ck330 FIND v(dout0_24) AT=170.025n

.meas tran vdout0_25ck330 FIND v(dout0_25) AT=170.025n

.meas tran vdout0_26ck330 FIND v(dout0_26) AT=170.025n

.meas tran vdout0_27ck330 FIND v(dout0_27) AT=170.025n

.meas tran vdout0_28ck330 FIND v(dout0_28) AT=170.025n

.meas tran vdout0_29ck330 FIND v(dout0_29) AT=170.025n

.meas tran vdout0_30ck330 FIND v(dout0_30) AT=170.025n

.meas tran vdout0_31ck330 FIND v(dout0_31) AT=170.025n

.meas tran vdout0_32ck330 FIND v(dout0_32) AT=170.025n

.meas tran vdout0_33ck330 FIND v(dout0_33) AT=170.025n

.meas tran vdout0_34ck330 FIND v(dout0_34) AT=170.025n

.meas tran vdout0_35ck330 FIND v(dout0_35) AT=170.025n

.meas tran vdout0_36ck330 FIND v(dout0_36) AT=170.025n

.meas tran vdout0_37ck330 FIND v(dout0_37) AT=170.025n

.meas tran vdout0_38ck330 FIND v(dout0_38) AT=170.025n

.meas tran vdout0_39ck330 FIND v(dout0_39) AT=170.025n

.meas tran vdout0_40ck330 FIND v(dout0_40) AT=170.025n

.meas tran vdout0_41ck330 FIND v(dout0_41) AT=170.025n

.meas tran vdout0_42ck330 FIND v(dout0_42) AT=170.025n

.meas tran vdout0_43ck330 FIND v(dout0_43) AT=170.025n

.meas tran vdout0_44ck330 FIND v(dout0_44) AT=170.025n

.meas tran vdout0_45ck330 FIND v(dout0_45) AT=170.025n

.meas tran vdout0_46ck330 FIND v(dout0_46) AT=170.025n

.meas tran vdout0_47ck330 FIND v(dout0_47) AT=170.025n

.meas tran vdout0_48ck330 FIND v(dout0_48) AT=170.025n

.meas tran vdout0_49ck330 FIND v(dout0_49) AT=170.025n

.meas tran vdout0_50ck330 FIND v(dout0_50) AT=170.025n

.meas tran vdout0_51ck330 FIND v(dout0_51) AT=170.025n

.meas tran vdout0_52ck330 FIND v(dout0_52) AT=170.025n

.meas tran vdout0_53ck330 FIND v(dout0_53) AT=170.025n

.meas tran vdout0_54ck330 FIND v(dout0_54) AT=170.025n

.meas tran vdout0_55ck330 FIND v(dout0_55) AT=170.025n

.meas tran vdout0_56ck330 FIND v(dout0_56) AT=170.025n

.meas tran vdout0_57ck330 FIND v(dout0_57) AT=170.025n

.meas tran vdout0_58ck330 FIND v(dout0_58) AT=170.025n

.meas tran vdout0_59ck330 FIND v(dout0_59) AT=170.025n

.meas tran vdout0_60ck330 FIND v(dout0_60) AT=170.025n

.meas tran vdout0_61ck330 FIND v(dout0_61) AT=170.025n

.meas tran vdout0_62ck330 FIND v(dout0_62) AT=170.025n

.meas tran vdout0_63ck330 FIND v(dout0_63) AT=170.025n

.meas tran vdout0_64ck330 FIND v(dout0_64) AT=170.025n

.meas tran vdout0_65ck330 FIND v(dout0_65) AT=170.025n

.meas tran vdout0_66ck330 FIND v(dout0_66) AT=170.025n

.meas tran vdout0_67ck330 FIND v(dout0_67) AT=170.025n

.meas tran vdout0_68ck330 FIND v(dout0_68) AT=170.025n

.meas tran vdout0_69ck330 FIND v(dout0_69) AT=170.025n

.meas tran vdout0_70ck330 FIND v(dout0_70) AT=170.025n

.meas tran vdout0_71ck330 FIND v(dout0_71) AT=170.025n

.meas tran vdout0_72ck330 FIND v(dout0_72) AT=170.025n

.meas tran vdout0_73ck330 FIND v(dout0_73) AT=170.025n

.meas tran vdout0_74ck330 FIND v(dout0_74) AT=170.025n

.meas tran vdout0_75ck330 FIND v(dout0_75) AT=170.025n

.meas tran vdout0_76ck330 FIND v(dout0_76) AT=170.025n

.meas tran vdout0_77ck330 FIND v(dout0_77) AT=170.025n

.meas tran vdout0_78ck330 FIND v(dout0_78) AT=170.025n

.meas tran vdout0_79ck330 FIND v(dout0_79) AT=170.025n

.meas tran vdout0_80ck330 FIND v(dout0_80) AT=170.025n

.meas tran vdout0_81ck330 FIND v(dout0_81) AT=170.025n

.meas tran vdout0_82ck330 FIND v(dout0_82) AT=170.025n

.meas tran vdout0_83ck330 FIND v(dout0_83) AT=170.025n

.meas tran vdout0_84ck330 FIND v(dout0_84) AT=170.025n

.meas tran vdout0_85ck330 FIND v(dout0_85) AT=170.025n

.meas tran vdout0_86ck330 FIND v(dout0_86) AT=170.025n

.meas tran vdout0_87ck330 FIND v(dout0_87) AT=170.025n

.meas tran vdout0_88ck330 FIND v(dout0_88) AT=170.025n

.meas tran vdout0_89ck330 FIND v(dout0_89) AT=170.025n

.meas tran vdout0_90ck330 FIND v(dout0_90) AT=170.025n

.meas tran vdout0_91ck330 FIND v(dout0_91) AT=170.025n

.meas tran vdout0_92ck330 FIND v(dout0_92) AT=170.025n

.meas tran vdout0_93ck330 FIND v(dout0_93) AT=170.025n

.meas tran vdout0_94ck330 FIND v(dout0_94) AT=170.025n

.meas tran vdout0_95ck330 FIND v(dout0_95) AT=170.025n

.meas tran vdout0_96ck330 FIND v(dout0_96) AT=170.025n

.meas tran vdout0_97ck330 FIND v(dout0_97) AT=170.025n

.meas tran vdout0_98ck330 FIND v(dout0_98) AT=170.025n

.meas tran vdout0_99ck330 FIND v(dout0_99) AT=170.025n

.meas tran vdout0_100ck330 FIND v(dout0_100) AT=170.025n

.meas tran vdout0_101ck330 FIND v(dout0_101) AT=170.025n

.meas tran vdout0_102ck330 FIND v(dout0_102) AT=170.025n

.meas tran vdout0_103ck330 FIND v(dout0_103) AT=170.025n

.meas tran vdout0_104ck330 FIND v(dout0_104) AT=170.025n

.meas tran vdout0_105ck330 FIND v(dout0_105) AT=170.025n

.meas tran vdout0_106ck330 FIND v(dout0_106) AT=170.025n

.meas tran vdout0_107ck330 FIND v(dout0_107) AT=170.025n

.meas tran vdout0_108ck330 FIND v(dout0_108) AT=170.025n

.meas tran vdout0_109ck330 FIND v(dout0_109) AT=170.025n

.meas tran vdout0_110ck330 FIND v(dout0_110) AT=170.025n

.meas tran vdout0_111ck330 FIND v(dout0_111) AT=170.025n

.meas tran vdout0_112ck330 FIND v(dout0_112) AT=170.025n

.meas tran vdout0_113ck330 FIND v(dout0_113) AT=170.025n

.meas tran vdout0_114ck330 FIND v(dout0_114) AT=170.025n

.meas tran vdout0_115ck330 FIND v(dout0_115) AT=170.025n

.meas tran vdout0_116ck330 FIND v(dout0_116) AT=170.025n

.meas tran vdout0_117ck330 FIND v(dout0_117) AT=170.025n

.meas tran vdout0_118ck330 FIND v(dout0_118) AT=170.025n

.meas tran vdout0_119ck330 FIND v(dout0_119) AT=170.025n

.meas tran vdout0_120ck330 FIND v(dout0_120) AT=170.025n

.meas tran vdout0_121ck330 FIND v(dout0_121) AT=170.025n

.meas tran vdout0_122ck330 FIND v(dout0_122) AT=170.025n

.meas tran vdout0_123ck330 FIND v(dout0_123) AT=170.025n

.meas tran vdout0_124ck330 FIND v(dout0_124) AT=170.025n

.meas tran vdout0_125ck330 FIND v(dout0_125) AT=170.025n

.meas tran vdout0_126ck330 FIND v(dout0_126) AT=170.025n

.meas tran vdout0_127ck330 FIND v(dout0_127) AT=170.025n

.meas tran vdout0_0ck340 FIND v(dout0_0) AT=175.025n

.meas tran vdout0_1ck340 FIND v(dout0_1) AT=175.025n

.meas tran vdout0_2ck340 FIND v(dout0_2) AT=175.025n

.meas tran vdout0_3ck340 FIND v(dout0_3) AT=175.025n

.meas tran vdout0_4ck340 FIND v(dout0_4) AT=175.025n

.meas tran vdout0_5ck340 FIND v(dout0_5) AT=175.025n

.meas tran vdout0_6ck340 FIND v(dout0_6) AT=175.025n

.meas tran vdout0_7ck340 FIND v(dout0_7) AT=175.025n

.meas tran vdout0_8ck340 FIND v(dout0_8) AT=175.025n

.meas tran vdout0_9ck340 FIND v(dout0_9) AT=175.025n

.meas tran vdout0_10ck340 FIND v(dout0_10) AT=175.025n

.meas tran vdout0_11ck340 FIND v(dout0_11) AT=175.025n

.meas tran vdout0_12ck340 FIND v(dout0_12) AT=175.025n

.meas tran vdout0_13ck340 FIND v(dout0_13) AT=175.025n

.meas tran vdout0_14ck340 FIND v(dout0_14) AT=175.025n

.meas tran vdout0_15ck340 FIND v(dout0_15) AT=175.025n

.meas tran vdout0_16ck340 FIND v(dout0_16) AT=175.025n

.meas tran vdout0_17ck340 FIND v(dout0_17) AT=175.025n

.meas tran vdout0_18ck340 FIND v(dout0_18) AT=175.025n

.meas tran vdout0_19ck340 FIND v(dout0_19) AT=175.025n

.meas tran vdout0_20ck340 FIND v(dout0_20) AT=175.025n

.meas tran vdout0_21ck340 FIND v(dout0_21) AT=175.025n

.meas tran vdout0_22ck340 FIND v(dout0_22) AT=175.025n

.meas tran vdout0_23ck340 FIND v(dout0_23) AT=175.025n

.meas tran vdout0_24ck340 FIND v(dout0_24) AT=175.025n

.meas tran vdout0_25ck340 FIND v(dout0_25) AT=175.025n

.meas tran vdout0_26ck340 FIND v(dout0_26) AT=175.025n

.meas tran vdout0_27ck340 FIND v(dout0_27) AT=175.025n

.meas tran vdout0_28ck340 FIND v(dout0_28) AT=175.025n

.meas tran vdout0_29ck340 FIND v(dout0_29) AT=175.025n

.meas tran vdout0_30ck340 FIND v(dout0_30) AT=175.025n

.meas tran vdout0_31ck340 FIND v(dout0_31) AT=175.025n

.meas tran vdout0_32ck340 FIND v(dout0_32) AT=175.025n

.meas tran vdout0_33ck340 FIND v(dout0_33) AT=175.025n

.meas tran vdout0_34ck340 FIND v(dout0_34) AT=175.025n

.meas tran vdout0_35ck340 FIND v(dout0_35) AT=175.025n

.meas tran vdout0_36ck340 FIND v(dout0_36) AT=175.025n

.meas tran vdout0_37ck340 FIND v(dout0_37) AT=175.025n

.meas tran vdout0_38ck340 FIND v(dout0_38) AT=175.025n

.meas tran vdout0_39ck340 FIND v(dout0_39) AT=175.025n

.meas tran vdout0_40ck340 FIND v(dout0_40) AT=175.025n

.meas tran vdout0_41ck340 FIND v(dout0_41) AT=175.025n

.meas tran vdout0_42ck340 FIND v(dout0_42) AT=175.025n

.meas tran vdout0_43ck340 FIND v(dout0_43) AT=175.025n

.meas tran vdout0_44ck340 FIND v(dout0_44) AT=175.025n

.meas tran vdout0_45ck340 FIND v(dout0_45) AT=175.025n

.meas tran vdout0_46ck340 FIND v(dout0_46) AT=175.025n

.meas tran vdout0_47ck340 FIND v(dout0_47) AT=175.025n

.meas tran vdout0_48ck340 FIND v(dout0_48) AT=175.025n

.meas tran vdout0_49ck340 FIND v(dout0_49) AT=175.025n

.meas tran vdout0_50ck340 FIND v(dout0_50) AT=175.025n

.meas tran vdout0_51ck340 FIND v(dout0_51) AT=175.025n

.meas tran vdout0_52ck340 FIND v(dout0_52) AT=175.025n

.meas tran vdout0_53ck340 FIND v(dout0_53) AT=175.025n

.meas tran vdout0_54ck340 FIND v(dout0_54) AT=175.025n

.meas tran vdout0_55ck340 FIND v(dout0_55) AT=175.025n

.meas tran vdout0_56ck340 FIND v(dout0_56) AT=175.025n

.meas tran vdout0_57ck340 FIND v(dout0_57) AT=175.025n

.meas tran vdout0_58ck340 FIND v(dout0_58) AT=175.025n

.meas tran vdout0_59ck340 FIND v(dout0_59) AT=175.025n

.meas tran vdout0_60ck340 FIND v(dout0_60) AT=175.025n

.meas tran vdout0_61ck340 FIND v(dout0_61) AT=175.025n

.meas tran vdout0_62ck340 FIND v(dout0_62) AT=175.025n

.meas tran vdout0_63ck340 FIND v(dout0_63) AT=175.025n

.meas tran vdout0_64ck340 FIND v(dout0_64) AT=175.025n

.meas tran vdout0_65ck340 FIND v(dout0_65) AT=175.025n

.meas tran vdout0_66ck340 FIND v(dout0_66) AT=175.025n

.meas tran vdout0_67ck340 FIND v(dout0_67) AT=175.025n

.meas tran vdout0_68ck340 FIND v(dout0_68) AT=175.025n

.meas tran vdout0_69ck340 FIND v(dout0_69) AT=175.025n

.meas tran vdout0_70ck340 FIND v(dout0_70) AT=175.025n

.meas tran vdout0_71ck340 FIND v(dout0_71) AT=175.025n

.meas tran vdout0_72ck340 FIND v(dout0_72) AT=175.025n

.meas tran vdout0_73ck340 FIND v(dout0_73) AT=175.025n

.meas tran vdout0_74ck340 FIND v(dout0_74) AT=175.025n

.meas tran vdout0_75ck340 FIND v(dout0_75) AT=175.025n

.meas tran vdout0_76ck340 FIND v(dout0_76) AT=175.025n

.meas tran vdout0_77ck340 FIND v(dout0_77) AT=175.025n

.meas tran vdout0_78ck340 FIND v(dout0_78) AT=175.025n

.meas tran vdout0_79ck340 FIND v(dout0_79) AT=175.025n

.meas tran vdout0_80ck340 FIND v(dout0_80) AT=175.025n

.meas tran vdout0_81ck340 FIND v(dout0_81) AT=175.025n

.meas tran vdout0_82ck340 FIND v(dout0_82) AT=175.025n

.meas tran vdout0_83ck340 FIND v(dout0_83) AT=175.025n

.meas tran vdout0_84ck340 FIND v(dout0_84) AT=175.025n

.meas tran vdout0_85ck340 FIND v(dout0_85) AT=175.025n

.meas tran vdout0_86ck340 FIND v(dout0_86) AT=175.025n

.meas tran vdout0_87ck340 FIND v(dout0_87) AT=175.025n

.meas tran vdout0_88ck340 FIND v(dout0_88) AT=175.025n

.meas tran vdout0_89ck340 FIND v(dout0_89) AT=175.025n

.meas tran vdout0_90ck340 FIND v(dout0_90) AT=175.025n

.meas tran vdout0_91ck340 FIND v(dout0_91) AT=175.025n

.meas tran vdout0_92ck340 FIND v(dout0_92) AT=175.025n

.meas tran vdout0_93ck340 FIND v(dout0_93) AT=175.025n

.meas tran vdout0_94ck340 FIND v(dout0_94) AT=175.025n

.meas tran vdout0_95ck340 FIND v(dout0_95) AT=175.025n

.meas tran vdout0_96ck340 FIND v(dout0_96) AT=175.025n

.meas tran vdout0_97ck340 FIND v(dout0_97) AT=175.025n

.meas tran vdout0_98ck340 FIND v(dout0_98) AT=175.025n

.meas tran vdout0_99ck340 FIND v(dout0_99) AT=175.025n

.meas tran vdout0_100ck340 FIND v(dout0_100) AT=175.025n

.meas tran vdout0_101ck340 FIND v(dout0_101) AT=175.025n

.meas tran vdout0_102ck340 FIND v(dout0_102) AT=175.025n

.meas tran vdout0_103ck340 FIND v(dout0_103) AT=175.025n

.meas tran vdout0_104ck340 FIND v(dout0_104) AT=175.025n

.meas tran vdout0_105ck340 FIND v(dout0_105) AT=175.025n

.meas tran vdout0_106ck340 FIND v(dout0_106) AT=175.025n

.meas tran vdout0_107ck340 FIND v(dout0_107) AT=175.025n

.meas tran vdout0_108ck340 FIND v(dout0_108) AT=175.025n

.meas tran vdout0_109ck340 FIND v(dout0_109) AT=175.025n

.meas tran vdout0_110ck340 FIND v(dout0_110) AT=175.025n

.meas tran vdout0_111ck340 FIND v(dout0_111) AT=175.025n

.meas tran vdout0_112ck340 FIND v(dout0_112) AT=175.025n

.meas tran vdout0_113ck340 FIND v(dout0_113) AT=175.025n

.meas tran vdout0_114ck340 FIND v(dout0_114) AT=175.025n

.meas tran vdout0_115ck340 FIND v(dout0_115) AT=175.025n

.meas tran vdout0_116ck340 FIND v(dout0_116) AT=175.025n

.meas tran vdout0_117ck340 FIND v(dout0_117) AT=175.025n

.meas tran vdout0_118ck340 FIND v(dout0_118) AT=175.025n

.meas tran vdout0_119ck340 FIND v(dout0_119) AT=175.025n

.meas tran vdout0_120ck340 FIND v(dout0_120) AT=175.025n

.meas tran vdout0_121ck340 FIND v(dout0_121) AT=175.025n

.meas tran vdout0_122ck340 FIND v(dout0_122) AT=175.025n

.meas tran vdout0_123ck340 FIND v(dout0_123) AT=175.025n

.meas tran vdout0_124ck340 FIND v(dout0_124) AT=175.025n

.meas tran vdout0_125ck340 FIND v(dout0_125) AT=175.025n

.meas tran vdout0_126ck340 FIND v(dout0_126) AT=175.025n

.meas tran vdout0_127ck340 FIND v(dout0_127) AT=175.025n

.meas tran vdout0_0ck350 FIND v(dout0_0) AT=180.025n

.meas tran vdout0_1ck350 FIND v(dout0_1) AT=180.025n

.meas tran vdout0_2ck350 FIND v(dout0_2) AT=180.025n

.meas tran vdout0_3ck350 FIND v(dout0_3) AT=180.025n

.meas tran vdout0_4ck350 FIND v(dout0_4) AT=180.025n

.meas tran vdout0_5ck350 FIND v(dout0_5) AT=180.025n

.meas tran vdout0_6ck350 FIND v(dout0_6) AT=180.025n

.meas tran vdout0_7ck350 FIND v(dout0_7) AT=180.025n

.meas tran vdout0_8ck350 FIND v(dout0_8) AT=180.025n

.meas tran vdout0_9ck350 FIND v(dout0_9) AT=180.025n

.meas tran vdout0_10ck350 FIND v(dout0_10) AT=180.025n

.meas tran vdout0_11ck350 FIND v(dout0_11) AT=180.025n

.meas tran vdout0_12ck350 FIND v(dout0_12) AT=180.025n

.meas tran vdout0_13ck350 FIND v(dout0_13) AT=180.025n

.meas tran vdout0_14ck350 FIND v(dout0_14) AT=180.025n

.meas tran vdout0_15ck350 FIND v(dout0_15) AT=180.025n

.meas tran vdout0_16ck350 FIND v(dout0_16) AT=180.025n

.meas tran vdout0_17ck350 FIND v(dout0_17) AT=180.025n

.meas tran vdout0_18ck350 FIND v(dout0_18) AT=180.025n

.meas tran vdout0_19ck350 FIND v(dout0_19) AT=180.025n

.meas tran vdout0_20ck350 FIND v(dout0_20) AT=180.025n

.meas tran vdout0_21ck350 FIND v(dout0_21) AT=180.025n

.meas tran vdout0_22ck350 FIND v(dout0_22) AT=180.025n

.meas tran vdout0_23ck350 FIND v(dout0_23) AT=180.025n

.meas tran vdout0_24ck350 FIND v(dout0_24) AT=180.025n

.meas tran vdout0_25ck350 FIND v(dout0_25) AT=180.025n

.meas tran vdout0_26ck350 FIND v(dout0_26) AT=180.025n

.meas tran vdout0_27ck350 FIND v(dout0_27) AT=180.025n

.meas tran vdout0_28ck350 FIND v(dout0_28) AT=180.025n

.meas tran vdout0_29ck350 FIND v(dout0_29) AT=180.025n

.meas tran vdout0_30ck350 FIND v(dout0_30) AT=180.025n

.meas tran vdout0_31ck350 FIND v(dout0_31) AT=180.025n

.meas tran vdout0_32ck350 FIND v(dout0_32) AT=180.025n

.meas tran vdout0_33ck350 FIND v(dout0_33) AT=180.025n

.meas tran vdout0_34ck350 FIND v(dout0_34) AT=180.025n

.meas tran vdout0_35ck350 FIND v(dout0_35) AT=180.025n

.meas tran vdout0_36ck350 FIND v(dout0_36) AT=180.025n

.meas tran vdout0_37ck350 FIND v(dout0_37) AT=180.025n

.meas tran vdout0_38ck350 FIND v(dout0_38) AT=180.025n

.meas tran vdout0_39ck350 FIND v(dout0_39) AT=180.025n

.meas tran vdout0_40ck350 FIND v(dout0_40) AT=180.025n

.meas tran vdout0_41ck350 FIND v(dout0_41) AT=180.025n

.meas tran vdout0_42ck350 FIND v(dout0_42) AT=180.025n

.meas tran vdout0_43ck350 FIND v(dout0_43) AT=180.025n

.meas tran vdout0_44ck350 FIND v(dout0_44) AT=180.025n

.meas tran vdout0_45ck350 FIND v(dout0_45) AT=180.025n

.meas tran vdout0_46ck350 FIND v(dout0_46) AT=180.025n

.meas tran vdout0_47ck350 FIND v(dout0_47) AT=180.025n

.meas tran vdout0_48ck350 FIND v(dout0_48) AT=180.025n

.meas tran vdout0_49ck350 FIND v(dout0_49) AT=180.025n

.meas tran vdout0_50ck350 FIND v(dout0_50) AT=180.025n

.meas tran vdout0_51ck350 FIND v(dout0_51) AT=180.025n

.meas tran vdout0_52ck350 FIND v(dout0_52) AT=180.025n

.meas tran vdout0_53ck350 FIND v(dout0_53) AT=180.025n

.meas tran vdout0_54ck350 FIND v(dout0_54) AT=180.025n

.meas tran vdout0_55ck350 FIND v(dout0_55) AT=180.025n

.meas tran vdout0_56ck350 FIND v(dout0_56) AT=180.025n

.meas tran vdout0_57ck350 FIND v(dout0_57) AT=180.025n

.meas tran vdout0_58ck350 FIND v(dout0_58) AT=180.025n

.meas tran vdout0_59ck350 FIND v(dout0_59) AT=180.025n

.meas tran vdout0_60ck350 FIND v(dout0_60) AT=180.025n

.meas tran vdout0_61ck350 FIND v(dout0_61) AT=180.025n

.meas tran vdout0_62ck350 FIND v(dout0_62) AT=180.025n

.meas tran vdout0_63ck350 FIND v(dout0_63) AT=180.025n

.meas tran vdout0_64ck350 FIND v(dout0_64) AT=180.025n

.meas tran vdout0_65ck350 FIND v(dout0_65) AT=180.025n

.meas tran vdout0_66ck350 FIND v(dout0_66) AT=180.025n

.meas tran vdout0_67ck350 FIND v(dout0_67) AT=180.025n

.meas tran vdout0_68ck350 FIND v(dout0_68) AT=180.025n

.meas tran vdout0_69ck350 FIND v(dout0_69) AT=180.025n

.meas tran vdout0_70ck350 FIND v(dout0_70) AT=180.025n

.meas tran vdout0_71ck350 FIND v(dout0_71) AT=180.025n

.meas tran vdout0_72ck350 FIND v(dout0_72) AT=180.025n

.meas tran vdout0_73ck350 FIND v(dout0_73) AT=180.025n

.meas tran vdout0_74ck350 FIND v(dout0_74) AT=180.025n

.meas tran vdout0_75ck350 FIND v(dout0_75) AT=180.025n

.meas tran vdout0_76ck350 FIND v(dout0_76) AT=180.025n

.meas tran vdout0_77ck350 FIND v(dout0_77) AT=180.025n

.meas tran vdout0_78ck350 FIND v(dout0_78) AT=180.025n

.meas tran vdout0_79ck350 FIND v(dout0_79) AT=180.025n

.meas tran vdout0_80ck350 FIND v(dout0_80) AT=180.025n

.meas tran vdout0_81ck350 FIND v(dout0_81) AT=180.025n

.meas tran vdout0_82ck350 FIND v(dout0_82) AT=180.025n

.meas tran vdout0_83ck350 FIND v(dout0_83) AT=180.025n

.meas tran vdout0_84ck350 FIND v(dout0_84) AT=180.025n

.meas tran vdout0_85ck350 FIND v(dout0_85) AT=180.025n

.meas tran vdout0_86ck350 FIND v(dout0_86) AT=180.025n

.meas tran vdout0_87ck350 FIND v(dout0_87) AT=180.025n

.meas tran vdout0_88ck350 FIND v(dout0_88) AT=180.025n

.meas tran vdout0_89ck350 FIND v(dout0_89) AT=180.025n

.meas tran vdout0_90ck350 FIND v(dout0_90) AT=180.025n

.meas tran vdout0_91ck350 FIND v(dout0_91) AT=180.025n

.meas tran vdout0_92ck350 FIND v(dout0_92) AT=180.025n

.meas tran vdout0_93ck350 FIND v(dout0_93) AT=180.025n

.meas tran vdout0_94ck350 FIND v(dout0_94) AT=180.025n

.meas tran vdout0_95ck350 FIND v(dout0_95) AT=180.025n

.meas tran vdout0_96ck350 FIND v(dout0_96) AT=180.025n

.meas tran vdout0_97ck350 FIND v(dout0_97) AT=180.025n

.meas tran vdout0_98ck350 FIND v(dout0_98) AT=180.025n

.meas tran vdout0_99ck350 FIND v(dout0_99) AT=180.025n

.meas tran vdout0_100ck350 FIND v(dout0_100) AT=180.025n

.meas tran vdout0_101ck350 FIND v(dout0_101) AT=180.025n

.meas tran vdout0_102ck350 FIND v(dout0_102) AT=180.025n

.meas tran vdout0_103ck350 FIND v(dout0_103) AT=180.025n

.meas tran vdout0_104ck350 FIND v(dout0_104) AT=180.025n

.meas tran vdout0_105ck350 FIND v(dout0_105) AT=180.025n

.meas tran vdout0_106ck350 FIND v(dout0_106) AT=180.025n

.meas tran vdout0_107ck350 FIND v(dout0_107) AT=180.025n

.meas tran vdout0_108ck350 FIND v(dout0_108) AT=180.025n

.meas tran vdout0_109ck350 FIND v(dout0_109) AT=180.025n

.meas tran vdout0_110ck350 FIND v(dout0_110) AT=180.025n

.meas tran vdout0_111ck350 FIND v(dout0_111) AT=180.025n

.meas tran vdout0_112ck350 FIND v(dout0_112) AT=180.025n

.meas tran vdout0_113ck350 FIND v(dout0_113) AT=180.025n

.meas tran vdout0_114ck350 FIND v(dout0_114) AT=180.025n

.meas tran vdout0_115ck350 FIND v(dout0_115) AT=180.025n

.meas tran vdout0_116ck350 FIND v(dout0_116) AT=180.025n

.meas tran vdout0_117ck350 FIND v(dout0_117) AT=180.025n

.meas tran vdout0_118ck350 FIND v(dout0_118) AT=180.025n

.meas tran vdout0_119ck350 FIND v(dout0_119) AT=180.025n

.meas tran vdout0_120ck350 FIND v(dout0_120) AT=180.025n

.meas tran vdout0_121ck350 FIND v(dout0_121) AT=180.025n

.meas tran vdout0_122ck350 FIND v(dout0_122) AT=180.025n

.meas tran vdout0_123ck350 FIND v(dout0_123) AT=180.025n

.meas tran vdout0_124ck350 FIND v(dout0_124) AT=180.025n

.meas tran vdout0_125ck350 FIND v(dout0_125) AT=180.025n

.meas tran vdout0_126ck350 FIND v(dout0_126) AT=180.025n

.meas tran vdout0_127ck350 FIND v(dout0_127) AT=180.025n

.meas tran vdout0_0ck370 FIND v(dout0_0) AT=190.025n

.meas tran vdout0_1ck370 FIND v(dout0_1) AT=190.025n

.meas tran vdout0_2ck370 FIND v(dout0_2) AT=190.025n

.meas tran vdout0_3ck370 FIND v(dout0_3) AT=190.025n

.meas tran vdout0_4ck370 FIND v(dout0_4) AT=190.025n

.meas tran vdout0_5ck370 FIND v(dout0_5) AT=190.025n

.meas tran vdout0_6ck370 FIND v(dout0_6) AT=190.025n

.meas tran vdout0_7ck370 FIND v(dout0_7) AT=190.025n

.meas tran vdout0_8ck370 FIND v(dout0_8) AT=190.025n

.meas tran vdout0_9ck370 FIND v(dout0_9) AT=190.025n

.meas tran vdout0_10ck370 FIND v(dout0_10) AT=190.025n

.meas tran vdout0_11ck370 FIND v(dout0_11) AT=190.025n

.meas tran vdout0_12ck370 FIND v(dout0_12) AT=190.025n

.meas tran vdout0_13ck370 FIND v(dout0_13) AT=190.025n

.meas tran vdout0_14ck370 FIND v(dout0_14) AT=190.025n

.meas tran vdout0_15ck370 FIND v(dout0_15) AT=190.025n

.meas tran vdout0_16ck370 FIND v(dout0_16) AT=190.025n

.meas tran vdout0_17ck370 FIND v(dout0_17) AT=190.025n

.meas tran vdout0_18ck370 FIND v(dout0_18) AT=190.025n

.meas tran vdout0_19ck370 FIND v(dout0_19) AT=190.025n

.meas tran vdout0_20ck370 FIND v(dout0_20) AT=190.025n

.meas tran vdout0_21ck370 FIND v(dout0_21) AT=190.025n

.meas tran vdout0_22ck370 FIND v(dout0_22) AT=190.025n

.meas tran vdout0_23ck370 FIND v(dout0_23) AT=190.025n

.meas tran vdout0_24ck370 FIND v(dout0_24) AT=190.025n

.meas tran vdout0_25ck370 FIND v(dout0_25) AT=190.025n

.meas tran vdout0_26ck370 FIND v(dout0_26) AT=190.025n

.meas tran vdout0_27ck370 FIND v(dout0_27) AT=190.025n

.meas tran vdout0_28ck370 FIND v(dout0_28) AT=190.025n

.meas tran vdout0_29ck370 FIND v(dout0_29) AT=190.025n

.meas tran vdout0_30ck370 FIND v(dout0_30) AT=190.025n

.meas tran vdout0_31ck370 FIND v(dout0_31) AT=190.025n

.meas tran vdout0_32ck370 FIND v(dout0_32) AT=190.025n

.meas tran vdout0_33ck370 FIND v(dout0_33) AT=190.025n

.meas tran vdout0_34ck370 FIND v(dout0_34) AT=190.025n

.meas tran vdout0_35ck370 FIND v(dout0_35) AT=190.025n

.meas tran vdout0_36ck370 FIND v(dout0_36) AT=190.025n

.meas tran vdout0_37ck370 FIND v(dout0_37) AT=190.025n

.meas tran vdout0_38ck370 FIND v(dout0_38) AT=190.025n

.meas tran vdout0_39ck370 FIND v(dout0_39) AT=190.025n

.meas tran vdout0_40ck370 FIND v(dout0_40) AT=190.025n

.meas tran vdout0_41ck370 FIND v(dout0_41) AT=190.025n

.meas tran vdout0_42ck370 FIND v(dout0_42) AT=190.025n

.meas tran vdout0_43ck370 FIND v(dout0_43) AT=190.025n

.meas tran vdout0_44ck370 FIND v(dout0_44) AT=190.025n

.meas tran vdout0_45ck370 FIND v(dout0_45) AT=190.025n

.meas tran vdout0_46ck370 FIND v(dout0_46) AT=190.025n

.meas tran vdout0_47ck370 FIND v(dout0_47) AT=190.025n

.meas tran vdout0_48ck370 FIND v(dout0_48) AT=190.025n

.meas tran vdout0_49ck370 FIND v(dout0_49) AT=190.025n

.meas tran vdout0_50ck370 FIND v(dout0_50) AT=190.025n

.meas tran vdout0_51ck370 FIND v(dout0_51) AT=190.025n

.meas tran vdout0_52ck370 FIND v(dout0_52) AT=190.025n

.meas tran vdout0_53ck370 FIND v(dout0_53) AT=190.025n

.meas tran vdout0_54ck370 FIND v(dout0_54) AT=190.025n

.meas tran vdout0_55ck370 FIND v(dout0_55) AT=190.025n

.meas tran vdout0_56ck370 FIND v(dout0_56) AT=190.025n

.meas tran vdout0_57ck370 FIND v(dout0_57) AT=190.025n

.meas tran vdout0_58ck370 FIND v(dout0_58) AT=190.025n

.meas tran vdout0_59ck370 FIND v(dout0_59) AT=190.025n

.meas tran vdout0_60ck370 FIND v(dout0_60) AT=190.025n

.meas tran vdout0_61ck370 FIND v(dout0_61) AT=190.025n

.meas tran vdout0_62ck370 FIND v(dout0_62) AT=190.025n

.meas tran vdout0_63ck370 FIND v(dout0_63) AT=190.025n

.meas tran vdout0_64ck370 FIND v(dout0_64) AT=190.025n

.meas tran vdout0_65ck370 FIND v(dout0_65) AT=190.025n

.meas tran vdout0_66ck370 FIND v(dout0_66) AT=190.025n

.meas tran vdout0_67ck370 FIND v(dout0_67) AT=190.025n

.meas tran vdout0_68ck370 FIND v(dout0_68) AT=190.025n

.meas tran vdout0_69ck370 FIND v(dout0_69) AT=190.025n

.meas tran vdout0_70ck370 FIND v(dout0_70) AT=190.025n

.meas tran vdout0_71ck370 FIND v(dout0_71) AT=190.025n

.meas tran vdout0_72ck370 FIND v(dout0_72) AT=190.025n

.meas tran vdout0_73ck370 FIND v(dout0_73) AT=190.025n

.meas tran vdout0_74ck370 FIND v(dout0_74) AT=190.025n

.meas tran vdout0_75ck370 FIND v(dout0_75) AT=190.025n

.meas tran vdout0_76ck370 FIND v(dout0_76) AT=190.025n

.meas tran vdout0_77ck370 FIND v(dout0_77) AT=190.025n

.meas tran vdout0_78ck370 FIND v(dout0_78) AT=190.025n

.meas tran vdout0_79ck370 FIND v(dout0_79) AT=190.025n

.meas tran vdout0_80ck370 FIND v(dout0_80) AT=190.025n

.meas tran vdout0_81ck370 FIND v(dout0_81) AT=190.025n

.meas tran vdout0_82ck370 FIND v(dout0_82) AT=190.025n

.meas tran vdout0_83ck370 FIND v(dout0_83) AT=190.025n

.meas tran vdout0_84ck370 FIND v(dout0_84) AT=190.025n

.meas tran vdout0_85ck370 FIND v(dout0_85) AT=190.025n

.meas tran vdout0_86ck370 FIND v(dout0_86) AT=190.025n

.meas tran vdout0_87ck370 FIND v(dout0_87) AT=190.025n

.meas tran vdout0_88ck370 FIND v(dout0_88) AT=190.025n

.meas tran vdout0_89ck370 FIND v(dout0_89) AT=190.025n

.meas tran vdout0_90ck370 FIND v(dout0_90) AT=190.025n

.meas tran vdout0_91ck370 FIND v(dout0_91) AT=190.025n

.meas tran vdout0_92ck370 FIND v(dout0_92) AT=190.025n

.meas tran vdout0_93ck370 FIND v(dout0_93) AT=190.025n

.meas tran vdout0_94ck370 FIND v(dout0_94) AT=190.025n

.meas tran vdout0_95ck370 FIND v(dout0_95) AT=190.025n

.meas tran vdout0_96ck370 FIND v(dout0_96) AT=190.025n

.meas tran vdout0_97ck370 FIND v(dout0_97) AT=190.025n

.meas tran vdout0_98ck370 FIND v(dout0_98) AT=190.025n

.meas tran vdout0_99ck370 FIND v(dout0_99) AT=190.025n

.meas tran vdout0_100ck370 FIND v(dout0_100) AT=190.025n

.meas tran vdout0_101ck370 FIND v(dout0_101) AT=190.025n

.meas tran vdout0_102ck370 FIND v(dout0_102) AT=190.025n

.meas tran vdout0_103ck370 FIND v(dout0_103) AT=190.025n

.meas tran vdout0_104ck370 FIND v(dout0_104) AT=190.025n

.meas tran vdout0_105ck370 FIND v(dout0_105) AT=190.025n

.meas tran vdout0_106ck370 FIND v(dout0_106) AT=190.025n

.meas tran vdout0_107ck370 FIND v(dout0_107) AT=190.025n

.meas tran vdout0_108ck370 FIND v(dout0_108) AT=190.025n

.meas tran vdout0_109ck370 FIND v(dout0_109) AT=190.025n

.meas tran vdout0_110ck370 FIND v(dout0_110) AT=190.025n

.meas tran vdout0_111ck370 FIND v(dout0_111) AT=190.025n

.meas tran vdout0_112ck370 FIND v(dout0_112) AT=190.025n

.meas tran vdout0_113ck370 FIND v(dout0_113) AT=190.025n

.meas tran vdout0_114ck370 FIND v(dout0_114) AT=190.025n

.meas tran vdout0_115ck370 FIND v(dout0_115) AT=190.025n

.meas tran vdout0_116ck370 FIND v(dout0_116) AT=190.025n

.meas tran vdout0_117ck370 FIND v(dout0_117) AT=190.025n

.meas tran vdout0_118ck370 FIND v(dout0_118) AT=190.025n

.meas tran vdout0_119ck370 FIND v(dout0_119) AT=190.025n

.meas tran vdout0_120ck370 FIND v(dout0_120) AT=190.025n

.meas tran vdout0_121ck370 FIND v(dout0_121) AT=190.025n

.meas tran vdout0_122ck370 FIND v(dout0_122) AT=190.025n

.meas tran vdout0_123ck370 FIND v(dout0_123) AT=190.025n

.meas tran vdout0_124ck370 FIND v(dout0_124) AT=190.025n

.meas tran vdout0_125ck370 FIND v(dout0_125) AT=190.025n

.meas tran vdout0_126ck370 FIND v(dout0_126) AT=190.025n

.meas tran vdout0_127ck370 FIND v(dout0_127) AT=190.025n

.meas tran vdout0_0ck380 FIND v(dout0_0) AT=195.025n

.meas tran vdout0_1ck380 FIND v(dout0_1) AT=195.025n

.meas tran vdout0_2ck380 FIND v(dout0_2) AT=195.025n

.meas tran vdout0_3ck380 FIND v(dout0_3) AT=195.025n

.meas tran vdout0_4ck380 FIND v(dout0_4) AT=195.025n

.meas tran vdout0_5ck380 FIND v(dout0_5) AT=195.025n

.meas tran vdout0_6ck380 FIND v(dout0_6) AT=195.025n

.meas tran vdout0_7ck380 FIND v(dout0_7) AT=195.025n

.meas tran vdout0_8ck380 FIND v(dout0_8) AT=195.025n

.meas tran vdout0_9ck380 FIND v(dout0_9) AT=195.025n

.meas tran vdout0_10ck380 FIND v(dout0_10) AT=195.025n

.meas tran vdout0_11ck380 FIND v(dout0_11) AT=195.025n

.meas tran vdout0_12ck380 FIND v(dout0_12) AT=195.025n

.meas tran vdout0_13ck380 FIND v(dout0_13) AT=195.025n

.meas tran vdout0_14ck380 FIND v(dout0_14) AT=195.025n

.meas tran vdout0_15ck380 FIND v(dout0_15) AT=195.025n

.meas tran vdout0_16ck380 FIND v(dout0_16) AT=195.025n

.meas tran vdout0_17ck380 FIND v(dout0_17) AT=195.025n

.meas tran vdout0_18ck380 FIND v(dout0_18) AT=195.025n

.meas tran vdout0_19ck380 FIND v(dout0_19) AT=195.025n

.meas tran vdout0_20ck380 FIND v(dout0_20) AT=195.025n

.meas tran vdout0_21ck380 FIND v(dout0_21) AT=195.025n

.meas tran vdout0_22ck380 FIND v(dout0_22) AT=195.025n

.meas tran vdout0_23ck380 FIND v(dout0_23) AT=195.025n

.meas tran vdout0_24ck380 FIND v(dout0_24) AT=195.025n

.meas tran vdout0_25ck380 FIND v(dout0_25) AT=195.025n

.meas tran vdout0_26ck380 FIND v(dout0_26) AT=195.025n

.meas tran vdout0_27ck380 FIND v(dout0_27) AT=195.025n

.meas tran vdout0_28ck380 FIND v(dout0_28) AT=195.025n

.meas tran vdout0_29ck380 FIND v(dout0_29) AT=195.025n

.meas tran vdout0_30ck380 FIND v(dout0_30) AT=195.025n

.meas tran vdout0_31ck380 FIND v(dout0_31) AT=195.025n

.meas tran vdout0_32ck380 FIND v(dout0_32) AT=195.025n

.meas tran vdout0_33ck380 FIND v(dout0_33) AT=195.025n

.meas tran vdout0_34ck380 FIND v(dout0_34) AT=195.025n

.meas tran vdout0_35ck380 FIND v(dout0_35) AT=195.025n

.meas tran vdout0_36ck380 FIND v(dout0_36) AT=195.025n

.meas tran vdout0_37ck380 FIND v(dout0_37) AT=195.025n

.meas tran vdout0_38ck380 FIND v(dout0_38) AT=195.025n

.meas tran vdout0_39ck380 FIND v(dout0_39) AT=195.025n

.meas tran vdout0_40ck380 FIND v(dout0_40) AT=195.025n

.meas tran vdout0_41ck380 FIND v(dout0_41) AT=195.025n

.meas tran vdout0_42ck380 FIND v(dout0_42) AT=195.025n

.meas tran vdout0_43ck380 FIND v(dout0_43) AT=195.025n

.meas tran vdout0_44ck380 FIND v(dout0_44) AT=195.025n

.meas tran vdout0_45ck380 FIND v(dout0_45) AT=195.025n

.meas tran vdout0_46ck380 FIND v(dout0_46) AT=195.025n

.meas tran vdout0_47ck380 FIND v(dout0_47) AT=195.025n

.meas tran vdout0_48ck380 FIND v(dout0_48) AT=195.025n

.meas tran vdout0_49ck380 FIND v(dout0_49) AT=195.025n

.meas tran vdout0_50ck380 FIND v(dout0_50) AT=195.025n

.meas tran vdout0_51ck380 FIND v(dout0_51) AT=195.025n

.meas tran vdout0_52ck380 FIND v(dout0_52) AT=195.025n

.meas tran vdout0_53ck380 FIND v(dout0_53) AT=195.025n

.meas tran vdout0_54ck380 FIND v(dout0_54) AT=195.025n

.meas tran vdout0_55ck380 FIND v(dout0_55) AT=195.025n

.meas tran vdout0_56ck380 FIND v(dout0_56) AT=195.025n

.meas tran vdout0_57ck380 FIND v(dout0_57) AT=195.025n

.meas tran vdout0_58ck380 FIND v(dout0_58) AT=195.025n

.meas tran vdout0_59ck380 FIND v(dout0_59) AT=195.025n

.meas tran vdout0_60ck380 FIND v(dout0_60) AT=195.025n

.meas tran vdout0_61ck380 FIND v(dout0_61) AT=195.025n

.meas tran vdout0_62ck380 FIND v(dout0_62) AT=195.025n

.meas tran vdout0_63ck380 FIND v(dout0_63) AT=195.025n

.meas tran vdout0_64ck380 FIND v(dout0_64) AT=195.025n

.meas tran vdout0_65ck380 FIND v(dout0_65) AT=195.025n

.meas tran vdout0_66ck380 FIND v(dout0_66) AT=195.025n

.meas tran vdout0_67ck380 FIND v(dout0_67) AT=195.025n

.meas tran vdout0_68ck380 FIND v(dout0_68) AT=195.025n

.meas tran vdout0_69ck380 FIND v(dout0_69) AT=195.025n

.meas tran vdout0_70ck380 FIND v(dout0_70) AT=195.025n

.meas tran vdout0_71ck380 FIND v(dout0_71) AT=195.025n

.meas tran vdout0_72ck380 FIND v(dout0_72) AT=195.025n

.meas tran vdout0_73ck380 FIND v(dout0_73) AT=195.025n

.meas tran vdout0_74ck380 FIND v(dout0_74) AT=195.025n

.meas tran vdout0_75ck380 FIND v(dout0_75) AT=195.025n

.meas tran vdout0_76ck380 FIND v(dout0_76) AT=195.025n

.meas tran vdout0_77ck380 FIND v(dout0_77) AT=195.025n

.meas tran vdout0_78ck380 FIND v(dout0_78) AT=195.025n

.meas tran vdout0_79ck380 FIND v(dout0_79) AT=195.025n

.meas tran vdout0_80ck380 FIND v(dout0_80) AT=195.025n

.meas tran vdout0_81ck380 FIND v(dout0_81) AT=195.025n

.meas tran vdout0_82ck380 FIND v(dout0_82) AT=195.025n

.meas tran vdout0_83ck380 FIND v(dout0_83) AT=195.025n

.meas tran vdout0_84ck380 FIND v(dout0_84) AT=195.025n

.meas tran vdout0_85ck380 FIND v(dout0_85) AT=195.025n

.meas tran vdout0_86ck380 FIND v(dout0_86) AT=195.025n

.meas tran vdout0_87ck380 FIND v(dout0_87) AT=195.025n

.meas tran vdout0_88ck380 FIND v(dout0_88) AT=195.025n

.meas tran vdout0_89ck380 FIND v(dout0_89) AT=195.025n

.meas tran vdout0_90ck380 FIND v(dout0_90) AT=195.025n

.meas tran vdout0_91ck380 FIND v(dout0_91) AT=195.025n

.meas tran vdout0_92ck380 FIND v(dout0_92) AT=195.025n

.meas tran vdout0_93ck380 FIND v(dout0_93) AT=195.025n

.meas tran vdout0_94ck380 FIND v(dout0_94) AT=195.025n

.meas tran vdout0_95ck380 FIND v(dout0_95) AT=195.025n

.meas tran vdout0_96ck380 FIND v(dout0_96) AT=195.025n

.meas tran vdout0_97ck380 FIND v(dout0_97) AT=195.025n

.meas tran vdout0_98ck380 FIND v(dout0_98) AT=195.025n

.meas tran vdout0_99ck380 FIND v(dout0_99) AT=195.025n

.meas tran vdout0_100ck380 FIND v(dout0_100) AT=195.025n

.meas tran vdout0_101ck380 FIND v(dout0_101) AT=195.025n

.meas tran vdout0_102ck380 FIND v(dout0_102) AT=195.025n

.meas tran vdout0_103ck380 FIND v(dout0_103) AT=195.025n

.meas tran vdout0_104ck380 FIND v(dout0_104) AT=195.025n

.meas tran vdout0_105ck380 FIND v(dout0_105) AT=195.025n

.meas tran vdout0_106ck380 FIND v(dout0_106) AT=195.025n

.meas tran vdout0_107ck380 FIND v(dout0_107) AT=195.025n

.meas tran vdout0_108ck380 FIND v(dout0_108) AT=195.025n

.meas tran vdout0_109ck380 FIND v(dout0_109) AT=195.025n

.meas tran vdout0_110ck380 FIND v(dout0_110) AT=195.025n

.meas tran vdout0_111ck380 FIND v(dout0_111) AT=195.025n

.meas tran vdout0_112ck380 FIND v(dout0_112) AT=195.025n

.meas tran vdout0_113ck380 FIND v(dout0_113) AT=195.025n

.meas tran vdout0_114ck380 FIND v(dout0_114) AT=195.025n

.meas tran vdout0_115ck380 FIND v(dout0_115) AT=195.025n

.meas tran vdout0_116ck380 FIND v(dout0_116) AT=195.025n

.meas tran vdout0_117ck380 FIND v(dout0_117) AT=195.025n

.meas tran vdout0_118ck380 FIND v(dout0_118) AT=195.025n

.meas tran vdout0_119ck380 FIND v(dout0_119) AT=195.025n

.meas tran vdout0_120ck380 FIND v(dout0_120) AT=195.025n

.meas tran vdout0_121ck380 FIND v(dout0_121) AT=195.025n

.meas tran vdout0_122ck380 FIND v(dout0_122) AT=195.025n

.meas tran vdout0_123ck380 FIND v(dout0_123) AT=195.025n

.meas tran vdout0_124ck380 FIND v(dout0_124) AT=195.025n

.meas tran vdout0_125ck380 FIND v(dout0_125) AT=195.025n

.meas tran vdout0_126ck380 FIND v(dout0_126) AT=195.025n

.meas tran vdout0_127ck380 FIND v(dout0_127) AT=195.025n

.meas tran vdout0_0ck390 FIND v(dout0_0) AT=200.025n

.meas tran vdout0_1ck390 FIND v(dout0_1) AT=200.025n

.meas tran vdout0_2ck390 FIND v(dout0_2) AT=200.025n

.meas tran vdout0_3ck390 FIND v(dout0_3) AT=200.025n

.meas tran vdout0_4ck390 FIND v(dout0_4) AT=200.025n

.meas tran vdout0_5ck390 FIND v(dout0_5) AT=200.025n

.meas tran vdout0_6ck390 FIND v(dout0_6) AT=200.025n

.meas tran vdout0_7ck390 FIND v(dout0_7) AT=200.025n

.meas tran vdout0_8ck390 FIND v(dout0_8) AT=200.025n

.meas tran vdout0_9ck390 FIND v(dout0_9) AT=200.025n

.meas tran vdout0_10ck390 FIND v(dout0_10) AT=200.025n

.meas tran vdout0_11ck390 FIND v(dout0_11) AT=200.025n

.meas tran vdout0_12ck390 FIND v(dout0_12) AT=200.025n

.meas tran vdout0_13ck390 FIND v(dout0_13) AT=200.025n

.meas tran vdout0_14ck390 FIND v(dout0_14) AT=200.025n

.meas tran vdout0_15ck390 FIND v(dout0_15) AT=200.025n

.meas tran vdout0_16ck390 FIND v(dout0_16) AT=200.025n

.meas tran vdout0_17ck390 FIND v(dout0_17) AT=200.025n

.meas tran vdout0_18ck390 FIND v(dout0_18) AT=200.025n

.meas tran vdout0_19ck390 FIND v(dout0_19) AT=200.025n

.meas tran vdout0_20ck390 FIND v(dout0_20) AT=200.025n

.meas tran vdout0_21ck390 FIND v(dout0_21) AT=200.025n

.meas tran vdout0_22ck390 FIND v(dout0_22) AT=200.025n

.meas tran vdout0_23ck390 FIND v(dout0_23) AT=200.025n

.meas tran vdout0_24ck390 FIND v(dout0_24) AT=200.025n

.meas tran vdout0_25ck390 FIND v(dout0_25) AT=200.025n

.meas tran vdout0_26ck390 FIND v(dout0_26) AT=200.025n

.meas tran vdout0_27ck390 FIND v(dout0_27) AT=200.025n

.meas tran vdout0_28ck390 FIND v(dout0_28) AT=200.025n

.meas tran vdout0_29ck390 FIND v(dout0_29) AT=200.025n

.meas tran vdout0_30ck390 FIND v(dout0_30) AT=200.025n

.meas tran vdout0_31ck390 FIND v(dout0_31) AT=200.025n

.meas tran vdout0_32ck390 FIND v(dout0_32) AT=200.025n

.meas tran vdout0_33ck390 FIND v(dout0_33) AT=200.025n

.meas tran vdout0_34ck390 FIND v(dout0_34) AT=200.025n

.meas tran vdout0_35ck390 FIND v(dout0_35) AT=200.025n

.meas tran vdout0_36ck390 FIND v(dout0_36) AT=200.025n

.meas tran vdout0_37ck390 FIND v(dout0_37) AT=200.025n

.meas tran vdout0_38ck390 FIND v(dout0_38) AT=200.025n

.meas tran vdout0_39ck390 FIND v(dout0_39) AT=200.025n

.meas tran vdout0_40ck390 FIND v(dout0_40) AT=200.025n

.meas tran vdout0_41ck390 FIND v(dout0_41) AT=200.025n

.meas tran vdout0_42ck390 FIND v(dout0_42) AT=200.025n

.meas tran vdout0_43ck390 FIND v(dout0_43) AT=200.025n

.meas tran vdout0_44ck390 FIND v(dout0_44) AT=200.025n

.meas tran vdout0_45ck390 FIND v(dout0_45) AT=200.025n

.meas tran vdout0_46ck390 FIND v(dout0_46) AT=200.025n

.meas tran vdout0_47ck390 FIND v(dout0_47) AT=200.025n

.meas tran vdout0_48ck390 FIND v(dout0_48) AT=200.025n

.meas tran vdout0_49ck390 FIND v(dout0_49) AT=200.025n

.meas tran vdout0_50ck390 FIND v(dout0_50) AT=200.025n

.meas tran vdout0_51ck390 FIND v(dout0_51) AT=200.025n

.meas tran vdout0_52ck390 FIND v(dout0_52) AT=200.025n

.meas tran vdout0_53ck390 FIND v(dout0_53) AT=200.025n

.meas tran vdout0_54ck390 FIND v(dout0_54) AT=200.025n

.meas tran vdout0_55ck390 FIND v(dout0_55) AT=200.025n

.meas tran vdout0_56ck390 FIND v(dout0_56) AT=200.025n

.meas tran vdout0_57ck390 FIND v(dout0_57) AT=200.025n

.meas tran vdout0_58ck390 FIND v(dout0_58) AT=200.025n

.meas tran vdout0_59ck390 FIND v(dout0_59) AT=200.025n

.meas tran vdout0_60ck390 FIND v(dout0_60) AT=200.025n

.meas tran vdout0_61ck390 FIND v(dout0_61) AT=200.025n

.meas tran vdout0_62ck390 FIND v(dout0_62) AT=200.025n

.meas tran vdout0_63ck390 FIND v(dout0_63) AT=200.025n

.meas tran vdout0_64ck390 FIND v(dout0_64) AT=200.025n

.meas tran vdout0_65ck390 FIND v(dout0_65) AT=200.025n

.meas tran vdout0_66ck390 FIND v(dout0_66) AT=200.025n

.meas tran vdout0_67ck390 FIND v(dout0_67) AT=200.025n

.meas tran vdout0_68ck390 FIND v(dout0_68) AT=200.025n

.meas tran vdout0_69ck390 FIND v(dout0_69) AT=200.025n

.meas tran vdout0_70ck390 FIND v(dout0_70) AT=200.025n

.meas tran vdout0_71ck390 FIND v(dout0_71) AT=200.025n

.meas tran vdout0_72ck390 FIND v(dout0_72) AT=200.025n

.meas tran vdout0_73ck390 FIND v(dout0_73) AT=200.025n

.meas tran vdout0_74ck390 FIND v(dout0_74) AT=200.025n

.meas tran vdout0_75ck390 FIND v(dout0_75) AT=200.025n

.meas tran vdout0_76ck390 FIND v(dout0_76) AT=200.025n

.meas tran vdout0_77ck390 FIND v(dout0_77) AT=200.025n

.meas tran vdout0_78ck390 FIND v(dout0_78) AT=200.025n

.meas tran vdout0_79ck390 FIND v(dout0_79) AT=200.025n

.meas tran vdout0_80ck390 FIND v(dout0_80) AT=200.025n

.meas tran vdout0_81ck390 FIND v(dout0_81) AT=200.025n

.meas tran vdout0_82ck390 FIND v(dout0_82) AT=200.025n

.meas tran vdout0_83ck390 FIND v(dout0_83) AT=200.025n

.meas tran vdout0_84ck390 FIND v(dout0_84) AT=200.025n

.meas tran vdout0_85ck390 FIND v(dout0_85) AT=200.025n

.meas tran vdout0_86ck390 FIND v(dout0_86) AT=200.025n

.meas tran vdout0_87ck390 FIND v(dout0_87) AT=200.025n

.meas tran vdout0_88ck390 FIND v(dout0_88) AT=200.025n

.meas tran vdout0_89ck390 FIND v(dout0_89) AT=200.025n

.meas tran vdout0_90ck390 FIND v(dout0_90) AT=200.025n

.meas tran vdout0_91ck390 FIND v(dout0_91) AT=200.025n

.meas tran vdout0_92ck390 FIND v(dout0_92) AT=200.025n

.meas tran vdout0_93ck390 FIND v(dout0_93) AT=200.025n

.meas tran vdout0_94ck390 FIND v(dout0_94) AT=200.025n

.meas tran vdout0_95ck390 FIND v(dout0_95) AT=200.025n

.meas tran vdout0_96ck390 FIND v(dout0_96) AT=200.025n

.meas tran vdout0_97ck390 FIND v(dout0_97) AT=200.025n

.meas tran vdout0_98ck390 FIND v(dout0_98) AT=200.025n

.meas tran vdout0_99ck390 FIND v(dout0_99) AT=200.025n

.meas tran vdout0_100ck390 FIND v(dout0_100) AT=200.025n

.meas tran vdout0_101ck390 FIND v(dout0_101) AT=200.025n

.meas tran vdout0_102ck390 FIND v(dout0_102) AT=200.025n

.meas tran vdout0_103ck390 FIND v(dout0_103) AT=200.025n

.meas tran vdout0_104ck390 FIND v(dout0_104) AT=200.025n

.meas tran vdout0_105ck390 FIND v(dout0_105) AT=200.025n

.meas tran vdout0_106ck390 FIND v(dout0_106) AT=200.025n

.meas tran vdout0_107ck390 FIND v(dout0_107) AT=200.025n

.meas tran vdout0_108ck390 FIND v(dout0_108) AT=200.025n

.meas tran vdout0_109ck390 FIND v(dout0_109) AT=200.025n

.meas tran vdout0_110ck390 FIND v(dout0_110) AT=200.025n

.meas tran vdout0_111ck390 FIND v(dout0_111) AT=200.025n

.meas tran vdout0_112ck390 FIND v(dout0_112) AT=200.025n

.meas tran vdout0_113ck390 FIND v(dout0_113) AT=200.025n

.meas tran vdout0_114ck390 FIND v(dout0_114) AT=200.025n

.meas tran vdout0_115ck390 FIND v(dout0_115) AT=200.025n

.meas tran vdout0_116ck390 FIND v(dout0_116) AT=200.025n

.meas tran vdout0_117ck390 FIND v(dout0_117) AT=200.025n

.meas tran vdout0_118ck390 FIND v(dout0_118) AT=200.025n

.meas tran vdout0_119ck390 FIND v(dout0_119) AT=200.025n

.meas tran vdout0_120ck390 FIND v(dout0_120) AT=200.025n

.meas tran vdout0_121ck390 FIND v(dout0_121) AT=200.025n

.meas tran vdout0_122ck390 FIND v(dout0_122) AT=200.025n

.meas tran vdout0_123ck390 FIND v(dout0_123) AT=200.025n

.meas tran vdout0_124ck390 FIND v(dout0_124) AT=200.025n

.meas tran vdout0_125ck390 FIND v(dout0_125) AT=200.025n

.meas tran vdout0_126ck390 FIND v(dout0_126) AT=200.025n

.meas tran vdout0_127ck390 FIND v(dout0_127) AT=200.025n

.meas tran vdout0_0ck400 FIND v(dout0_0) AT=205.025n

.meas tran vdout0_1ck400 FIND v(dout0_1) AT=205.025n

.meas tran vdout0_2ck400 FIND v(dout0_2) AT=205.025n

.meas tran vdout0_3ck400 FIND v(dout0_3) AT=205.025n

.meas tran vdout0_4ck400 FIND v(dout0_4) AT=205.025n

.meas tran vdout0_5ck400 FIND v(dout0_5) AT=205.025n

.meas tran vdout0_6ck400 FIND v(dout0_6) AT=205.025n

.meas tran vdout0_7ck400 FIND v(dout0_7) AT=205.025n

.meas tran vdout0_8ck400 FIND v(dout0_8) AT=205.025n

.meas tran vdout0_9ck400 FIND v(dout0_9) AT=205.025n

.meas tran vdout0_10ck400 FIND v(dout0_10) AT=205.025n

.meas tran vdout0_11ck400 FIND v(dout0_11) AT=205.025n

.meas tran vdout0_12ck400 FIND v(dout0_12) AT=205.025n

.meas tran vdout0_13ck400 FIND v(dout0_13) AT=205.025n

.meas tran vdout0_14ck400 FIND v(dout0_14) AT=205.025n

.meas tran vdout0_15ck400 FIND v(dout0_15) AT=205.025n

.meas tran vdout0_16ck400 FIND v(dout0_16) AT=205.025n

.meas tran vdout0_17ck400 FIND v(dout0_17) AT=205.025n

.meas tran vdout0_18ck400 FIND v(dout0_18) AT=205.025n

.meas tran vdout0_19ck400 FIND v(dout0_19) AT=205.025n

.meas tran vdout0_20ck400 FIND v(dout0_20) AT=205.025n

.meas tran vdout0_21ck400 FIND v(dout0_21) AT=205.025n

.meas tran vdout0_22ck400 FIND v(dout0_22) AT=205.025n

.meas tran vdout0_23ck400 FIND v(dout0_23) AT=205.025n

.meas tran vdout0_24ck400 FIND v(dout0_24) AT=205.025n

.meas tran vdout0_25ck400 FIND v(dout0_25) AT=205.025n

.meas tran vdout0_26ck400 FIND v(dout0_26) AT=205.025n

.meas tran vdout0_27ck400 FIND v(dout0_27) AT=205.025n

.meas tran vdout0_28ck400 FIND v(dout0_28) AT=205.025n

.meas tran vdout0_29ck400 FIND v(dout0_29) AT=205.025n

.meas tran vdout0_30ck400 FIND v(dout0_30) AT=205.025n

.meas tran vdout0_31ck400 FIND v(dout0_31) AT=205.025n

.meas tran vdout0_32ck400 FIND v(dout0_32) AT=205.025n

.meas tran vdout0_33ck400 FIND v(dout0_33) AT=205.025n

.meas tran vdout0_34ck400 FIND v(dout0_34) AT=205.025n

.meas tran vdout0_35ck400 FIND v(dout0_35) AT=205.025n

.meas tran vdout0_36ck400 FIND v(dout0_36) AT=205.025n

.meas tran vdout0_37ck400 FIND v(dout0_37) AT=205.025n

.meas tran vdout0_38ck400 FIND v(dout0_38) AT=205.025n

.meas tran vdout0_39ck400 FIND v(dout0_39) AT=205.025n

.meas tran vdout0_40ck400 FIND v(dout0_40) AT=205.025n

.meas tran vdout0_41ck400 FIND v(dout0_41) AT=205.025n

.meas tran vdout0_42ck400 FIND v(dout0_42) AT=205.025n

.meas tran vdout0_43ck400 FIND v(dout0_43) AT=205.025n

.meas tran vdout0_44ck400 FIND v(dout0_44) AT=205.025n

.meas tran vdout0_45ck400 FIND v(dout0_45) AT=205.025n

.meas tran vdout0_46ck400 FIND v(dout0_46) AT=205.025n

.meas tran vdout0_47ck400 FIND v(dout0_47) AT=205.025n

.meas tran vdout0_48ck400 FIND v(dout0_48) AT=205.025n

.meas tran vdout0_49ck400 FIND v(dout0_49) AT=205.025n

.meas tran vdout0_50ck400 FIND v(dout0_50) AT=205.025n

.meas tran vdout0_51ck400 FIND v(dout0_51) AT=205.025n

.meas tran vdout0_52ck400 FIND v(dout0_52) AT=205.025n

.meas tran vdout0_53ck400 FIND v(dout0_53) AT=205.025n

.meas tran vdout0_54ck400 FIND v(dout0_54) AT=205.025n

.meas tran vdout0_55ck400 FIND v(dout0_55) AT=205.025n

.meas tran vdout0_56ck400 FIND v(dout0_56) AT=205.025n

.meas tran vdout0_57ck400 FIND v(dout0_57) AT=205.025n

.meas tran vdout0_58ck400 FIND v(dout0_58) AT=205.025n

.meas tran vdout0_59ck400 FIND v(dout0_59) AT=205.025n

.meas tran vdout0_60ck400 FIND v(dout0_60) AT=205.025n

.meas tran vdout0_61ck400 FIND v(dout0_61) AT=205.025n

.meas tran vdout0_62ck400 FIND v(dout0_62) AT=205.025n

.meas tran vdout0_63ck400 FIND v(dout0_63) AT=205.025n

.meas tran vdout0_64ck400 FIND v(dout0_64) AT=205.025n

.meas tran vdout0_65ck400 FIND v(dout0_65) AT=205.025n

.meas tran vdout0_66ck400 FIND v(dout0_66) AT=205.025n

.meas tran vdout0_67ck400 FIND v(dout0_67) AT=205.025n

.meas tran vdout0_68ck400 FIND v(dout0_68) AT=205.025n

.meas tran vdout0_69ck400 FIND v(dout0_69) AT=205.025n

.meas tran vdout0_70ck400 FIND v(dout0_70) AT=205.025n

.meas tran vdout0_71ck400 FIND v(dout0_71) AT=205.025n

.meas tran vdout0_72ck400 FIND v(dout0_72) AT=205.025n

.meas tran vdout0_73ck400 FIND v(dout0_73) AT=205.025n

.meas tran vdout0_74ck400 FIND v(dout0_74) AT=205.025n

.meas tran vdout0_75ck400 FIND v(dout0_75) AT=205.025n

.meas tran vdout0_76ck400 FIND v(dout0_76) AT=205.025n

.meas tran vdout0_77ck400 FIND v(dout0_77) AT=205.025n

.meas tran vdout0_78ck400 FIND v(dout0_78) AT=205.025n

.meas tran vdout0_79ck400 FIND v(dout0_79) AT=205.025n

.meas tran vdout0_80ck400 FIND v(dout0_80) AT=205.025n

.meas tran vdout0_81ck400 FIND v(dout0_81) AT=205.025n

.meas tran vdout0_82ck400 FIND v(dout0_82) AT=205.025n

.meas tran vdout0_83ck400 FIND v(dout0_83) AT=205.025n

.meas tran vdout0_84ck400 FIND v(dout0_84) AT=205.025n

.meas tran vdout0_85ck400 FIND v(dout0_85) AT=205.025n

.meas tran vdout0_86ck400 FIND v(dout0_86) AT=205.025n

.meas tran vdout0_87ck400 FIND v(dout0_87) AT=205.025n

.meas tran vdout0_88ck400 FIND v(dout0_88) AT=205.025n

.meas tran vdout0_89ck400 FIND v(dout0_89) AT=205.025n

.meas tran vdout0_90ck400 FIND v(dout0_90) AT=205.025n

.meas tran vdout0_91ck400 FIND v(dout0_91) AT=205.025n

.meas tran vdout0_92ck400 FIND v(dout0_92) AT=205.025n

.meas tran vdout0_93ck400 FIND v(dout0_93) AT=205.025n

.meas tran vdout0_94ck400 FIND v(dout0_94) AT=205.025n

.meas tran vdout0_95ck400 FIND v(dout0_95) AT=205.025n

.meas tran vdout0_96ck400 FIND v(dout0_96) AT=205.025n

.meas tran vdout0_97ck400 FIND v(dout0_97) AT=205.025n

.meas tran vdout0_98ck400 FIND v(dout0_98) AT=205.025n

.meas tran vdout0_99ck400 FIND v(dout0_99) AT=205.025n

.meas tran vdout0_100ck400 FIND v(dout0_100) AT=205.025n

.meas tran vdout0_101ck400 FIND v(dout0_101) AT=205.025n

.meas tran vdout0_102ck400 FIND v(dout0_102) AT=205.025n

.meas tran vdout0_103ck400 FIND v(dout0_103) AT=205.025n

.meas tran vdout0_104ck400 FIND v(dout0_104) AT=205.025n

.meas tran vdout0_105ck400 FIND v(dout0_105) AT=205.025n

.meas tran vdout0_106ck400 FIND v(dout0_106) AT=205.025n

.meas tran vdout0_107ck400 FIND v(dout0_107) AT=205.025n

.meas tran vdout0_108ck400 FIND v(dout0_108) AT=205.025n

.meas tran vdout0_109ck400 FIND v(dout0_109) AT=205.025n

.meas tran vdout0_110ck400 FIND v(dout0_110) AT=205.025n

.meas tran vdout0_111ck400 FIND v(dout0_111) AT=205.025n

.meas tran vdout0_112ck400 FIND v(dout0_112) AT=205.025n

.meas tran vdout0_113ck400 FIND v(dout0_113) AT=205.025n

.meas tran vdout0_114ck400 FIND v(dout0_114) AT=205.025n

.meas tran vdout0_115ck400 FIND v(dout0_115) AT=205.025n

.meas tran vdout0_116ck400 FIND v(dout0_116) AT=205.025n

.meas tran vdout0_117ck400 FIND v(dout0_117) AT=205.025n

.meas tran vdout0_118ck400 FIND v(dout0_118) AT=205.025n

.meas tran vdout0_119ck400 FIND v(dout0_119) AT=205.025n

.meas tran vdout0_120ck400 FIND v(dout0_120) AT=205.025n

.meas tran vdout0_121ck400 FIND v(dout0_121) AT=205.025n

.meas tran vdout0_122ck400 FIND v(dout0_122) AT=205.025n

.meas tran vdout0_123ck400 FIND v(dout0_123) AT=205.025n

.meas tran vdout0_124ck400 FIND v(dout0_124) AT=205.025n

.meas tran vdout0_125ck400 FIND v(dout0_125) AT=205.025n

.meas tran vdout0_126ck400 FIND v(dout0_126) AT=205.025n

.meas tran vdout0_127ck400 FIND v(dout0_127) AT=205.025n

.meas tran vdout0_0ck440 FIND v(dout0_0) AT=225.025n

.meas tran vdout0_1ck440 FIND v(dout0_1) AT=225.025n

.meas tran vdout0_2ck440 FIND v(dout0_2) AT=225.025n

.meas tran vdout0_3ck440 FIND v(dout0_3) AT=225.025n

.meas tran vdout0_4ck440 FIND v(dout0_4) AT=225.025n

.meas tran vdout0_5ck440 FIND v(dout0_5) AT=225.025n

.meas tran vdout0_6ck440 FIND v(dout0_6) AT=225.025n

.meas tran vdout0_7ck440 FIND v(dout0_7) AT=225.025n

.meas tran vdout0_8ck440 FIND v(dout0_8) AT=225.025n

.meas tran vdout0_9ck440 FIND v(dout0_9) AT=225.025n

.meas tran vdout0_10ck440 FIND v(dout0_10) AT=225.025n

.meas tran vdout0_11ck440 FIND v(dout0_11) AT=225.025n

.meas tran vdout0_12ck440 FIND v(dout0_12) AT=225.025n

.meas tran vdout0_13ck440 FIND v(dout0_13) AT=225.025n

.meas tran vdout0_14ck440 FIND v(dout0_14) AT=225.025n

.meas tran vdout0_15ck440 FIND v(dout0_15) AT=225.025n

.meas tran vdout0_16ck440 FIND v(dout0_16) AT=225.025n

.meas tran vdout0_17ck440 FIND v(dout0_17) AT=225.025n

.meas tran vdout0_18ck440 FIND v(dout0_18) AT=225.025n

.meas tran vdout0_19ck440 FIND v(dout0_19) AT=225.025n

.meas tran vdout0_20ck440 FIND v(dout0_20) AT=225.025n

.meas tran vdout0_21ck440 FIND v(dout0_21) AT=225.025n

.meas tran vdout0_22ck440 FIND v(dout0_22) AT=225.025n

.meas tran vdout0_23ck440 FIND v(dout0_23) AT=225.025n

.meas tran vdout0_24ck440 FIND v(dout0_24) AT=225.025n

.meas tran vdout0_25ck440 FIND v(dout0_25) AT=225.025n

.meas tran vdout0_26ck440 FIND v(dout0_26) AT=225.025n

.meas tran vdout0_27ck440 FIND v(dout0_27) AT=225.025n

.meas tran vdout0_28ck440 FIND v(dout0_28) AT=225.025n

.meas tran vdout0_29ck440 FIND v(dout0_29) AT=225.025n

.meas tran vdout0_30ck440 FIND v(dout0_30) AT=225.025n

.meas tran vdout0_31ck440 FIND v(dout0_31) AT=225.025n

.meas tran vdout0_32ck440 FIND v(dout0_32) AT=225.025n

.meas tran vdout0_33ck440 FIND v(dout0_33) AT=225.025n

.meas tran vdout0_34ck440 FIND v(dout0_34) AT=225.025n

.meas tran vdout0_35ck440 FIND v(dout0_35) AT=225.025n

.meas tran vdout0_36ck440 FIND v(dout0_36) AT=225.025n

.meas tran vdout0_37ck440 FIND v(dout0_37) AT=225.025n

.meas tran vdout0_38ck440 FIND v(dout0_38) AT=225.025n

.meas tran vdout0_39ck440 FIND v(dout0_39) AT=225.025n

.meas tran vdout0_40ck440 FIND v(dout0_40) AT=225.025n

.meas tran vdout0_41ck440 FIND v(dout0_41) AT=225.025n

.meas tran vdout0_42ck440 FIND v(dout0_42) AT=225.025n

.meas tran vdout0_43ck440 FIND v(dout0_43) AT=225.025n

.meas tran vdout0_44ck440 FIND v(dout0_44) AT=225.025n

.meas tran vdout0_45ck440 FIND v(dout0_45) AT=225.025n

.meas tran vdout0_46ck440 FIND v(dout0_46) AT=225.025n

.meas tran vdout0_47ck440 FIND v(dout0_47) AT=225.025n

.meas tran vdout0_48ck440 FIND v(dout0_48) AT=225.025n

.meas tran vdout0_49ck440 FIND v(dout0_49) AT=225.025n

.meas tran vdout0_50ck440 FIND v(dout0_50) AT=225.025n

.meas tran vdout0_51ck440 FIND v(dout0_51) AT=225.025n

.meas tran vdout0_52ck440 FIND v(dout0_52) AT=225.025n

.meas tran vdout0_53ck440 FIND v(dout0_53) AT=225.025n

.meas tran vdout0_54ck440 FIND v(dout0_54) AT=225.025n

.meas tran vdout0_55ck440 FIND v(dout0_55) AT=225.025n

.meas tran vdout0_56ck440 FIND v(dout0_56) AT=225.025n

.meas tran vdout0_57ck440 FIND v(dout0_57) AT=225.025n

.meas tran vdout0_58ck440 FIND v(dout0_58) AT=225.025n

.meas tran vdout0_59ck440 FIND v(dout0_59) AT=225.025n

.meas tran vdout0_60ck440 FIND v(dout0_60) AT=225.025n

.meas tran vdout0_61ck440 FIND v(dout0_61) AT=225.025n

.meas tran vdout0_62ck440 FIND v(dout0_62) AT=225.025n

.meas tran vdout0_63ck440 FIND v(dout0_63) AT=225.025n

.meas tran vdout0_64ck440 FIND v(dout0_64) AT=225.025n

.meas tran vdout0_65ck440 FIND v(dout0_65) AT=225.025n

.meas tran vdout0_66ck440 FIND v(dout0_66) AT=225.025n

.meas tran vdout0_67ck440 FIND v(dout0_67) AT=225.025n

.meas tran vdout0_68ck440 FIND v(dout0_68) AT=225.025n

.meas tran vdout0_69ck440 FIND v(dout0_69) AT=225.025n

.meas tran vdout0_70ck440 FIND v(dout0_70) AT=225.025n

.meas tran vdout0_71ck440 FIND v(dout0_71) AT=225.025n

.meas tran vdout0_72ck440 FIND v(dout0_72) AT=225.025n

.meas tran vdout0_73ck440 FIND v(dout0_73) AT=225.025n

.meas tran vdout0_74ck440 FIND v(dout0_74) AT=225.025n

.meas tran vdout0_75ck440 FIND v(dout0_75) AT=225.025n

.meas tran vdout0_76ck440 FIND v(dout0_76) AT=225.025n

.meas tran vdout0_77ck440 FIND v(dout0_77) AT=225.025n

.meas tran vdout0_78ck440 FIND v(dout0_78) AT=225.025n

.meas tran vdout0_79ck440 FIND v(dout0_79) AT=225.025n

.meas tran vdout0_80ck440 FIND v(dout0_80) AT=225.025n

.meas tran vdout0_81ck440 FIND v(dout0_81) AT=225.025n

.meas tran vdout0_82ck440 FIND v(dout0_82) AT=225.025n

.meas tran vdout0_83ck440 FIND v(dout0_83) AT=225.025n

.meas tran vdout0_84ck440 FIND v(dout0_84) AT=225.025n

.meas tran vdout0_85ck440 FIND v(dout0_85) AT=225.025n

.meas tran vdout0_86ck440 FIND v(dout0_86) AT=225.025n

.meas tran vdout0_87ck440 FIND v(dout0_87) AT=225.025n

.meas tran vdout0_88ck440 FIND v(dout0_88) AT=225.025n

.meas tran vdout0_89ck440 FIND v(dout0_89) AT=225.025n

.meas tran vdout0_90ck440 FIND v(dout0_90) AT=225.025n

.meas tran vdout0_91ck440 FIND v(dout0_91) AT=225.025n

.meas tran vdout0_92ck440 FIND v(dout0_92) AT=225.025n

.meas tran vdout0_93ck440 FIND v(dout0_93) AT=225.025n

.meas tran vdout0_94ck440 FIND v(dout0_94) AT=225.025n

.meas tran vdout0_95ck440 FIND v(dout0_95) AT=225.025n

.meas tran vdout0_96ck440 FIND v(dout0_96) AT=225.025n

.meas tran vdout0_97ck440 FIND v(dout0_97) AT=225.025n

.meas tran vdout0_98ck440 FIND v(dout0_98) AT=225.025n

.meas tran vdout0_99ck440 FIND v(dout0_99) AT=225.025n

.meas tran vdout0_100ck440 FIND v(dout0_100) AT=225.025n

.meas tran vdout0_101ck440 FIND v(dout0_101) AT=225.025n

.meas tran vdout0_102ck440 FIND v(dout0_102) AT=225.025n

.meas tran vdout0_103ck440 FIND v(dout0_103) AT=225.025n

.meas tran vdout0_104ck440 FIND v(dout0_104) AT=225.025n

.meas tran vdout0_105ck440 FIND v(dout0_105) AT=225.025n

.meas tran vdout0_106ck440 FIND v(dout0_106) AT=225.025n

.meas tran vdout0_107ck440 FIND v(dout0_107) AT=225.025n

.meas tran vdout0_108ck440 FIND v(dout0_108) AT=225.025n

.meas tran vdout0_109ck440 FIND v(dout0_109) AT=225.025n

.meas tran vdout0_110ck440 FIND v(dout0_110) AT=225.025n

.meas tran vdout0_111ck440 FIND v(dout0_111) AT=225.025n

.meas tran vdout0_112ck440 FIND v(dout0_112) AT=225.025n

.meas tran vdout0_113ck440 FIND v(dout0_113) AT=225.025n

.meas tran vdout0_114ck440 FIND v(dout0_114) AT=225.025n

.meas tran vdout0_115ck440 FIND v(dout0_115) AT=225.025n

.meas tran vdout0_116ck440 FIND v(dout0_116) AT=225.025n

.meas tran vdout0_117ck440 FIND v(dout0_117) AT=225.025n

.meas tran vdout0_118ck440 FIND v(dout0_118) AT=225.025n

.meas tran vdout0_119ck440 FIND v(dout0_119) AT=225.025n

.meas tran vdout0_120ck440 FIND v(dout0_120) AT=225.025n

.meas tran vdout0_121ck440 FIND v(dout0_121) AT=225.025n

.meas tran vdout0_122ck440 FIND v(dout0_122) AT=225.025n

.meas tran vdout0_123ck440 FIND v(dout0_123) AT=225.025n

.meas tran vdout0_124ck440 FIND v(dout0_124) AT=225.025n

.meas tran vdout0_125ck440 FIND v(dout0_125) AT=225.025n

.meas tran vdout0_126ck440 FIND v(dout0_126) AT=225.025n

.meas tran vdout0_127ck440 FIND v(dout0_127) AT=225.025n

.meas tran vdout0_0ck450 FIND v(dout0_0) AT=230.025n

.meas tran vdout0_1ck450 FIND v(dout0_1) AT=230.025n

.meas tran vdout0_2ck450 FIND v(dout0_2) AT=230.025n

.meas tran vdout0_3ck450 FIND v(dout0_3) AT=230.025n

.meas tran vdout0_4ck450 FIND v(dout0_4) AT=230.025n

.meas tran vdout0_5ck450 FIND v(dout0_5) AT=230.025n

.meas tran vdout0_6ck450 FIND v(dout0_6) AT=230.025n

.meas tran vdout0_7ck450 FIND v(dout0_7) AT=230.025n

.meas tran vdout0_8ck450 FIND v(dout0_8) AT=230.025n

.meas tran vdout0_9ck450 FIND v(dout0_9) AT=230.025n

.meas tran vdout0_10ck450 FIND v(dout0_10) AT=230.025n

.meas tran vdout0_11ck450 FIND v(dout0_11) AT=230.025n

.meas tran vdout0_12ck450 FIND v(dout0_12) AT=230.025n

.meas tran vdout0_13ck450 FIND v(dout0_13) AT=230.025n

.meas tran vdout0_14ck450 FIND v(dout0_14) AT=230.025n

.meas tran vdout0_15ck450 FIND v(dout0_15) AT=230.025n

.meas tran vdout0_16ck450 FIND v(dout0_16) AT=230.025n

.meas tran vdout0_17ck450 FIND v(dout0_17) AT=230.025n

.meas tran vdout0_18ck450 FIND v(dout0_18) AT=230.025n

.meas tran vdout0_19ck450 FIND v(dout0_19) AT=230.025n

.meas tran vdout0_20ck450 FIND v(dout0_20) AT=230.025n

.meas tran vdout0_21ck450 FIND v(dout0_21) AT=230.025n

.meas tran vdout0_22ck450 FIND v(dout0_22) AT=230.025n

.meas tran vdout0_23ck450 FIND v(dout0_23) AT=230.025n

.meas tran vdout0_24ck450 FIND v(dout0_24) AT=230.025n

.meas tran vdout0_25ck450 FIND v(dout0_25) AT=230.025n

.meas tran vdout0_26ck450 FIND v(dout0_26) AT=230.025n

.meas tran vdout0_27ck450 FIND v(dout0_27) AT=230.025n

.meas tran vdout0_28ck450 FIND v(dout0_28) AT=230.025n

.meas tran vdout0_29ck450 FIND v(dout0_29) AT=230.025n

.meas tran vdout0_30ck450 FIND v(dout0_30) AT=230.025n

.meas tran vdout0_31ck450 FIND v(dout0_31) AT=230.025n

.meas tran vdout0_32ck450 FIND v(dout0_32) AT=230.025n

.meas tran vdout0_33ck450 FIND v(dout0_33) AT=230.025n

.meas tran vdout0_34ck450 FIND v(dout0_34) AT=230.025n

.meas tran vdout0_35ck450 FIND v(dout0_35) AT=230.025n

.meas tran vdout0_36ck450 FIND v(dout0_36) AT=230.025n

.meas tran vdout0_37ck450 FIND v(dout0_37) AT=230.025n

.meas tran vdout0_38ck450 FIND v(dout0_38) AT=230.025n

.meas tran vdout0_39ck450 FIND v(dout0_39) AT=230.025n

.meas tran vdout0_40ck450 FIND v(dout0_40) AT=230.025n

.meas tran vdout0_41ck450 FIND v(dout0_41) AT=230.025n

.meas tran vdout0_42ck450 FIND v(dout0_42) AT=230.025n

.meas tran vdout0_43ck450 FIND v(dout0_43) AT=230.025n

.meas tran vdout0_44ck450 FIND v(dout0_44) AT=230.025n

.meas tran vdout0_45ck450 FIND v(dout0_45) AT=230.025n

.meas tran vdout0_46ck450 FIND v(dout0_46) AT=230.025n

.meas tran vdout0_47ck450 FIND v(dout0_47) AT=230.025n

.meas tran vdout0_48ck450 FIND v(dout0_48) AT=230.025n

.meas tran vdout0_49ck450 FIND v(dout0_49) AT=230.025n

.meas tran vdout0_50ck450 FIND v(dout0_50) AT=230.025n

.meas tran vdout0_51ck450 FIND v(dout0_51) AT=230.025n

.meas tran vdout0_52ck450 FIND v(dout0_52) AT=230.025n

.meas tran vdout0_53ck450 FIND v(dout0_53) AT=230.025n

.meas tran vdout0_54ck450 FIND v(dout0_54) AT=230.025n

.meas tran vdout0_55ck450 FIND v(dout0_55) AT=230.025n

.meas tran vdout0_56ck450 FIND v(dout0_56) AT=230.025n

.meas tran vdout0_57ck450 FIND v(dout0_57) AT=230.025n

.meas tran vdout0_58ck450 FIND v(dout0_58) AT=230.025n

.meas tran vdout0_59ck450 FIND v(dout0_59) AT=230.025n

.meas tran vdout0_60ck450 FIND v(dout0_60) AT=230.025n

.meas tran vdout0_61ck450 FIND v(dout0_61) AT=230.025n

.meas tran vdout0_62ck450 FIND v(dout0_62) AT=230.025n

.meas tran vdout0_63ck450 FIND v(dout0_63) AT=230.025n

.meas tran vdout0_64ck450 FIND v(dout0_64) AT=230.025n

.meas tran vdout0_65ck450 FIND v(dout0_65) AT=230.025n

.meas tran vdout0_66ck450 FIND v(dout0_66) AT=230.025n

.meas tran vdout0_67ck450 FIND v(dout0_67) AT=230.025n

.meas tran vdout0_68ck450 FIND v(dout0_68) AT=230.025n

.meas tran vdout0_69ck450 FIND v(dout0_69) AT=230.025n

.meas tran vdout0_70ck450 FIND v(dout0_70) AT=230.025n

.meas tran vdout0_71ck450 FIND v(dout0_71) AT=230.025n

.meas tran vdout0_72ck450 FIND v(dout0_72) AT=230.025n

.meas tran vdout0_73ck450 FIND v(dout0_73) AT=230.025n

.meas tran vdout0_74ck450 FIND v(dout0_74) AT=230.025n

.meas tran vdout0_75ck450 FIND v(dout0_75) AT=230.025n

.meas tran vdout0_76ck450 FIND v(dout0_76) AT=230.025n

.meas tran vdout0_77ck450 FIND v(dout0_77) AT=230.025n

.meas tran vdout0_78ck450 FIND v(dout0_78) AT=230.025n

.meas tran vdout0_79ck450 FIND v(dout0_79) AT=230.025n

.meas tran vdout0_80ck450 FIND v(dout0_80) AT=230.025n

.meas tran vdout0_81ck450 FIND v(dout0_81) AT=230.025n

.meas tran vdout0_82ck450 FIND v(dout0_82) AT=230.025n

.meas tran vdout0_83ck450 FIND v(dout0_83) AT=230.025n

.meas tran vdout0_84ck450 FIND v(dout0_84) AT=230.025n

.meas tran vdout0_85ck450 FIND v(dout0_85) AT=230.025n

.meas tran vdout0_86ck450 FIND v(dout0_86) AT=230.025n

.meas tran vdout0_87ck450 FIND v(dout0_87) AT=230.025n

.meas tran vdout0_88ck450 FIND v(dout0_88) AT=230.025n

.meas tran vdout0_89ck450 FIND v(dout0_89) AT=230.025n

.meas tran vdout0_90ck450 FIND v(dout0_90) AT=230.025n

.meas tran vdout0_91ck450 FIND v(dout0_91) AT=230.025n

.meas tran vdout0_92ck450 FIND v(dout0_92) AT=230.025n

.meas tran vdout0_93ck450 FIND v(dout0_93) AT=230.025n

.meas tran vdout0_94ck450 FIND v(dout0_94) AT=230.025n

.meas tran vdout0_95ck450 FIND v(dout0_95) AT=230.025n

.meas tran vdout0_96ck450 FIND v(dout0_96) AT=230.025n

.meas tran vdout0_97ck450 FIND v(dout0_97) AT=230.025n

.meas tran vdout0_98ck450 FIND v(dout0_98) AT=230.025n

.meas tran vdout0_99ck450 FIND v(dout0_99) AT=230.025n

.meas tran vdout0_100ck450 FIND v(dout0_100) AT=230.025n

.meas tran vdout0_101ck450 FIND v(dout0_101) AT=230.025n

.meas tran vdout0_102ck450 FIND v(dout0_102) AT=230.025n

.meas tran vdout0_103ck450 FIND v(dout0_103) AT=230.025n

.meas tran vdout0_104ck450 FIND v(dout0_104) AT=230.025n

.meas tran vdout0_105ck450 FIND v(dout0_105) AT=230.025n

.meas tran vdout0_106ck450 FIND v(dout0_106) AT=230.025n

.meas tran vdout0_107ck450 FIND v(dout0_107) AT=230.025n

.meas tran vdout0_108ck450 FIND v(dout0_108) AT=230.025n

.meas tran vdout0_109ck450 FIND v(dout0_109) AT=230.025n

.meas tran vdout0_110ck450 FIND v(dout0_110) AT=230.025n

.meas tran vdout0_111ck450 FIND v(dout0_111) AT=230.025n

.meas tran vdout0_112ck450 FIND v(dout0_112) AT=230.025n

.meas tran vdout0_113ck450 FIND v(dout0_113) AT=230.025n

.meas tran vdout0_114ck450 FIND v(dout0_114) AT=230.025n

.meas tran vdout0_115ck450 FIND v(dout0_115) AT=230.025n

.meas tran vdout0_116ck450 FIND v(dout0_116) AT=230.025n

.meas tran vdout0_117ck450 FIND v(dout0_117) AT=230.025n

.meas tran vdout0_118ck450 FIND v(dout0_118) AT=230.025n

.meas tran vdout0_119ck450 FIND v(dout0_119) AT=230.025n

.meas tran vdout0_120ck450 FIND v(dout0_120) AT=230.025n

.meas tran vdout0_121ck450 FIND v(dout0_121) AT=230.025n

.meas tran vdout0_122ck450 FIND v(dout0_122) AT=230.025n

.meas tran vdout0_123ck450 FIND v(dout0_123) AT=230.025n

.meas tran vdout0_124ck450 FIND v(dout0_124) AT=230.025n

.meas tran vdout0_125ck450 FIND v(dout0_125) AT=230.025n

.meas tran vdout0_126ck450 FIND v(dout0_126) AT=230.025n

.meas tran vdout0_127ck450 FIND v(dout0_127) AT=230.025n

.meas tran vdout0_0ck460 FIND v(dout0_0) AT=235.025n

.meas tran vdout0_1ck460 FIND v(dout0_1) AT=235.025n

.meas tran vdout0_2ck460 FIND v(dout0_2) AT=235.025n

.meas tran vdout0_3ck460 FIND v(dout0_3) AT=235.025n

.meas tran vdout0_4ck460 FIND v(dout0_4) AT=235.025n

.meas tran vdout0_5ck460 FIND v(dout0_5) AT=235.025n

.meas tran vdout0_6ck460 FIND v(dout0_6) AT=235.025n

.meas tran vdout0_7ck460 FIND v(dout0_7) AT=235.025n

.meas tran vdout0_8ck460 FIND v(dout0_8) AT=235.025n

.meas tran vdout0_9ck460 FIND v(dout0_9) AT=235.025n

.meas tran vdout0_10ck460 FIND v(dout0_10) AT=235.025n

.meas tran vdout0_11ck460 FIND v(dout0_11) AT=235.025n

.meas tran vdout0_12ck460 FIND v(dout0_12) AT=235.025n

.meas tran vdout0_13ck460 FIND v(dout0_13) AT=235.025n

.meas tran vdout0_14ck460 FIND v(dout0_14) AT=235.025n

.meas tran vdout0_15ck460 FIND v(dout0_15) AT=235.025n

.meas tran vdout0_16ck460 FIND v(dout0_16) AT=235.025n

.meas tran vdout0_17ck460 FIND v(dout0_17) AT=235.025n

.meas tran vdout0_18ck460 FIND v(dout0_18) AT=235.025n

.meas tran vdout0_19ck460 FIND v(dout0_19) AT=235.025n

.meas tran vdout0_20ck460 FIND v(dout0_20) AT=235.025n

.meas tran vdout0_21ck460 FIND v(dout0_21) AT=235.025n

.meas tran vdout0_22ck460 FIND v(dout0_22) AT=235.025n

.meas tran vdout0_23ck460 FIND v(dout0_23) AT=235.025n

.meas tran vdout0_24ck460 FIND v(dout0_24) AT=235.025n

.meas tran vdout0_25ck460 FIND v(dout0_25) AT=235.025n

.meas tran vdout0_26ck460 FIND v(dout0_26) AT=235.025n

.meas tran vdout0_27ck460 FIND v(dout0_27) AT=235.025n

.meas tran vdout0_28ck460 FIND v(dout0_28) AT=235.025n

.meas tran vdout0_29ck460 FIND v(dout0_29) AT=235.025n

.meas tran vdout0_30ck460 FIND v(dout0_30) AT=235.025n

.meas tran vdout0_31ck460 FIND v(dout0_31) AT=235.025n

.meas tran vdout0_32ck460 FIND v(dout0_32) AT=235.025n

.meas tran vdout0_33ck460 FIND v(dout0_33) AT=235.025n

.meas tran vdout0_34ck460 FIND v(dout0_34) AT=235.025n

.meas tran vdout0_35ck460 FIND v(dout0_35) AT=235.025n

.meas tran vdout0_36ck460 FIND v(dout0_36) AT=235.025n

.meas tran vdout0_37ck460 FIND v(dout0_37) AT=235.025n

.meas tran vdout0_38ck460 FIND v(dout0_38) AT=235.025n

.meas tran vdout0_39ck460 FIND v(dout0_39) AT=235.025n

.meas tran vdout0_40ck460 FIND v(dout0_40) AT=235.025n

.meas tran vdout0_41ck460 FIND v(dout0_41) AT=235.025n

.meas tran vdout0_42ck460 FIND v(dout0_42) AT=235.025n

.meas tran vdout0_43ck460 FIND v(dout0_43) AT=235.025n

.meas tran vdout0_44ck460 FIND v(dout0_44) AT=235.025n

.meas tran vdout0_45ck460 FIND v(dout0_45) AT=235.025n

.meas tran vdout0_46ck460 FIND v(dout0_46) AT=235.025n

.meas tran vdout0_47ck460 FIND v(dout0_47) AT=235.025n

.meas tran vdout0_48ck460 FIND v(dout0_48) AT=235.025n

.meas tran vdout0_49ck460 FIND v(dout0_49) AT=235.025n

.meas tran vdout0_50ck460 FIND v(dout0_50) AT=235.025n

.meas tran vdout0_51ck460 FIND v(dout0_51) AT=235.025n

.meas tran vdout0_52ck460 FIND v(dout0_52) AT=235.025n

.meas tran vdout0_53ck460 FIND v(dout0_53) AT=235.025n

.meas tran vdout0_54ck460 FIND v(dout0_54) AT=235.025n

.meas tran vdout0_55ck460 FIND v(dout0_55) AT=235.025n

.meas tran vdout0_56ck460 FIND v(dout0_56) AT=235.025n

.meas tran vdout0_57ck460 FIND v(dout0_57) AT=235.025n

.meas tran vdout0_58ck460 FIND v(dout0_58) AT=235.025n

.meas tran vdout0_59ck460 FIND v(dout0_59) AT=235.025n

.meas tran vdout0_60ck460 FIND v(dout0_60) AT=235.025n

.meas tran vdout0_61ck460 FIND v(dout0_61) AT=235.025n

.meas tran vdout0_62ck460 FIND v(dout0_62) AT=235.025n

.meas tran vdout0_63ck460 FIND v(dout0_63) AT=235.025n

.meas tran vdout0_64ck460 FIND v(dout0_64) AT=235.025n

.meas tran vdout0_65ck460 FIND v(dout0_65) AT=235.025n

.meas tran vdout0_66ck460 FIND v(dout0_66) AT=235.025n

.meas tran vdout0_67ck460 FIND v(dout0_67) AT=235.025n

.meas tran vdout0_68ck460 FIND v(dout0_68) AT=235.025n

.meas tran vdout0_69ck460 FIND v(dout0_69) AT=235.025n

.meas tran vdout0_70ck460 FIND v(dout0_70) AT=235.025n

.meas tran vdout0_71ck460 FIND v(dout0_71) AT=235.025n

.meas tran vdout0_72ck460 FIND v(dout0_72) AT=235.025n

.meas tran vdout0_73ck460 FIND v(dout0_73) AT=235.025n

.meas tran vdout0_74ck460 FIND v(dout0_74) AT=235.025n

.meas tran vdout0_75ck460 FIND v(dout0_75) AT=235.025n

.meas tran vdout0_76ck460 FIND v(dout0_76) AT=235.025n

.meas tran vdout0_77ck460 FIND v(dout0_77) AT=235.025n

.meas tran vdout0_78ck460 FIND v(dout0_78) AT=235.025n

.meas tran vdout0_79ck460 FIND v(dout0_79) AT=235.025n

.meas tran vdout0_80ck460 FIND v(dout0_80) AT=235.025n

.meas tran vdout0_81ck460 FIND v(dout0_81) AT=235.025n

.meas tran vdout0_82ck460 FIND v(dout0_82) AT=235.025n

.meas tran vdout0_83ck460 FIND v(dout0_83) AT=235.025n

.meas tran vdout0_84ck460 FIND v(dout0_84) AT=235.025n

.meas tran vdout0_85ck460 FIND v(dout0_85) AT=235.025n

.meas tran vdout0_86ck460 FIND v(dout0_86) AT=235.025n

.meas tran vdout0_87ck460 FIND v(dout0_87) AT=235.025n

.meas tran vdout0_88ck460 FIND v(dout0_88) AT=235.025n

.meas tran vdout0_89ck460 FIND v(dout0_89) AT=235.025n

.meas tran vdout0_90ck460 FIND v(dout0_90) AT=235.025n

.meas tran vdout0_91ck460 FIND v(dout0_91) AT=235.025n

.meas tran vdout0_92ck460 FIND v(dout0_92) AT=235.025n

.meas tran vdout0_93ck460 FIND v(dout0_93) AT=235.025n

.meas tran vdout0_94ck460 FIND v(dout0_94) AT=235.025n

.meas tran vdout0_95ck460 FIND v(dout0_95) AT=235.025n

.meas tran vdout0_96ck460 FIND v(dout0_96) AT=235.025n

.meas tran vdout0_97ck460 FIND v(dout0_97) AT=235.025n

.meas tran vdout0_98ck460 FIND v(dout0_98) AT=235.025n

.meas tran vdout0_99ck460 FIND v(dout0_99) AT=235.025n

.meas tran vdout0_100ck460 FIND v(dout0_100) AT=235.025n

.meas tran vdout0_101ck460 FIND v(dout0_101) AT=235.025n

.meas tran vdout0_102ck460 FIND v(dout0_102) AT=235.025n

.meas tran vdout0_103ck460 FIND v(dout0_103) AT=235.025n

.meas tran vdout0_104ck460 FIND v(dout0_104) AT=235.025n

.meas tran vdout0_105ck460 FIND v(dout0_105) AT=235.025n

.meas tran vdout0_106ck460 FIND v(dout0_106) AT=235.025n

.meas tran vdout0_107ck460 FIND v(dout0_107) AT=235.025n

.meas tran vdout0_108ck460 FIND v(dout0_108) AT=235.025n

.meas tran vdout0_109ck460 FIND v(dout0_109) AT=235.025n

.meas tran vdout0_110ck460 FIND v(dout0_110) AT=235.025n

.meas tran vdout0_111ck460 FIND v(dout0_111) AT=235.025n

.meas tran vdout0_112ck460 FIND v(dout0_112) AT=235.025n

.meas tran vdout0_113ck460 FIND v(dout0_113) AT=235.025n

.meas tran vdout0_114ck460 FIND v(dout0_114) AT=235.025n

.meas tran vdout0_115ck460 FIND v(dout0_115) AT=235.025n

.meas tran vdout0_116ck460 FIND v(dout0_116) AT=235.025n

.meas tran vdout0_117ck460 FIND v(dout0_117) AT=235.025n

.meas tran vdout0_118ck460 FIND v(dout0_118) AT=235.025n

.meas tran vdout0_119ck460 FIND v(dout0_119) AT=235.025n

.meas tran vdout0_120ck460 FIND v(dout0_120) AT=235.025n

.meas tran vdout0_121ck460 FIND v(dout0_121) AT=235.025n

.meas tran vdout0_122ck460 FIND v(dout0_122) AT=235.025n

.meas tran vdout0_123ck460 FIND v(dout0_123) AT=235.025n

.meas tran vdout0_124ck460 FIND v(dout0_124) AT=235.025n

.meas tran vdout0_125ck460 FIND v(dout0_125) AT=235.025n

.meas tran vdout0_126ck460 FIND v(dout0_126) AT=235.025n

.meas tran vdout0_127ck460 FIND v(dout0_127) AT=235.025n

.meas tran vdout0_0ck480 FIND v(dout0_0) AT=245.025n

.meas tran vdout0_1ck480 FIND v(dout0_1) AT=245.025n

.meas tran vdout0_2ck480 FIND v(dout0_2) AT=245.025n

.meas tran vdout0_3ck480 FIND v(dout0_3) AT=245.025n

.meas tran vdout0_4ck480 FIND v(dout0_4) AT=245.025n

.meas tran vdout0_5ck480 FIND v(dout0_5) AT=245.025n

.meas tran vdout0_6ck480 FIND v(dout0_6) AT=245.025n

.meas tran vdout0_7ck480 FIND v(dout0_7) AT=245.025n

.meas tran vdout0_8ck480 FIND v(dout0_8) AT=245.025n

.meas tran vdout0_9ck480 FIND v(dout0_9) AT=245.025n

.meas tran vdout0_10ck480 FIND v(dout0_10) AT=245.025n

.meas tran vdout0_11ck480 FIND v(dout0_11) AT=245.025n

.meas tran vdout0_12ck480 FIND v(dout0_12) AT=245.025n

.meas tran vdout0_13ck480 FIND v(dout0_13) AT=245.025n

.meas tran vdout0_14ck480 FIND v(dout0_14) AT=245.025n

.meas tran vdout0_15ck480 FIND v(dout0_15) AT=245.025n

.meas tran vdout0_16ck480 FIND v(dout0_16) AT=245.025n

.meas tran vdout0_17ck480 FIND v(dout0_17) AT=245.025n

.meas tran vdout0_18ck480 FIND v(dout0_18) AT=245.025n

.meas tran vdout0_19ck480 FIND v(dout0_19) AT=245.025n

.meas tran vdout0_20ck480 FIND v(dout0_20) AT=245.025n

.meas tran vdout0_21ck480 FIND v(dout0_21) AT=245.025n

.meas tran vdout0_22ck480 FIND v(dout0_22) AT=245.025n

.meas tran vdout0_23ck480 FIND v(dout0_23) AT=245.025n

.meas tran vdout0_24ck480 FIND v(dout0_24) AT=245.025n

.meas tran vdout0_25ck480 FIND v(dout0_25) AT=245.025n

.meas tran vdout0_26ck480 FIND v(dout0_26) AT=245.025n

.meas tran vdout0_27ck480 FIND v(dout0_27) AT=245.025n

.meas tran vdout0_28ck480 FIND v(dout0_28) AT=245.025n

.meas tran vdout0_29ck480 FIND v(dout0_29) AT=245.025n

.meas tran vdout0_30ck480 FIND v(dout0_30) AT=245.025n

.meas tran vdout0_31ck480 FIND v(dout0_31) AT=245.025n

.meas tran vdout0_32ck480 FIND v(dout0_32) AT=245.025n

.meas tran vdout0_33ck480 FIND v(dout0_33) AT=245.025n

.meas tran vdout0_34ck480 FIND v(dout0_34) AT=245.025n

.meas tran vdout0_35ck480 FIND v(dout0_35) AT=245.025n

.meas tran vdout0_36ck480 FIND v(dout0_36) AT=245.025n

.meas tran vdout0_37ck480 FIND v(dout0_37) AT=245.025n

.meas tran vdout0_38ck480 FIND v(dout0_38) AT=245.025n

.meas tran vdout0_39ck480 FIND v(dout0_39) AT=245.025n

.meas tran vdout0_40ck480 FIND v(dout0_40) AT=245.025n

.meas tran vdout0_41ck480 FIND v(dout0_41) AT=245.025n

.meas tran vdout0_42ck480 FIND v(dout0_42) AT=245.025n

.meas tran vdout0_43ck480 FIND v(dout0_43) AT=245.025n

.meas tran vdout0_44ck480 FIND v(dout0_44) AT=245.025n

.meas tran vdout0_45ck480 FIND v(dout0_45) AT=245.025n

.meas tran vdout0_46ck480 FIND v(dout0_46) AT=245.025n

.meas tran vdout0_47ck480 FIND v(dout0_47) AT=245.025n

.meas tran vdout0_48ck480 FIND v(dout0_48) AT=245.025n

.meas tran vdout0_49ck480 FIND v(dout0_49) AT=245.025n

.meas tran vdout0_50ck480 FIND v(dout0_50) AT=245.025n

.meas tran vdout0_51ck480 FIND v(dout0_51) AT=245.025n

.meas tran vdout0_52ck480 FIND v(dout0_52) AT=245.025n

.meas tran vdout0_53ck480 FIND v(dout0_53) AT=245.025n

.meas tran vdout0_54ck480 FIND v(dout0_54) AT=245.025n

.meas tran vdout0_55ck480 FIND v(dout0_55) AT=245.025n

.meas tran vdout0_56ck480 FIND v(dout0_56) AT=245.025n

.meas tran vdout0_57ck480 FIND v(dout0_57) AT=245.025n

.meas tran vdout0_58ck480 FIND v(dout0_58) AT=245.025n

.meas tran vdout0_59ck480 FIND v(dout0_59) AT=245.025n

.meas tran vdout0_60ck480 FIND v(dout0_60) AT=245.025n

.meas tran vdout0_61ck480 FIND v(dout0_61) AT=245.025n

.meas tran vdout0_62ck480 FIND v(dout0_62) AT=245.025n

.meas tran vdout0_63ck480 FIND v(dout0_63) AT=245.025n

.meas tran vdout0_64ck480 FIND v(dout0_64) AT=245.025n

.meas tran vdout0_65ck480 FIND v(dout0_65) AT=245.025n

.meas tran vdout0_66ck480 FIND v(dout0_66) AT=245.025n

.meas tran vdout0_67ck480 FIND v(dout0_67) AT=245.025n

.meas tran vdout0_68ck480 FIND v(dout0_68) AT=245.025n

.meas tran vdout0_69ck480 FIND v(dout0_69) AT=245.025n

.meas tran vdout0_70ck480 FIND v(dout0_70) AT=245.025n

.meas tran vdout0_71ck480 FIND v(dout0_71) AT=245.025n

.meas tran vdout0_72ck480 FIND v(dout0_72) AT=245.025n

.meas tran vdout0_73ck480 FIND v(dout0_73) AT=245.025n

.meas tran vdout0_74ck480 FIND v(dout0_74) AT=245.025n

.meas tran vdout0_75ck480 FIND v(dout0_75) AT=245.025n

.meas tran vdout0_76ck480 FIND v(dout0_76) AT=245.025n

.meas tran vdout0_77ck480 FIND v(dout0_77) AT=245.025n

.meas tran vdout0_78ck480 FIND v(dout0_78) AT=245.025n

.meas tran vdout0_79ck480 FIND v(dout0_79) AT=245.025n

.meas tran vdout0_80ck480 FIND v(dout0_80) AT=245.025n

.meas tran vdout0_81ck480 FIND v(dout0_81) AT=245.025n

.meas tran vdout0_82ck480 FIND v(dout0_82) AT=245.025n

.meas tran vdout0_83ck480 FIND v(dout0_83) AT=245.025n

.meas tran vdout0_84ck480 FIND v(dout0_84) AT=245.025n

.meas tran vdout0_85ck480 FIND v(dout0_85) AT=245.025n

.meas tran vdout0_86ck480 FIND v(dout0_86) AT=245.025n

.meas tran vdout0_87ck480 FIND v(dout0_87) AT=245.025n

.meas tran vdout0_88ck480 FIND v(dout0_88) AT=245.025n

.meas tran vdout0_89ck480 FIND v(dout0_89) AT=245.025n

.meas tran vdout0_90ck480 FIND v(dout0_90) AT=245.025n

.meas tran vdout0_91ck480 FIND v(dout0_91) AT=245.025n

.meas tran vdout0_92ck480 FIND v(dout0_92) AT=245.025n

.meas tran vdout0_93ck480 FIND v(dout0_93) AT=245.025n

.meas tran vdout0_94ck480 FIND v(dout0_94) AT=245.025n

.meas tran vdout0_95ck480 FIND v(dout0_95) AT=245.025n

.meas tran vdout0_96ck480 FIND v(dout0_96) AT=245.025n

.meas tran vdout0_97ck480 FIND v(dout0_97) AT=245.025n

.meas tran vdout0_98ck480 FIND v(dout0_98) AT=245.025n

.meas tran vdout0_99ck480 FIND v(dout0_99) AT=245.025n

.meas tran vdout0_100ck480 FIND v(dout0_100) AT=245.025n

.meas tran vdout0_101ck480 FIND v(dout0_101) AT=245.025n

.meas tran vdout0_102ck480 FIND v(dout0_102) AT=245.025n

.meas tran vdout0_103ck480 FIND v(dout0_103) AT=245.025n

.meas tran vdout0_104ck480 FIND v(dout0_104) AT=245.025n

.meas tran vdout0_105ck480 FIND v(dout0_105) AT=245.025n

.meas tran vdout0_106ck480 FIND v(dout0_106) AT=245.025n

.meas tran vdout0_107ck480 FIND v(dout0_107) AT=245.025n

.meas tran vdout0_108ck480 FIND v(dout0_108) AT=245.025n

.meas tran vdout0_109ck480 FIND v(dout0_109) AT=245.025n

.meas tran vdout0_110ck480 FIND v(dout0_110) AT=245.025n

.meas tran vdout0_111ck480 FIND v(dout0_111) AT=245.025n

.meas tran vdout0_112ck480 FIND v(dout0_112) AT=245.025n

.meas tran vdout0_113ck480 FIND v(dout0_113) AT=245.025n

.meas tran vdout0_114ck480 FIND v(dout0_114) AT=245.025n

.meas tran vdout0_115ck480 FIND v(dout0_115) AT=245.025n

.meas tran vdout0_116ck480 FIND v(dout0_116) AT=245.025n

.meas tran vdout0_117ck480 FIND v(dout0_117) AT=245.025n

.meas tran vdout0_118ck480 FIND v(dout0_118) AT=245.025n

.meas tran vdout0_119ck480 FIND v(dout0_119) AT=245.025n

.meas tran vdout0_120ck480 FIND v(dout0_120) AT=245.025n

.meas tran vdout0_121ck480 FIND v(dout0_121) AT=245.025n

.meas tran vdout0_122ck480 FIND v(dout0_122) AT=245.025n

.meas tran vdout0_123ck480 FIND v(dout0_123) AT=245.025n

.meas tran vdout0_124ck480 FIND v(dout0_124) AT=245.025n

.meas tran vdout0_125ck480 FIND v(dout0_125) AT=245.025n

.meas tran vdout0_126ck480 FIND v(dout0_126) AT=245.025n

.meas tran vdout0_127ck480 FIND v(dout0_127) AT=245.025n

.meas tran vdout0_0ck520 FIND v(dout0_0) AT=265.025n

.meas tran vdout0_1ck520 FIND v(dout0_1) AT=265.025n

.meas tran vdout0_2ck520 FIND v(dout0_2) AT=265.025n

.meas tran vdout0_3ck520 FIND v(dout0_3) AT=265.025n

.meas tran vdout0_4ck520 FIND v(dout0_4) AT=265.025n

.meas tran vdout0_5ck520 FIND v(dout0_5) AT=265.025n

.meas tran vdout0_6ck520 FIND v(dout0_6) AT=265.025n

.meas tran vdout0_7ck520 FIND v(dout0_7) AT=265.025n

.meas tran vdout0_8ck520 FIND v(dout0_8) AT=265.025n

.meas tran vdout0_9ck520 FIND v(dout0_9) AT=265.025n

.meas tran vdout0_10ck520 FIND v(dout0_10) AT=265.025n

.meas tran vdout0_11ck520 FIND v(dout0_11) AT=265.025n

.meas tran vdout0_12ck520 FIND v(dout0_12) AT=265.025n

.meas tran vdout0_13ck520 FIND v(dout0_13) AT=265.025n

.meas tran vdout0_14ck520 FIND v(dout0_14) AT=265.025n

.meas tran vdout0_15ck520 FIND v(dout0_15) AT=265.025n

.meas tran vdout0_16ck520 FIND v(dout0_16) AT=265.025n

.meas tran vdout0_17ck520 FIND v(dout0_17) AT=265.025n

.meas tran vdout0_18ck520 FIND v(dout0_18) AT=265.025n

.meas tran vdout0_19ck520 FIND v(dout0_19) AT=265.025n

.meas tran vdout0_20ck520 FIND v(dout0_20) AT=265.025n

.meas tran vdout0_21ck520 FIND v(dout0_21) AT=265.025n

.meas tran vdout0_22ck520 FIND v(dout0_22) AT=265.025n

.meas tran vdout0_23ck520 FIND v(dout0_23) AT=265.025n

.meas tran vdout0_24ck520 FIND v(dout0_24) AT=265.025n

.meas tran vdout0_25ck520 FIND v(dout0_25) AT=265.025n

.meas tran vdout0_26ck520 FIND v(dout0_26) AT=265.025n

.meas tran vdout0_27ck520 FIND v(dout0_27) AT=265.025n

.meas tran vdout0_28ck520 FIND v(dout0_28) AT=265.025n

.meas tran vdout0_29ck520 FIND v(dout0_29) AT=265.025n

.meas tran vdout0_30ck520 FIND v(dout0_30) AT=265.025n

.meas tran vdout0_31ck520 FIND v(dout0_31) AT=265.025n

.meas tran vdout0_32ck520 FIND v(dout0_32) AT=265.025n

.meas tran vdout0_33ck520 FIND v(dout0_33) AT=265.025n

.meas tran vdout0_34ck520 FIND v(dout0_34) AT=265.025n

.meas tran vdout0_35ck520 FIND v(dout0_35) AT=265.025n

.meas tran vdout0_36ck520 FIND v(dout0_36) AT=265.025n

.meas tran vdout0_37ck520 FIND v(dout0_37) AT=265.025n

.meas tran vdout0_38ck520 FIND v(dout0_38) AT=265.025n

.meas tran vdout0_39ck520 FIND v(dout0_39) AT=265.025n

.meas tran vdout0_40ck520 FIND v(dout0_40) AT=265.025n

.meas tran vdout0_41ck520 FIND v(dout0_41) AT=265.025n

.meas tran vdout0_42ck520 FIND v(dout0_42) AT=265.025n

.meas tran vdout0_43ck520 FIND v(dout0_43) AT=265.025n

.meas tran vdout0_44ck520 FIND v(dout0_44) AT=265.025n

.meas tran vdout0_45ck520 FIND v(dout0_45) AT=265.025n

.meas tran vdout0_46ck520 FIND v(dout0_46) AT=265.025n

.meas tran vdout0_47ck520 FIND v(dout0_47) AT=265.025n

.meas tran vdout0_48ck520 FIND v(dout0_48) AT=265.025n

.meas tran vdout0_49ck520 FIND v(dout0_49) AT=265.025n

.meas tran vdout0_50ck520 FIND v(dout0_50) AT=265.025n

.meas tran vdout0_51ck520 FIND v(dout0_51) AT=265.025n

.meas tran vdout0_52ck520 FIND v(dout0_52) AT=265.025n

.meas tran vdout0_53ck520 FIND v(dout0_53) AT=265.025n

.meas tran vdout0_54ck520 FIND v(dout0_54) AT=265.025n

.meas tran vdout0_55ck520 FIND v(dout0_55) AT=265.025n

.meas tran vdout0_56ck520 FIND v(dout0_56) AT=265.025n

.meas tran vdout0_57ck520 FIND v(dout0_57) AT=265.025n

.meas tran vdout0_58ck520 FIND v(dout0_58) AT=265.025n

.meas tran vdout0_59ck520 FIND v(dout0_59) AT=265.025n

.meas tran vdout0_60ck520 FIND v(dout0_60) AT=265.025n

.meas tran vdout0_61ck520 FIND v(dout0_61) AT=265.025n

.meas tran vdout0_62ck520 FIND v(dout0_62) AT=265.025n

.meas tran vdout0_63ck520 FIND v(dout0_63) AT=265.025n

.meas tran vdout0_64ck520 FIND v(dout0_64) AT=265.025n

.meas tran vdout0_65ck520 FIND v(dout0_65) AT=265.025n

.meas tran vdout0_66ck520 FIND v(dout0_66) AT=265.025n

.meas tran vdout0_67ck520 FIND v(dout0_67) AT=265.025n

.meas tran vdout0_68ck520 FIND v(dout0_68) AT=265.025n

.meas tran vdout0_69ck520 FIND v(dout0_69) AT=265.025n

.meas tran vdout0_70ck520 FIND v(dout0_70) AT=265.025n

.meas tran vdout0_71ck520 FIND v(dout0_71) AT=265.025n

.meas tran vdout0_72ck520 FIND v(dout0_72) AT=265.025n

.meas tran vdout0_73ck520 FIND v(dout0_73) AT=265.025n

.meas tran vdout0_74ck520 FIND v(dout0_74) AT=265.025n

.meas tran vdout0_75ck520 FIND v(dout0_75) AT=265.025n

.meas tran vdout0_76ck520 FIND v(dout0_76) AT=265.025n

.meas tran vdout0_77ck520 FIND v(dout0_77) AT=265.025n

.meas tran vdout0_78ck520 FIND v(dout0_78) AT=265.025n

.meas tran vdout0_79ck520 FIND v(dout0_79) AT=265.025n

.meas tran vdout0_80ck520 FIND v(dout0_80) AT=265.025n

.meas tran vdout0_81ck520 FIND v(dout0_81) AT=265.025n

.meas tran vdout0_82ck520 FIND v(dout0_82) AT=265.025n

.meas tran vdout0_83ck520 FIND v(dout0_83) AT=265.025n

.meas tran vdout0_84ck520 FIND v(dout0_84) AT=265.025n

.meas tran vdout0_85ck520 FIND v(dout0_85) AT=265.025n

.meas tran vdout0_86ck520 FIND v(dout0_86) AT=265.025n

.meas tran vdout0_87ck520 FIND v(dout0_87) AT=265.025n

.meas tran vdout0_88ck520 FIND v(dout0_88) AT=265.025n

.meas tran vdout0_89ck520 FIND v(dout0_89) AT=265.025n

.meas tran vdout0_90ck520 FIND v(dout0_90) AT=265.025n

.meas tran vdout0_91ck520 FIND v(dout0_91) AT=265.025n

.meas tran vdout0_92ck520 FIND v(dout0_92) AT=265.025n

.meas tran vdout0_93ck520 FIND v(dout0_93) AT=265.025n

.meas tran vdout0_94ck520 FIND v(dout0_94) AT=265.025n

.meas tran vdout0_95ck520 FIND v(dout0_95) AT=265.025n

.meas tran vdout0_96ck520 FIND v(dout0_96) AT=265.025n

.meas tran vdout0_97ck520 FIND v(dout0_97) AT=265.025n

.meas tran vdout0_98ck520 FIND v(dout0_98) AT=265.025n

.meas tran vdout0_99ck520 FIND v(dout0_99) AT=265.025n

.meas tran vdout0_100ck520 FIND v(dout0_100) AT=265.025n

.meas tran vdout0_101ck520 FIND v(dout0_101) AT=265.025n

.meas tran vdout0_102ck520 FIND v(dout0_102) AT=265.025n

.meas tran vdout0_103ck520 FIND v(dout0_103) AT=265.025n

.meas tran vdout0_104ck520 FIND v(dout0_104) AT=265.025n

.meas tran vdout0_105ck520 FIND v(dout0_105) AT=265.025n

.meas tran vdout0_106ck520 FIND v(dout0_106) AT=265.025n

.meas tran vdout0_107ck520 FIND v(dout0_107) AT=265.025n

.meas tran vdout0_108ck520 FIND v(dout0_108) AT=265.025n

.meas tran vdout0_109ck520 FIND v(dout0_109) AT=265.025n

.meas tran vdout0_110ck520 FIND v(dout0_110) AT=265.025n

.meas tran vdout0_111ck520 FIND v(dout0_111) AT=265.025n

.meas tran vdout0_112ck520 FIND v(dout0_112) AT=265.025n

.meas tran vdout0_113ck520 FIND v(dout0_113) AT=265.025n

.meas tran vdout0_114ck520 FIND v(dout0_114) AT=265.025n

.meas tran vdout0_115ck520 FIND v(dout0_115) AT=265.025n

.meas tran vdout0_116ck520 FIND v(dout0_116) AT=265.025n

.meas tran vdout0_117ck520 FIND v(dout0_117) AT=265.025n

.meas tran vdout0_118ck520 FIND v(dout0_118) AT=265.025n

.meas tran vdout0_119ck520 FIND v(dout0_119) AT=265.025n

.meas tran vdout0_120ck520 FIND v(dout0_120) AT=265.025n

.meas tran vdout0_121ck520 FIND v(dout0_121) AT=265.025n

.meas tran vdout0_122ck520 FIND v(dout0_122) AT=265.025n

.meas tran vdout0_123ck520 FIND v(dout0_123) AT=265.025n

.meas tran vdout0_124ck520 FIND v(dout0_124) AT=265.025n

.meas tran vdout0_125ck520 FIND v(dout0_125) AT=265.025n

.meas tran vdout0_126ck520 FIND v(dout0_126) AT=265.025n

.meas tran vdout0_127ck520 FIND v(dout0_127) AT=265.025n

.meas tran vdout0_0ck560 FIND v(dout0_0) AT=285.025n

.meas tran vdout0_1ck560 FIND v(dout0_1) AT=285.025n

.meas tran vdout0_2ck560 FIND v(dout0_2) AT=285.025n

.meas tran vdout0_3ck560 FIND v(dout0_3) AT=285.025n

.meas tran vdout0_4ck560 FIND v(dout0_4) AT=285.025n

.meas tran vdout0_5ck560 FIND v(dout0_5) AT=285.025n

.meas tran vdout0_6ck560 FIND v(dout0_6) AT=285.025n

.meas tran vdout0_7ck560 FIND v(dout0_7) AT=285.025n

.meas tran vdout0_8ck560 FIND v(dout0_8) AT=285.025n

.meas tran vdout0_9ck560 FIND v(dout0_9) AT=285.025n

.meas tran vdout0_10ck560 FIND v(dout0_10) AT=285.025n

.meas tran vdout0_11ck560 FIND v(dout0_11) AT=285.025n

.meas tran vdout0_12ck560 FIND v(dout0_12) AT=285.025n

.meas tran vdout0_13ck560 FIND v(dout0_13) AT=285.025n

.meas tran vdout0_14ck560 FIND v(dout0_14) AT=285.025n

.meas tran vdout0_15ck560 FIND v(dout0_15) AT=285.025n

.meas tran vdout0_16ck560 FIND v(dout0_16) AT=285.025n

.meas tran vdout0_17ck560 FIND v(dout0_17) AT=285.025n

.meas tran vdout0_18ck560 FIND v(dout0_18) AT=285.025n

.meas tran vdout0_19ck560 FIND v(dout0_19) AT=285.025n

.meas tran vdout0_20ck560 FIND v(dout0_20) AT=285.025n

.meas tran vdout0_21ck560 FIND v(dout0_21) AT=285.025n

.meas tran vdout0_22ck560 FIND v(dout0_22) AT=285.025n

.meas tran vdout0_23ck560 FIND v(dout0_23) AT=285.025n

.meas tran vdout0_24ck560 FIND v(dout0_24) AT=285.025n

.meas tran vdout0_25ck560 FIND v(dout0_25) AT=285.025n

.meas tran vdout0_26ck560 FIND v(dout0_26) AT=285.025n

.meas tran vdout0_27ck560 FIND v(dout0_27) AT=285.025n

.meas tran vdout0_28ck560 FIND v(dout0_28) AT=285.025n

.meas tran vdout0_29ck560 FIND v(dout0_29) AT=285.025n

.meas tran vdout0_30ck560 FIND v(dout0_30) AT=285.025n

.meas tran vdout0_31ck560 FIND v(dout0_31) AT=285.025n

.meas tran vdout0_32ck560 FIND v(dout0_32) AT=285.025n

.meas tran vdout0_33ck560 FIND v(dout0_33) AT=285.025n

.meas tran vdout0_34ck560 FIND v(dout0_34) AT=285.025n

.meas tran vdout0_35ck560 FIND v(dout0_35) AT=285.025n

.meas tran vdout0_36ck560 FIND v(dout0_36) AT=285.025n

.meas tran vdout0_37ck560 FIND v(dout0_37) AT=285.025n

.meas tran vdout0_38ck560 FIND v(dout0_38) AT=285.025n

.meas tran vdout0_39ck560 FIND v(dout0_39) AT=285.025n

.meas tran vdout0_40ck560 FIND v(dout0_40) AT=285.025n

.meas tran vdout0_41ck560 FIND v(dout0_41) AT=285.025n

.meas tran vdout0_42ck560 FIND v(dout0_42) AT=285.025n

.meas tran vdout0_43ck560 FIND v(dout0_43) AT=285.025n

.meas tran vdout0_44ck560 FIND v(dout0_44) AT=285.025n

.meas tran vdout0_45ck560 FIND v(dout0_45) AT=285.025n

.meas tran vdout0_46ck560 FIND v(dout0_46) AT=285.025n

.meas tran vdout0_47ck560 FIND v(dout0_47) AT=285.025n

.meas tran vdout0_48ck560 FIND v(dout0_48) AT=285.025n

.meas tran vdout0_49ck560 FIND v(dout0_49) AT=285.025n

.meas tran vdout0_50ck560 FIND v(dout0_50) AT=285.025n

.meas tran vdout0_51ck560 FIND v(dout0_51) AT=285.025n

.meas tran vdout0_52ck560 FIND v(dout0_52) AT=285.025n

.meas tran vdout0_53ck560 FIND v(dout0_53) AT=285.025n

.meas tran vdout0_54ck560 FIND v(dout0_54) AT=285.025n

.meas tran vdout0_55ck560 FIND v(dout0_55) AT=285.025n

.meas tran vdout0_56ck560 FIND v(dout0_56) AT=285.025n

.meas tran vdout0_57ck560 FIND v(dout0_57) AT=285.025n

.meas tran vdout0_58ck560 FIND v(dout0_58) AT=285.025n

.meas tran vdout0_59ck560 FIND v(dout0_59) AT=285.025n

.meas tran vdout0_60ck560 FIND v(dout0_60) AT=285.025n

.meas tran vdout0_61ck560 FIND v(dout0_61) AT=285.025n

.meas tran vdout0_62ck560 FIND v(dout0_62) AT=285.025n

.meas tran vdout0_63ck560 FIND v(dout0_63) AT=285.025n

.meas tran vdout0_64ck560 FIND v(dout0_64) AT=285.025n

.meas tran vdout0_65ck560 FIND v(dout0_65) AT=285.025n

.meas tran vdout0_66ck560 FIND v(dout0_66) AT=285.025n

.meas tran vdout0_67ck560 FIND v(dout0_67) AT=285.025n

.meas tran vdout0_68ck560 FIND v(dout0_68) AT=285.025n

.meas tran vdout0_69ck560 FIND v(dout0_69) AT=285.025n

.meas tran vdout0_70ck560 FIND v(dout0_70) AT=285.025n

.meas tran vdout0_71ck560 FIND v(dout0_71) AT=285.025n

.meas tran vdout0_72ck560 FIND v(dout0_72) AT=285.025n

.meas tran vdout0_73ck560 FIND v(dout0_73) AT=285.025n

.meas tran vdout0_74ck560 FIND v(dout0_74) AT=285.025n

.meas tran vdout0_75ck560 FIND v(dout0_75) AT=285.025n

.meas tran vdout0_76ck560 FIND v(dout0_76) AT=285.025n

.meas tran vdout0_77ck560 FIND v(dout0_77) AT=285.025n

.meas tran vdout0_78ck560 FIND v(dout0_78) AT=285.025n

.meas tran vdout0_79ck560 FIND v(dout0_79) AT=285.025n

.meas tran vdout0_80ck560 FIND v(dout0_80) AT=285.025n

.meas tran vdout0_81ck560 FIND v(dout0_81) AT=285.025n

.meas tran vdout0_82ck560 FIND v(dout0_82) AT=285.025n

.meas tran vdout0_83ck560 FIND v(dout0_83) AT=285.025n

.meas tran vdout0_84ck560 FIND v(dout0_84) AT=285.025n

.meas tran vdout0_85ck560 FIND v(dout0_85) AT=285.025n

.meas tran vdout0_86ck560 FIND v(dout0_86) AT=285.025n

.meas tran vdout0_87ck560 FIND v(dout0_87) AT=285.025n

.meas tran vdout0_88ck560 FIND v(dout0_88) AT=285.025n

.meas tran vdout0_89ck560 FIND v(dout0_89) AT=285.025n

.meas tran vdout0_90ck560 FIND v(dout0_90) AT=285.025n

.meas tran vdout0_91ck560 FIND v(dout0_91) AT=285.025n

.meas tran vdout0_92ck560 FIND v(dout0_92) AT=285.025n

.meas tran vdout0_93ck560 FIND v(dout0_93) AT=285.025n

.meas tran vdout0_94ck560 FIND v(dout0_94) AT=285.025n

.meas tran vdout0_95ck560 FIND v(dout0_95) AT=285.025n

.meas tran vdout0_96ck560 FIND v(dout0_96) AT=285.025n

.meas tran vdout0_97ck560 FIND v(dout0_97) AT=285.025n

.meas tran vdout0_98ck560 FIND v(dout0_98) AT=285.025n

.meas tran vdout0_99ck560 FIND v(dout0_99) AT=285.025n

.meas tran vdout0_100ck560 FIND v(dout0_100) AT=285.025n

.meas tran vdout0_101ck560 FIND v(dout0_101) AT=285.025n

.meas tran vdout0_102ck560 FIND v(dout0_102) AT=285.025n

.meas tran vdout0_103ck560 FIND v(dout0_103) AT=285.025n

.meas tran vdout0_104ck560 FIND v(dout0_104) AT=285.025n

.meas tran vdout0_105ck560 FIND v(dout0_105) AT=285.025n

.meas tran vdout0_106ck560 FIND v(dout0_106) AT=285.025n

.meas tran vdout0_107ck560 FIND v(dout0_107) AT=285.025n

.meas tran vdout0_108ck560 FIND v(dout0_108) AT=285.025n

.meas tran vdout0_109ck560 FIND v(dout0_109) AT=285.025n

.meas tran vdout0_110ck560 FIND v(dout0_110) AT=285.025n

.meas tran vdout0_111ck560 FIND v(dout0_111) AT=285.025n

.meas tran vdout0_112ck560 FIND v(dout0_112) AT=285.025n

.meas tran vdout0_113ck560 FIND v(dout0_113) AT=285.025n

.meas tran vdout0_114ck560 FIND v(dout0_114) AT=285.025n

.meas tran vdout0_115ck560 FIND v(dout0_115) AT=285.025n

.meas tran vdout0_116ck560 FIND v(dout0_116) AT=285.025n

.meas tran vdout0_117ck560 FIND v(dout0_117) AT=285.025n

.meas tran vdout0_118ck560 FIND v(dout0_118) AT=285.025n

.meas tran vdout0_119ck560 FIND v(dout0_119) AT=285.025n

.meas tran vdout0_120ck560 FIND v(dout0_120) AT=285.025n

.meas tran vdout0_121ck560 FIND v(dout0_121) AT=285.025n

.meas tran vdout0_122ck560 FIND v(dout0_122) AT=285.025n

.meas tran vdout0_123ck560 FIND v(dout0_123) AT=285.025n

.meas tran vdout0_124ck560 FIND v(dout0_124) AT=285.025n

.meas tran vdout0_125ck560 FIND v(dout0_125) AT=285.025n

.meas tran vdout0_126ck560 FIND v(dout0_126) AT=285.025n

.meas tran vdout0_127ck560 FIND v(dout0_127) AT=285.025n

.meas tran vdout0_0ck580 FIND v(dout0_0) AT=295.025n

.meas tran vdout0_1ck580 FIND v(dout0_1) AT=295.025n

.meas tran vdout0_2ck580 FIND v(dout0_2) AT=295.025n

.meas tran vdout0_3ck580 FIND v(dout0_3) AT=295.025n

.meas tran vdout0_4ck580 FIND v(dout0_4) AT=295.025n

.meas tran vdout0_5ck580 FIND v(dout0_5) AT=295.025n

.meas tran vdout0_6ck580 FIND v(dout0_6) AT=295.025n

.meas tran vdout0_7ck580 FIND v(dout0_7) AT=295.025n

.meas tran vdout0_8ck580 FIND v(dout0_8) AT=295.025n

.meas tran vdout0_9ck580 FIND v(dout0_9) AT=295.025n

.meas tran vdout0_10ck580 FIND v(dout0_10) AT=295.025n

.meas tran vdout0_11ck580 FIND v(dout0_11) AT=295.025n

.meas tran vdout0_12ck580 FIND v(dout0_12) AT=295.025n

.meas tran vdout0_13ck580 FIND v(dout0_13) AT=295.025n

.meas tran vdout0_14ck580 FIND v(dout0_14) AT=295.025n

.meas tran vdout0_15ck580 FIND v(dout0_15) AT=295.025n

.meas tran vdout0_16ck580 FIND v(dout0_16) AT=295.025n

.meas tran vdout0_17ck580 FIND v(dout0_17) AT=295.025n

.meas tran vdout0_18ck580 FIND v(dout0_18) AT=295.025n

.meas tran vdout0_19ck580 FIND v(dout0_19) AT=295.025n

.meas tran vdout0_20ck580 FIND v(dout0_20) AT=295.025n

.meas tran vdout0_21ck580 FIND v(dout0_21) AT=295.025n

.meas tran vdout0_22ck580 FIND v(dout0_22) AT=295.025n

.meas tran vdout0_23ck580 FIND v(dout0_23) AT=295.025n

.meas tran vdout0_24ck580 FIND v(dout0_24) AT=295.025n

.meas tran vdout0_25ck580 FIND v(dout0_25) AT=295.025n

.meas tran vdout0_26ck580 FIND v(dout0_26) AT=295.025n

.meas tran vdout0_27ck580 FIND v(dout0_27) AT=295.025n

.meas tran vdout0_28ck580 FIND v(dout0_28) AT=295.025n

.meas tran vdout0_29ck580 FIND v(dout0_29) AT=295.025n

.meas tran vdout0_30ck580 FIND v(dout0_30) AT=295.025n

.meas tran vdout0_31ck580 FIND v(dout0_31) AT=295.025n

.meas tran vdout0_32ck580 FIND v(dout0_32) AT=295.025n

.meas tran vdout0_33ck580 FIND v(dout0_33) AT=295.025n

.meas tran vdout0_34ck580 FIND v(dout0_34) AT=295.025n

.meas tran vdout0_35ck580 FIND v(dout0_35) AT=295.025n

.meas tran vdout0_36ck580 FIND v(dout0_36) AT=295.025n

.meas tran vdout0_37ck580 FIND v(dout0_37) AT=295.025n

.meas tran vdout0_38ck580 FIND v(dout0_38) AT=295.025n

.meas tran vdout0_39ck580 FIND v(dout0_39) AT=295.025n

.meas tran vdout0_40ck580 FIND v(dout0_40) AT=295.025n

.meas tran vdout0_41ck580 FIND v(dout0_41) AT=295.025n

.meas tran vdout0_42ck580 FIND v(dout0_42) AT=295.025n

.meas tran vdout0_43ck580 FIND v(dout0_43) AT=295.025n

.meas tran vdout0_44ck580 FIND v(dout0_44) AT=295.025n

.meas tran vdout0_45ck580 FIND v(dout0_45) AT=295.025n

.meas tran vdout0_46ck580 FIND v(dout0_46) AT=295.025n

.meas tran vdout0_47ck580 FIND v(dout0_47) AT=295.025n

.meas tran vdout0_48ck580 FIND v(dout0_48) AT=295.025n

.meas tran vdout0_49ck580 FIND v(dout0_49) AT=295.025n

.meas tran vdout0_50ck580 FIND v(dout0_50) AT=295.025n

.meas tran vdout0_51ck580 FIND v(dout0_51) AT=295.025n

.meas tran vdout0_52ck580 FIND v(dout0_52) AT=295.025n

.meas tran vdout0_53ck580 FIND v(dout0_53) AT=295.025n

.meas tran vdout0_54ck580 FIND v(dout0_54) AT=295.025n

.meas tran vdout0_55ck580 FIND v(dout0_55) AT=295.025n

.meas tran vdout0_56ck580 FIND v(dout0_56) AT=295.025n

.meas tran vdout0_57ck580 FIND v(dout0_57) AT=295.025n

.meas tran vdout0_58ck580 FIND v(dout0_58) AT=295.025n

.meas tran vdout0_59ck580 FIND v(dout0_59) AT=295.025n

.meas tran vdout0_60ck580 FIND v(dout0_60) AT=295.025n

.meas tran vdout0_61ck580 FIND v(dout0_61) AT=295.025n

.meas tran vdout0_62ck580 FIND v(dout0_62) AT=295.025n

.meas tran vdout0_63ck580 FIND v(dout0_63) AT=295.025n

.meas tran vdout0_64ck580 FIND v(dout0_64) AT=295.025n

.meas tran vdout0_65ck580 FIND v(dout0_65) AT=295.025n

.meas tran vdout0_66ck580 FIND v(dout0_66) AT=295.025n

.meas tran vdout0_67ck580 FIND v(dout0_67) AT=295.025n

.meas tran vdout0_68ck580 FIND v(dout0_68) AT=295.025n

.meas tran vdout0_69ck580 FIND v(dout0_69) AT=295.025n

.meas tran vdout0_70ck580 FIND v(dout0_70) AT=295.025n

.meas tran vdout0_71ck580 FIND v(dout0_71) AT=295.025n

.meas tran vdout0_72ck580 FIND v(dout0_72) AT=295.025n

.meas tran vdout0_73ck580 FIND v(dout0_73) AT=295.025n

.meas tran vdout0_74ck580 FIND v(dout0_74) AT=295.025n

.meas tran vdout0_75ck580 FIND v(dout0_75) AT=295.025n

.meas tran vdout0_76ck580 FIND v(dout0_76) AT=295.025n

.meas tran vdout0_77ck580 FIND v(dout0_77) AT=295.025n

.meas tran vdout0_78ck580 FIND v(dout0_78) AT=295.025n

.meas tran vdout0_79ck580 FIND v(dout0_79) AT=295.025n

.meas tran vdout0_80ck580 FIND v(dout0_80) AT=295.025n

.meas tran vdout0_81ck580 FIND v(dout0_81) AT=295.025n

.meas tran vdout0_82ck580 FIND v(dout0_82) AT=295.025n

.meas tran vdout0_83ck580 FIND v(dout0_83) AT=295.025n

.meas tran vdout0_84ck580 FIND v(dout0_84) AT=295.025n

.meas tran vdout0_85ck580 FIND v(dout0_85) AT=295.025n

.meas tran vdout0_86ck580 FIND v(dout0_86) AT=295.025n

.meas tran vdout0_87ck580 FIND v(dout0_87) AT=295.025n

.meas tran vdout0_88ck580 FIND v(dout0_88) AT=295.025n

.meas tran vdout0_89ck580 FIND v(dout0_89) AT=295.025n

.meas tran vdout0_90ck580 FIND v(dout0_90) AT=295.025n

.meas tran vdout0_91ck580 FIND v(dout0_91) AT=295.025n

.meas tran vdout0_92ck580 FIND v(dout0_92) AT=295.025n

.meas tran vdout0_93ck580 FIND v(dout0_93) AT=295.025n

.meas tran vdout0_94ck580 FIND v(dout0_94) AT=295.025n

.meas tran vdout0_95ck580 FIND v(dout0_95) AT=295.025n

.meas tran vdout0_96ck580 FIND v(dout0_96) AT=295.025n

.meas tran vdout0_97ck580 FIND v(dout0_97) AT=295.025n

.meas tran vdout0_98ck580 FIND v(dout0_98) AT=295.025n

.meas tran vdout0_99ck580 FIND v(dout0_99) AT=295.025n

.meas tran vdout0_100ck580 FIND v(dout0_100) AT=295.025n

.meas tran vdout0_101ck580 FIND v(dout0_101) AT=295.025n

.meas tran vdout0_102ck580 FIND v(dout0_102) AT=295.025n

.meas tran vdout0_103ck580 FIND v(dout0_103) AT=295.025n

.meas tran vdout0_104ck580 FIND v(dout0_104) AT=295.025n

.meas tran vdout0_105ck580 FIND v(dout0_105) AT=295.025n

.meas tran vdout0_106ck580 FIND v(dout0_106) AT=295.025n

.meas tran vdout0_107ck580 FIND v(dout0_107) AT=295.025n

.meas tran vdout0_108ck580 FIND v(dout0_108) AT=295.025n

.meas tran vdout0_109ck580 FIND v(dout0_109) AT=295.025n

.meas tran vdout0_110ck580 FIND v(dout0_110) AT=295.025n

.meas tran vdout0_111ck580 FIND v(dout0_111) AT=295.025n

.meas tran vdout0_112ck580 FIND v(dout0_112) AT=295.025n

.meas tran vdout0_113ck580 FIND v(dout0_113) AT=295.025n

.meas tran vdout0_114ck580 FIND v(dout0_114) AT=295.025n

.meas tran vdout0_115ck580 FIND v(dout0_115) AT=295.025n

.meas tran vdout0_116ck580 FIND v(dout0_116) AT=295.025n

.meas tran vdout0_117ck580 FIND v(dout0_117) AT=295.025n

.meas tran vdout0_118ck580 FIND v(dout0_118) AT=295.025n

.meas tran vdout0_119ck580 FIND v(dout0_119) AT=295.025n

.meas tran vdout0_120ck580 FIND v(dout0_120) AT=295.025n

.meas tran vdout0_121ck580 FIND v(dout0_121) AT=295.025n

.meas tran vdout0_122ck580 FIND v(dout0_122) AT=295.025n

.meas tran vdout0_123ck580 FIND v(dout0_123) AT=295.025n

.meas tran vdout0_124ck580 FIND v(dout0_124) AT=295.025n

.meas tran vdout0_125ck580 FIND v(dout0_125) AT=295.025n

.meas tran vdout0_126ck580 FIND v(dout0_126) AT=295.025n

.meas tran vdout0_127ck580 FIND v(dout0_127) AT=295.025n

.meas tran vdout0_0ck590 FIND v(dout0_0) AT=300.025n

.meas tran vdout0_1ck590 FIND v(dout0_1) AT=300.025n

.meas tran vdout0_2ck590 FIND v(dout0_2) AT=300.025n

.meas tran vdout0_3ck590 FIND v(dout0_3) AT=300.025n

.meas tran vdout0_4ck590 FIND v(dout0_4) AT=300.025n

.meas tran vdout0_5ck590 FIND v(dout0_5) AT=300.025n

.meas tran vdout0_6ck590 FIND v(dout0_6) AT=300.025n

.meas tran vdout0_7ck590 FIND v(dout0_7) AT=300.025n

.meas tran vdout0_8ck590 FIND v(dout0_8) AT=300.025n

.meas tran vdout0_9ck590 FIND v(dout0_9) AT=300.025n

.meas tran vdout0_10ck590 FIND v(dout0_10) AT=300.025n

.meas tran vdout0_11ck590 FIND v(dout0_11) AT=300.025n

.meas tran vdout0_12ck590 FIND v(dout0_12) AT=300.025n

.meas tran vdout0_13ck590 FIND v(dout0_13) AT=300.025n

.meas tran vdout0_14ck590 FIND v(dout0_14) AT=300.025n

.meas tran vdout0_15ck590 FIND v(dout0_15) AT=300.025n

.meas tran vdout0_16ck590 FIND v(dout0_16) AT=300.025n

.meas tran vdout0_17ck590 FIND v(dout0_17) AT=300.025n

.meas tran vdout0_18ck590 FIND v(dout0_18) AT=300.025n

.meas tran vdout0_19ck590 FIND v(dout0_19) AT=300.025n

.meas tran vdout0_20ck590 FIND v(dout0_20) AT=300.025n

.meas tran vdout0_21ck590 FIND v(dout0_21) AT=300.025n

.meas tran vdout0_22ck590 FIND v(dout0_22) AT=300.025n

.meas tran vdout0_23ck590 FIND v(dout0_23) AT=300.025n

.meas tran vdout0_24ck590 FIND v(dout0_24) AT=300.025n

.meas tran vdout0_25ck590 FIND v(dout0_25) AT=300.025n

.meas tran vdout0_26ck590 FIND v(dout0_26) AT=300.025n

.meas tran vdout0_27ck590 FIND v(dout0_27) AT=300.025n

.meas tran vdout0_28ck590 FIND v(dout0_28) AT=300.025n

.meas tran vdout0_29ck590 FIND v(dout0_29) AT=300.025n

.meas tran vdout0_30ck590 FIND v(dout0_30) AT=300.025n

.meas tran vdout0_31ck590 FIND v(dout0_31) AT=300.025n

.meas tran vdout0_32ck590 FIND v(dout0_32) AT=300.025n

.meas tran vdout0_33ck590 FIND v(dout0_33) AT=300.025n

.meas tran vdout0_34ck590 FIND v(dout0_34) AT=300.025n

.meas tran vdout0_35ck590 FIND v(dout0_35) AT=300.025n

.meas tran vdout0_36ck590 FIND v(dout0_36) AT=300.025n

.meas tran vdout0_37ck590 FIND v(dout0_37) AT=300.025n

.meas tran vdout0_38ck590 FIND v(dout0_38) AT=300.025n

.meas tran vdout0_39ck590 FIND v(dout0_39) AT=300.025n

.meas tran vdout0_40ck590 FIND v(dout0_40) AT=300.025n

.meas tran vdout0_41ck590 FIND v(dout0_41) AT=300.025n

.meas tran vdout0_42ck590 FIND v(dout0_42) AT=300.025n

.meas tran vdout0_43ck590 FIND v(dout0_43) AT=300.025n

.meas tran vdout0_44ck590 FIND v(dout0_44) AT=300.025n

.meas tran vdout0_45ck590 FIND v(dout0_45) AT=300.025n

.meas tran vdout0_46ck590 FIND v(dout0_46) AT=300.025n

.meas tran vdout0_47ck590 FIND v(dout0_47) AT=300.025n

.meas tran vdout0_48ck590 FIND v(dout0_48) AT=300.025n

.meas tran vdout0_49ck590 FIND v(dout0_49) AT=300.025n

.meas tran vdout0_50ck590 FIND v(dout0_50) AT=300.025n

.meas tran vdout0_51ck590 FIND v(dout0_51) AT=300.025n

.meas tran vdout0_52ck590 FIND v(dout0_52) AT=300.025n

.meas tran vdout0_53ck590 FIND v(dout0_53) AT=300.025n

.meas tran vdout0_54ck590 FIND v(dout0_54) AT=300.025n

.meas tran vdout0_55ck590 FIND v(dout0_55) AT=300.025n

.meas tran vdout0_56ck590 FIND v(dout0_56) AT=300.025n

.meas tran vdout0_57ck590 FIND v(dout0_57) AT=300.025n

.meas tran vdout0_58ck590 FIND v(dout0_58) AT=300.025n

.meas tran vdout0_59ck590 FIND v(dout0_59) AT=300.025n

.meas tran vdout0_60ck590 FIND v(dout0_60) AT=300.025n

.meas tran vdout0_61ck590 FIND v(dout0_61) AT=300.025n

.meas tran vdout0_62ck590 FIND v(dout0_62) AT=300.025n

.meas tran vdout0_63ck590 FIND v(dout0_63) AT=300.025n

.meas tran vdout0_64ck590 FIND v(dout0_64) AT=300.025n

.meas tran vdout0_65ck590 FIND v(dout0_65) AT=300.025n

.meas tran vdout0_66ck590 FIND v(dout0_66) AT=300.025n

.meas tran vdout0_67ck590 FIND v(dout0_67) AT=300.025n

.meas tran vdout0_68ck590 FIND v(dout0_68) AT=300.025n

.meas tran vdout0_69ck590 FIND v(dout0_69) AT=300.025n

.meas tran vdout0_70ck590 FIND v(dout0_70) AT=300.025n

.meas tran vdout0_71ck590 FIND v(dout0_71) AT=300.025n

.meas tran vdout0_72ck590 FIND v(dout0_72) AT=300.025n

.meas tran vdout0_73ck590 FIND v(dout0_73) AT=300.025n

.meas tran vdout0_74ck590 FIND v(dout0_74) AT=300.025n

.meas tran vdout0_75ck590 FIND v(dout0_75) AT=300.025n

.meas tran vdout0_76ck590 FIND v(dout0_76) AT=300.025n

.meas tran vdout0_77ck590 FIND v(dout0_77) AT=300.025n

.meas tran vdout0_78ck590 FIND v(dout0_78) AT=300.025n

.meas tran vdout0_79ck590 FIND v(dout0_79) AT=300.025n

.meas tran vdout0_80ck590 FIND v(dout0_80) AT=300.025n

.meas tran vdout0_81ck590 FIND v(dout0_81) AT=300.025n

.meas tran vdout0_82ck590 FIND v(dout0_82) AT=300.025n

.meas tran vdout0_83ck590 FIND v(dout0_83) AT=300.025n

.meas tran vdout0_84ck590 FIND v(dout0_84) AT=300.025n

.meas tran vdout0_85ck590 FIND v(dout0_85) AT=300.025n

.meas tran vdout0_86ck590 FIND v(dout0_86) AT=300.025n

.meas tran vdout0_87ck590 FIND v(dout0_87) AT=300.025n

.meas tran vdout0_88ck590 FIND v(dout0_88) AT=300.025n

.meas tran vdout0_89ck590 FIND v(dout0_89) AT=300.025n

.meas tran vdout0_90ck590 FIND v(dout0_90) AT=300.025n

.meas tran vdout0_91ck590 FIND v(dout0_91) AT=300.025n

.meas tran vdout0_92ck590 FIND v(dout0_92) AT=300.025n

.meas tran vdout0_93ck590 FIND v(dout0_93) AT=300.025n

.meas tran vdout0_94ck590 FIND v(dout0_94) AT=300.025n

.meas tran vdout0_95ck590 FIND v(dout0_95) AT=300.025n

.meas tran vdout0_96ck590 FIND v(dout0_96) AT=300.025n

.meas tran vdout0_97ck590 FIND v(dout0_97) AT=300.025n

.meas tran vdout0_98ck590 FIND v(dout0_98) AT=300.025n

.meas tran vdout0_99ck590 FIND v(dout0_99) AT=300.025n

.meas tran vdout0_100ck590 FIND v(dout0_100) AT=300.025n

.meas tran vdout0_101ck590 FIND v(dout0_101) AT=300.025n

.meas tran vdout0_102ck590 FIND v(dout0_102) AT=300.025n

.meas tran vdout0_103ck590 FIND v(dout0_103) AT=300.025n

.meas tran vdout0_104ck590 FIND v(dout0_104) AT=300.025n

.meas tran vdout0_105ck590 FIND v(dout0_105) AT=300.025n

.meas tran vdout0_106ck590 FIND v(dout0_106) AT=300.025n

.meas tran vdout0_107ck590 FIND v(dout0_107) AT=300.025n

.meas tran vdout0_108ck590 FIND v(dout0_108) AT=300.025n

.meas tran vdout0_109ck590 FIND v(dout0_109) AT=300.025n

.meas tran vdout0_110ck590 FIND v(dout0_110) AT=300.025n

.meas tran vdout0_111ck590 FIND v(dout0_111) AT=300.025n

.meas tran vdout0_112ck590 FIND v(dout0_112) AT=300.025n

.meas tran vdout0_113ck590 FIND v(dout0_113) AT=300.025n

.meas tran vdout0_114ck590 FIND v(dout0_114) AT=300.025n

.meas tran vdout0_115ck590 FIND v(dout0_115) AT=300.025n

.meas tran vdout0_116ck590 FIND v(dout0_116) AT=300.025n

.meas tran vdout0_117ck590 FIND v(dout0_117) AT=300.025n

.meas tran vdout0_118ck590 FIND v(dout0_118) AT=300.025n

.meas tran vdout0_119ck590 FIND v(dout0_119) AT=300.025n

.meas tran vdout0_120ck590 FIND v(dout0_120) AT=300.025n

.meas tran vdout0_121ck590 FIND v(dout0_121) AT=300.025n

.meas tran vdout0_122ck590 FIND v(dout0_122) AT=300.025n

.meas tran vdout0_123ck590 FIND v(dout0_123) AT=300.025n

.meas tran vdout0_124ck590 FIND v(dout0_124) AT=300.025n

.meas tran vdout0_125ck590 FIND v(dout0_125) AT=300.025n

.meas tran vdout0_126ck590 FIND v(dout0_126) AT=300.025n

.meas tran vdout0_127ck590 FIND v(dout0_127) AT=300.025n

.meas tran vdout0_0ck600 FIND v(dout0_0) AT=305.025n

.meas tran vdout0_1ck600 FIND v(dout0_1) AT=305.025n

.meas tran vdout0_2ck600 FIND v(dout0_2) AT=305.025n

.meas tran vdout0_3ck600 FIND v(dout0_3) AT=305.025n

.meas tran vdout0_4ck600 FIND v(dout0_4) AT=305.025n

.meas tran vdout0_5ck600 FIND v(dout0_5) AT=305.025n

.meas tran vdout0_6ck600 FIND v(dout0_6) AT=305.025n

.meas tran vdout0_7ck600 FIND v(dout0_7) AT=305.025n

.meas tran vdout0_8ck600 FIND v(dout0_8) AT=305.025n

.meas tran vdout0_9ck600 FIND v(dout0_9) AT=305.025n

.meas tran vdout0_10ck600 FIND v(dout0_10) AT=305.025n

.meas tran vdout0_11ck600 FIND v(dout0_11) AT=305.025n

.meas tran vdout0_12ck600 FIND v(dout0_12) AT=305.025n

.meas tran vdout0_13ck600 FIND v(dout0_13) AT=305.025n

.meas tran vdout0_14ck600 FIND v(dout0_14) AT=305.025n

.meas tran vdout0_15ck600 FIND v(dout0_15) AT=305.025n

.meas tran vdout0_16ck600 FIND v(dout0_16) AT=305.025n

.meas tran vdout0_17ck600 FIND v(dout0_17) AT=305.025n

.meas tran vdout0_18ck600 FIND v(dout0_18) AT=305.025n

.meas tran vdout0_19ck600 FIND v(dout0_19) AT=305.025n

.meas tran vdout0_20ck600 FIND v(dout0_20) AT=305.025n

.meas tran vdout0_21ck600 FIND v(dout0_21) AT=305.025n

.meas tran vdout0_22ck600 FIND v(dout0_22) AT=305.025n

.meas tran vdout0_23ck600 FIND v(dout0_23) AT=305.025n

.meas tran vdout0_24ck600 FIND v(dout0_24) AT=305.025n

.meas tran vdout0_25ck600 FIND v(dout0_25) AT=305.025n

.meas tran vdout0_26ck600 FIND v(dout0_26) AT=305.025n

.meas tran vdout0_27ck600 FIND v(dout0_27) AT=305.025n

.meas tran vdout0_28ck600 FIND v(dout0_28) AT=305.025n

.meas tran vdout0_29ck600 FIND v(dout0_29) AT=305.025n

.meas tran vdout0_30ck600 FIND v(dout0_30) AT=305.025n

.meas tran vdout0_31ck600 FIND v(dout0_31) AT=305.025n

.meas tran vdout0_32ck600 FIND v(dout0_32) AT=305.025n

.meas tran vdout0_33ck600 FIND v(dout0_33) AT=305.025n

.meas tran vdout0_34ck600 FIND v(dout0_34) AT=305.025n

.meas tran vdout0_35ck600 FIND v(dout0_35) AT=305.025n

.meas tran vdout0_36ck600 FIND v(dout0_36) AT=305.025n

.meas tran vdout0_37ck600 FIND v(dout0_37) AT=305.025n

.meas tran vdout0_38ck600 FIND v(dout0_38) AT=305.025n

.meas tran vdout0_39ck600 FIND v(dout0_39) AT=305.025n

.meas tran vdout0_40ck600 FIND v(dout0_40) AT=305.025n

.meas tran vdout0_41ck600 FIND v(dout0_41) AT=305.025n

.meas tran vdout0_42ck600 FIND v(dout0_42) AT=305.025n

.meas tran vdout0_43ck600 FIND v(dout0_43) AT=305.025n

.meas tran vdout0_44ck600 FIND v(dout0_44) AT=305.025n

.meas tran vdout0_45ck600 FIND v(dout0_45) AT=305.025n

.meas tran vdout0_46ck600 FIND v(dout0_46) AT=305.025n

.meas tran vdout0_47ck600 FIND v(dout0_47) AT=305.025n

.meas tran vdout0_48ck600 FIND v(dout0_48) AT=305.025n

.meas tran vdout0_49ck600 FIND v(dout0_49) AT=305.025n

.meas tran vdout0_50ck600 FIND v(dout0_50) AT=305.025n

.meas tran vdout0_51ck600 FIND v(dout0_51) AT=305.025n

.meas tran vdout0_52ck600 FIND v(dout0_52) AT=305.025n

.meas tran vdout0_53ck600 FIND v(dout0_53) AT=305.025n

.meas tran vdout0_54ck600 FIND v(dout0_54) AT=305.025n

.meas tran vdout0_55ck600 FIND v(dout0_55) AT=305.025n

.meas tran vdout0_56ck600 FIND v(dout0_56) AT=305.025n

.meas tran vdout0_57ck600 FIND v(dout0_57) AT=305.025n

.meas tran vdout0_58ck600 FIND v(dout0_58) AT=305.025n

.meas tran vdout0_59ck600 FIND v(dout0_59) AT=305.025n

.meas tran vdout0_60ck600 FIND v(dout0_60) AT=305.025n

.meas tran vdout0_61ck600 FIND v(dout0_61) AT=305.025n

.meas tran vdout0_62ck600 FIND v(dout0_62) AT=305.025n

.meas tran vdout0_63ck600 FIND v(dout0_63) AT=305.025n

.meas tran vdout0_64ck600 FIND v(dout0_64) AT=305.025n

.meas tran vdout0_65ck600 FIND v(dout0_65) AT=305.025n

.meas tran vdout0_66ck600 FIND v(dout0_66) AT=305.025n

.meas tran vdout0_67ck600 FIND v(dout0_67) AT=305.025n

.meas tran vdout0_68ck600 FIND v(dout0_68) AT=305.025n

.meas tran vdout0_69ck600 FIND v(dout0_69) AT=305.025n

.meas tran vdout0_70ck600 FIND v(dout0_70) AT=305.025n

.meas tran vdout0_71ck600 FIND v(dout0_71) AT=305.025n

.meas tran vdout0_72ck600 FIND v(dout0_72) AT=305.025n

.meas tran vdout0_73ck600 FIND v(dout0_73) AT=305.025n

.meas tran vdout0_74ck600 FIND v(dout0_74) AT=305.025n

.meas tran vdout0_75ck600 FIND v(dout0_75) AT=305.025n

.meas tran vdout0_76ck600 FIND v(dout0_76) AT=305.025n

.meas tran vdout0_77ck600 FIND v(dout0_77) AT=305.025n

.meas tran vdout0_78ck600 FIND v(dout0_78) AT=305.025n

.meas tran vdout0_79ck600 FIND v(dout0_79) AT=305.025n

.meas tran vdout0_80ck600 FIND v(dout0_80) AT=305.025n

.meas tran vdout0_81ck600 FIND v(dout0_81) AT=305.025n

.meas tran vdout0_82ck600 FIND v(dout0_82) AT=305.025n

.meas tran vdout0_83ck600 FIND v(dout0_83) AT=305.025n

.meas tran vdout0_84ck600 FIND v(dout0_84) AT=305.025n

.meas tran vdout0_85ck600 FIND v(dout0_85) AT=305.025n

.meas tran vdout0_86ck600 FIND v(dout0_86) AT=305.025n

.meas tran vdout0_87ck600 FIND v(dout0_87) AT=305.025n

.meas tran vdout0_88ck600 FIND v(dout0_88) AT=305.025n

.meas tran vdout0_89ck600 FIND v(dout0_89) AT=305.025n

.meas tran vdout0_90ck600 FIND v(dout0_90) AT=305.025n

.meas tran vdout0_91ck600 FIND v(dout0_91) AT=305.025n

.meas tran vdout0_92ck600 FIND v(dout0_92) AT=305.025n

.meas tran vdout0_93ck600 FIND v(dout0_93) AT=305.025n

.meas tran vdout0_94ck600 FIND v(dout0_94) AT=305.025n

.meas tran vdout0_95ck600 FIND v(dout0_95) AT=305.025n

.meas tran vdout0_96ck600 FIND v(dout0_96) AT=305.025n

.meas tran vdout0_97ck600 FIND v(dout0_97) AT=305.025n

.meas tran vdout0_98ck600 FIND v(dout0_98) AT=305.025n

.meas tran vdout0_99ck600 FIND v(dout0_99) AT=305.025n

.meas tran vdout0_100ck600 FIND v(dout0_100) AT=305.025n

.meas tran vdout0_101ck600 FIND v(dout0_101) AT=305.025n

.meas tran vdout0_102ck600 FIND v(dout0_102) AT=305.025n

.meas tran vdout0_103ck600 FIND v(dout0_103) AT=305.025n

.meas tran vdout0_104ck600 FIND v(dout0_104) AT=305.025n

.meas tran vdout0_105ck600 FIND v(dout0_105) AT=305.025n

.meas tran vdout0_106ck600 FIND v(dout0_106) AT=305.025n

.meas tran vdout0_107ck600 FIND v(dout0_107) AT=305.025n

.meas tran vdout0_108ck600 FIND v(dout0_108) AT=305.025n

.meas tran vdout0_109ck600 FIND v(dout0_109) AT=305.025n

.meas tran vdout0_110ck600 FIND v(dout0_110) AT=305.025n

.meas tran vdout0_111ck600 FIND v(dout0_111) AT=305.025n

.meas tran vdout0_112ck600 FIND v(dout0_112) AT=305.025n

.meas tran vdout0_113ck600 FIND v(dout0_113) AT=305.025n

.meas tran vdout0_114ck600 FIND v(dout0_114) AT=305.025n

.meas tran vdout0_115ck600 FIND v(dout0_115) AT=305.025n

.meas tran vdout0_116ck600 FIND v(dout0_116) AT=305.025n

.meas tran vdout0_117ck600 FIND v(dout0_117) AT=305.025n

.meas tran vdout0_118ck600 FIND v(dout0_118) AT=305.025n

.meas tran vdout0_119ck600 FIND v(dout0_119) AT=305.025n

.meas tran vdout0_120ck600 FIND v(dout0_120) AT=305.025n

.meas tran vdout0_121ck600 FIND v(dout0_121) AT=305.025n

.meas tran vdout0_122ck600 FIND v(dout0_122) AT=305.025n

.meas tran vdout0_123ck600 FIND v(dout0_123) AT=305.025n

.meas tran vdout0_124ck600 FIND v(dout0_124) AT=305.025n

.meas tran vdout0_125ck600 FIND v(dout0_125) AT=305.025n

.meas tran vdout0_126ck600 FIND v(dout0_126) AT=305.025n

.meas tran vdout0_127ck600 FIND v(dout0_127) AT=305.025n

.meas tran vdout0_0ck630 FIND v(dout0_0) AT=320.025n

.meas tran vdout0_1ck630 FIND v(dout0_1) AT=320.025n

.meas tran vdout0_2ck630 FIND v(dout0_2) AT=320.025n

.meas tran vdout0_3ck630 FIND v(dout0_3) AT=320.025n

.meas tran vdout0_4ck630 FIND v(dout0_4) AT=320.025n

.meas tran vdout0_5ck630 FIND v(dout0_5) AT=320.025n

.meas tran vdout0_6ck630 FIND v(dout0_6) AT=320.025n

.meas tran vdout0_7ck630 FIND v(dout0_7) AT=320.025n

.meas tran vdout0_8ck630 FIND v(dout0_8) AT=320.025n

.meas tran vdout0_9ck630 FIND v(dout0_9) AT=320.025n

.meas tran vdout0_10ck630 FIND v(dout0_10) AT=320.025n

.meas tran vdout0_11ck630 FIND v(dout0_11) AT=320.025n

.meas tran vdout0_12ck630 FIND v(dout0_12) AT=320.025n

.meas tran vdout0_13ck630 FIND v(dout0_13) AT=320.025n

.meas tran vdout0_14ck630 FIND v(dout0_14) AT=320.025n

.meas tran vdout0_15ck630 FIND v(dout0_15) AT=320.025n

.meas tran vdout0_16ck630 FIND v(dout0_16) AT=320.025n

.meas tran vdout0_17ck630 FIND v(dout0_17) AT=320.025n

.meas tran vdout0_18ck630 FIND v(dout0_18) AT=320.025n

.meas tran vdout0_19ck630 FIND v(dout0_19) AT=320.025n

.meas tran vdout0_20ck630 FIND v(dout0_20) AT=320.025n

.meas tran vdout0_21ck630 FIND v(dout0_21) AT=320.025n

.meas tran vdout0_22ck630 FIND v(dout0_22) AT=320.025n

.meas tran vdout0_23ck630 FIND v(dout0_23) AT=320.025n

.meas tran vdout0_24ck630 FIND v(dout0_24) AT=320.025n

.meas tran vdout0_25ck630 FIND v(dout0_25) AT=320.025n

.meas tran vdout0_26ck630 FIND v(dout0_26) AT=320.025n

.meas tran vdout0_27ck630 FIND v(dout0_27) AT=320.025n

.meas tran vdout0_28ck630 FIND v(dout0_28) AT=320.025n

.meas tran vdout0_29ck630 FIND v(dout0_29) AT=320.025n

.meas tran vdout0_30ck630 FIND v(dout0_30) AT=320.025n

.meas tran vdout0_31ck630 FIND v(dout0_31) AT=320.025n

.meas tran vdout0_32ck630 FIND v(dout0_32) AT=320.025n

.meas tran vdout0_33ck630 FIND v(dout0_33) AT=320.025n

.meas tran vdout0_34ck630 FIND v(dout0_34) AT=320.025n

.meas tran vdout0_35ck630 FIND v(dout0_35) AT=320.025n

.meas tran vdout0_36ck630 FIND v(dout0_36) AT=320.025n

.meas tran vdout0_37ck630 FIND v(dout0_37) AT=320.025n

.meas tran vdout0_38ck630 FIND v(dout0_38) AT=320.025n

.meas tran vdout0_39ck630 FIND v(dout0_39) AT=320.025n

.meas tran vdout0_40ck630 FIND v(dout0_40) AT=320.025n

.meas tran vdout0_41ck630 FIND v(dout0_41) AT=320.025n

.meas tran vdout0_42ck630 FIND v(dout0_42) AT=320.025n

.meas tran vdout0_43ck630 FIND v(dout0_43) AT=320.025n

.meas tran vdout0_44ck630 FIND v(dout0_44) AT=320.025n

.meas tran vdout0_45ck630 FIND v(dout0_45) AT=320.025n

.meas tran vdout0_46ck630 FIND v(dout0_46) AT=320.025n

.meas tran vdout0_47ck630 FIND v(dout0_47) AT=320.025n

.meas tran vdout0_48ck630 FIND v(dout0_48) AT=320.025n

.meas tran vdout0_49ck630 FIND v(dout0_49) AT=320.025n

.meas tran vdout0_50ck630 FIND v(dout0_50) AT=320.025n

.meas tran vdout0_51ck630 FIND v(dout0_51) AT=320.025n

.meas tran vdout0_52ck630 FIND v(dout0_52) AT=320.025n

.meas tran vdout0_53ck630 FIND v(dout0_53) AT=320.025n

.meas tran vdout0_54ck630 FIND v(dout0_54) AT=320.025n

.meas tran vdout0_55ck630 FIND v(dout0_55) AT=320.025n

.meas tran vdout0_56ck630 FIND v(dout0_56) AT=320.025n

.meas tran vdout0_57ck630 FIND v(dout0_57) AT=320.025n

.meas tran vdout0_58ck630 FIND v(dout0_58) AT=320.025n

.meas tran vdout0_59ck630 FIND v(dout0_59) AT=320.025n

.meas tran vdout0_60ck630 FIND v(dout0_60) AT=320.025n

.meas tran vdout0_61ck630 FIND v(dout0_61) AT=320.025n

.meas tran vdout0_62ck630 FIND v(dout0_62) AT=320.025n

.meas tran vdout0_63ck630 FIND v(dout0_63) AT=320.025n

.meas tran vdout0_64ck630 FIND v(dout0_64) AT=320.025n

.meas tran vdout0_65ck630 FIND v(dout0_65) AT=320.025n

.meas tran vdout0_66ck630 FIND v(dout0_66) AT=320.025n

.meas tran vdout0_67ck630 FIND v(dout0_67) AT=320.025n

.meas tran vdout0_68ck630 FIND v(dout0_68) AT=320.025n

.meas tran vdout0_69ck630 FIND v(dout0_69) AT=320.025n

.meas tran vdout0_70ck630 FIND v(dout0_70) AT=320.025n

.meas tran vdout0_71ck630 FIND v(dout0_71) AT=320.025n

.meas tran vdout0_72ck630 FIND v(dout0_72) AT=320.025n

.meas tran vdout0_73ck630 FIND v(dout0_73) AT=320.025n

.meas tran vdout0_74ck630 FIND v(dout0_74) AT=320.025n

.meas tran vdout0_75ck630 FIND v(dout0_75) AT=320.025n

.meas tran vdout0_76ck630 FIND v(dout0_76) AT=320.025n

.meas tran vdout0_77ck630 FIND v(dout0_77) AT=320.025n

.meas tran vdout0_78ck630 FIND v(dout0_78) AT=320.025n

.meas tran vdout0_79ck630 FIND v(dout0_79) AT=320.025n

.meas tran vdout0_80ck630 FIND v(dout0_80) AT=320.025n

.meas tran vdout0_81ck630 FIND v(dout0_81) AT=320.025n

.meas tran vdout0_82ck630 FIND v(dout0_82) AT=320.025n

.meas tran vdout0_83ck630 FIND v(dout0_83) AT=320.025n

.meas tran vdout0_84ck630 FIND v(dout0_84) AT=320.025n

.meas tran vdout0_85ck630 FIND v(dout0_85) AT=320.025n

.meas tran vdout0_86ck630 FIND v(dout0_86) AT=320.025n

.meas tran vdout0_87ck630 FIND v(dout0_87) AT=320.025n

.meas tran vdout0_88ck630 FIND v(dout0_88) AT=320.025n

.meas tran vdout0_89ck630 FIND v(dout0_89) AT=320.025n

.meas tran vdout0_90ck630 FIND v(dout0_90) AT=320.025n

.meas tran vdout0_91ck630 FIND v(dout0_91) AT=320.025n

.meas tran vdout0_92ck630 FIND v(dout0_92) AT=320.025n

.meas tran vdout0_93ck630 FIND v(dout0_93) AT=320.025n

.meas tran vdout0_94ck630 FIND v(dout0_94) AT=320.025n

.meas tran vdout0_95ck630 FIND v(dout0_95) AT=320.025n

.meas tran vdout0_96ck630 FIND v(dout0_96) AT=320.025n

.meas tran vdout0_97ck630 FIND v(dout0_97) AT=320.025n

.meas tran vdout0_98ck630 FIND v(dout0_98) AT=320.025n

.meas tran vdout0_99ck630 FIND v(dout0_99) AT=320.025n

.meas tran vdout0_100ck630 FIND v(dout0_100) AT=320.025n

.meas tran vdout0_101ck630 FIND v(dout0_101) AT=320.025n

.meas tran vdout0_102ck630 FIND v(dout0_102) AT=320.025n

.meas tran vdout0_103ck630 FIND v(dout0_103) AT=320.025n

.meas tran vdout0_104ck630 FIND v(dout0_104) AT=320.025n

.meas tran vdout0_105ck630 FIND v(dout0_105) AT=320.025n

.meas tran vdout0_106ck630 FIND v(dout0_106) AT=320.025n

.meas tran vdout0_107ck630 FIND v(dout0_107) AT=320.025n

.meas tran vdout0_108ck630 FIND v(dout0_108) AT=320.025n

.meas tran vdout0_109ck630 FIND v(dout0_109) AT=320.025n

.meas tran vdout0_110ck630 FIND v(dout0_110) AT=320.025n

.meas tran vdout0_111ck630 FIND v(dout0_111) AT=320.025n

.meas tran vdout0_112ck630 FIND v(dout0_112) AT=320.025n

.meas tran vdout0_113ck630 FIND v(dout0_113) AT=320.025n

.meas tran vdout0_114ck630 FIND v(dout0_114) AT=320.025n

.meas tran vdout0_115ck630 FIND v(dout0_115) AT=320.025n

.meas tran vdout0_116ck630 FIND v(dout0_116) AT=320.025n

.meas tran vdout0_117ck630 FIND v(dout0_117) AT=320.025n

.meas tran vdout0_118ck630 FIND v(dout0_118) AT=320.025n

.meas tran vdout0_119ck630 FIND v(dout0_119) AT=320.025n

.meas tran vdout0_120ck630 FIND v(dout0_120) AT=320.025n

.meas tran vdout0_121ck630 FIND v(dout0_121) AT=320.025n

.meas tran vdout0_122ck630 FIND v(dout0_122) AT=320.025n

.meas tran vdout0_123ck630 FIND v(dout0_123) AT=320.025n

.meas tran vdout0_124ck630 FIND v(dout0_124) AT=320.025n

.meas tran vdout0_125ck630 FIND v(dout0_125) AT=320.025n

.meas tran vdout0_126ck630 FIND v(dout0_126) AT=320.025n

.meas tran vdout0_127ck630 FIND v(dout0_127) AT=320.025n

.meas tran vdout0_0ck640 FIND v(dout0_0) AT=325.025n

.meas tran vdout0_1ck640 FIND v(dout0_1) AT=325.025n

.meas tran vdout0_2ck640 FIND v(dout0_2) AT=325.025n

.meas tran vdout0_3ck640 FIND v(dout0_3) AT=325.025n

.meas tran vdout0_4ck640 FIND v(dout0_4) AT=325.025n

.meas tran vdout0_5ck640 FIND v(dout0_5) AT=325.025n

.meas tran vdout0_6ck640 FIND v(dout0_6) AT=325.025n

.meas tran vdout0_7ck640 FIND v(dout0_7) AT=325.025n

.meas tran vdout0_8ck640 FIND v(dout0_8) AT=325.025n

.meas tran vdout0_9ck640 FIND v(dout0_9) AT=325.025n

.meas tran vdout0_10ck640 FIND v(dout0_10) AT=325.025n

.meas tran vdout0_11ck640 FIND v(dout0_11) AT=325.025n

.meas tran vdout0_12ck640 FIND v(dout0_12) AT=325.025n

.meas tran vdout0_13ck640 FIND v(dout0_13) AT=325.025n

.meas tran vdout0_14ck640 FIND v(dout0_14) AT=325.025n

.meas tran vdout0_15ck640 FIND v(dout0_15) AT=325.025n

.meas tran vdout0_16ck640 FIND v(dout0_16) AT=325.025n

.meas tran vdout0_17ck640 FIND v(dout0_17) AT=325.025n

.meas tran vdout0_18ck640 FIND v(dout0_18) AT=325.025n

.meas tran vdout0_19ck640 FIND v(dout0_19) AT=325.025n

.meas tran vdout0_20ck640 FIND v(dout0_20) AT=325.025n

.meas tran vdout0_21ck640 FIND v(dout0_21) AT=325.025n

.meas tran vdout0_22ck640 FIND v(dout0_22) AT=325.025n

.meas tran vdout0_23ck640 FIND v(dout0_23) AT=325.025n

.meas tran vdout0_24ck640 FIND v(dout0_24) AT=325.025n

.meas tran vdout0_25ck640 FIND v(dout0_25) AT=325.025n

.meas tran vdout0_26ck640 FIND v(dout0_26) AT=325.025n

.meas tran vdout0_27ck640 FIND v(dout0_27) AT=325.025n

.meas tran vdout0_28ck640 FIND v(dout0_28) AT=325.025n

.meas tran vdout0_29ck640 FIND v(dout0_29) AT=325.025n

.meas tran vdout0_30ck640 FIND v(dout0_30) AT=325.025n

.meas tran vdout0_31ck640 FIND v(dout0_31) AT=325.025n

.meas tran vdout0_32ck640 FIND v(dout0_32) AT=325.025n

.meas tran vdout0_33ck640 FIND v(dout0_33) AT=325.025n

.meas tran vdout0_34ck640 FIND v(dout0_34) AT=325.025n

.meas tran vdout0_35ck640 FIND v(dout0_35) AT=325.025n

.meas tran vdout0_36ck640 FIND v(dout0_36) AT=325.025n

.meas tran vdout0_37ck640 FIND v(dout0_37) AT=325.025n

.meas tran vdout0_38ck640 FIND v(dout0_38) AT=325.025n

.meas tran vdout0_39ck640 FIND v(dout0_39) AT=325.025n

.meas tran vdout0_40ck640 FIND v(dout0_40) AT=325.025n

.meas tran vdout0_41ck640 FIND v(dout0_41) AT=325.025n

.meas tran vdout0_42ck640 FIND v(dout0_42) AT=325.025n

.meas tran vdout0_43ck640 FIND v(dout0_43) AT=325.025n

.meas tran vdout0_44ck640 FIND v(dout0_44) AT=325.025n

.meas tran vdout0_45ck640 FIND v(dout0_45) AT=325.025n

.meas tran vdout0_46ck640 FIND v(dout0_46) AT=325.025n

.meas tran vdout0_47ck640 FIND v(dout0_47) AT=325.025n

.meas tran vdout0_48ck640 FIND v(dout0_48) AT=325.025n

.meas tran vdout0_49ck640 FIND v(dout0_49) AT=325.025n

.meas tran vdout0_50ck640 FIND v(dout0_50) AT=325.025n

.meas tran vdout0_51ck640 FIND v(dout0_51) AT=325.025n

.meas tran vdout0_52ck640 FIND v(dout0_52) AT=325.025n

.meas tran vdout0_53ck640 FIND v(dout0_53) AT=325.025n

.meas tran vdout0_54ck640 FIND v(dout0_54) AT=325.025n

.meas tran vdout0_55ck640 FIND v(dout0_55) AT=325.025n

.meas tran vdout0_56ck640 FIND v(dout0_56) AT=325.025n

.meas tran vdout0_57ck640 FIND v(dout0_57) AT=325.025n

.meas tran vdout0_58ck640 FIND v(dout0_58) AT=325.025n

.meas tran vdout0_59ck640 FIND v(dout0_59) AT=325.025n

.meas tran vdout0_60ck640 FIND v(dout0_60) AT=325.025n

.meas tran vdout0_61ck640 FIND v(dout0_61) AT=325.025n

.meas tran vdout0_62ck640 FIND v(dout0_62) AT=325.025n

.meas tran vdout0_63ck640 FIND v(dout0_63) AT=325.025n

.meas tran vdout0_64ck640 FIND v(dout0_64) AT=325.025n

.meas tran vdout0_65ck640 FIND v(dout0_65) AT=325.025n

.meas tran vdout0_66ck640 FIND v(dout0_66) AT=325.025n

.meas tran vdout0_67ck640 FIND v(dout0_67) AT=325.025n

.meas tran vdout0_68ck640 FIND v(dout0_68) AT=325.025n

.meas tran vdout0_69ck640 FIND v(dout0_69) AT=325.025n

.meas tran vdout0_70ck640 FIND v(dout0_70) AT=325.025n

.meas tran vdout0_71ck640 FIND v(dout0_71) AT=325.025n

.meas tran vdout0_72ck640 FIND v(dout0_72) AT=325.025n

.meas tran vdout0_73ck640 FIND v(dout0_73) AT=325.025n

.meas tran vdout0_74ck640 FIND v(dout0_74) AT=325.025n

.meas tran vdout0_75ck640 FIND v(dout0_75) AT=325.025n

.meas tran vdout0_76ck640 FIND v(dout0_76) AT=325.025n

.meas tran vdout0_77ck640 FIND v(dout0_77) AT=325.025n

.meas tran vdout0_78ck640 FIND v(dout0_78) AT=325.025n

.meas tran vdout0_79ck640 FIND v(dout0_79) AT=325.025n

.meas tran vdout0_80ck640 FIND v(dout0_80) AT=325.025n

.meas tran vdout0_81ck640 FIND v(dout0_81) AT=325.025n

.meas tran vdout0_82ck640 FIND v(dout0_82) AT=325.025n

.meas tran vdout0_83ck640 FIND v(dout0_83) AT=325.025n

.meas tran vdout0_84ck640 FIND v(dout0_84) AT=325.025n

.meas tran vdout0_85ck640 FIND v(dout0_85) AT=325.025n

.meas tran vdout0_86ck640 FIND v(dout0_86) AT=325.025n

.meas tran vdout0_87ck640 FIND v(dout0_87) AT=325.025n

.meas tran vdout0_88ck640 FIND v(dout0_88) AT=325.025n

.meas tran vdout0_89ck640 FIND v(dout0_89) AT=325.025n

.meas tran vdout0_90ck640 FIND v(dout0_90) AT=325.025n

.meas tran vdout0_91ck640 FIND v(dout0_91) AT=325.025n

.meas tran vdout0_92ck640 FIND v(dout0_92) AT=325.025n

.meas tran vdout0_93ck640 FIND v(dout0_93) AT=325.025n

.meas tran vdout0_94ck640 FIND v(dout0_94) AT=325.025n

.meas tran vdout0_95ck640 FIND v(dout0_95) AT=325.025n

.meas tran vdout0_96ck640 FIND v(dout0_96) AT=325.025n

.meas tran vdout0_97ck640 FIND v(dout0_97) AT=325.025n

.meas tran vdout0_98ck640 FIND v(dout0_98) AT=325.025n

.meas tran vdout0_99ck640 FIND v(dout0_99) AT=325.025n

.meas tran vdout0_100ck640 FIND v(dout0_100) AT=325.025n

.meas tran vdout0_101ck640 FIND v(dout0_101) AT=325.025n

.meas tran vdout0_102ck640 FIND v(dout0_102) AT=325.025n

.meas tran vdout0_103ck640 FIND v(dout0_103) AT=325.025n

.meas tran vdout0_104ck640 FIND v(dout0_104) AT=325.025n

.meas tran vdout0_105ck640 FIND v(dout0_105) AT=325.025n

.meas tran vdout0_106ck640 FIND v(dout0_106) AT=325.025n

.meas tran vdout0_107ck640 FIND v(dout0_107) AT=325.025n

.meas tran vdout0_108ck640 FIND v(dout0_108) AT=325.025n

.meas tran vdout0_109ck640 FIND v(dout0_109) AT=325.025n

.meas tran vdout0_110ck640 FIND v(dout0_110) AT=325.025n

.meas tran vdout0_111ck640 FIND v(dout0_111) AT=325.025n

.meas tran vdout0_112ck640 FIND v(dout0_112) AT=325.025n

.meas tran vdout0_113ck640 FIND v(dout0_113) AT=325.025n

.meas tran vdout0_114ck640 FIND v(dout0_114) AT=325.025n

.meas tran vdout0_115ck640 FIND v(dout0_115) AT=325.025n

.meas tran vdout0_116ck640 FIND v(dout0_116) AT=325.025n

.meas tran vdout0_117ck640 FIND v(dout0_117) AT=325.025n

.meas tran vdout0_118ck640 FIND v(dout0_118) AT=325.025n

.meas tran vdout0_119ck640 FIND v(dout0_119) AT=325.025n

.meas tran vdout0_120ck640 FIND v(dout0_120) AT=325.025n

.meas tran vdout0_121ck640 FIND v(dout0_121) AT=325.025n

.meas tran vdout0_122ck640 FIND v(dout0_122) AT=325.025n

.meas tran vdout0_123ck640 FIND v(dout0_123) AT=325.025n

.meas tran vdout0_124ck640 FIND v(dout0_124) AT=325.025n

.meas tran vdout0_125ck640 FIND v(dout0_125) AT=325.025n

.meas tran vdout0_126ck640 FIND v(dout0_126) AT=325.025n

.meas tran vdout0_127ck640 FIND v(dout0_127) AT=325.025n

.meas tran vdout0_0ck650 FIND v(dout0_0) AT=330.025n

.meas tran vdout0_1ck650 FIND v(dout0_1) AT=330.025n

.meas tran vdout0_2ck650 FIND v(dout0_2) AT=330.025n

.meas tran vdout0_3ck650 FIND v(dout0_3) AT=330.025n

.meas tran vdout0_4ck650 FIND v(dout0_4) AT=330.025n

.meas tran vdout0_5ck650 FIND v(dout0_5) AT=330.025n

.meas tran vdout0_6ck650 FIND v(dout0_6) AT=330.025n

.meas tran vdout0_7ck650 FIND v(dout0_7) AT=330.025n

.meas tran vdout0_8ck650 FIND v(dout0_8) AT=330.025n

.meas tran vdout0_9ck650 FIND v(dout0_9) AT=330.025n

.meas tran vdout0_10ck650 FIND v(dout0_10) AT=330.025n

.meas tran vdout0_11ck650 FIND v(dout0_11) AT=330.025n

.meas tran vdout0_12ck650 FIND v(dout0_12) AT=330.025n

.meas tran vdout0_13ck650 FIND v(dout0_13) AT=330.025n

.meas tran vdout0_14ck650 FIND v(dout0_14) AT=330.025n

.meas tran vdout0_15ck650 FIND v(dout0_15) AT=330.025n

.meas tran vdout0_16ck650 FIND v(dout0_16) AT=330.025n

.meas tran vdout0_17ck650 FIND v(dout0_17) AT=330.025n

.meas tran vdout0_18ck650 FIND v(dout0_18) AT=330.025n

.meas tran vdout0_19ck650 FIND v(dout0_19) AT=330.025n

.meas tran vdout0_20ck650 FIND v(dout0_20) AT=330.025n

.meas tran vdout0_21ck650 FIND v(dout0_21) AT=330.025n

.meas tran vdout0_22ck650 FIND v(dout0_22) AT=330.025n

.meas tran vdout0_23ck650 FIND v(dout0_23) AT=330.025n

.meas tran vdout0_24ck650 FIND v(dout0_24) AT=330.025n

.meas tran vdout0_25ck650 FIND v(dout0_25) AT=330.025n

.meas tran vdout0_26ck650 FIND v(dout0_26) AT=330.025n

.meas tran vdout0_27ck650 FIND v(dout0_27) AT=330.025n

.meas tran vdout0_28ck650 FIND v(dout0_28) AT=330.025n

.meas tran vdout0_29ck650 FIND v(dout0_29) AT=330.025n

.meas tran vdout0_30ck650 FIND v(dout0_30) AT=330.025n

.meas tran vdout0_31ck650 FIND v(dout0_31) AT=330.025n

.meas tran vdout0_32ck650 FIND v(dout0_32) AT=330.025n

.meas tran vdout0_33ck650 FIND v(dout0_33) AT=330.025n

.meas tran vdout0_34ck650 FIND v(dout0_34) AT=330.025n

.meas tran vdout0_35ck650 FIND v(dout0_35) AT=330.025n

.meas tran vdout0_36ck650 FIND v(dout0_36) AT=330.025n

.meas tran vdout0_37ck650 FIND v(dout0_37) AT=330.025n

.meas tran vdout0_38ck650 FIND v(dout0_38) AT=330.025n

.meas tran vdout0_39ck650 FIND v(dout0_39) AT=330.025n

.meas tran vdout0_40ck650 FIND v(dout0_40) AT=330.025n

.meas tran vdout0_41ck650 FIND v(dout0_41) AT=330.025n

.meas tran vdout0_42ck650 FIND v(dout0_42) AT=330.025n

.meas tran vdout0_43ck650 FIND v(dout0_43) AT=330.025n

.meas tran vdout0_44ck650 FIND v(dout0_44) AT=330.025n

.meas tran vdout0_45ck650 FIND v(dout0_45) AT=330.025n

.meas tran vdout0_46ck650 FIND v(dout0_46) AT=330.025n

.meas tran vdout0_47ck650 FIND v(dout0_47) AT=330.025n

.meas tran vdout0_48ck650 FIND v(dout0_48) AT=330.025n

.meas tran vdout0_49ck650 FIND v(dout0_49) AT=330.025n

.meas tran vdout0_50ck650 FIND v(dout0_50) AT=330.025n

.meas tran vdout0_51ck650 FIND v(dout0_51) AT=330.025n

.meas tran vdout0_52ck650 FIND v(dout0_52) AT=330.025n

.meas tran vdout0_53ck650 FIND v(dout0_53) AT=330.025n

.meas tran vdout0_54ck650 FIND v(dout0_54) AT=330.025n

.meas tran vdout0_55ck650 FIND v(dout0_55) AT=330.025n

.meas tran vdout0_56ck650 FIND v(dout0_56) AT=330.025n

.meas tran vdout0_57ck650 FIND v(dout0_57) AT=330.025n

.meas tran vdout0_58ck650 FIND v(dout0_58) AT=330.025n

.meas tran vdout0_59ck650 FIND v(dout0_59) AT=330.025n

.meas tran vdout0_60ck650 FIND v(dout0_60) AT=330.025n

.meas tran vdout0_61ck650 FIND v(dout0_61) AT=330.025n

.meas tran vdout0_62ck650 FIND v(dout0_62) AT=330.025n

.meas tran vdout0_63ck650 FIND v(dout0_63) AT=330.025n

.meas tran vdout0_64ck650 FIND v(dout0_64) AT=330.025n

.meas tran vdout0_65ck650 FIND v(dout0_65) AT=330.025n

.meas tran vdout0_66ck650 FIND v(dout0_66) AT=330.025n

.meas tran vdout0_67ck650 FIND v(dout0_67) AT=330.025n

.meas tran vdout0_68ck650 FIND v(dout0_68) AT=330.025n

.meas tran vdout0_69ck650 FIND v(dout0_69) AT=330.025n

.meas tran vdout0_70ck650 FIND v(dout0_70) AT=330.025n

.meas tran vdout0_71ck650 FIND v(dout0_71) AT=330.025n

.meas tran vdout0_72ck650 FIND v(dout0_72) AT=330.025n

.meas tran vdout0_73ck650 FIND v(dout0_73) AT=330.025n

.meas tran vdout0_74ck650 FIND v(dout0_74) AT=330.025n

.meas tran vdout0_75ck650 FIND v(dout0_75) AT=330.025n

.meas tran vdout0_76ck650 FIND v(dout0_76) AT=330.025n

.meas tran vdout0_77ck650 FIND v(dout0_77) AT=330.025n

.meas tran vdout0_78ck650 FIND v(dout0_78) AT=330.025n

.meas tran vdout0_79ck650 FIND v(dout0_79) AT=330.025n

.meas tran vdout0_80ck650 FIND v(dout0_80) AT=330.025n

.meas tran vdout0_81ck650 FIND v(dout0_81) AT=330.025n

.meas tran vdout0_82ck650 FIND v(dout0_82) AT=330.025n

.meas tran vdout0_83ck650 FIND v(dout0_83) AT=330.025n

.meas tran vdout0_84ck650 FIND v(dout0_84) AT=330.025n

.meas tran vdout0_85ck650 FIND v(dout0_85) AT=330.025n

.meas tran vdout0_86ck650 FIND v(dout0_86) AT=330.025n

.meas tran vdout0_87ck650 FIND v(dout0_87) AT=330.025n

.meas tran vdout0_88ck650 FIND v(dout0_88) AT=330.025n

.meas tran vdout0_89ck650 FIND v(dout0_89) AT=330.025n

.meas tran vdout0_90ck650 FIND v(dout0_90) AT=330.025n

.meas tran vdout0_91ck650 FIND v(dout0_91) AT=330.025n

.meas tran vdout0_92ck650 FIND v(dout0_92) AT=330.025n

.meas tran vdout0_93ck650 FIND v(dout0_93) AT=330.025n

.meas tran vdout0_94ck650 FIND v(dout0_94) AT=330.025n

.meas tran vdout0_95ck650 FIND v(dout0_95) AT=330.025n

.meas tran vdout0_96ck650 FIND v(dout0_96) AT=330.025n

.meas tran vdout0_97ck650 FIND v(dout0_97) AT=330.025n

.meas tran vdout0_98ck650 FIND v(dout0_98) AT=330.025n

.meas tran vdout0_99ck650 FIND v(dout0_99) AT=330.025n

.meas tran vdout0_100ck650 FIND v(dout0_100) AT=330.025n

.meas tran vdout0_101ck650 FIND v(dout0_101) AT=330.025n

.meas tran vdout0_102ck650 FIND v(dout0_102) AT=330.025n

.meas tran vdout0_103ck650 FIND v(dout0_103) AT=330.025n

.meas tran vdout0_104ck650 FIND v(dout0_104) AT=330.025n

.meas tran vdout0_105ck650 FIND v(dout0_105) AT=330.025n

.meas tran vdout0_106ck650 FIND v(dout0_106) AT=330.025n

.meas tran vdout0_107ck650 FIND v(dout0_107) AT=330.025n

.meas tran vdout0_108ck650 FIND v(dout0_108) AT=330.025n

.meas tran vdout0_109ck650 FIND v(dout0_109) AT=330.025n

.meas tran vdout0_110ck650 FIND v(dout0_110) AT=330.025n

.meas tran vdout0_111ck650 FIND v(dout0_111) AT=330.025n

.meas tran vdout0_112ck650 FIND v(dout0_112) AT=330.025n

.meas tran vdout0_113ck650 FIND v(dout0_113) AT=330.025n

.meas tran vdout0_114ck650 FIND v(dout0_114) AT=330.025n

.meas tran vdout0_115ck650 FIND v(dout0_115) AT=330.025n

.meas tran vdout0_116ck650 FIND v(dout0_116) AT=330.025n

.meas tran vdout0_117ck650 FIND v(dout0_117) AT=330.025n

.meas tran vdout0_118ck650 FIND v(dout0_118) AT=330.025n

.meas tran vdout0_119ck650 FIND v(dout0_119) AT=330.025n

.meas tran vdout0_120ck650 FIND v(dout0_120) AT=330.025n

.meas tran vdout0_121ck650 FIND v(dout0_121) AT=330.025n

.meas tran vdout0_122ck650 FIND v(dout0_122) AT=330.025n

.meas tran vdout0_123ck650 FIND v(dout0_123) AT=330.025n

.meas tran vdout0_124ck650 FIND v(dout0_124) AT=330.025n

.meas tran vdout0_125ck650 FIND v(dout0_125) AT=330.025n

.meas tran vdout0_126ck650 FIND v(dout0_126) AT=330.025n

.meas tran vdout0_127ck650 FIND v(dout0_127) AT=330.025n

.meas tran vdout0_0ck670 FIND v(dout0_0) AT=340.025n

.meas tran vdout0_1ck670 FIND v(dout0_1) AT=340.025n

.meas tran vdout0_2ck670 FIND v(dout0_2) AT=340.025n

.meas tran vdout0_3ck670 FIND v(dout0_3) AT=340.025n

.meas tran vdout0_4ck670 FIND v(dout0_4) AT=340.025n

.meas tran vdout0_5ck670 FIND v(dout0_5) AT=340.025n

.meas tran vdout0_6ck670 FIND v(dout0_6) AT=340.025n

.meas tran vdout0_7ck670 FIND v(dout0_7) AT=340.025n

.meas tran vdout0_8ck670 FIND v(dout0_8) AT=340.025n

.meas tran vdout0_9ck670 FIND v(dout0_9) AT=340.025n

.meas tran vdout0_10ck670 FIND v(dout0_10) AT=340.025n

.meas tran vdout0_11ck670 FIND v(dout0_11) AT=340.025n

.meas tran vdout0_12ck670 FIND v(dout0_12) AT=340.025n

.meas tran vdout0_13ck670 FIND v(dout0_13) AT=340.025n

.meas tran vdout0_14ck670 FIND v(dout0_14) AT=340.025n

.meas tran vdout0_15ck670 FIND v(dout0_15) AT=340.025n

.meas tran vdout0_16ck670 FIND v(dout0_16) AT=340.025n

.meas tran vdout0_17ck670 FIND v(dout0_17) AT=340.025n

.meas tran vdout0_18ck670 FIND v(dout0_18) AT=340.025n

.meas tran vdout0_19ck670 FIND v(dout0_19) AT=340.025n

.meas tran vdout0_20ck670 FIND v(dout0_20) AT=340.025n

.meas tran vdout0_21ck670 FIND v(dout0_21) AT=340.025n

.meas tran vdout0_22ck670 FIND v(dout0_22) AT=340.025n

.meas tran vdout0_23ck670 FIND v(dout0_23) AT=340.025n

.meas tran vdout0_24ck670 FIND v(dout0_24) AT=340.025n

.meas tran vdout0_25ck670 FIND v(dout0_25) AT=340.025n

.meas tran vdout0_26ck670 FIND v(dout0_26) AT=340.025n

.meas tran vdout0_27ck670 FIND v(dout0_27) AT=340.025n

.meas tran vdout0_28ck670 FIND v(dout0_28) AT=340.025n

.meas tran vdout0_29ck670 FIND v(dout0_29) AT=340.025n

.meas tran vdout0_30ck670 FIND v(dout0_30) AT=340.025n

.meas tran vdout0_31ck670 FIND v(dout0_31) AT=340.025n

.meas tran vdout0_32ck670 FIND v(dout0_32) AT=340.025n

.meas tran vdout0_33ck670 FIND v(dout0_33) AT=340.025n

.meas tran vdout0_34ck670 FIND v(dout0_34) AT=340.025n

.meas tran vdout0_35ck670 FIND v(dout0_35) AT=340.025n

.meas tran vdout0_36ck670 FIND v(dout0_36) AT=340.025n

.meas tran vdout0_37ck670 FIND v(dout0_37) AT=340.025n

.meas tran vdout0_38ck670 FIND v(dout0_38) AT=340.025n

.meas tran vdout0_39ck670 FIND v(dout0_39) AT=340.025n

.meas tran vdout0_40ck670 FIND v(dout0_40) AT=340.025n

.meas tran vdout0_41ck670 FIND v(dout0_41) AT=340.025n

.meas tran vdout0_42ck670 FIND v(dout0_42) AT=340.025n

.meas tran vdout0_43ck670 FIND v(dout0_43) AT=340.025n

.meas tran vdout0_44ck670 FIND v(dout0_44) AT=340.025n

.meas tran vdout0_45ck670 FIND v(dout0_45) AT=340.025n

.meas tran vdout0_46ck670 FIND v(dout0_46) AT=340.025n

.meas tran vdout0_47ck670 FIND v(dout0_47) AT=340.025n

.meas tran vdout0_48ck670 FIND v(dout0_48) AT=340.025n

.meas tran vdout0_49ck670 FIND v(dout0_49) AT=340.025n

.meas tran vdout0_50ck670 FIND v(dout0_50) AT=340.025n

.meas tran vdout0_51ck670 FIND v(dout0_51) AT=340.025n

.meas tran vdout0_52ck670 FIND v(dout0_52) AT=340.025n

.meas tran vdout0_53ck670 FIND v(dout0_53) AT=340.025n

.meas tran vdout0_54ck670 FIND v(dout0_54) AT=340.025n

.meas tran vdout0_55ck670 FIND v(dout0_55) AT=340.025n

.meas tran vdout0_56ck670 FIND v(dout0_56) AT=340.025n

.meas tran vdout0_57ck670 FIND v(dout0_57) AT=340.025n

.meas tran vdout0_58ck670 FIND v(dout0_58) AT=340.025n

.meas tran vdout0_59ck670 FIND v(dout0_59) AT=340.025n

.meas tran vdout0_60ck670 FIND v(dout0_60) AT=340.025n

.meas tran vdout0_61ck670 FIND v(dout0_61) AT=340.025n

.meas tran vdout0_62ck670 FIND v(dout0_62) AT=340.025n

.meas tran vdout0_63ck670 FIND v(dout0_63) AT=340.025n

.meas tran vdout0_64ck670 FIND v(dout0_64) AT=340.025n

.meas tran vdout0_65ck670 FIND v(dout0_65) AT=340.025n

.meas tran vdout0_66ck670 FIND v(dout0_66) AT=340.025n

.meas tran vdout0_67ck670 FIND v(dout0_67) AT=340.025n

.meas tran vdout0_68ck670 FIND v(dout0_68) AT=340.025n

.meas tran vdout0_69ck670 FIND v(dout0_69) AT=340.025n

.meas tran vdout0_70ck670 FIND v(dout0_70) AT=340.025n

.meas tran vdout0_71ck670 FIND v(dout0_71) AT=340.025n

.meas tran vdout0_72ck670 FIND v(dout0_72) AT=340.025n

.meas tran vdout0_73ck670 FIND v(dout0_73) AT=340.025n

.meas tran vdout0_74ck670 FIND v(dout0_74) AT=340.025n

.meas tran vdout0_75ck670 FIND v(dout0_75) AT=340.025n

.meas tran vdout0_76ck670 FIND v(dout0_76) AT=340.025n

.meas tran vdout0_77ck670 FIND v(dout0_77) AT=340.025n

.meas tran vdout0_78ck670 FIND v(dout0_78) AT=340.025n

.meas tran vdout0_79ck670 FIND v(dout0_79) AT=340.025n

.meas tran vdout0_80ck670 FIND v(dout0_80) AT=340.025n

.meas tran vdout0_81ck670 FIND v(dout0_81) AT=340.025n

.meas tran vdout0_82ck670 FIND v(dout0_82) AT=340.025n

.meas tran vdout0_83ck670 FIND v(dout0_83) AT=340.025n

.meas tran vdout0_84ck670 FIND v(dout0_84) AT=340.025n

.meas tran vdout0_85ck670 FIND v(dout0_85) AT=340.025n

.meas tran vdout0_86ck670 FIND v(dout0_86) AT=340.025n

.meas tran vdout0_87ck670 FIND v(dout0_87) AT=340.025n

.meas tran vdout0_88ck670 FIND v(dout0_88) AT=340.025n

.meas tran vdout0_89ck670 FIND v(dout0_89) AT=340.025n

.meas tran vdout0_90ck670 FIND v(dout0_90) AT=340.025n

.meas tran vdout0_91ck670 FIND v(dout0_91) AT=340.025n

.meas tran vdout0_92ck670 FIND v(dout0_92) AT=340.025n

.meas tran vdout0_93ck670 FIND v(dout0_93) AT=340.025n

.meas tran vdout0_94ck670 FIND v(dout0_94) AT=340.025n

.meas tran vdout0_95ck670 FIND v(dout0_95) AT=340.025n

.meas tran vdout0_96ck670 FIND v(dout0_96) AT=340.025n

.meas tran vdout0_97ck670 FIND v(dout0_97) AT=340.025n

.meas tran vdout0_98ck670 FIND v(dout0_98) AT=340.025n

.meas tran vdout0_99ck670 FIND v(dout0_99) AT=340.025n

.meas tran vdout0_100ck670 FIND v(dout0_100) AT=340.025n

.meas tran vdout0_101ck670 FIND v(dout0_101) AT=340.025n

.meas tran vdout0_102ck670 FIND v(dout0_102) AT=340.025n

.meas tran vdout0_103ck670 FIND v(dout0_103) AT=340.025n

.meas tran vdout0_104ck670 FIND v(dout0_104) AT=340.025n

.meas tran vdout0_105ck670 FIND v(dout0_105) AT=340.025n

.meas tran vdout0_106ck670 FIND v(dout0_106) AT=340.025n

.meas tran vdout0_107ck670 FIND v(dout0_107) AT=340.025n

.meas tran vdout0_108ck670 FIND v(dout0_108) AT=340.025n

.meas tran vdout0_109ck670 FIND v(dout0_109) AT=340.025n

.meas tran vdout0_110ck670 FIND v(dout0_110) AT=340.025n

.meas tran vdout0_111ck670 FIND v(dout0_111) AT=340.025n

.meas tran vdout0_112ck670 FIND v(dout0_112) AT=340.025n

.meas tran vdout0_113ck670 FIND v(dout0_113) AT=340.025n

.meas tran vdout0_114ck670 FIND v(dout0_114) AT=340.025n

.meas tran vdout0_115ck670 FIND v(dout0_115) AT=340.025n

.meas tran vdout0_116ck670 FIND v(dout0_116) AT=340.025n

.meas tran vdout0_117ck670 FIND v(dout0_117) AT=340.025n

.meas tran vdout0_118ck670 FIND v(dout0_118) AT=340.025n

.meas tran vdout0_119ck670 FIND v(dout0_119) AT=340.025n

.meas tran vdout0_120ck670 FIND v(dout0_120) AT=340.025n

.meas tran vdout0_121ck670 FIND v(dout0_121) AT=340.025n

.meas tran vdout0_122ck670 FIND v(dout0_122) AT=340.025n

.meas tran vdout0_123ck670 FIND v(dout0_123) AT=340.025n

.meas tran vdout0_124ck670 FIND v(dout0_124) AT=340.025n

.meas tran vdout0_125ck670 FIND v(dout0_125) AT=340.025n

.meas tran vdout0_126ck670 FIND v(dout0_126) AT=340.025n

.meas tran vdout0_127ck670 FIND v(dout0_127) AT=340.025n

.meas tran vdout0_0ck680 FIND v(dout0_0) AT=345.025n

.meas tran vdout0_1ck680 FIND v(dout0_1) AT=345.025n

.meas tran vdout0_2ck680 FIND v(dout0_2) AT=345.025n

.meas tran vdout0_3ck680 FIND v(dout0_3) AT=345.025n

.meas tran vdout0_4ck680 FIND v(dout0_4) AT=345.025n

.meas tran vdout0_5ck680 FIND v(dout0_5) AT=345.025n

.meas tran vdout0_6ck680 FIND v(dout0_6) AT=345.025n

.meas tran vdout0_7ck680 FIND v(dout0_7) AT=345.025n

.meas tran vdout0_8ck680 FIND v(dout0_8) AT=345.025n

.meas tran vdout0_9ck680 FIND v(dout0_9) AT=345.025n

.meas tran vdout0_10ck680 FIND v(dout0_10) AT=345.025n

.meas tran vdout0_11ck680 FIND v(dout0_11) AT=345.025n

.meas tran vdout0_12ck680 FIND v(dout0_12) AT=345.025n

.meas tran vdout0_13ck680 FIND v(dout0_13) AT=345.025n

.meas tran vdout0_14ck680 FIND v(dout0_14) AT=345.025n

.meas tran vdout0_15ck680 FIND v(dout0_15) AT=345.025n

.meas tran vdout0_16ck680 FIND v(dout0_16) AT=345.025n

.meas tran vdout0_17ck680 FIND v(dout0_17) AT=345.025n

.meas tran vdout0_18ck680 FIND v(dout0_18) AT=345.025n

.meas tran vdout0_19ck680 FIND v(dout0_19) AT=345.025n

.meas tran vdout0_20ck680 FIND v(dout0_20) AT=345.025n

.meas tran vdout0_21ck680 FIND v(dout0_21) AT=345.025n

.meas tran vdout0_22ck680 FIND v(dout0_22) AT=345.025n

.meas tran vdout0_23ck680 FIND v(dout0_23) AT=345.025n

.meas tran vdout0_24ck680 FIND v(dout0_24) AT=345.025n

.meas tran vdout0_25ck680 FIND v(dout0_25) AT=345.025n

.meas tran vdout0_26ck680 FIND v(dout0_26) AT=345.025n

.meas tran vdout0_27ck680 FIND v(dout0_27) AT=345.025n

.meas tran vdout0_28ck680 FIND v(dout0_28) AT=345.025n

.meas tran vdout0_29ck680 FIND v(dout0_29) AT=345.025n

.meas tran vdout0_30ck680 FIND v(dout0_30) AT=345.025n

.meas tran vdout0_31ck680 FIND v(dout0_31) AT=345.025n

.meas tran vdout0_32ck680 FIND v(dout0_32) AT=345.025n

.meas tran vdout0_33ck680 FIND v(dout0_33) AT=345.025n

.meas tran vdout0_34ck680 FIND v(dout0_34) AT=345.025n

.meas tran vdout0_35ck680 FIND v(dout0_35) AT=345.025n

.meas tran vdout0_36ck680 FIND v(dout0_36) AT=345.025n

.meas tran vdout0_37ck680 FIND v(dout0_37) AT=345.025n

.meas tran vdout0_38ck680 FIND v(dout0_38) AT=345.025n

.meas tran vdout0_39ck680 FIND v(dout0_39) AT=345.025n

.meas tran vdout0_40ck680 FIND v(dout0_40) AT=345.025n

.meas tran vdout0_41ck680 FIND v(dout0_41) AT=345.025n

.meas tran vdout0_42ck680 FIND v(dout0_42) AT=345.025n

.meas tran vdout0_43ck680 FIND v(dout0_43) AT=345.025n

.meas tran vdout0_44ck680 FIND v(dout0_44) AT=345.025n

.meas tran vdout0_45ck680 FIND v(dout0_45) AT=345.025n

.meas tran vdout0_46ck680 FIND v(dout0_46) AT=345.025n

.meas tran vdout0_47ck680 FIND v(dout0_47) AT=345.025n

.meas tran vdout0_48ck680 FIND v(dout0_48) AT=345.025n

.meas tran vdout0_49ck680 FIND v(dout0_49) AT=345.025n

.meas tran vdout0_50ck680 FIND v(dout0_50) AT=345.025n

.meas tran vdout0_51ck680 FIND v(dout0_51) AT=345.025n

.meas tran vdout0_52ck680 FIND v(dout0_52) AT=345.025n

.meas tran vdout0_53ck680 FIND v(dout0_53) AT=345.025n

.meas tran vdout0_54ck680 FIND v(dout0_54) AT=345.025n

.meas tran vdout0_55ck680 FIND v(dout0_55) AT=345.025n

.meas tran vdout0_56ck680 FIND v(dout0_56) AT=345.025n

.meas tran vdout0_57ck680 FIND v(dout0_57) AT=345.025n

.meas tran vdout0_58ck680 FIND v(dout0_58) AT=345.025n

.meas tran vdout0_59ck680 FIND v(dout0_59) AT=345.025n

.meas tran vdout0_60ck680 FIND v(dout0_60) AT=345.025n

.meas tran vdout0_61ck680 FIND v(dout0_61) AT=345.025n

.meas tran vdout0_62ck680 FIND v(dout0_62) AT=345.025n

.meas tran vdout0_63ck680 FIND v(dout0_63) AT=345.025n

.meas tran vdout0_64ck680 FIND v(dout0_64) AT=345.025n

.meas tran vdout0_65ck680 FIND v(dout0_65) AT=345.025n

.meas tran vdout0_66ck680 FIND v(dout0_66) AT=345.025n

.meas tran vdout0_67ck680 FIND v(dout0_67) AT=345.025n

.meas tran vdout0_68ck680 FIND v(dout0_68) AT=345.025n

.meas tran vdout0_69ck680 FIND v(dout0_69) AT=345.025n

.meas tran vdout0_70ck680 FIND v(dout0_70) AT=345.025n

.meas tran vdout0_71ck680 FIND v(dout0_71) AT=345.025n

.meas tran vdout0_72ck680 FIND v(dout0_72) AT=345.025n

.meas tran vdout0_73ck680 FIND v(dout0_73) AT=345.025n

.meas tran vdout0_74ck680 FIND v(dout0_74) AT=345.025n

.meas tran vdout0_75ck680 FIND v(dout0_75) AT=345.025n

.meas tran vdout0_76ck680 FIND v(dout0_76) AT=345.025n

.meas tran vdout0_77ck680 FIND v(dout0_77) AT=345.025n

.meas tran vdout0_78ck680 FIND v(dout0_78) AT=345.025n

.meas tran vdout0_79ck680 FIND v(dout0_79) AT=345.025n

.meas tran vdout0_80ck680 FIND v(dout0_80) AT=345.025n

.meas tran vdout0_81ck680 FIND v(dout0_81) AT=345.025n

.meas tran vdout0_82ck680 FIND v(dout0_82) AT=345.025n

.meas tran vdout0_83ck680 FIND v(dout0_83) AT=345.025n

.meas tran vdout0_84ck680 FIND v(dout0_84) AT=345.025n

.meas tran vdout0_85ck680 FIND v(dout0_85) AT=345.025n

.meas tran vdout0_86ck680 FIND v(dout0_86) AT=345.025n

.meas tran vdout0_87ck680 FIND v(dout0_87) AT=345.025n

.meas tran vdout0_88ck680 FIND v(dout0_88) AT=345.025n

.meas tran vdout0_89ck680 FIND v(dout0_89) AT=345.025n

.meas tran vdout0_90ck680 FIND v(dout0_90) AT=345.025n

.meas tran vdout0_91ck680 FIND v(dout0_91) AT=345.025n

.meas tran vdout0_92ck680 FIND v(dout0_92) AT=345.025n

.meas tran vdout0_93ck680 FIND v(dout0_93) AT=345.025n

.meas tran vdout0_94ck680 FIND v(dout0_94) AT=345.025n

.meas tran vdout0_95ck680 FIND v(dout0_95) AT=345.025n

.meas tran vdout0_96ck680 FIND v(dout0_96) AT=345.025n

.meas tran vdout0_97ck680 FIND v(dout0_97) AT=345.025n

.meas tran vdout0_98ck680 FIND v(dout0_98) AT=345.025n

.meas tran vdout0_99ck680 FIND v(dout0_99) AT=345.025n

.meas tran vdout0_100ck680 FIND v(dout0_100) AT=345.025n

.meas tran vdout0_101ck680 FIND v(dout0_101) AT=345.025n

.meas tran vdout0_102ck680 FIND v(dout0_102) AT=345.025n

.meas tran vdout0_103ck680 FIND v(dout0_103) AT=345.025n

.meas tran vdout0_104ck680 FIND v(dout0_104) AT=345.025n

.meas tran vdout0_105ck680 FIND v(dout0_105) AT=345.025n

.meas tran vdout0_106ck680 FIND v(dout0_106) AT=345.025n

.meas tran vdout0_107ck680 FIND v(dout0_107) AT=345.025n

.meas tran vdout0_108ck680 FIND v(dout0_108) AT=345.025n

.meas tran vdout0_109ck680 FIND v(dout0_109) AT=345.025n

.meas tran vdout0_110ck680 FIND v(dout0_110) AT=345.025n

.meas tran vdout0_111ck680 FIND v(dout0_111) AT=345.025n

.meas tran vdout0_112ck680 FIND v(dout0_112) AT=345.025n

.meas tran vdout0_113ck680 FIND v(dout0_113) AT=345.025n

.meas tran vdout0_114ck680 FIND v(dout0_114) AT=345.025n

.meas tran vdout0_115ck680 FIND v(dout0_115) AT=345.025n

.meas tran vdout0_116ck680 FIND v(dout0_116) AT=345.025n

.meas tran vdout0_117ck680 FIND v(dout0_117) AT=345.025n

.meas tran vdout0_118ck680 FIND v(dout0_118) AT=345.025n

.meas tran vdout0_119ck680 FIND v(dout0_119) AT=345.025n

.meas tran vdout0_120ck680 FIND v(dout0_120) AT=345.025n

.meas tran vdout0_121ck680 FIND v(dout0_121) AT=345.025n

.meas tran vdout0_122ck680 FIND v(dout0_122) AT=345.025n

.meas tran vdout0_123ck680 FIND v(dout0_123) AT=345.025n

.meas tran vdout0_124ck680 FIND v(dout0_124) AT=345.025n

.meas tran vdout0_125ck680 FIND v(dout0_125) AT=345.025n

.meas tran vdout0_126ck680 FIND v(dout0_126) AT=345.025n

.meas tran vdout0_127ck680 FIND v(dout0_127) AT=345.025n

.meas tran vdout0_0ck690 FIND v(dout0_0) AT=350.025n

.meas tran vdout0_1ck690 FIND v(dout0_1) AT=350.025n

.meas tran vdout0_2ck690 FIND v(dout0_2) AT=350.025n

.meas tran vdout0_3ck690 FIND v(dout0_3) AT=350.025n

.meas tran vdout0_4ck690 FIND v(dout0_4) AT=350.025n

.meas tran vdout0_5ck690 FIND v(dout0_5) AT=350.025n

.meas tran vdout0_6ck690 FIND v(dout0_6) AT=350.025n

.meas tran vdout0_7ck690 FIND v(dout0_7) AT=350.025n

.meas tran vdout0_8ck690 FIND v(dout0_8) AT=350.025n

.meas tran vdout0_9ck690 FIND v(dout0_9) AT=350.025n

.meas tran vdout0_10ck690 FIND v(dout0_10) AT=350.025n

.meas tran vdout0_11ck690 FIND v(dout0_11) AT=350.025n

.meas tran vdout0_12ck690 FIND v(dout0_12) AT=350.025n

.meas tran vdout0_13ck690 FIND v(dout0_13) AT=350.025n

.meas tran vdout0_14ck690 FIND v(dout0_14) AT=350.025n

.meas tran vdout0_15ck690 FIND v(dout0_15) AT=350.025n

.meas tran vdout0_16ck690 FIND v(dout0_16) AT=350.025n

.meas tran vdout0_17ck690 FIND v(dout0_17) AT=350.025n

.meas tran vdout0_18ck690 FIND v(dout0_18) AT=350.025n

.meas tran vdout0_19ck690 FIND v(dout0_19) AT=350.025n

.meas tran vdout0_20ck690 FIND v(dout0_20) AT=350.025n

.meas tran vdout0_21ck690 FIND v(dout0_21) AT=350.025n

.meas tran vdout0_22ck690 FIND v(dout0_22) AT=350.025n

.meas tran vdout0_23ck690 FIND v(dout0_23) AT=350.025n

.meas tran vdout0_24ck690 FIND v(dout0_24) AT=350.025n

.meas tran vdout0_25ck690 FIND v(dout0_25) AT=350.025n

.meas tran vdout0_26ck690 FIND v(dout0_26) AT=350.025n

.meas tran vdout0_27ck690 FIND v(dout0_27) AT=350.025n

.meas tran vdout0_28ck690 FIND v(dout0_28) AT=350.025n

.meas tran vdout0_29ck690 FIND v(dout0_29) AT=350.025n

.meas tran vdout0_30ck690 FIND v(dout0_30) AT=350.025n

.meas tran vdout0_31ck690 FIND v(dout0_31) AT=350.025n

.meas tran vdout0_32ck690 FIND v(dout0_32) AT=350.025n

.meas tran vdout0_33ck690 FIND v(dout0_33) AT=350.025n

.meas tran vdout0_34ck690 FIND v(dout0_34) AT=350.025n

.meas tran vdout0_35ck690 FIND v(dout0_35) AT=350.025n

.meas tran vdout0_36ck690 FIND v(dout0_36) AT=350.025n

.meas tran vdout0_37ck690 FIND v(dout0_37) AT=350.025n

.meas tran vdout0_38ck690 FIND v(dout0_38) AT=350.025n

.meas tran vdout0_39ck690 FIND v(dout0_39) AT=350.025n

.meas tran vdout0_40ck690 FIND v(dout0_40) AT=350.025n

.meas tran vdout0_41ck690 FIND v(dout0_41) AT=350.025n

.meas tran vdout0_42ck690 FIND v(dout0_42) AT=350.025n

.meas tran vdout0_43ck690 FIND v(dout0_43) AT=350.025n

.meas tran vdout0_44ck690 FIND v(dout0_44) AT=350.025n

.meas tran vdout0_45ck690 FIND v(dout0_45) AT=350.025n

.meas tran vdout0_46ck690 FIND v(dout0_46) AT=350.025n

.meas tran vdout0_47ck690 FIND v(dout0_47) AT=350.025n

.meas tran vdout0_48ck690 FIND v(dout0_48) AT=350.025n

.meas tran vdout0_49ck690 FIND v(dout0_49) AT=350.025n

.meas tran vdout0_50ck690 FIND v(dout0_50) AT=350.025n

.meas tran vdout0_51ck690 FIND v(dout0_51) AT=350.025n

.meas tran vdout0_52ck690 FIND v(dout0_52) AT=350.025n

.meas tran vdout0_53ck690 FIND v(dout0_53) AT=350.025n

.meas tran vdout0_54ck690 FIND v(dout0_54) AT=350.025n

.meas tran vdout0_55ck690 FIND v(dout0_55) AT=350.025n

.meas tran vdout0_56ck690 FIND v(dout0_56) AT=350.025n

.meas tran vdout0_57ck690 FIND v(dout0_57) AT=350.025n

.meas tran vdout0_58ck690 FIND v(dout0_58) AT=350.025n

.meas tran vdout0_59ck690 FIND v(dout0_59) AT=350.025n

.meas tran vdout0_60ck690 FIND v(dout0_60) AT=350.025n

.meas tran vdout0_61ck690 FIND v(dout0_61) AT=350.025n

.meas tran vdout0_62ck690 FIND v(dout0_62) AT=350.025n

.meas tran vdout0_63ck690 FIND v(dout0_63) AT=350.025n

.meas tran vdout0_64ck690 FIND v(dout0_64) AT=350.025n

.meas tran vdout0_65ck690 FIND v(dout0_65) AT=350.025n

.meas tran vdout0_66ck690 FIND v(dout0_66) AT=350.025n

.meas tran vdout0_67ck690 FIND v(dout0_67) AT=350.025n

.meas tran vdout0_68ck690 FIND v(dout0_68) AT=350.025n

.meas tran vdout0_69ck690 FIND v(dout0_69) AT=350.025n

.meas tran vdout0_70ck690 FIND v(dout0_70) AT=350.025n

.meas tran vdout0_71ck690 FIND v(dout0_71) AT=350.025n

.meas tran vdout0_72ck690 FIND v(dout0_72) AT=350.025n

.meas tran vdout0_73ck690 FIND v(dout0_73) AT=350.025n

.meas tran vdout0_74ck690 FIND v(dout0_74) AT=350.025n

.meas tran vdout0_75ck690 FIND v(dout0_75) AT=350.025n

.meas tran vdout0_76ck690 FIND v(dout0_76) AT=350.025n

.meas tran vdout0_77ck690 FIND v(dout0_77) AT=350.025n

.meas tran vdout0_78ck690 FIND v(dout0_78) AT=350.025n

.meas tran vdout0_79ck690 FIND v(dout0_79) AT=350.025n

.meas tran vdout0_80ck690 FIND v(dout0_80) AT=350.025n

.meas tran vdout0_81ck690 FIND v(dout0_81) AT=350.025n

.meas tran vdout0_82ck690 FIND v(dout0_82) AT=350.025n

.meas tran vdout0_83ck690 FIND v(dout0_83) AT=350.025n

.meas tran vdout0_84ck690 FIND v(dout0_84) AT=350.025n

.meas tran vdout0_85ck690 FIND v(dout0_85) AT=350.025n

.meas tran vdout0_86ck690 FIND v(dout0_86) AT=350.025n

.meas tran vdout0_87ck690 FIND v(dout0_87) AT=350.025n

.meas tran vdout0_88ck690 FIND v(dout0_88) AT=350.025n

.meas tran vdout0_89ck690 FIND v(dout0_89) AT=350.025n

.meas tran vdout0_90ck690 FIND v(dout0_90) AT=350.025n

.meas tran vdout0_91ck690 FIND v(dout0_91) AT=350.025n

.meas tran vdout0_92ck690 FIND v(dout0_92) AT=350.025n

.meas tran vdout0_93ck690 FIND v(dout0_93) AT=350.025n

.meas tran vdout0_94ck690 FIND v(dout0_94) AT=350.025n

.meas tran vdout0_95ck690 FIND v(dout0_95) AT=350.025n

.meas tran vdout0_96ck690 FIND v(dout0_96) AT=350.025n

.meas tran vdout0_97ck690 FIND v(dout0_97) AT=350.025n

.meas tran vdout0_98ck690 FIND v(dout0_98) AT=350.025n

.meas tran vdout0_99ck690 FIND v(dout0_99) AT=350.025n

.meas tran vdout0_100ck690 FIND v(dout0_100) AT=350.025n

.meas tran vdout0_101ck690 FIND v(dout0_101) AT=350.025n

.meas tran vdout0_102ck690 FIND v(dout0_102) AT=350.025n

.meas tran vdout0_103ck690 FIND v(dout0_103) AT=350.025n

.meas tran vdout0_104ck690 FIND v(dout0_104) AT=350.025n

.meas tran vdout0_105ck690 FIND v(dout0_105) AT=350.025n

.meas tran vdout0_106ck690 FIND v(dout0_106) AT=350.025n

.meas tran vdout0_107ck690 FIND v(dout0_107) AT=350.025n

.meas tran vdout0_108ck690 FIND v(dout0_108) AT=350.025n

.meas tran vdout0_109ck690 FIND v(dout0_109) AT=350.025n

.meas tran vdout0_110ck690 FIND v(dout0_110) AT=350.025n

.meas tran vdout0_111ck690 FIND v(dout0_111) AT=350.025n

.meas tran vdout0_112ck690 FIND v(dout0_112) AT=350.025n

.meas tran vdout0_113ck690 FIND v(dout0_113) AT=350.025n

.meas tran vdout0_114ck690 FIND v(dout0_114) AT=350.025n

.meas tran vdout0_115ck690 FIND v(dout0_115) AT=350.025n

.meas tran vdout0_116ck690 FIND v(dout0_116) AT=350.025n

.meas tran vdout0_117ck690 FIND v(dout0_117) AT=350.025n

.meas tran vdout0_118ck690 FIND v(dout0_118) AT=350.025n

.meas tran vdout0_119ck690 FIND v(dout0_119) AT=350.025n

.meas tran vdout0_120ck690 FIND v(dout0_120) AT=350.025n

.meas tran vdout0_121ck690 FIND v(dout0_121) AT=350.025n

.meas tran vdout0_122ck690 FIND v(dout0_122) AT=350.025n

.meas tran vdout0_123ck690 FIND v(dout0_123) AT=350.025n

.meas tran vdout0_124ck690 FIND v(dout0_124) AT=350.025n

.meas tran vdout0_125ck690 FIND v(dout0_125) AT=350.025n

.meas tran vdout0_126ck690 FIND v(dout0_126) AT=350.025n

.meas tran vdout0_127ck690 FIND v(dout0_127) AT=350.025n

.meas tran vdout0_0ck700 FIND v(dout0_0) AT=355.025n

.meas tran vdout0_1ck700 FIND v(dout0_1) AT=355.025n

.meas tran vdout0_2ck700 FIND v(dout0_2) AT=355.025n

.meas tran vdout0_3ck700 FIND v(dout0_3) AT=355.025n

.meas tran vdout0_4ck700 FIND v(dout0_4) AT=355.025n

.meas tran vdout0_5ck700 FIND v(dout0_5) AT=355.025n

.meas tran vdout0_6ck700 FIND v(dout0_6) AT=355.025n

.meas tran vdout0_7ck700 FIND v(dout0_7) AT=355.025n

.meas tran vdout0_8ck700 FIND v(dout0_8) AT=355.025n

.meas tran vdout0_9ck700 FIND v(dout0_9) AT=355.025n

.meas tran vdout0_10ck700 FIND v(dout0_10) AT=355.025n

.meas tran vdout0_11ck700 FIND v(dout0_11) AT=355.025n

.meas tran vdout0_12ck700 FIND v(dout0_12) AT=355.025n

.meas tran vdout0_13ck700 FIND v(dout0_13) AT=355.025n

.meas tran vdout0_14ck700 FIND v(dout0_14) AT=355.025n

.meas tran vdout0_15ck700 FIND v(dout0_15) AT=355.025n

.meas tran vdout0_16ck700 FIND v(dout0_16) AT=355.025n

.meas tran vdout0_17ck700 FIND v(dout0_17) AT=355.025n

.meas tran vdout0_18ck700 FIND v(dout0_18) AT=355.025n

.meas tran vdout0_19ck700 FIND v(dout0_19) AT=355.025n

.meas tran vdout0_20ck700 FIND v(dout0_20) AT=355.025n

.meas tran vdout0_21ck700 FIND v(dout0_21) AT=355.025n

.meas tran vdout0_22ck700 FIND v(dout0_22) AT=355.025n

.meas tran vdout0_23ck700 FIND v(dout0_23) AT=355.025n

.meas tran vdout0_24ck700 FIND v(dout0_24) AT=355.025n

.meas tran vdout0_25ck700 FIND v(dout0_25) AT=355.025n

.meas tran vdout0_26ck700 FIND v(dout0_26) AT=355.025n

.meas tran vdout0_27ck700 FIND v(dout0_27) AT=355.025n

.meas tran vdout0_28ck700 FIND v(dout0_28) AT=355.025n

.meas tran vdout0_29ck700 FIND v(dout0_29) AT=355.025n

.meas tran vdout0_30ck700 FIND v(dout0_30) AT=355.025n

.meas tran vdout0_31ck700 FIND v(dout0_31) AT=355.025n

.meas tran vdout0_32ck700 FIND v(dout0_32) AT=355.025n

.meas tran vdout0_33ck700 FIND v(dout0_33) AT=355.025n

.meas tran vdout0_34ck700 FIND v(dout0_34) AT=355.025n

.meas tran vdout0_35ck700 FIND v(dout0_35) AT=355.025n

.meas tran vdout0_36ck700 FIND v(dout0_36) AT=355.025n

.meas tran vdout0_37ck700 FIND v(dout0_37) AT=355.025n

.meas tran vdout0_38ck700 FIND v(dout0_38) AT=355.025n

.meas tran vdout0_39ck700 FIND v(dout0_39) AT=355.025n

.meas tran vdout0_40ck700 FIND v(dout0_40) AT=355.025n

.meas tran vdout0_41ck700 FIND v(dout0_41) AT=355.025n

.meas tran vdout0_42ck700 FIND v(dout0_42) AT=355.025n

.meas tran vdout0_43ck700 FIND v(dout0_43) AT=355.025n

.meas tran vdout0_44ck700 FIND v(dout0_44) AT=355.025n

.meas tran vdout0_45ck700 FIND v(dout0_45) AT=355.025n

.meas tran vdout0_46ck700 FIND v(dout0_46) AT=355.025n

.meas tran vdout0_47ck700 FIND v(dout0_47) AT=355.025n

.meas tran vdout0_48ck700 FIND v(dout0_48) AT=355.025n

.meas tran vdout0_49ck700 FIND v(dout0_49) AT=355.025n

.meas tran vdout0_50ck700 FIND v(dout0_50) AT=355.025n

.meas tran vdout0_51ck700 FIND v(dout0_51) AT=355.025n

.meas tran vdout0_52ck700 FIND v(dout0_52) AT=355.025n

.meas tran vdout0_53ck700 FIND v(dout0_53) AT=355.025n

.meas tran vdout0_54ck700 FIND v(dout0_54) AT=355.025n

.meas tran vdout0_55ck700 FIND v(dout0_55) AT=355.025n

.meas tran vdout0_56ck700 FIND v(dout0_56) AT=355.025n

.meas tran vdout0_57ck700 FIND v(dout0_57) AT=355.025n

.meas tran vdout0_58ck700 FIND v(dout0_58) AT=355.025n

.meas tran vdout0_59ck700 FIND v(dout0_59) AT=355.025n

.meas tran vdout0_60ck700 FIND v(dout0_60) AT=355.025n

.meas tran vdout0_61ck700 FIND v(dout0_61) AT=355.025n

.meas tran vdout0_62ck700 FIND v(dout0_62) AT=355.025n

.meas tran vdout0_63ck700 FIND v(dout0_63) AT=355.025n

.meas tran vdout0_64ck700 FIND v(dout0_64) AT=355.025n

.meas tran vdout0_65ck700 FIND v(dout0_65) AT=355.025n

.meas tran vdout0_66ck700 FIND v(dout0_66) AT=355.025n

.meas tran vdout0_67ck700 FIND v(dout0_67) AT=355.025n

.meas tran vdout0_68ck700 FIND v(dout0_68) AT=355.025n

.meas tran vdout0_69ck700 FIND v(dout0_69) AT=355.025n

.meas tran vdout0_70ck700 FIND v(dout0_70) AT=355.025n

.meas tran vdout0_71ck700 FIND v(dout0_71) AT=355.025n

.meas tran vdout0_72ck700 FIND v(dout0_72) AT=355.025n

.meas tran vdout0_73ck700 FIND v(dout0_73) AT=355.025n

.meas tran vdout0_74ck700 FIND v(dout0_74) AT=355.025n

.meas tran vdout0_75ck700 FIND v(dout0_75) AT=355.025n

.meas tran vdout0_76ck700 FIND v(dout0_76) AT=355.025n

.meas tran vdout0_77ck700 FIND v(dout0_77) AT=355.025n

.meas tran vdout0_78ck700 FIND v(dout0_78) AT=355.025n

.meas tran vdout0_79ck700 FIND v(dout0_79) AT=355.025n

.meas tran vdout0_80ck700 FIND v(dout0_80) AT=355.025n

.meas tran vdout0_81ck700 FIND v(dout0_81) AT=355.025n

.meas tran vdout0_82ck700 FIND v(dout0_82) AT=355.025n

.meas tran vdout0_83ck700 FIND v(dout0_83) AT=355.025n

.meas tran vdout0_84ck700 FIND v(dout0_84) AT=355.025n

.meas tran vdout0_85ck700 FIND v(dout0_85) AT=355.025n

.meas tran vdout0_86ck700 FIND v(dout0_86) AT=355.025n

.meas tran vdout0_87ck700 FIND v(dout0_87) AT=355.025n

.meas tran vdout0_88ck700 FIND v(dout0_88) AT=355.025n

.meas tran vdout0_89ck700 FIND v(dout0_89) AT=355.025n

.meas tran vdout0_90ck700 FIND v(dout0_90) AT=355.025n

.meas tran vdout0_91ck700 FIND v(dout0_91) AT=355.025n

.meas tran vdout0_92ck700 FIND v(dout0_92) AT=355.025n

.meas tran vdout0_93ck700 FIND v(dout0_93) AT=355.025n

.meas tran vdout0_94ck700 FIND v(dout0_94) AT=355.025n

.meas tran vdout0_95ck700 FIND v(dout0_95) AT=355.025n

.meas tran vdout0_96ck700 FIND v(dout0_96) AT=355.025n

.meas tran vdout0_97ck700 FIND v(dout0_97) AT=355.025n

.meas tran vdout0_98ck700 FIND v(dout0_98) AT=355.025n

.meas tran vdout0_99ck700 FIND v(dout0_99) AT=355.025n

.meas tran vdout0_100ck700 FIND v(dout0_100) AT=355.025n

.meas tran vdout0_101ck700 FIND v(dout0_101) AT=355.025n

.meas tran vdout0_102ck700 FIND v(dout0_102) AT=355.025n

.meas tran vdout0_103ck700 FIND v(dout0_103) AT=355.025n

.meas tran vdout0_104ck700 FIND v(dout0_104) AT=355.025n

.meas tran vdout0_105ck700 FIND v(dout0_105) AT=355.025n

.meas tran vdout0_106ck700 FIND v(dout0_106) AT=355.025n

.meas tran vdout0_107ck700 FIND v(dout0_107) AT=355.025n

.meas tran vdout0_108ck700 FIND v(dout0_108) AT=355.025n

.meas tran vdout0_109ck700 FIND v(dout0_109) AT=355.025n

.meas tran vdout0_110ck700 FIND v(dout0_110) AT=355.025n

.meas tran vdout0_111ck700 FIND v(dout0_111) AT=355.025n

.meas tran vdout0_112ck700 FIND v(dout0_112) AT=355.025n

.meas tran vdout0_113ck700 FIND v(dout0_113) AT=355.025n

.meas tran vdout0_114ck700 FIND v(dout0_114) AT=355.025n

.meas tran vdout0_115ck700 FIND v(dout0_115) AT=355.025n

.meas tran vdout0_116ck700 FIND v(dout0_116) AT=355.025n

.meas tran vdout0_117ck700 FIND v(dout0_117) AT=355.025n

.meas tran vdout0_118ck700 FIND v(dout0_118) AT=355.025n

.meas tran vdout0_119ck700 FIND v(dout0_119) AT=355.025n

.meas tran vdout0_120ck700 FIND v(dout0_120) AT=355.025n

.meas tran vdout0_121ck700 FIND v(dout0_121) AT=355.025n

.meas tran vdout0_122ck700 FIND v(dout0_122) AT=355.025n

.meas tran vdout0_123ck700 FIND v(dout0_123) AT=355.025n

.meas tran vdout0_124ck700 FIND v(dout0_124) AT=355.025n

.meas tran vdout0_125ck700 FIND v(dout0_125) AT=355.025n

.meas tran vdout0_126ck700 FIND v(dout0_126) AT=355.025n

.meas tran vdout0_127ck700 FIND v(dout0_127) AT=355.025n

.meas tran vdout0_0ck710 FIND v(dout0_0) AT=360.025n

.meas tran vdout0_1ck710 FIND v(dout0_1) AT=360.025n

.meas tran vdout0_2ck710 FIND v(dout0_2) AT=360.025n

.meas tran vdout0_3ck710 FIND v(dout0_3) AT=360.025n

.meas tran vdout0_4ck710 FIND v(dout0_4) AT=360.025n

.meas tran vdout0_5ck710 FIND v(dout0_5) AT=360.025n

.meas tran vdout0_6ck710 FIND v(dout0_6) AT=360.025n

.meas tran vdout0_7ck710 FIND v(dout0_7) AT=360.025n

.meas tran vdout0_8ck710 FIND v(dout0_8) AT=360.025n

.meas tran vdout0_9ck710 FIND v(dout0_9) AT=360.025n

.meas tran vdout0_10ck710 FIND v(dout0_10) AT=360.025n

.meas tran vdout0_11ck710 FIND v(dout0_11) AT=360.025n

.meas tran vdout0_12ck710 FIND v(dout0_12) AT=360.025n

.meas tran vdout0_13ck710 FIND v(dout0_13) AT=360.025n

.meas tran vdout0_14ck710 FIND v(dout0_14) AT=360.025n

.meas tran vdout0_15ck710 FIND v(dout0_15) AT=360.025n

.meas tran vdout0_16ck710 FIND v(dout0_16) AT=360.025n

.meas tran vdout0_17ck710 FIND v(dout0_17) AT=360.025n

.meas tran vdout0_18ck710 FIND v(dout0_18) AT=360.025n

.meas tran vdout0_19ck710 FIND v(dout0_19) AT=360.025n

.meas tran vdout0_20ck710 FIND v(dout0_20) AT=360.025n

.meas tran vdout0_21ck710 FIND v(dout0_21) AT=360.025n

.meas tran vdout0_22ck710 FIND v(dout0_22) AT=360.025n

.meas tran vdout0_23ck710 FIND v(dout0_23) AT=360.025n

.meas tran vdout0_24ck710 FIND v(dout0_24) AT=360.025n

.meas tran vdout0_25ck710 FIND v(dout0_25) AT=360.025n

.meas tran vdout0_26ck710 FIND v(dout0_26) AT=360.025n

.meas tran vdout0_27ck710 FIND v(dout0_27) AT=360.025n

.meas tran vdout0_28ck710 FIND v(dout0_28) AT=360.025n

.meas tran vdout0_29ck710 FIND v(dout0_29) AT=360.025n

.meas tran vdout0_30ck710 FIND v(dout0_30) AT=360.025n

.meas tran vdout0_31ck710 FIND v(dout0_31) AT=360.025n

.meas tran vdout0_32ck710 FIND v(dout0_32) AT=360.025n

.meas tran vdout0_33ck710 FIND v(dout0_33) AT=360.025n

.meas tran vdout0_34ck710 FIND v(dout0_34) AT=360.025n

.meas tran vdout0_35ck710 FIND v(dout0_35) AT=360.025n

.meas tran vdout0_36ck710 FIND v(dout0_36) AT=360.025n

.meas tran vdout0_37ck710 FIND v(dout0_37) AT=360.025n

.meas tran vdout0_38ck710 FIND v(dout0_38) AT=360.025n

.meas tran vdout0_39ck710 FIND v(dout0_39) AT=360.025n

.meas tran vdout0_40ck710 FIND v(dout0_40) AT=360.025n

.meas tran vdout0_41ck710 FIND v(dout0_41) AT=360.025n

.meas tran vdout0_42ck710 FIND v(dout0_42) AT=360.025n

.meas tran vdout0_43ck710 FIND v(dout0_43) AT=360.025n

.meas tran vdout0_44ck710 FIND v(dout0_44) AT=360.025n

.meas tran vdout0_45ck710 FIND v(dout0_45) AT=360.025n

.meas tran vdout0_46ck710 FIND v(dout0_46) AT=360.025n

.meas tran vdout0_47ck710 FIND v(dout0_47) AT=360.025n

.meas tran vdout0_48ck710 FIND v(dout0_48) AT=360.025n

.meas tran vdout0_49ck710 FIND v(dout0_49) AT=360.025n

.meas tran vdout0_50ck710 FIND v(dout0_50) AT=360.025n

.meas tran vdout0_51ck710 FIND v(dout0_51) AT=360.025n

.meas tran vdout0_52ck710 FIND v(dout0_52) AT=360.025n

.meas tran vdout0_53ck710 FIND v(dout0_53) AT=360.025n

.meas tran vdout0_54ck710 FIND v(dout0_54) AT=360.025n

.meas tran vdout0_55ck710 FIND v(dout0_55) AT=360.025n

.meas tran vdout0_56ck710 FIND v(dout0_56) AT=360.025n

.meas tran vdout0_57ck710 FIND v(dout0_57) AT=360.025n

.meas tran vdout0_58ck710 FIND v(dout0_58) AT=360.025n

.meas tran vdout0_59ck710 FIND v(dout0_59) AT=360.025n

.meas tran vdout0_60ck710 FIND v(dout0_60) AT=360.025n

.meas tran vdout0_61ck710 FIND v(dout0_61) AT=360.025n

.meas tran vdout0_62ck710 FIND v(dout0_62) AT=360.025n

.meas tran vdout0_63ck710 FIND v(dout0_63) AT=360.025n

.meas tran vdout0_64ck710 FIND v(dout0_64) AT=360.025n

.meas tran vdout0_65ck710 FIND v(dout0_65) AT=360.025n

.meas tran vdout0_66ck710 FIND v(dout0_66) AT=360.025n

.meas tran vdout0_67ck710 FIND v(dout0_67) AT=360.025n

.meas tran vdout0_68ck710 FIND v(dout0_68) AT=360.025n

.meas tran vdout0_69ck710 FIND v(dout0_69) AT=360.025n

.meas tran vdout0_70ck710 FIND v(dout0_70) AT=360.025n

.meas tran vdout0_71ck710 FIND v(dout0_71) AT=360.025n

.meas tran vdout0_72ck710 FIND v(dout0_72) AT=360.025n

.meas tran vdout0_73ck710 FIND v(dout0_73) AT=360.025n

.meas tran vdout0_74ck710 FIND v(dout0_74) AT=360.025n

.meas tran vdout0_75ck710 FIND v(dout0_75) AT=360.025n

.meas tran vdout0_76ck710 FIND v(dout0_76) AT=360.025n

.meas tran vdout0_77ck710 FIND v(dout0_77) AT=360.025n

.meas tran vdout0_78ck710 FIND v(dout0_78) AT=360.025n

.meas tran vdout0_79ck710 FIND v(dout0_79) AT=360.025n

.meas tran vdout0_80ck710 FIND v(dout0_80) AT=360.025n

.meas tran vdout0_81ck710 FIND v(dout0_81) AT=360.025n

.meas tran vdout0_82ck710 FIND v(dout0_82) AT=360.025n

.meas tran vdout0_83ck710 FIND v(dout0_83) AT=360.025n

.meas tran vdout0_84ck710 FIND v(dout0_84) AT=360.025n

.meas tran vdout0_85ck710 FIND v(dout0_85) AT=360.025n

.meas tran vdout0_86ck710 FIND v(dout0_86) AT=360.025n

.meas tran vdout0_87ck710 FIND v(dout0_87) AT=360.025n

.meas tran vdout0_88ck710 FIND v(dout0_88) AT=360.025n

.meas tran vdout0_89ck710 FIND v(dout0_89) AT=360.025n

.meas tran vdout0_90ck710 FIND v(dout0_90) AT=360.025n

.meas tran vdout0_91ck710 FIND v(dout0_91) AT=360.025n

.meas tran vdout0_92ck710 FIND v(dout0_92) AT=360.025n

.meas tran vdout0_93ck710 FIND v(dout0_93) AT=360.025n

.meas tran vdout0_94ck710 FIND v(dout0_94) AT=360.025n

.meas tran vdout0_95ck710 FIND v(dout0_95) AT=360.025n

.meas tran vdout0_96ck710 FIND v(dout0_96) AT=360.025n

.meas tran vdout0_97ck710 FIND v(dout0_97) AT=360.025n

.meas tran vdout0_98ck710 FIND v(dout0_98) AT=360.025n

.meas tran vdout0_99ck710 FIND v(dout0_99) AT=360.025n

.meas tran vdout0_100ck710 FIND v(dout0_100) AT=360.025n

.meas tran vdout0_101ck710 FIND v(dout0_101) AT=360.025n

.meas tran vdout0_102ck710 FIND v(dout0_102) AT=360.025n

.meas tran vdout0_103ck710 FIND v(dout0_103) AT=360.025n

.meas tran vdout0_104ck710 FIND v(dout0_104) AT=360.025n

.meas tran vdout0_105ck710 FIND v(dout0_105) AT=360.025n

.meas tran vdout0_106ck710 FIND v(dout0_106) AT=360.025n

.meas tran vdout0_107ck710 FIND v(dout0_107) AT=360.025n

.meas tran vdout0_108ck710 FIND v(dout0_108) AT=360.025n

.meas tran vdout0_109ck710 FIND v(dout0_109) AT=360.025n

.meas tran vdout0_110ck710 FIND v(dout0_110) AT=360.025n

.meas tran vdout0_111ck710 FIND v(dout0_111) AT=360.025n

.meas tran vdout0_112ck710 FIND v(dout0_112) AT=360.025n

.meas tran vdout0_113ck710 FIND v(dout0_113) AT=360.025n

.meas tran vdout0_114ck710 FIND v(dout0_114) AT=360.025n

.meas tran vdout0_115ck710 FIND v(dout0_115) AT=360.025n

.meas tran vdout0_116ck710 FIND v(dout0_116) AT=360.025n

.meas tran vdout0_117ck710 FIND v(dout0_117) AT=360.025n

.meas tran vdout0_118ck710 FIND v(dout0_118) AT=360.025n

.meas tran vdout0_119ck710 FIND v(dout0_119) AT=360.025n

.meas tran vdout0_120ck710 FIND v(dout0_120) AT=360.025n

.meas tran vdout0_121ck710 FIND v(dout0_121) AT=360.025n

.meas tran vdout0_122ck710 FIND v(dout0_122) AT=360.025n

.meas tran vdout0_123ck710 FIND v(dout0_123) AT=360.025n

.meas tran vdout0_124ck710 FIND v(dout0_124) AT=360.025n

.meas tran vdout0_125ck710 FIND v(dout0_125) AT=360.025n

.meas tran vdout0_126ck710 FIND v(dout0_126) AT=360.025n

.meas tran vdout0_127ck710 FIND v(dout0_127) AT=360.025n

.meas tran vdout0_0ck750 FIND v(dout0_0) AT=380.025n

.meas tran vdout0_1ck750 FIND v(dout0_1) AT=380.025n

.meas tran vdout0_2ck750 FIND v(dout0_2) AT=380.025n

.meas tran vdout0_3ck750 FIND v(dout0_3) AT=380.025n

.meas tran vdout0_4ck750 FIND v(dout0_4) AT=380.025n

.meas tran vdout0_5ck750 FIND v(dout0_5) AT=380.025n

.meas tran vdout0_6ck750 FIND v(dout0_6) AT=380.025n

.meas tran vdout0_7ck750 FIND v(dout0_7) AT=380.025n

.meas tran vdout0_8ck750 FIND v(dout0_8) AT=380.025n

.meas tran vdout0_9ck750 FIND v(dout0_9) AT=380.025n

.meas tran vdout0_10ck750 FIND v(dout0_10) AT=380.025n

.meas tran vdout0_11ck750 FIND v(dout0_11) AT=380.025n

.meas tran vdout0_12ck750 FIND v(dout0_12) AT=380.025n

.meas tran vdout0_13ck750 FIND v(dout0_13) AT=380.025n

.meas tran vdout0_14ck750 FIND v(dout0_14) AT=380.025n

.meas tran vdout0_15ck750 FIND v(dout0_15) AT=380.025n

.meas tran vdout0_16ck750 FIND v(dout0_16) AT=380.025n

.meas tran vdout0_17ck750 FIND v(dout0_17) AT=380.025n

.meas tran vdout0_18ck750 FIND v(dout0_18) AT=380.025n

.meas tran vdout0_19ck750 FIND v(dout0_19) AT=380.025n

.meas tran vdout0_20ck750 FIND v(dout0_20) AT=380.025n

.meas tran vdout0_21ck750 FIND v(dout0_21) AT=380.025n

.meas tran vdout0_22ck750 FIND v(dout0_22) AT=380.025n

.meas tran vdout0_23ck750 FIND v(dout0_23) AT=380.025n

.meas tran vdout0_24ck750 FIND v(dout0_24) AT=380.025n

.meas tran vdout0_25ck750 FIND v(dout0_25) AT=380.025n

.meas tran vdout0_26ck750 FIND v(dout0_26) AT=380.025n

.meas tran vdout0_27ck750 FIND v(dout0_27) AT=380.025n

.meas tran vdout0_28ck750 FIND v(dout0_28) AT=380.025n

.meas tran vdout0_29ck750 FIND v(dout0_29) AT=380.025n

.meas tran vdout0_30ck750 FIND v(dout0_30) AT=380.025n

.meas tran vdout0_31ck750 FIND v(dout0_31) AT=380.025n

.meas tran vdout0_32ck750 FIND v(dout0_32) AT=380.025n

.meas tran vdout0_33ck750 FIND v(dout0_33) AT=380.025n

.meas tran vdout0_34ck750 FIND v(dout0_34) AT=380.025n

.meas tran vdout0_35ck750 FIND v(dout0_35) AT=380.025n

.meas tran vdout0_36ck750 FIND v(dout0_36) AT=380.025n

.meas tran vdout0_37ck750 FIND v(dout0_37) AT=380.025n

.meas tran vdout0_38ck750 FIND v(dout0_38) AT=380.025n

.meas tran vdout0_39ck750 FIND v(dout0_39) AT=380.025n

.meas tran vdout0_40ck750 FIND v(dout0_40) AT=380.025n

.meas tran vdout0_41ck750 FIND v(dout0_41) AT=380.025n

.meas tran vdout0_42ck750 FIND v(dout0_42) AT=380.025n

.meas tran vdout0_43ck750 FIND v(dout0_43) AT=380.025n

.meas tran vdout0_44ck750 FIND v(dout0_44) AT=380.025n

.meas tran vdout0_45ck750 FIND v(dout0_45) AT=380.025n

.meas tran vdout0_46ck750 FIND v(dout0_46) AT=380.025n

.meas tran vdout0_47ck750 FIND v(dout0_47) AT=380.025n

.meas tran vdout0_48ck750 FIND v(dout0_48) AT=380.025n

.meas tran vdout0_49ck750 FIND v(dout0_49) AT=380.025n

.meas tran vdout0_50ck750 FIND v(dout0_50) AT=380.025n

.meas tran vdout0_51ck750 FIND v(dout0_51) AT=380.025n

.meas tran vdout0_52ck750 FIND v(dout0_52) AT=380.025n

.meas tran vdout0_53ck750 FIND v(dout0_53) AT=380.025n

.meas tran vdout0_54ck750 FIND v(dout0_54) AT=380.025n

.meas tran vdout0_55ck750 FIND v(dout0_55) AT=380.025n

.meas tran vdout0_56ck750 FIND v(dout0_56) AT=380.025n

.meas tran vdout0_57ck750 FIND v(dout0_57) AT=380.025n

.meas tran vdout0_58ck750 FIND v(dout0_58) AT=380.025n

.meas tran vdout0_59ck750 FIND v(dout0_59) AT=380.025n

.meas tran vdout0_60ck750 FIND v(dout0_60) AT=380.025n

.meas tran vdout0_61ck750 FIND v(dout0_61) AT=380.025n

.meas tran vdout0_62ck750 FIND v(dout0_62) AT=380.025n

.meas tran vdout0_63ck750 FIND v(dout0_63) AT=380.025n

.meas tran vdout0_64ck750 FIND v(dout0_64) AT=380.025n

.meas tran vdout0_65ck750 FIND v(dout0_65) AT=380.025n

.meas tran vdout0_66ck750 FIND v(dout0_66) AT=380.025n

.meas tran vdout0_67ck750 FIND v(dout0_67) AT=380.025n

.meas tran vdout0_68ck750 FIND v(dout0_68) AT=380.025n

.meas tran vdout0_69ck750 FIND v(dout0_69) AT=380.025n

.meas tran vdout0_70ck750 FIND v(dout0_70) AT=380.025n

.meas tran vdout0_71ck750 FIND v(dout0_71) AT=380.025n

.meas tran vdout0_72ck750 FIND v(dout0_72) AT=380.025n

.meas tran vdout0_73ck750 FIND v(dout0_73) AT=380.025n

.meas tran vdout0_74ck750 FIND v(dout0_74) AT=380.025n

.meas tran vdout0_75ck750 FIND v(dout0_75) AT=380.025n

.meas tran vdout0_76ck750 FIND v(dout0_76) AT=380.025n

.meas tran vdout0_77ck750 FIND v(dout0_77) AT=380.025n

.meas tran vdout0_78ck750 FIND v(dout0_78) AT=380.025n

.meas tran vdout0_79ck750 FIND v(dout0_79) AT=380.025n

.meas tran vdout0_80ck750 FIND v(dout0_80) AT=380.025n

.meas tran vdout0_81ck750 FIND v(dout0_81) AT=380.025n

.meas tran vdout0_82ck750 FIND v(dout0_82) AT=380.025n

.meas tran vdout0_83ck750 FIND v(dout0_83) AT=380.025n

.meas tran vdout0_84ck750 FIND v(dout0_84) AT=380.025n

.meas tran vdout0_85ck750 FIND v(dout0_85) AT=380.025n

.meas tran vdout0_86ck750 FIND v(dout0_86) AT=380.025n

.meas tran vdout0_87ck750 FIND v(dout0_87) AT=380.025n

.meas tran vdout0_88ck750 FIND v(dout0_88) AT=380.025n

.meas tran vdout0_89ck750 FIND v(dout0_89) AT=380.025n

.meas tran vdout0_90ck750 FIND v(dout0_90) AT=380.025n

.meas tran vdout0_91ck750 FIND v(dout0_91) AT=380.025n

.meas tran vdout0_92ck750 FIND v(dout0_92) AT=380.025n

.meas tran vdout0_93ck750 FIND v(dout0_93) AT=380.025n

.meas tran vdout0_94ck750 FIND v(dout0_94) AT=380.025n

.meas tran vdout0_95ck750 FIND v(dout0_95) AT=380.025n

.meas tran vdout0_96ck750 FIND v(dout0_96) AT=380.025n

.meas tran vdout0_97ck750 FIND v(dout0_97) AT=380.025n

.meas tran vdout0_98ck750 FIND v(dout0_98) AT=380.025n

.meas tran vdout0_99ck750 FIND v(dout0_99) AT=380.025n

.meas tran vdout0_100ck750 FIND v(dout0_100) AT=380.025n

.meas tran vdout0_101ck750 FIND v(dout0_101) AT=380.025n

.meas tran vdout0_102ck750 FIND v(dout0_102) AT=380.025n

.meas tran vdout0_103ck750 FIND v(dout0_103) AT=380.025n

.meas tran vdout0_104ck750 FIND v(dout0_104) AT=380.025n

.meas tran vdout0_105ck750 FIND v(dout0_105) AT=380.025n

.meas tran vdout0_106ck750 FIND v(dout0_106) AT=380.025n

.meas tran vdout0_107ck750 FIND v(dout0_107) AT=380.025n

.meas tran vdout0_108ck750 FIND v(dout0_108) AT=380.025n

.meas tran vdout0_109ck750 FIND v(dout0_109) AT=380.025n

.meas tran vdout0_110ck750 FIND v(dout0_110) AT=380.025n

.meas tran vdout0_111ck750 FIND v(dout0_111) AT=380.025n

.meas tran vdout0_112ck750 FIND v(dout0_112) AT=380.025n

.meas tran vdout0_113ck750 FIND v(dout0_113) AT=380.025n

.meas tran vdout0_114ck750 FIND v(dout0_114) AT=380.025n

.meas tran vdout0_115ck750 FIND v(dout0_115) AT=380.025n

.meas tran vdout0_116ck750 FIND v(dout0_116) AT=380.025n

.meas tran vdout0_117ck750 FIND v(dout0_117) AT=380.025n

.meas tran vdout0_118ck750 FIND v(dout0_118) AT=380.025n

.meas tran vdout0_119ck750 FIND v(dout0_119) AT=380.025n

.meas tran vdout0_120ck750 FIND v(dout0_120) AT=380.025n

.meas tran vdout0_121ck750 FIND v(dout0_121) AT=380.025n

.meas tran vdout0_122ck750 FIND v(dout0_122) AT=380.025n

.meas tran vdout0_123ck750 FIND v(dout0_123) AT=380.025n

.meas tran vdout0_124ck750 FIND v(dout0_124) AT=380.025n

.meas tran vdout0_125ck750 FIND v(dout0_125) AT=380.025n

.meas tran vdout0_126ck750 FIND v(dout0_126) AT=380.025n

.meas tran vdout0_127ck750 FIND v(dout0_127) AT=380.025n

.meas tran vdout0_0ck820 FIND v(dout0_0) AT=415.025n

.meas tran vdout0_1ck820 FIND v(dout0_1) AT=415.025n

.meas tran vdout0_2ck820 FIND v(dout0_2) AT=415.025n

.meas tran vdout0_3ck820 FIND v(dout0_3) AT=415.025n

.meas tran vdout0_4ck820 FIND v(dout0_4) AT=415.025n

.meas tran vdout0_5ck820 FIND v(dout0_5) AT=415.025n

.meas tran vdout0_6ck820 FIND v(dout0_6) AT=415.025n

.meas tran vdout0_7ck820 FIND v(dout0_7) AT=415.025n

.meas tran vdout0_8ck820 FIND v(dout0_8) AT=415.025n

.meas tran vdout0_9ck820 FIND v(dout0_9) AT=415.025n

.meas tran vdout0_10ck820 FIND v(dout0_10) AT=415.025n

.meas tran vdout0_11ck820 FIND v(dout0_11) AT=415.025n

.meas tran vdout0_12ck820 FIND v(dout0_12) AT=415.025n

.meas tran vdout0_13ck820 FIND v(dout0_13) AT=415.025n

.meas tran vdout0_14ck820 FIND v(dout0_14) AT=415.025n

.meas tran vdout0_15ck820 FIND v(dout0_15) AT=415.025n

.meas tran vdout0_16ck820 FIND v(dout0_16) AT=415.025n

.meas tran vdout0_17ck820 FIND v(dout0_17) AT=415.025n

.meas tran vdout0_18ck820 FIND v(dout0_18) AT=415.025n

.meas tran vdout0_19ck820 FIND v(dout0_19) AT=415.025n

.meas tran vdout0_20ck820 FIND v(dout0_20) AT=415.025n

.meas tran vdout0_21ck820 FIND v(dout0_21) AT=415.025n

.meas tran vdout0_22ck820 FIND v(dout0_22) AT=415.025n

.meas tran vdout0_23ck820 FIND v(dout0_23) AT=415.025n

.meas tran vdout0_24ck820 FIND v(dout0_24) AT=415.025n

.meas tran vdout0_25ck820 FIND v(dout0_25) AT=415.025n

.meas tran vdout0_26ck820 FIND v(dout0_26) AT=415.025n

.meas tran vdout0_27ck820 FIND v(dout0_27) AT=415.025n

.meas tran vdout0_28ck820 FIND v(dout0_28) AT=415.025n

.meas tran vdout0_29ck820 FIND v(dout0_29) AT=415.025n

.meas tran vdout0_30ck820 FIND v(dout0_30) AT=415.025n

.meas tran vdout0_31ck820 FIND v(dout0_31) AT=415.025n

.meas tran vdout0_32ck820 FIND v(dout0_32) AT=415.025n

.meas tran vdout0_33ck820 FIND v(dout0_33) AT=415.025n

.meas tran vdout0_34ck820 FIND v(dout0_34) AT=415.025n

.meas tran vdout0_35ck820 FIND v(dout0_35) AT=415.025n

.meas tran vdout0_36ck820 FIND v(dout0_36) AT=415.025n

.meas tran vdout0_37ck820 FIND v(dout0_37) AT=415.025n

.meas tran vdout0_38ck820 FIND v(dout0_38) AT=415.025n

.meas tran vdout0_39ck820 FIND v(dout0_39) AT=415.025n

.meas tran vdout0_40ck820 FIND v(dout0_40) AT=415.025n

.meas tran vdout0_41ck820 FIND v(dout0_41) AT=415.025n

.meas tran vdout0_42ck820 FIND v(dout0_42) AT=415.025n

.meas tran vdout0_43ck820 FIND v(dout0_43) AT=415.025n

.meas tran vdout0_44ck820 FIND v(dout0_44) AT=415.025n

.meas tran vdout0_45ck820 FIND v(dout0_45) AT=415.025n

.meas tran vdout0_46ck820 FIND v(dout0_46) AT=415.025n

.meas tran vdout0_47ck820 FIND v(dout0_47) AT=415.025n

.meas tran vdout0_48ck820 FIND v(dout0_48) AT=415.025n

.meas tran vdout0_49ck820 FIND v(dout0_49) AT=415.025n

.meas tran vdout0_50ck820 FIND v(dout0_50) AT=415.025n

.meas tran vdout0_51ck820 FIND v(dout0_51) AT=415.025n

.meas tran vdout0_52ck820 FIND v(dout0_52) AT=415.025n

.meas tran vdout0_53ck820 FIND v(dout0_53) AT=415.025n

.meas tran vdout0_54ck820 FIND v(dout0_54) AT=415.025n

.meas tran vdout0_55ck820 FIND v(dout0_55) AT=415.025n

.meas tran vdout0_56ck820 FIND v(dout0_56) AT=415.025n

.meas tran vdout0_57ck820 FIND v(dout0_57) AT=415.025n

.meas tran vdout0_58ck820 FIND v(dout0_58) AT=415.025n

.meas tran vdout0_59ck820 FIND v(dout0_59) AT=415.025n

.meas tran vdout0_60ck820 FIND v(dout0_60) AT=415.025n

.meas tran vdout0_61ck820 FIND v(dout0_61) AT=415.025n

.meas tran vdout0_62ck820 FIND v(dout0_62) AT=415.025n

.meas tran vdout0_63ck820 FIND v(dout0_63) AT=415.025n

.meas tran vdout0_64ck820 FIND v(dout0_64) AT=415.025n

.meas tran vdout0_65ck820 FIND v(dout0_65) AT=415.025n

.meas tran vdout0_66ck820 FIND v(dout0_66) AT=415.025n

.meas tran vdout0_67ck820 FIND v(dout0_67) AT=415.025n

.meas tran vdout0_68ck820 FIND v(dout0_68) AT=415.025n

.meas tran vdout0_69ck820 FIND v(dout0_69) AT=415.025n

.meas tran vdout0_70ck820 FIND v(dout0_70) AT=415.025n

.meas tran vdout0_71ck820 FIND v(dout0_71) AT=415.025n

.meas tran vdout0_72ck820 FIND v(dout0_72) AT=415.025n

.meas tran vdout0_73ck820 FIND v(dout0_73) AT=415.025n

.meas tran vdout0_74ck820 FIND v(dout0_74) AT=415.025n

.meas tran vdout0_75ck820 FIND v(dout0_75) AT=415.025n

.meas tran vdout0_76ck820 FIND v(dout0_76) AT=415.025n

.meas tran vdout0_77ck820 FIND v(dout0_77) AT=415.025n

.meas tran vdout0_78ck820 FIND v(dout0_78) AT=415.025n

.meas tran vdout0_79ck820 FIND v(dout0_79) AT=415.025n

.meas tran vdout0_80ck820 FIND v(dout0_80) AT=415.025n

.meas tran vdout0_81ck820 FIND v(dout0_81) AT=415.025n

.meas tran vdout0_82ck820 FIND v(dout0_82) AT=415.025n

.meas tran vdout0_83ck820 FIND v(dout0_83) AT=415.025n

.meas tran vdout0_84ck820 FIND v(dout0_84) AT=415.025n

.meas tran vdout0_85ck820 FIND v(dout0_85) AT=415.025n

.meas tran vdout0_86ck820 FIND v(dout0_86) AT=415.025n

.meas tran vdout0_87ck820 FIND v(dout0_87) AT=415.025n

.meas tran vdout0_88ck820 FIND v(dout0_88) AT=415.025n

.meas tran vdout0_89ck820 FIND v(dout0_89) AT=415.025n

.meas tran vdout0_90ck820 FIND v(dout0_90) AT=415.025n

.meas tran vdout0_91ck820 FIND v(dout0_91) AT=415.025n

.meas tran vdout0_92ck820 FIND v(dout0_92) AT=415.025n

.meas tran vdout0_93ck820 FIND v(dout0_93) AT=415.025n

.meas tran vdout0_94ck820 FIND v(dout0_94) AT=415.025n

.meas tran vdout0_95ck820 FIND v(dout0_95) AT=415.025n

.meas tran vdout0_96ck820 FIND v(dout0_96) AT=415.025n

.meas tran vdout0_97ck820 FIND v(dout0_97) AT=415.025n

.meas tran vdout0_98ck820 FIND v(dout0_98) AT=415.025n

.meas tran vdout0_99ck820 FIND v(dout0_99) AT=415.025n

.meas tran vdout0_100ck820 FIND v(dout0_100) AT=415.025n

.meas tran vdout0_101ck820 FIND v(dout0_101) AT=415.025n

.meas tran vdout0_102ck820 FIND v(dout0_102) AT=415.025n

.meas tran vdout0_103ck820 FIND v(dout0_103) AT=415.025n

.meas tran vdout0_104ck820 FIND v(dout0_104) AT=415.025n

.meas tran vdout0_105ck820 FIND v(dout0_105) AT=415.025n

.meas tran vdout0_106ck820 FIND v(dout0_106) AT=415.025n

.meas tran vdout0_107ck820 FIND v(dout0_107) AT=415.025n

.meas tran vdout0_108ck820 FIND v(dout0_108) AT=415.025n

.meas tran vdout0_109ck820 FIND v(dout0_109) AT=415.025n

.meas tran vdout0_110ck820 FIND v(dout0_110) AT=415.025n

.meas tran vdout0_111ck820 FIND v(dout0_111) AT=415.025n

.meas tran vdout0_112ck820 FIND v(dout0_112) AT=415.025n

.meas tran vdout0_113ck820 FIND v(dout0_113) AT=415.025n

.meas tran vdout0_114ck820 FIND v(dout0_114) AT=415.025n

.meas tran vdout0_115ck820 FIND v(dout0_115) AT=415.025n

.meas tran vdout0_116ck820 FIND v(dout0_116) AT=415.025n

.meas tran vdout0_117ck820 FIND v(dout0_117) AT=415.025n

.meas tran vdout0_118ck820 FIND v(dout0_118) AT=415.025n

.meas tran vdout0_119ck820 FIND v(dout0_119) AT=415.025n

.meas tran vdout0_120ck820 FIND v(dout0_120) AT=415.025n

.meas tran vdout0_121ck820 FIND v(dout0_121) AT=415.025n

.meas tran vdout0_122ck820 FIND v(dout0_122) AT=415.025n

.meas tran vdout0_123ck820 FIND v(dout0_123) AT=415.025n

.meas tran vdout0_124ck820 FIND v(dout0_124) AT=415.025n

.meas tran vdout0_125ck820 FIND v(dout0_125) AT=415.025n

.meas tran vdout0_126ck820 FIND v(dout0_126) AT=415.025n

.meas tran vdout0_127ck820 FIND v(dout0_127) AT=415.025n

.meas tran vdout0_0ck850 FIND v(dout0_0) AT=430.025n

.meas tran vdout0_1ck850 FIND v(dout0_1) AT=430.025n

.meas tran vdout0_2ck850 FIND v(dout0_2) AT=430.025n

.meas tran vdout0_3ck850 FIND v(dout0_3) AT=430.025n

.meas tran vdout0_4ck850 FIND v(dout0_4) AT=430.025n

.meas tran vdout0_5ck850 FIND v(dout0_5) AT=430.025n

.meas tran vdout0_6ck850 FIND v(dout0_6) AT=430.025n

.meas tran vdout0_7ck850 FIND v(dout0_7) AT=430.025n

.meas tran vdout0_8ck850 FIND v(dout0_8) AT=430.025n

.meas tran vdout0_9ck850 FIND v(dout0_9) AT=430.025n

.meas tran vdout0_10ck850 FIND v(dout0_10) AT=430.025n

.meas tran vdout0_11ck850 FIND v(dout0_11) AT=430.025n

.meas tran vdout0_12ck850 FIND v(dout0_12) AT=430.025n

.meas tran vdout0_13ck850 FIND v(dout0_13) AT=430.025n

.meas tran vdout0_14ck850 FIND v(dout0_14) AT=430.025n

.meas tran vdout0_15ck850 FIND v(dout0_15) AT=430.025n

.meas tran vdout0_16ck850 FIND v(dout0_16) AT=430.025n

.meas tran vdout0_17ck850 FIND v(dout0_17) AT=430.025n

.meas tran vdout0_18ck850 FIND v(dout0_18) AT=430.025n

.meas tran vdout0_19ck850 FIND v(dout0_19) AT=430.025n

.meas tran vdout0_20ck850 FIND v(dout0_20) AT=430.025n

.meas tran vdout0_21ck850 FIND v(dout0_21) AT=430.025n

.meas tran vdout0_22ck850 FIND v(dout0_22) AT=430.025n

.meas tran vdout0_23ck850 FIND v(dout0_23) AT=430.025n

.meas tran vdout0_24ck850 FIND v(dout0_24) AT=430.025n

.meas tran vdout0_25ck850 FIND v(dout0_25) AT=430.025n

.meas tran vdout0_26ck850 FIND v(dout0_26) AT=430.025n

.meas tran vdout0_27ck850 FIND v(dout0_27) AT=430.025n

.meas tran vdout0_28ck850 FIND v(dout0_28) AT=430.025n

.meas tran vdout0_29ck850 FIND v(dout0_29) AT=430.025n

.meas tran vdout0_30ck850 FIND v(dout0_30) AT=430.025n

.meas tran vdout0_31ck850 FIND v(dout0_31) AT=430.025n

.meas tran vdout0_32ck850 FIND v(dout0_32) AT=430.025n

.meas tran vdout0_33ck850 FIND v(dout0_33) AT=430.025n

.meas tran vdout0_34ck850 FIND v(dout0_34) AT=430.025n

.meas tran vdout0_35ck850 FIND v(dout0_35) AT=430.025n

.meas tran vdout0_36ck850 FIND v(dout0_36) AT=430.025n

.meas tran vdout0_37ck850 FIND v(dout0_37) AT=430.025n

.meas tran vdout0_38ck850 FIND v(dout0_38) AT=430.025n

.meas tran vdout0_39ck850 FIND v(dout0_39) AT=430.025n

.meas tran vdout0_40ck850 FIND v(dout0_40) AT=430.025n

.meas tran vdout0_41ck850 FIND v(dout0_41) AT=430.025n

.meas tran vdout0_42ck850 FIND v(dout0_42) AT=430.025n

.meas tran vdout0_43ck850 FIND v(dout0_43) AT=430.025n

.meas tran vdout0_44ck850 FIND v(dout0_44) AT=430.025n

.meas tran vdout0_45ck850 FIND v(dout0_45) AT=430.025n

.meas tran vdout0_46ck850 FIND v(dout0_46) AT=430.025n

.meas tran vdout0_47ck850 FIND v(dout0_47) AT=430.025n

.meas tran vdout0_48ck850 FIND v(dout0_48) AT=430.025n

.meas tran vdout0_49ck850 FIND v(dout0_49) AT=430.025n

.meas tran vdout0_50ck850 FIND v(dout0_50) AT=430.025n

.meas tran vdout0_51ck850 FIND v(dout0_51) AT=430.025n

.meas tran vdout0_52ck850 FIND v(dout0_52) AT=430.025n

.meas tran vdout0_53ck850 FIND v(dout0_53) AT=430.025n

.meas tran vdout0_54ck850 FIND v(dout0_54) AT=430.025n

.meas tran vdout0_55ck850 FIND v(dout0_55) AT=430.025n

.meas tran vdout0_56ck850 FIND v(dout0_56) AT=430.025n

.meas tran vdout0_57ck850 FIND v(dout0_57) AT=430.025n

.meas tran vdout0_58ck850 FIND v(dout0_58) AT=430.025n

.meas tran vdout0_59ck850 FIND v(dout0_59) AT=430.025n

.meas tran vdout0_60ck850 FIND v(dout0_60) AT=430.025n

.meas tran vdout0_61ck850 FIND v(dout0_61) AT=430.025n

.meas tran vdout0_62ck850 FIND v(dout0_62) AT=430.025n

.meas tran vdout0_63ck850 FIND v(dout0_63) AT=430.025n

.meas tran vdout0_64ck850 FIND v(dout0_64) AT=430.025n

.meas tran vdout0_65ck850 FIND v(dout0_65) AT=430.025n

.meas tran vdout0_66ck850 FIND v(dout0_66) AT=430.025n

.meas tran vdout0_67ck850 FIND v(dout0_67) AT=430.025n

.meas tran vdout0_68ck850 FIND v(dout0_68) AT=430.025n

.meas tran vdout0_69ck850 FIND v(dout0_69) AT=430.025n

.meas tran vdout0_70ck850 FIND v(dout0_70) AT=430.025n

.meas tran vdout0_71ck850 FIND v(dout0_71) AT=430.025n

.meas tran vdout0_72ck850 FIND v(dout0_72) AT=430.025n

.meas tran vdout0_73ck850 FIND v(dout0_73) AT=430.025n

.meas tran vdout0_74ck850 FIND v(dout0_74) AT=430.025n

.meas tran vdout0_75ck850 FIND v(dout0_75) AT=430.025n

.meas tran vdout0_76ck850 FIND v(dout0_76) AT=430.025n

.meas tran vdout0_77ck850 FIND v(dout0_77) AT=430.025n

.meas tran vdout0_78ck850 FIND v(dout0_78) AT=430.025n

.meas tran vdout0_79ck850 FIND v(dout0_79) AT=430.025n

.meas tran vdout0_80ck850 FIND v(dout0_80) AT=430.025n

.meas tran vdout0_81ck850 FIND v(dout0_81) AT=430.025n

.meas tran vdout0_82ck850 FIND v(dout0_82) AT=430.025n

.meas tran vdout0_83ck850 FIND v(dout0_83) AT=430.025n

.meas tran vdout0_84ck850 FIND v(dout0_84) AT=430.025n

.meas tran vdout0_85ck850 FIND v(dout0_85) AT=430.025n

.meas tran vdout0_86ck850 FIND v(dout0_86) AT=430.025n

.meas tran vdout0_87ck850 FIND v(dout0_87) AT=430.025n

.meas tran vdout0_88ck850 FIND v(dout0_88) AT=430.025n

.meas tran vdout0_89ck850 FIND v(dout0_89) AT=430.025n

.meas tran vdout0_90ck850 FIND v(dout0_90) AT=430.025n

.meas tran vdout0_91ck850 FIND v(dout0_91) AT=430.025n

.meas tran vdout0_92ck850 FIND v(dout0_92) AT=430.025n

.meas tran vdout0_93ck850 FIND v(dout0_93) AT=430.025n

.meas tran vdout0_94ck850 FIND v(dout0_94) AT=430.025n

.meas tran vdout0_95ck850 FIND v(dout0_95) AT=430.025n

.meas tran vdout0_96ck850 FIND v(dout0_96) AT=430.025n

.meas tran vdout0_97ck850 FIND v(dout0_97) AT=430.025n

.meas tran vdout0_98ck850 FIND v(dout0_98) AT=430.025n

.meas tran vdout0_99ck850 FIND v(dout0_99) AT=430.025n

.meas tran vdout0_100ck850 FIND v(dout0_100) AT=430.025n

.meas tran vdout0_101ck850 FIND v(dout0_101) AT=430.025n

.meas tran vdout0_102ck850 FIND v(dout0_102) AT=430.025n

.meas tran vdout0_103ck850 FIND v(dout0_103) AT=430.025n

.meas tran vdout0_104ck850 FIND v(dout0_104) AT=430.025n

.meas tran vdout0_105ck850 FIND v(dout0_105) AT=430.025n

.meas tran vdout0_106ck850 FIND v(dout0_106) AT=430.025n

.meas tran vdout0_107ck850 FIND v(dout0_107) AT=430.025n

.meas tran vdout0_108ck850 FIND v(dout0_108) AT=430.025n

.meas tran vdout0_109ck850 FIND v(dout0_109) AT=430.025n

.meas tran vdout0_110ck850 FIND v(dout0_110) AT=430.025n

.meas tran vdout0_111ck850 FIND v(dout0_111) AT=430.025n

.meas tran vdout0_112ck850 FIND v(dout0_112) AT=430.025n

.meas tran vdout0_113ck850 FIND v(dout0_113) AT=430.025n

.meas tran vdout0_114ck850 FIND v(dout0_114) AT=430.025n

.meas tran vdout0_115ck850 FIND v(dout0_115) AT=430.025n

.meas tran vdout0_116ck850 FIND v(dout0_116) AT=430.025n

.meas tran vdout0_117ck850 FIND v(dout0_117) AT=430.025n

.meas tran vdout0_118ck850 FIND v(dout0_118) AT=430.025n

.meas tran vdout0_119ck850 FIND v(dout0_119) AT=430.025n

.meas tran vdout0_120ck850 FIND v(dout0_120) AT=430.025n

.meas tran vdout0_121ck850 FIND v(dout0_121) AT=430.025n

.meas tran vdout0_122ck850 FIND v(dout0_122) AT=430.025n

.meas tran vdout0_123ck850 FIND v(dout0_123) AT=430.025n

.meas tran vdout0_124ck850 FIND v(dout0_124) AT=430.025n

.meas tran vdout0_125ck850 FIND v(dout0_125) AT=430.025n

.meas tran vdout0_126ck850 FIND v(dout0_126) AT=430.025n

.meas tran vdout0_127ck850 FIND v(dout0_127) AT=430.025n

.meas tran vdout0_0ck870 FIND v(dout0_0) AT=440.025n

.meas tran vdout0_1ck870 FIND v(dout0_1) AT=440.025n

.meas tran vdout0_2ck870 FIND v(dout0_2) AT=440.025n

.meas tran vdout0_3ck870 FIND v(dout0_3) AT=440.025n

.meas tran vdout0_4ck870 FIND v(dout0_4) AT=440.025n

.meas tran vdout0_5ck870 FIND v(dout0_5) AT=440.025n

.meas tran vdout0_6ck870 FIND v(dout0_6) AT=440.025n

.meas tran vdout0_7ck870 FIND v(dout0_7) AT=440.025n

.meas tran vdout0_8ck870 FIND v(dout0_8) AT=440.025n

.meas tran vdout0_9ck870 FIND v(dout0_9) AT=440.025n

.meas tran vdout0_10ck870 FIND v(dout0_10) AT=440.025n

.meas tran vdout0_11ck870 FIND v(dout0_11) AT=440.025n

.meas tran vdout0_12ck870 FIND v(dout0_12) AT=440.025n

.meas tran vdout0_13ck870 FIND v(dout0_13) AT=440.025n

.meas tran vdout0_14ck870 FIND v(dout0_14) AT=440.025n

.meas tran vdout0_15ck870 FIND v(dout0_15) AT=440.025n

.meas tran vdout0_16ck870 FIND v(dout0_16) AT=440.025n

.meas tran vdout0_17ck870 FIND v(dout0_17) AT=440.025n

.meas tran vdout0_18ck870 FIND v(dout0_18) AT=440.025n

.meas tran vdout0_19ck870 FIND v(dout0_19) AT=440.025n

.meas tran vdout0_20ck870 FIND v(dout0_20) AT=440.025n

.meas tran vdout0_21ck870 FIND v(dout0_21) AT=440.025n

.meas tran vdout0_22ck870 FIND v(dout0_22) AT=440.025n

.meas tran vdout0_23ck870 FIND v(dout0_23) AT=440.025n

.meas tran vdout0_24ck870 FIND v(dout0_24) AT=440.025n

.meas tran vdout0_25ck870 FIND v(dout0_25) AT=440.025n

.meas tran vdout0_26ck870 FIND v(dout0_26) AT=440.025n

.meas tran vdout0_27ck870 FIND v(dout0_27) AT=440.025n

.meas tran vdout0_28ck870 FIND v(dout0_28) AT=440.025n

.meas tran vdout0_29ck870 FIND v(dout0_29) AT=440.025n

.meas tran vdout0_30ck870 FIND v(dout0_30) AT=440.025n

.meas tran vdout0_31ck870 FIND v(dout0_31) AT=440.025n

.meas tran vdout0_32ck870 FIND v(dout0_32) AT=440.025n

.meas tran vdout0_33ck870 FIND v(dout0_33) AT=440.025n

.meas tran vdout0_34ck870 FIND v(dout0_34) AT=440.025n

.meas tran vdout0_35ck870 FIND v(dout0_35) AT=440.025n

.meas tran vdout0_36ck870 FIND v(dout0_36) AT=440.025n

.meas tran vdout0_37ck870 FIND v(dout0_37) AT=440.025n

.meas tran vdout0_38ck870 FIND v(dout0_38) AT=440.025n

.meas tran vdout0_39ck870 FIND v(dout0_39) AT=440.025n

.meas tran vdout0_40ck870 FIND v(dout0_40) AT=440.025n

.meas tran vdout0_41ck870 FIND v(dout0_41) AT=440.025n

.meas tran vdout0_42ck870 FIND v(dout0_42) AT=440.025n

.meas tran vdout0_43ck870 FIND v(dout0_43) AT=440.025n

.meas tran vdout0_44ck870 FIND v(dout0_44) AT=440.025n

.meas tran vdout0_45ck870 FIND v(dout0_45) AT=440.025n

.meas tran vdout0_46ck870 FIND v(dout0_46) AT=440.025n

.meas tran vdout0_47ck870 FIND v(dout0_47) AT=440.025n

.meas tran vdout0_48ck870 FIND v(dout0_48) AT=440.025n

.meas tran vdout0_49ck870 FIND v(dout0_49) AT=440.025n

.meas tran vdout0_50ck870 FIND v(dout0_50) AT=440.025n

.meas tran vdout0_51ck870 FIND v(dout0_51) AT=440.025n

.meas tran vdout0_52ck870 FIND v(dout0_52) AT=440.025n

.meas tran vdout0_53ck870 FIND v(dout0_53) AT=440.025n

.meas tran vdout0_54ck870 FIND v(dout0_54) AT=440.025n

.meas tran vdout0_55ck870 FIND v(dout0_55) AT=440.025n

.meas tran vdout0_56ck870 FIND v(dout0_56) AT=440.025n

.meas tran vdout0_57ck870 FIND v(dout0_57) AT=440.025n

.meas tran vdout0_58ck870 FIND v(dout0_58) AT=440.025n

.meas tran vdout0_59ck870 FIND v(dout0_59) AT=440.025n

.meas tran vdout0_60ck870 FIND v(dout0_60) AT=440.025n

.meas tran vdout0_61ck870 FIND v(dout0_61) AT=440.025n

.meas tran vdout0_62ck870 FIND v(dout0_62) AT=440.025n

.meas tran vdout0_63ck870 FIND v(dout0_63) AT=440.025n

.meas tran vdout0_64ck870 FIND v(dout0_64) AT=440.025n

.meas tran vdout0_65ck870 FIND v(dout0_65) AT=440.025n

.meas tran vdout0_66ck870 FIND v(dout0_66) AT=440.025n

.meas tran vdout0_67ck870 FIND v(dout0_67) AT=440.025n

.meas tran vdout0_68ck870 FIND v(dout0_68) AT=440.025n

.meas tran vdout0_69ck870 FIND v(dout0_69) AT=440.025n

.meas tran vdout0_70ck870 FIND v(dout0_70) AT=440.025n

.meas tran vdout0_71ck870 FIND v(dout0_71) AT=440.025n

.meas tran vdout0_72ck870 FIND v(dout0_72) AT=440.025n

.meas tran vdout0_73ck870 FIND v(dout0_73) AT=440.025n

.meas tran vdout0_74ck870 FIND v(dout0_74) AT=440.025n

.meas tran vdout0_75ck870 FIND v(dout0_75) AT=440.025n

.meas tran vdout0_76ck870 FIND v(dout0_76) AT=440.025n

.meas tran vdout0_77ck870 FIND v(dout0_77) AT=440.025n

.meas tran vdout0_78ck870 FIND v(dout0_78) AT=440.025n

.meas tran vdout0_79ck870 FIND v(dout0_79) AT=440.025n

.meas tran vdout0_80ck870 FIND v(dout0_80) AT=440.025n

.meas tran vdout0_81ck870 FIND v(dout0_81) AT=440.025n

.meas tran vdout0_82ck870 FIND v(dout0_82) AT=440.025n

.meas tran vdout0_83ck870 FIND v(dout0_83) AT=440.025n

.meas tran vdout0_84ck870 FIND v(dout0_84) AT=440.025n

.meas tran vdout0_85ck870 FIND v(dout0_85) AT=440.025n

.meas tran vdout0_86ck870 FIND v(dout0_86) AT=440.025n

.meas tran vdout0_87ck870 FIND v(dout0_87) AT=440.025n

.meas tran vdout0_88ck870 FIND v(dout0_88) AT=440.025n

.meas tran vdout0_89ck870 FIND v(dout0_89) AT=440.025n

.meas tran vdout0_90ck870 FIND v(dout0_90) AT=440.025n

.meas tran vdout0_91ck870 FIND v(dout0_91) AT=440.025n

.meas tran vdout0_92ck870 FIND v(dout0_92) AT=440.025n

.meas tran vdout0_93ck870 FIND v(dout0_93) AT=440.025n

.meas tran vdout0_94ck870 FIND v(dout0_94) AT=440.025n

.meas tran vdout0_95ck870 FIND v(dout0_95) AT=440.025n

.meas tran vdout0_96ck870 FIND v(dout0_96) AT=440.025n

.meas tran vdout0_97ck870 FIND v(dout0_97) AT=440.025n

.meas tran vdout0_98ck870 FIND v(dout0_98) AT=440.025n

.meas tran vdout0_99ck870 FIND v(dout0_99) AT=440.025n

.meas tran vdout0_100ck870 FIND v(dout0_100) AT=440.025n

.meas tran vdout0_101ck870 FIND v(dout0_101) AT=440.025n

.meas tran vdout0_102ck870 FIND v(dout0_102) AT=440.025n

.meas tran vdout0_103ck870 FIND v(dout0_103) AT=440.025n

.meas tran vdout0_104ck870 FIND v(dout0_104) AT=440.025n

.meas tran vdout0_105ck870 FIND v(dout0_105) AT=440.025n

.meas tran vdout0_106ck870 FIND v(dout0_106) AT=440.025n

.meas tran vdout0_107ck870 FIND v(dout0_107) AT=440.025n

.meas tran vdout0_108ck870 FIND v(dout0_108) AT=440.025n

.meas tran vdout0_109ck870 FIND v(dout0_109) AT=440.025n

.meas tran vdout0_110ck870 FIND v(dout0_110) AT=440.025n

.meas tran vdout0_111ck870 FIND v(dout0_111) AT=440.025n

.meas tran vdout0_112ck870 FIND v(dout0_112) AT=440.025n

.meas tran vdout0_113ck870 FIND v(dout0_113) AT=440.025n

.meas tran vdout0_114ck870 FIND v(dout0_114) AT=440.025n

.meas tran vdout0_115ck870 FIND v(dout0_115) AT=440.025n

.meas tran vdout0_116ck870 FIND v(dout0_116) AT=440.025n

.meas tran vdout0_117ck870 FIND v(dout0_117) AT=440.025n

.meas tran vdout0_118ck870 FIND v(dout0_118) AT=440.025n

.meas tran vdout0_119ck870 FIND v(dout0_119) AT=440.025n

.meas tran vdout0_120ck870 FIND v(dout0_120) AT=440.025n

.meas tran vdout0_121ck870 FIND v(dout0_121) AT=440.025n

.meas tran vdout0_122ck870 FIND v(dout0_122) AT=440.025n

.meas tran vdout0_123ck870 FIND v(dout0_123) AT=440.025n

.meas tran vdout0_124ck870 FIND v(dout0_124) AT=440.025n

.meas tran vdout0_125ck870 FIND v(dout0_125) AT=440.025n

.meas tran vdout0_126ck870 FIND v(dout0_126) AT=440.025n

.meas tran vdout0_127ck870 FIND v(dout0_127) AT=440.025n

.meas tran vdout0_0ck1010 FIND v(dout0_0) AT=510.025n

.meas tran vdout0_1ck1010 FIND v(dout0_1) AT=510.025n

.meas tran vdout0_2ck1010 FIND v(dout0_2) AT=510.025n

.meas tran vdout0_3ck1010 FIND v(dout0_3) AT=510.025n

.meas tran vdout0_4ck1010 FIND v(dout0_4) AT=510.025n

.meas tran vdout0_5ck1010 FIND v(dout0_5) AT=510.025n

.meas tran vdout0_6ck1010 FIND v(dout0_6) AT=510.025n

.meas tran vdout0_7ck1010 FIND v(dout0_7) AT=510.025n

.meas tran vdout0_8ck1010 FIND v(dout0_8) AT=510.025n

.meas tran vdout0_9ck1010 FIND v(dout0_9) AT=510.025n

.meas tran vdout0_10ck1010 FIND v(dout0_10) AT=510.025n

.meas tran vdout0_11ck1010 FIND v(dout0_11) AT=510.025n

.meas tran vdout0_12ck1010 FIND v(dout0_12) AT=510.025n

.meas tran vdout0_13ck1010 FIND v(dout0_13) AT=510.025n

.meas tran vdout0_14ck1010 FIND v(dout0_14) AT=510.025n

.meas tran vdout0_15ck1010 FIND v(dout0_15) AT=510.025n

.meas tran vdout0_16ck1010 FIND v(dout0_16) AT=510.025n

.meas tran vdout0_17ck1010 FIND v(dout0_17) AT=510.025n

.meas tran vdout0_18ck1010 FIND v(dout0_18) AT=510.025n

.meas tran vdout0_19ck1010 FIND v(dout0_19) AT=510.025n

.meas tran vdout0_20ck1010 FIND v(dout0_20) AT=510.025n

.meas tran vdout0_21ck1010 FIND v(dout0_21) AT=510.025n

.meas tran vdout0_22ck1010 FIND v(dout0_22) AT=510.025n

.meas tran vdout0_23ck1010 FIND v(dout0_23) AT=510.025n

.meas tran vdout0_24ck1010 FIND v(dout0_24) AT=510.025n

.meas tran vdout0_25ck1010 FIND v(dout0_25) AT=510.025n

.meas tran vdout0_26ck1010 FIND v(dout0_26) AT=510.025n

.meas tran vdout0_27ck1010 FIND v(dout0_27) AT=510.025n

.meas tran vdout0_28ck1010 FIND v(dout0_28) AT=510.025n

.meas tran vdout0_29ck1010 FIND v(dout0_29) AT=510.025n

.meas tran vdout0_30ck1010 FIND v(dout0_30) AT=510.025n

.meas tran vdout0_31ck1010 FIND v(dout0_31) AT=510.025n

.meas tran vdout0_32ck1010 FIND v(dout0_32) AT=510.025n

.meas tran vdout0_33ck1010 FIND v(dout0_33) AT=510.025n

.meas tran vdout0_34ck1010 FIND v(dout0_34) AT=510.025n

.meas tran vdout0_35ck1010 FIND v(dout0_35) AT=510.025n

.meas tran vdout0_36ck1010 FIND v(dout0_36) AT=510.025n

.meas tran vdout0_37ck1010 FIND v(dout0_37) AT=510.025n

.meas tran vdout0_38ck1010 FIND v(dout0_38) AT=510.025n

.meas tran vdout0_39ck1010 FIND v(dout0_39) AT=510.025n

.meas tran vdout0_40ck1010 FIND v(dout0_40) AT=510.025n

.meas tran vdout0_41ck1010 FIND v(dout0_41) AT=510.025n

.meas tran vdout0_42ck1010 FIND v(dout0_42) AT=510.025n

.meas tran vdout0_43ck1010 FIND v(dout0_43) AT=510.025n

.meas tran vdout0_44ck1010 FIND v(dout0_44) AT=510.025n

.meas tran vdout0_45ck1010 FIND v(dout0_45) AT=510.025n

.meas tran vdout0_46ck1010 FIND v(dout0_46) AT=510.025n

.meas tran vdout0_47ck1010 FIND v(dout0_47) AT=510.025n

.meas tran vdout0_48ck1010 FIND v(dout0_48) AT=510.025n

.meas tran vdout0_49ck1010 FIND v(dout0_49) AT=510.025n

.meas tran vdout0_50ck1010 FIND v(dout0_50) AT=510.025n

.meas tran vdout0_51ck1010 FIND v(dout0_51) AT=510.025n

.meas tran vdout0_52ck1010 FIND v(dout0_52) AT=510.025n

.meas tran vdout0_53ck1010 FIND v(dout0_53) AT=510.025n

.meas tran vdout0_54ck1010 FIND v(dout0_54) AT=510.025n

.meas tran vdout0_55ck1010 FIND v(dout0_55) AT=510.025n

.meas tran vdout0_56ck1010 FIND v(dout0_56) AT=510.025n

.meas tran vdout0_57ck1010 FIND v(dout0_57) AT=510.025n

.meas tran vdout0_58ck1010 FIND v(dout0_58) AT=510.025n

.meas tran vdout0_59ck1010 FIND v(dout0_59) AT=510.025n

.meas tran vdout0_60ck1010 FIND v(dout0_60) AT=510.025n

.meas tran vdout0_61ck1010 FIND v(dout0_61) AT=510.025n

.meas tran vdout0_62ck1010 FIND v(dout0_62) AT=510.025n

.meas tran vdout0_63ck1010 FIND v(dout0_63) AT=510.025n

.meas tran vdout0_64ck1010 FIND v(dout0_64) AT=510.025n

.meas tran vdout0_65ck1010 FIND v(dout0_65) AT=510.025n

.meas tran vdout0_66ck1010 FIND v(dout0_66) AT=510.025n

.meas tran vdout0_67ck1010 FIND v(dout0_67) AT=510.025n

.meas tran vdout0_68ck1010 FIND v(dout0_68) AT=510.025n

.meas tran vdout0_69ck1010 FIND v(dout0_69) AT=510.025n

.meas tran vdout0_70ck1010 FIND v(dout0_70) AT=510.025n

.meas tran vdout0_71ck1010 FIND v(dout0_71) AT=510.025n

.meas tran vdout0_72ck1010 FIND v(dout0_72) AT=510.025n

.meas tran vdout0_73ck1010 FIND v(dout0_73) AT=510.025n

.meas tran vdout0_74ck1010 FIND v(dout0_74) AT=510.025n

.meas tran vdout0_75ck1010 FIND v(dout0_75) AT=510.025n

.meas tran vdout0_76ck1010 FIND v(dout0_76) AT=510.025n

.meas tran vdout0_77ck1010 FIND v(dout0_77) AT=510.025n

.meas tran vdout0_78ck1010 FIND v(dout0_78) AT=510.025n

.meas tran vdout0_79ck1010 FIND v(dout0_79) AT=510.025n

.meas tran vdout0_80ck1010 FIND v(dout0_80) AT=510.025n

.meas tran vdout0_81ck1010 FIND v(dout0_81) AT=510.025n

.meas tran vdout0_82ck1010 FIND v(dout0_82) AT=510.025n

.meas tran vdout0_83ck1010 FIND v(dout0_83) AT=510.025n

.meas tran vdout0_84ck1010 FIND v(dout0_84) AT=510.025n

.meas tran vdout0_85ck1010 FIND v(dout0_85) AT=510.025n

.meas tran vdout0_86ck1010 FIND v(dout0_86) AT=510.025n

.meas tran vdout0_87ck1010 FIND v(dout0_87) AT=510.025n

.meas tran vdout0_88ck1010 FIND v(dout0_88) AT=510.025n

.meas tran vdout0_89ck1010 FIND v(dout0_89) AT=510.025n

.meas tran vdout0_90ck1010 FIND v(dout0_90) AT=510.025n

.meas tran vdout0_91ck1010 FIND v(dout0_91) AT=510.025n

.meas tran vdout0_92ck1010 FIND v(dout0_92) AT=510.025n

.meas tran vdout0_93ck1010 FIND v(dout0_93) AT=510.025n

.meas tran vdout0_94ck1010 FIND v(dout0_94) AT=510.025n

.meas tran vdout0_95ck1010 FIND v(dout0_95) AT=510.025n

.meas tran vdout0_96ck1010 FIND v(dout0_96) AT=510.025n

.meas tran vdout0_97ck1010 FIND v(dout0_97) AT=510.025n

.meas tran vdout0_98ck1010 FIND v(dout0_98) AT=510.025n

.meas tran vdout0_99ck1010 FIND v(dout0_99) AT=510.025n

.meas tran vdout0_100ck1010 FIND v(dout0_100) AT=510.025n

.meas tran vdout0_101ck1010 FIND v(dout0_101) AT=510.025n

.meas tran vdout0_102ck1010 FIND v(dout0_102) AT=510.025n

.meas tran vdout0_103ck1010 FIND v(dout0_103) AT=510.025n

.meas tran vdout0_104ck1010 FIND v(dout0_104) AT=510.025n

.meas tran vdout0_105ck1010 FIND v(dout0_105) AT=510.025n

.meas tran vdout0_106ck1010 FIND v(dout0_106) AT=510.025n

.meas tran vdout0_107ck1010 FIND v(dout0_107) AT=510.025n

.meas tran vdout0_108ck1010 FIND v(dout0_108) AT=510.025n

.meas tran vdout0_109ck1010 FIND v(dout0_109) AT=510.025n

.meas tran vdout0_110ck1010 FIND v(dout0_110) AT=510.025n

.meas tran vdout0_111ck1010 FIND v(dout0_111) AT=510.025n

.meas tran vdout0_112ck1010 FIND v(dout0_112) AT=510.025n

.meas tran vdout0_113ck1010 FIND v(dout0_113) AT=510.025n

.meas tran vdout0_114ck1010 FIND v(dout0_114) AT=510.025n

.meas tran vdout0_115ck1010 FIND v(dout0_115) AT=510.025n

.meas tran vdout0_116ck1010 FIND v(dout0_116) AT=510.025n

.meas tran vdout0_117ck1010 FIND v(dout0_117) AT=510.025n

.meas tran vdout0_118ck1010 FIND v(dout0_118) AT=510.025n

.meas tran vdout0_119ck1010 FIND v(dout0_119) AT=510.025n

.meas tran vdout0_120ck1010 FIND v(dout0_120) AT=510.025n

.meas tran vdout0_121ck1010 FIND v(dout0_121) AT=510.025n

.meas tran vdout0_122ck1010 FIND v(dout0_122) AT=510.025n

.meas tran vdout0_123ck1010 FIND v(dout0_123) AT=510.025n

.meas tran vdout0_124ck1010 FIND v(dout0_124) AT=510.025n

.meas tran vdout0_125ck1010 FIND v(dout0_125) AT=510.025n

.meas tran vdout0_126ck1010 FIND v(dout0_126) AT=510.025n

.meas tran vdout0_127ck1010 FIND v(dout0_127) AT=510.025n

.meas tran vdout0_0ck1020 FIND v(dout0_0) AT=515.025n

.meas tran vdout0_1ck1020 FIND v(dout0_1) AT=515.025n

.meas tran vdout0_2ck1020 FIND v(dout0_2) AT=515.025n

.meas tran vdout0_3ck1020 FIND v(dout0_3) AT=515.025n

.meas tran vdout0_4ck1020 FIND v(dout0_4) AT=515.025n

.meas tran vdout0_5ck1020 FIND v(dout0_5) AT=515.025n

.meas tran vdout0_6ck1020 FIND v(dout0_6) AT=515.025n

.meas tran vdout0_7ck1020 FIND v(dout0_7) AT=515.025n

.meas tran vdout0_8ck1020 FIND v(dout0_8) AT=515.025n

.meas tran vdout0_9ck1020 FIND v(dout0_9) AT=515.025n

.meas tran vdout0_10ck1020 FIND v(dout0_10) AT=515.025n

.meas tran vdout0_11ck1020 FIND v(dout0_11) AT=515.025n

.meas tran vdout0_12ck1020 FIND v(dout0_12) AT=515.025n

.meas tran vdout0_13ck1020 FIND v(dout0_13) AT=515.025n

.meas tran vdout0_14ck1020 FIND v(dout0_14) AT=515.025n

.meas tran vdout0_15ck1020 FIND v(dout0_15) AT=515.025n

.meas tran vdout0_16ck1020 FIND v(dout0_16) AT=515.025n

.meas tran vdout0_17ck1020 FIND v(dout0_17) AT=515.025n

.meas tran vdout0_18ck1020 FIND v(dout0_18) AT=515.025n

.meas tran vdout0_19ck1020 FIND v(dout0_19) AT=515.025n

.meas tran vdout0_20ck1020 FIND v(dout0_20) AT=515.025n

.meas tran vdout0_21ck1020 FIND v(dout0_21) AT=515.025n

.meas tran vdout0_22ck1020 FIND v(dout0_22) AT=515.025n

.meas tran vdout0_23ck1020 FIND v(dout0_23) AT=515.025n

.meas tran vdout0_24ck1020 FIND v(dout0_24) AT=515.025n

.meas tran vdout0_25ck1020 FIND v(dout0_25) AT=515.025n

.meas tran vdout0_26ck1020 FIND v(dout0_26) AT=515.025n

.meas tran vdout0_27ck1020 FIND v(dout0_27) AT=515.025n

.meas tran vdout0_28ck1020 FIND v(dout0_28) AT=515.025n

.meas tran vdout0_29ck1020 FIND v(dout0_29) AT=515.025n

.meas tran vdout0_30ck1020 FIND v(dout0_30) AT=515.025n

.meas tran vdout0_31ck1020 FIND v(dout0_31) AT=515.025n

.meas tran vdout0_32ck1020 FIND v(dout0_32) AT=515.025n

.meas tran vdout0_33ck1020 FIND v(dout0_33) AT=515.025n

.meas tran vdout0_34ck1020 FIND v(dout0_34) AT=515.025n

.meas tran vdout0_35ck1020 FIND v(dout0_35) AT=515.025n

.meas tran vdout0_36ck1020 FIND v(dout0_36) AT=515.025n

.meas tran vdout0_37ck1020 FIND v(dout0_37) AT=515.025n

.meas tran vdout0_38ck1020 FIND v(dout0_38) AT=515.025n

.meas tran vdout0_39ck1020 FIND v(dout0_39) AT=515.025n

.meas tran vdout0_40ck1020 FIND v(dout0_40) AT=515.025n

.meas tran vdout0_41ck1020 FIND v(dout0_41) AT=515.025n

.meas tran vdout0_42ck1020 FIND v(dout0_42) AT=515.025n

.meas tran vdout0_43ck1020 FIND v(dout0_43) AT=515.025n

.meas tran vdout0_44ck1020 FIND v(dout0_44) AT=515.025n

.meas tran vdout0_45ck1020 FIND v(dout0_45) AT=515.025n

.meas tran vdout0_46ck1020 FIND v(dout0_46) AT=515.025n

.meas tran vdout0_47ck1020 FIND v(dout0_47) AT=515.025n

.meas tran vdout0_48ck1020 FIND v(dout0_48) AT=515.025n

.meas tran vdout0_49ck1020 FIND v(dout0_49) AT=515.025n

.meas tran vdout0_50ck1020 FIND v(dout0_50) AT=515.025n

.meas tran vdout0_51ck1020 FIND v(dout0_51) AT=515.025n

.meas tran vdout0_52ck1020 FIND v(dout0_52) AT=515.025n

.meas tran vdout0_53ck1020 FIND v(dout0_53) AT=515.025n

.meas tran vdout0_54ck1020 FIND v(dout0_54) AT=515.025n

.meas tran vdout0_55ck1020 FIND v(dout0_55) AT=515.025n

.meas tran vdout0_56ck1020 FIND v(dout0_56) AT=515.025n

.meas tran vdout0_57ck1020 FIND v(dout0_57) AT=515.025n

.meas tran vdout0_58ck1020 FIND v(dout0_58) AT=515.025n

.meas tran vdout0_59ck1020 FIND v(dout0_59) AT=515.025n

.meas tran vdout0_60ck1020 FIND v(dout0_60) AT=515.025n

.meas tran vdout0_61ck1020 FIND v(dout0_61) AT=515.025n

.meas tran vdout0_62ck1020 FIND v(dout0_62) AT=515.025n

.meas tran vdout0_63ck1020 FIND v(dout0_63) AT=515.025n

.meas tran vdout0_64ck1020 FIND v(dout0_64) AT=515.025n

.meas tran vdout0_65ck1020 FIND v(dout0_65) AT=515.025n

.meas tran vdout0_66ck1020 FIND v(dout0_66) AT=515.025n

.meas tran vdout0_67ck1020 FIND v(dout0_67) AT=515.025n

.meas tran vdout0_68ck1020 FIND v(dout0_68) AT=515.025n

.meas tran vdout0_69ck1020 FIND v(dout0_69) AT=515.025n

.meas tran vdout0_70ck1020 FIND v(dout0_70) AT=515.025n

.meas tran vdout0_71ck1020 FIND v(dout0_71) AT=515.025n

.meas tran vdout0_72ck1020 FIND v(dout0_72) AT=515.025n

.meas tran vdout0_73ck1020 FIND v(dout0_73) AT=515.025n

.meas tran vdout0_74ck1020 FIND v(dout0_74) AT=515.025n

.meas tran vdout0_75ck1020 FIND v(dout0_75) AT=515.025n

.meas tran vdout0_76ck1020 FIND v(dout0_76) AT=515.025n

.meas tran vdout0_77ck1020 FIND v(dout0_77) AT=515.025n

.meas tran vdout0_78ck1020 FIND v(dout0_78) AT=515.025n

.meas tran vdout0_79ck1020 FIND v(dout0_79) AT=515.025n

.meas tran vdout0_80ck1020 FIND v(dout0_80) AT=515.025n

.meas tran vdout0_81ck1020 FIND v(dout0_81) AT=515.025n

.meas tran vdout0_82ck1020 FIND v(dout0_82) AT=515.025n

.meas tran vdout0_83ck1020 FIND v(dout0_83) AT=515.025n

.meas tran vdout0_84ck1020 FIND v(dout0_84) AT=515.025n

.meas tran vdout0_85ck1020 FIND v(dout0_85) AT=515.025n

.meas tran vdout0_86ck1020 FIND v(dout0_86) AT=515.025n

.meas tran vdout0_87ck1020 FIND v(dout0_87) AT=515.025n

.meas tran vdout0_88ck1020 FIND v(dout0_88) AT=515.025n

.meas tran vdout0_89ck1020 FIND v(dout0_89) AT=515.025n

.meas tran vdout0_90ck1020 FIND v(dout0_90) AT=515.025n

.meas tran vdout0_91ck1020 FIND v(dout0_91) AT=515.025n

.meas tran vdout0_92ck1020 FIND v(dout0_92) AT=515.025n

.meas tran vdout0_93ck1020 FIND v(dout0_93) AT=515.025n

.meas tran vdout0_94ck1020 FIND v(dout0_94) AT=515.025n

.meas tran vdout0_95ck1020 FIND v(dout0_95) AT=515.025n

.meas tran vdout0_96ck1020 FIND v(dout0_96) AT=515.025n

.meas tran vdout0_97ck1020 FIND v(dout0_97) AT=515.025n

.meas tran vdout0_98ck1020 FIND v(dout0_98) AT=515.025n

.meas tran vdout0_99ck1020 FIND v(dout0_99) AT=515.025n

.meas tran vdout0_100ck1020 FIND v(dout0_100) AT=515.025n

.meas tran vdout0_101ck1020 FIND v(dout0_101) AT=515.025n

.meas tran vdout0_102ck1020 FIND v(dout0_102) AT=515.025n

.meas tran vdout0_103ck1020 FIND v(dout0_103) AT=515.025n

.meas tran vdout0_104ck1020 FIND v(dout0_104) AT=515.025n

.meas tran vdout0_105ck1020 FIND v(dout0_105) AT=515.025n

.meas tran vdout0_106ck1020 FIND v(dout0_106) AT=515.025n

.meas tran vdout0_107ck1020 FIND v(dout0_107) AT=515.025n

.meas tran vdout0_108ck1020 FIND v(dout0_108) AT=515.025n

.meas tran vdout0_109ck1020 FIND v(dout0_109) AT=515.025n

.meas tran vdout0_110ck1020 FIND v(dout0_110) AT=515.025n

.meas tran vdout0_111ck1020 FIND v(dout0_111) AT=515.025n

.meas tran vdout0_112ck1020 FIND v(dout0_112) AT=515.025n

.meas tran vdout0_113ck1020 FIND v(dout0_113) AT=515.025n

.meas tran vdout0_114ck1020 FIND v(dout0_114) AT=515.025n

.meas tran vdout0_115ck1020 FIND v(dout0_115) AT=515.025n

.meas tran vdout0_116ck1020 FIND v(dout0_116) AT=515.025n

.meas tran vdout0_117ck1020 FIND v(dout0_117) AT=515.025n

.meas tran vdout0_118ck1020 FIND v(dout0_118) AT=515.025n

.meas tran vdout0_119ck1020 FIND v(dout0_119) AT=515.025n

.meas tran vdout0_120ck1020 FIND v(dout0_120) AT=515.025n

.meas tran vdout0_121ck1020 FIND v(dout0_121) AT=515.025n

.meas tran vdout0_122ck1020 FIND v(dout0_122) AT=515.025n

.meas tran vdout0_123ck1020 FIND v(dout0_123) AT=515.025n

.meas tran vdout0_124ck1020 FIND v(dout0_124) AT=515.025n

.meas tran vdout0_125ck1020 FIND v(dout0_125) AT=515.025n

.meas tran vdout0_126ck1020 FIND v(dout0_126) AT=515.025n

.meas tran vdout0_127ck1020 FIND v(dout0_127) AT=515.025n

.meas tran vdout0_0ck1030 FIND v(dout0_0) AT=520.025n

.meas tran vdout0_1ck1030 FIND v(dout0_1) AT=520.025n

.meas tran vdout0_2ck1030 FIND v(dout0_2) AT=520.025n

.meas tran vdout0_3ck1030 FIND v(dout0_3) AT=520.025n

.meas tran vdout0_4ck1030 FIND v(dout0_4) AT=520.025n

.meas tran vdout0_5ck1030 FIND v(dout0_5) AT=520.025n

.meas tran vdout0_6ck1030 FIND v(dout0_6) AT=520.025n

.meas tran vdout0_7ck1030 FIND v(dout0_7) AT=520.025n

.meas tran vdout0_8ck1030 FIND v(dout0_8) AT=520.025n

.meas tran vdout0_9ck1030 FIND v(dout0_9) AT=520.025n

.meas tran vdout0_10ck1030 FIND v(dout0_10) AT=520.025n

.meas tran vdout0_11ck1030 FIND v(dout0_11) AT=520.025n

.meas tran vdout0_12ck1030 FIND v(dout0_12) AT=520.025n

.meas tran vdout0_13ck1030 FIND v(dout0_13) AT=520.025n

.meas tran vdout0_14ck1030 FIND v(dout0_14) AT=520.025n

.meas tran vdout0_15ck1030 FIND v(dout0_15) AT=520.025n

.meas tran vdout0_16ck1030 FIND v(dout0_16) AT=520.025n

.meas tran vdout0_17ck1030 FIND v(dout0_17) AT=520.025n

.meas tran vdout0_18ck1030 FIND v(dout0_18) AT=520.025n

.meas tran vdout0_19ck1030 FIND v(dout0_19) AT=520.025n

.meas tran vdout0_20ck1030 FIND v(dout0_20) AT=520.025n

.meas tran vdout0_21ck1030 FIND v(dout0_21) AT=520.025n

.meas tran vdout0_22ck1030 FIND v(dout0_22) AT=520.025n

.meas tran vdout0_23ck1030 FIND v(dout0_23) AT=520.025n

.meas tran vdout0_24ck1030 FIND v(dout0_24) AT=520.025n

.meas tran vdout0_25ck1030 FIND v(dout0_25) AT=520.025n

.meas tran vdout0_26ck1030 FIND v(dout0_26) AT=520.025n

.meas tran vdout0_27ck1030 FIND v(dout0_27) AT=520.025n

.meas tran vdout0_28ck1030 FIND v(dout0_28) AT=520.025n

.meas tran vdout0_29ck1030 FIND v(dout0_29) AT=520.025n

.meas tran vdout0_30ck1030 FIND v(dout0_30) AT=520.025n

.meas tran vdout0_31ck1030 FIND v(dout0_31) AT=520.025n

.meas tran vdout0_32ck1030 FIND v(dout0_32) AT=520.025n

.meas tran vdout0_33ck1030 FIND v(dout0_33) AT=520.025n

.meas tran vdout0_34ck1030 FIND v(dout0_34) AT=520.025n

.meas tran vdout0_35ck1030 FIND v(dout0_35) AT=520.025n

.meas tran vdout0_36ck1030 FIND v(dout0_36) AT=520.025n

.meas tran vdout0_37ck1030 FIND v(dout0_37) AT=520.025n

.meas tran vdout0_38ck1030 FIND v(dout0_38) AT=520.025n

.meas tran vdout0_39ck1030 FIND v(dout0_39) AT=520.025n

.meas tran vdout0_40ck1030 FIND v(dout0_40) AT=520.025n

.meas tran vdout0_41ck1030 FIND v(dout0_41) AT=520.025n

.meas tran vdout0_42ck1030 FIND v(dout0_42) AT=520.025n

.meas tran vdout0_43ck1030 FIND v(dout0_43) AT=520.025n

.meas tran vdout0_44ck1030 FIND v(dout0_44) AT=520.025n

.meas tran vdout0_45ck1030 FIND v(dout0_45) AT=520.025n

.meas tran vdout0_46ck1030 FIND v(dout0_46) AT=520.025n

.meas tran vdout0_47ck1030 FIND v(dout0_47) AT=520.025n

.meas tran vdout0_48ck1030 FIND v(dout0_48) AT=520.025n

.meas tran vdout0_49ck1030 FIND v(dout0_49) AT=520.025n

.meas tran vdout0_50ck1030 FIND v(dout0_50) AT=520.025n

.meas tran vdout0_51ck1030 FIND v(dout0_51) AT=520.025n

.meas tran vdout0_52ck1030 FIND v(dout0_52) AT=520.025n

.meas tran vdout0_53ck1030 FIND v(dout0_53) AT=520.025n

.meas tran vdout0_54ck1030 FIND v(dout0_54) AT=520.025n

.meas tran vdout0_55ck1030 FIND v(dout0_55) AT=520.025n

.meas tran vdout0_56ck1030 FIND v(dout0_56) AT=520.025n

.meas tran vdout0_57ck1030 FIND v(dout0_57) AT=520.025n

.meas tran vdout0_58ck1030 FIND v(dout0_58) AT=520.025n

.meas tran vdout0_59ck1030 FIND v(dout0_59) AT=520.025n

.meas tran vdout0_60ck1030 FIND v(dout0_60) AT=520.025n

.meas tran vdout0_61ck1030 FIND v(dout0_61) AT=520.025n

.meas tran vdout0_62ck1030 FIND v(dout0_62) AT=520.025n

.meas tran vdout0_63ck1030 FIND v(dout0_63) AT=520.025n

.meas tran vdout0_64ck1030 FIND v(dout0_64) AT=520.025n

.meas tran vdout0_65ck1030 FIND v(dout0_65) AT=520.025n

.meas tran vdout0_66ck1030 FIND v(dout0_66) AT=520.025n

.meas tran vdout0_67ck1030 FIND v(dout0_67) AT=520.025n

.meas tran vdout0_68ck1030 FIND v(dout0_68) AT=520.025n

.meas tran vdout0_69ck1030 FIND v(dout0_69) AT=520.025n

.meas tran vdout0_70ck1030 FIND v(dout0_70) AT=520.025n

.meas tran vdout0_71ck1030 FIND v(dout0_71) AT=520.025n

.meas tran vdout0_72ck1030 FIND v(dout0_72) AT=520.025n

.meas tran vdout0_73ck1030 FIND v(dout0_73) AT=520.025n

.meas tran vdout0_74ck1030 FIND v(dout0_74) AT=520.025n

.meas tran vdout0_75ck1030 FIND v(dout0_75) AT=520.025n

.meas tran vdout0_76ck1030 FIND v(dout0_76) AT=520.025n

.meas tran vdout0_77ck1030 FIND v(dout0_77) AT=520.025n

.meas tran vdout0_78ck1030 FIND v(dout0_78) AT=520.025n

.meas tran vdout0_79ck1030 FIND v(dout0_79) AT=520.025n

.meas tran vdout0_80ck1030 FIND v(dout0_80) AT=520.025n

.meas tran vdout0_81ck1030 FIND v(dout0_81) AT=520.025n

.meas tran vdout0_82ck1030 FIND v(dout0_82) AT=520.025n

.meas tran vdout0_83ck1030 FIND v(dout0_83) AT=520.025n

.meas tran vdout0_84ck1030 FIND v(dout0_84) AT=520.025n

.meas tran vdout0_85ck1030 FIND v(dout0_85) AT=520.025n

.meas tran vdout0_86ck1030 FIND v(dout0_86) AT=520.025n

.meas tran vdout0_87ck1030 FIND v(dout0_87) AT=520.025n

.meas tran vdout0_88ck1030 FIND v(dout0_88) AT=520.025n

.meas tran vdout0_89ck1030 FIND v(dout0_89) AT=520.025n

.meas tran vdout0_90ck1030 FIND v(dout0_90) AT=520.025n

.meas tran vdout0_91ck1030 FIND v(dout0_91) AT=520.025n

.meas tran vdout0_92ck1030 FIND v(dout0_92) AT=520.025n

.meas tran vdout0_93ck1030 FIND v(dout0_93) AT=520.025n

.meas tran vdout0_94ck1030 FIND v(dout0_94) AT=520.025n

.meas tran vdout0_95ck1030 FIND v(dout0_95) AT=520.025n

.meas tran vdout0_96ck1030 FIND v(dout0_96) AT=520.025n

.meas tran vdout0_97ck1030 FIND v(dout0_97) AT=520.025n

.meas tran vdout0_98ck1030 FIND v(dout0_98) AT=520.025n

.meas tran vdout0_99ck1030 FIND v(dout0_99) AT=520.025n

.meas tran vdout0_100ck1030 FIND v(dout0_100) AT=520.025n

.meas tran vdout0_101ck1030 FIND v(dout0_101) AT=520.025n

.meas tran vdout0_102ck1030 FIND v(dout0_102) AT=520.025n

.meas tran vdout0_103ck1030 FIND v(dout0_103) AT=520.025n

.meas tran vdout0_104ck1030 FIND v(dout0_104) AT=520.025n

.meas tran vdout0_105ck1030 FIND v(dout0_105) AT=520.025n

.meas tran vdout0_106ck1030 FIND v(dout0_106) AT=520.025n

.meas tran vdout0_107ck1030 FIND v(dout0_107) AT=520.025n

.meas tran vdout0_108ck1030 FIND v(dout0_108) AT=520.025n

.meas tran vdout0_109ck1030 FIND v(dout0_109) AT=520.025n

.meas tran vdout0_110ck1030 FIND v(dout0_110) AT=520.025n

.meas tran vdout0_111ck1030 FIND v(dout0_111) AT=520.025n

.meas tran vdout0_112ck1030 FIND v(dout0_112) AT=520.025n

.meas tran vdout0_113ck1030 FIND v(dout0_113) AT=520.025n

.meas tran vdout0_114ck1030 FIND v(dout0_114) AT=520.025n

.meas tran vdout0_115ck1030 FIND v(dout0_115) AT=520.025n

.meas tran vdout0_116ck1030 FIND v(dout0_116) AT=520.025n

.meas tran vdout0_117ck1030 FIND v(dout0_117) AT=520.025n

.meas tran vdout0_118ck1030 FIND v(dout0_118) AT=520.025n

.meas tran vdout0_119ck1030 FIND v(dout0_119) AT=520.025n

.meas tran vdout0_120ck1030 FIND v(dout0_120) AT=520.025n

.meas tran vdout0_121ck1030 FIND v(dout0_121) AT=520.025n

.meas tran vdout0_122ck1030 FIND v(dout0_122) AT=520.025n

.meas tran vdout0_123ck1030 FIND v(dout0_123) AT=520.025n

.meas tran vdout0_124ck1030 FIND v(dout0_124) AT=520.025n

.meas tran vdout0_125ck1030 FIND v(dout0_125) AT=520.025n

.meas tran vdout0_126ck1030 FIND v(dout0_126) AT=520.025n

.meas tran vdout0_127ck1030 FIND v(dout0_127) AT=520.025n

.meas tran vdout0_0ck1050 FIND v(dout0_0) AT=530.025n

.meas tran vdout0_1ck1050 FIND v(dout0_1) AT=530.025n

.meas tran vdout0_2ck1050 FIND v(dout0_2) AT=530.025n

.meas tran vdout0_3ck1050 FIND v(dout0_3) AT=530.025n

.meas tran vdout0_4ck1050 FIND v(dout0_4) AT=530.025n

.meas tran vdout0_5ck1050 FIND v(dout0_5) AT=530.025n

.meas tran vdout0_6ck1050 FIND v(dout0_6) AT=530.025n

.meas tran vdout0_7ck1050 FIND v(dout0_7) AT=530.025n

.meas tran vdout0_8ck1050 FIND v(dout0_8) AT=530.025n

.meas tran vdout0_9ck1050 FIND v(dout0_9) AT=530.025n

.meas tran vdout0_10ck1050 FIND v(dout0_10) AT=530.025n

.meas tran vdout0_11ck1050 FIND v(dout0_11) AT=530.025n

.meas tran vdout0_12ck1050 FIND v(dout0_12) AT=530.025n

.meas tran vdout0_13ck1050 FIND v(dout0_13) AT=530.025n

.meas tran vdout0_14ck1050 FIND v(dout0_14) AT=530.025n

.meas tran vdout0_15ck1050 FIND v(dout0_15) AT=530.025n

.meas tran vdout0_16ck1050 FIND v(dout0_16) AT=530.025n

.meas tran vdout0_17ck1050 FIND v(dout0_17) AT=530.025n

.meas tran vdout0_18ck1050 FIND v(dout0_18) AT=530.025n

.meas tran vdout0_19ck1050 FIND v(dout0_19) AT=530.025n

.meas tran vdout0_20ck1050 FIND v(dout0_20) AT=530.025n

.meas tran vdout0_21ck1050 FIND v(dout0_21) AT=530.025n

.meas tran vdout0_22ck1050 FIND v(dout0_22) AT=530.025n

.meas tran vdout0_23ck1050 FIND v(dout0_23) AT=530.025n

.meas tran vdout0_24ck1050 FIND v(dout0_24) AT=530.025n

.meas tran vdout0_25ck1050 FIND v(dout0_25) AT=530.025n

.meas tran vdout0_26ck1050 FIND v(dout0_26) AT=530.025n

.meas tran vdout0_27ck1050 FIND v(dout0_27) AT=530.025n

.meas tran vdout0_28ck1050 FIND v(dout0_28) AT=530.025n

.meas tran vdout0_29ck1050 FIND v(dout0_29) AT=530.025n

.meas tran vdout0_30ck1050 FIND v(dout0_30) AT=530.025n

.meas tran vdout0_31ck1050 FIND v(dout0_31) AT=530.025n

.meas tran vdout0_32ck1050 FIND v(dout0_32) AT=530.025n

.meas tran vdout0_33ck1050 FIND v(dout0_33) AT=530.025n

.meas tran vdout0_34ck1050 FIND v(dout0_34) AT=530.025n

.meas tran vdout0_35ck1050 FIND v(dout0_35) AT=530.025n

.meas tran vdout0_36ck1050 FIND v(dout0_36) AT=530.025n

.meas tran vdout0_37ck1050 FIND v(dout0_37) AT=530.025n

.meas tran vdout0_38ck1050 FIND v(dout0_38) AT=530.025n

.meas tran vdout0_39ck1050 FIND v(dout0_39) AT=530.025n

.meas tran vdout0_40ck1050 FIND v(dout0_40) AT=530.025n

.meas tran vdout0_41ck1050 FIND v(dout0_41) AT=530.025n

.meas tran vdout0_42ck1050 FIND v(dout0_42) AT=530.025n

.meas tran vdout0_43ck1050 FIND v(dout0_43) AT=530.025n

.meas tran vdout0_44ck1050 FIND v(dout0_44) AT=530.025n

.meas tran vdout0_45ck1050 FIND v(dout0_45) AT=530.025n

.meas tran vdout0_46ck1050 FIND v(dout0_46) AT=530.025n

.meas tran vdout0_47ck1050 FIND v(dout0_47) AT=530.025n

.meas tran vdout0_48ck1050 FIND v(dout0_48) AT=530.025n

.meas tran vdout0_49ck1050 FIND v(dout0_49) AT=530.025n

.meas tran vdout0_50ck1050 FIND v(dout0_50) AT=530.025n

.meas tran vdout0_51ck1050 FIND v(dout0_51) AT=530.025n

.meas tran vdout0_52ck1050 FIND v(dout0_52) AT=530.025n

.meas tran vdout0_53ck1050 FIND v(dout0_53) AT=530.025n

.meas tran vdout0_54ck1050 FIND v(dout0_54) AT=530.025n

.meas tran vdout0_55ck1050 FIND v(dout0_55) AT=530.025n

.meas tran vdout0_56ck1050 FIND v(dout0_56) AT=530.025n

.meas tran vdout0_57ck1050 FIND v(dout0_57) AT=530.025n

.meas tran vdout0_58ck1050 FIND v(dout0_58) AT=530.025n

.meas tran vdout0_59ck1050 FIND v(dout0_59) AT=530.025n

.meas tran vdout0_60ck1050 FIND v(dout0_60) AT=530.025n

.meas tran vdout0_61ck1050 FIND v(dout0_61) AT=530.025n

.meas tran vdout0_62ck1050 FIND v(dout0_62) AT=530.025n

.meas tran vdout0_63ck1050 FIND v(dout0_63) AT=530.025n

.meas tran vdout0_64ck1050 FIND v(dout0_64) AT=530.025n

.meas tran vdout0_65ck1050 FIND v(dout0_65) AT=530.025n

.meas tran vdout0_66ck1050 FIND v(dout0_66) AT=530.025n

.meas tran vdout0_67ck1050 FIND v(dout0_67) AT=530.025n

.meas tran vdout0_68ck1050 FIND v(dout0_68) AT=530.025n

.meas tran vdout0_69ck1050 FIND v(dout0_69) AT=530.025n

.meas tran vdout0_70ck1050 FIND v(dout0_70) AT=530.025n

.meas tran vdout0_71ck1050 FIND v(dout0_71) AT=530.025n

.meas tran vdout0_72ck1050 FIND v(dout0_72) AT=530.025n

.meas tran vdout0_73ck1050 FIND v(dout0_73) AT=530.025n

.meas tran vdout0_74ck1050 FIND v(dout0_74) AT=530.025n

.meas tran vdout0_75ck1050 FIND v(dout0_75) AT=530.025n

.meas tran vdout0_76ck1050 FIND v(dout0_76) AT=530.025n

.meas tran vdout0_77ck1050 FIND v(dout0_77) AT=530.025n

.meas tran vdout0_78ck1050 FIND v(dout0_78) AT=530.025n

.meas tran vdout0_79ck1050 FIND v(dout0_79) AT=530.025n

.meas tran vdout0_80ck1050 FIND v(dout0_80) AT=530.025n

.meas tran vdout0_81ck1050 FIND v(dout0_81) AT=530.025n

.meas tran vdout0_82ck1050 FIND v(dout0_82) AT=530.025n

.meas tran vdout0_83ck1050 FIND v(dout0_83) AT=530.025n

.meas tran vdout0_84ck1050 FIND v(dout0_84) AT=530.025n

.meas tran vdout0_85ck1050 FIND v(dout0_85) AT=530.025n

.meas tran vdout0_86ck1050 FIND v(dout0_86) AT=530.025n

.meas tran vdout0_87ck1050 FIND v(dout0_87) AT=530.025n

.meas tran vdout0_88ck1050 FIND v(dout0_88) AT=530.025n

.meas tran vdout0_89ck1050 FIND v(dout0_89) AT=530.025n

.meas tran vdout0_90ck1050 FIND v(dout0_90) AT=530.025n

.meas tran vdout0_91ck1050 FIND v(dout0_91) AT=530.025n

.meas tran vdout0_92ck1050 FIND v(dout0_92) AT=530.025n

.meas tran vdout0_93ck1050 FIND v(dout0_93) AT=530.025n

.meas tran vdout0_94ck1050 FIND v(dout0_94) AT=530.025n

.meas tran vdout0_95ck1050 FIND v(dout0_95) AT=530.025n

.meas tran vdout0_96ck1050 FIND v(dout0_96) AT=530.025n

.meas tran vdout0_97ck1050 FIND v(dout0_97) AT=530.025n

.meas tran vdout0_98ck1050 FIND v(dout0_98) AT=530.025n

.meas tran vdout0_99ck1050 FIND v(dout0_99) AT=530.025n

.meas tran vdout0_100ck1050 FIND v(dout0_100) AT=530.025n

.meas tran vdout0_101ck1050 FIND v(dout0_101) AT=530.025n

.meas tran vdout0_102ck1050 FIND v(dout0_102) AT=530.025n

.meas tran vdout0_103ck1050 FIND v(dout0_103) AT=530.025n

.meas tran vdout0_104ck1050 FIND v(dout0_104) AT=530.025n

.meas tran vdout0_105ck1050 FIND v(dout0_105) AT=530.025n

.meas tran vdout0_106ck1050 FIND v(dout0_106) AT=530.025n

.meas tran vdout0_107ck1050 FIND v(dout0_107) AT=530.025n

.meas tran vdout0_108ck1050 FIND v(dout0_108) AT=530.025n

.meas tran vdout0_109ck1050 FIND v(dout0_109) AT=530.025n

.meas tran vdout0_110ck1050 FIND v(dout0_110) AT=530.025n

.meas tran vdout0_111ck1050 FIND v(dout0_111) AT=530.025n

.meas tran vdout0_112ck1050 FIND v(dout0_112) AT=530.025n

.meas tran vdout0_113ck1050 FIND v(dout0_113) AT=530.025n

.meas tran vdout0_114ck1050 FIND v(dout0_114) AT=530.025n

.meas tran vdout0_115ck1050 FIND v(dout0_115) AT=530.025n

.meas tran vdout0_116ck1050 FIND v(dout0_116) AT=530.025n

.meas tran vdout0_117ck1050 FIND v(dout0_117) AT=530.025n

.meas tran vdout0_118ck1050 FIND v(dout0_118) AT=530.025n

.meas tran vdout0_119ck1050 FIND v(dout0_119) AT=530.025n

.meas tran vdout0_120ck1050 FIND v(dout0_120) AT=530.025n

.meas tran vdout0_121ck1050 FIND v(dout0_121) AT=530.025n

.meas tran vdout0_122ck1050 FIND v(dout0_122) AT=530.025n

.meas tran vdout0_123ck1050 FIND v(dout0_123) AT=530.025n

.meas tran vdout0_124ck1050 FIND v(dout0_124) AT=530.025n

.meas tran vdout0_125ck1050 FIND v(dout0_125) AT=530.025n

.meas tran vdout0_126ck1050 FIND v(dout0_126) AT=530.025n

.meas tran vdout0_127ck1050 FIND v(dout0_127) AT=530.025n

.meas tran vdout0_0ck1100 FIND v(dout0_0) AT=555.025n

.meas tran vdout0_1ck1100 FIND v(dout0_1) AT=555.025n

.meas tran vdout0_2ck1100 FIND v(dout0_2) AT=555.025n

.meas tran vdout0_3ck1100 FIND v(dout0_3) AT=555.025n

.meas tran vdout0_4ck1100 FIND v(dout0_4) AT=555.025n

.meas tran vdout0_5ck1100 FIND v(dout0_5) AT=555.025n

.meas tran vdout0_6ck1100 FIND v(dout0_6) AT=555.025n

.meas tran vdout0_7ck1100 FIND v(dout0_7) AT=555.025n

.meas tran vdout0_8ck1100 FIND v(dout0_8) AT=555.025n

.meas tran vdout0_9ck1100 FIND v(dout0_9) AT=555.025n

.meas tran vdout0_10ck1100 FIND v(dout0_10) AT=555.025n

.meas tran vdout0_11ck1100 FIND v(dout0_11) AT=555.025n

.meas tran vdout0_12ck1100 FIND v(dout0_12) AT=555.025n

.meas tran vdout0_13ck1100 FIND v(dout0_13) AT=555.025n

.meas tran vdout0_14ck1100 FIND v(dout0_14) AT=555.025n

.meas tran vdout0_15ck1100 FIND v(dout0_15) AT=555.025n

.meas tran vdout0_16ck1100 FIND v(dout0_16) AT=555.025n

.meas tran vdout0_17ck1100 FIND v(dout0_17) AT=555.025n

.meas tran vdout0_18ck1100 FIND v(dout0_18) AT=555.025n

.meas tran vdout0_19ck1100 FIND v(dout0_19) AT=555.025n

.meas tran vdout0_20ck1100 FIND v(dout0_20) AT=555.025n

.meas tran vdout0_21ck1100 FIND v(dout0_21) AT=555.025n

.meas tran vdout0_22ck1100 FIND v(dout0_22) AT=555.025n

.meas tran vdout0_23ck1100 FIND v(dout0_23) AT=555.025n

.meas tran vdout0_24ck1100 FIND v(dout0_24) AT=555.025n

.meas tran vdout0_25ck1100 FIND v(dout0_25) AT=555.025n

.meas tran vdout0_26ck1100 FIND v(dout0_26) AT=555.025n

.meas tran vdout0_27ck1100 FIND v(dout0_27) AT=555.025n

.meas tran vdout0_28ck1100 FIND v(dout0_28) AT=555.025n

.meas tran vdout0_29ck1100 FIND v(dout0_29) AT=555.025n

.meas tran vdout0_30ck1100 FIND v(dout0_30) AT=555.025n

.meas tran vdout0_31ck1100 FIND v(dout0_31) AT=555.025n

.meas tran vdout0_32ck1100 FIND v(dout0_32) AT=555.025n

.meas tran vdout0_33ck1100 FIND v(dout0_33) AT=555.025n

.meas tran vdout0_34ck1100 FIND v(dout0_34) AT=555.025n

.meas tran vdout0_35ck1100 FIND v(dout0_35) AT=555.025n

.meas tran vdout0_36ck1100 FIND v(dout0_36) AT=555.025n

.meas tran vdout0_37ck1100 FIND v(dout0_37) AT=555.025n

.meas tran vdout0_38ck1100 FIND v(dout0_38) AT=555.025n

.meas tran vdout0_39ck1100 FIND v(dout0_39) AT=555.025n

.meas tran vdout0_40ck1100 FIND v(dout0_40) AT=555.025n

.meas tran vdout0_41ck1100 FIND v(dout0_41) AT=555.025n

.meas tran vdout0_42ck1100 FIND v(dout0_42) AT=555.025n

.meas tran vdout0_43ck1100 FIND v(dout0_43) AT=555.025n

.meas tran vdout0_44ck1100 FIND v(dout0_44) AT=555.025n

.meas tran vdout0_45ck1100 FIND v(dout0_45) AT=555.025n

.meas tran vdout0_46ck1100 FIND v(dout0_46) AT=555.025n

.meas tran vdout0_47ck1100 FIND v(dout0_47) AT=555.025n

.meas tran vdout0_48ck1100 FIND v(dout0_48) AT=555.025n

.meas tran vdout0_49ck1100 FIND v(dout0_49) AT=555.025n

.meas tran vdout0_50ck1100 FIND v(dout0_50) AT=555.025n

.meas tran vdout0_51ck1100 FIND v(dout0_51) AT=555.025n

.meas tran vdout0_52ck1100 FIND v(dout0_52) AT=555.025n

.meas tran vdout0_53ck1100 FIND v(dout0_53) AT=555.025n

.meas tran vdout0_54ck1100 FIND v(dout0_54) AT=555.025n

.meas tran vdout0_55ck1100 FIND v(dout0_55) AT=555.025n

.meas tran vdout0_56ck1100 FIND v(dout0_56) AT=555.025n

.meas tran vdout0_57ck1100 FIND v(dout0_57) AT=555.025n

.meas tran vdout0_58ck1100 FIND v(dout0_58) AT=555.025n

.meas tran vdout0_59ck1100 FIND v(dout0_59) AT=555.025n

.meas tran vdout0_60ck1100 FIND v(dout0_60) AT=555.025n

.meas tran vdout0_61ck1100 FIND v(dout0_61) AT=555.025n

.meas tran vdout0_62ck1100 FIND v(dout0_62) AT=555.025n

.meas tran vdout0_63ck1100 FIND v(dout0_63) AT=555.025n

.meas tran vdout0_64ck1100 FIND v(dout0_64) AT=555.025n

.meas tran vdout0_65ck1100 FIND v(dout0_65) AT=555.025n

.meas tran vdout0_66ck1100 FIND v(dout0_66) AT=555.025n

.meas tran vdout0_67ck1100 FIND v(dout0_67) AT=555.025n

.meas tran vdout0_68ck1100 FIND v(dout0_68) AT=555.025n

.meas tran vdout0_69ck1100 FIND v(dout0_69) AT=555.025n

.meas tran vdout0_70ck1100 FIND v(dout0_70) AT=555.025n

.meas tran vdout0_71ck1100 FIND v(dout0_71) AT=555.025n

.meas tran vdout0_72ck1100 FIND v(dout0_72) AT=555.025n

.meas tran vdout0_73ck1100 FIND v(dout0_73) AT=555.025n

.meas tran vdout0_74ck1100 FIND v(dout0_74) AT=555.025n

.meas tran vdout0_75ck1100 FIND v(dout0_75) AT=555.025n

.meas tran vdout0_76ck1100 FIND v(dout0_76) AT=555.025n

.meas tran vdout0_77ck1100 FIND v(dout0_77) AT=555.025n

.meas tran vdout0_78ck1100 FIND v(dout0_78) AT=555.025n

.meas tran vdout0_79ck1100 FIND v(dout0_79) AT=555.025n

.meas tran vdout0_80ck1100 FIND v(dout0_80) AT=555.025n

.meas tran vdout0_81ck1100 FIND v(dout0_81) AT=555.025n

.meas tran vdout0_82ck1100 FIND v(dout0_82) AT=555.025n

.meas tran vdout0_83ck1100 FIND v(dout0_83) AT=555.025n

.meas tran vdout0_84ck1100 FIND v(dout0_84) AT=555.025n

.meas tran vdout0_85ck1100 FIND v(dout0_85) AT=555.025n

.meas tran vdout0_86ck1100 FIND v(dout0_86) AT=555.025n

.meas tran vdout0_87ck1100 FIND v(dout0_87) AT=555.025n

.meas tran vdout0_88ck1100 FIND v(dout0_88) AT=555.025n

.meas tran vdout0_89ck1100 FIND v(dout0_89) AT=555.025n

.meas tran vdout0_90ck1100 FIND v(dout0_90) AT=555.025n

.meas tran vdout0_91ck1100 FIND v(dout0_91) AT=555.025n

.meas tran vdout0_92ck1100 FIND v(dout0_92) AT=555.025n

.meas tran vdout0_93ck1100 FIND v(dout0_93) AT=555.025n

.meas tran vdout0_94ck1100 FIND v(dout0_94) AT=555.025n

.meas tran vdout0_95ck1100 FIND v(dout0_95) AT=555.025n

.meas tran vdout0_96ck1100 FIND v(dout0_96) AT=555.025n

.meas tran vdout0_97ck1100 FIND v(dout0_97) AT=555.025n

.meas tran vdout0_98ck1100 FIND v(dout0_98) AT=555.025n

.meas tran vdout0_99ck1100 FIND v(dout0_99) AT=555.025n

.meas tran vdout0_100ck1100 FIND v(dout0_100) AT=555.025n

.meas tran vdout0_101ck1100 FIND v(dout0_101) AT=555.025n

.meas tran vdout0_102ck1100 FIND v(dout0_102) AT=555.025n

.meas tran vdout0_103ck1100 FIND v(dout0_103) AT=555.025n

.meas tran vdout0_104ck1100 FIND v(dout0_104) AT=555.025n

.meas tran vdout0_105ck1100 FIND v(dout0_105) AT=555.025n

.meas tran vdout0_106ck1100 FIND v(dout0_106) AT=555.025n

.meas tran vdout0_107ck1100 FIND v(dout0_107) AT=555.025n

.meas tran vdout0_108ck1100 FIND v(dout0_108) AT=555.025n

.meas tran vdout0_109ck1100 FIND v(dout0_109) AT=555.025n

.meas tran vdout0_110ck1100 FIND v(dout0_110) AT=555.025n

.meas tran vdout0_111ck1100 FIND v(dout0_111) AT=555.025n

.meas tran vdout0_112ck1100 FIND v(dout0_112) AT=555.025n

.meas tran vdout0_113ck1100 FIND v(dout0_113) AT=555.025n

.meas tran vdout0_114ck1100 FIND v(dout0_114) AT=555.025n

.meas tran vdout0_115ck1100 FIND v(dout0_115) AT=555.025n

.meas tran vdout0_116ck1100 FIND v(dout0_116) AT=555.025n

.meas tran vdout0_117ck1100 FIND v(dout0_117) AT=555.025n

.meas tran vdout0_118ck1100 FIND v(dout0_118) AT=555.025n

.meas tran vdout0_119ck1100 FIND v(dout0_119) AT=555.025n

.meas tran vdout0_120ck1100 FIND v(dout0_120) AT=555.025n

.meas tran vdout0_121ck1100 FIND v(dout0_121) AT=555.025n

.meas tran vdout0_122ck1100 FIND v(dout0_122) AT=555.025n

.meas tran vdout0_123ck1100 FIND v(dout0_123) AT=555.025n

.meas tran vdout0_124ck1100 FIND v(dout0_124) AT=555.025n

.meas tran vdout0_125ck1100 FIND v(dout0_125) AT=555.025n

.meas tran vdout0_126ck1100 FIND v(dout0_126) AT=555.025n

.meas tran vdout0_127ck1100 FIND v(dout0_127) AT=555.025n

.meas tran vdout0_0ck1180 FIND v(dout0_0) AT=595.025n

.meas tran vdout0_1ck1180 FIND v(dout0_1) AT=595.025n

.meas tran vdout0_2ck1180 FIND v(dout0_2) AT=595.025n

.meas tran vdout0_3ck1180 FIND v(dout0_3) AT=595.025n

.meas tran vdout0_4ck1180 FIND v(dout0_4) AT=595.025n

.meas tran vdout0_5ck1180 FIND v(dout0_5) AT=595.025n

.meas tran vdout0_6ck1180 FIND v(dout0_6) AT=595.025n

.meas tran vdout0_7ck1180 FIND v(dout0_7) AT=595.025n

.meas tran vdout0_8ck1180 FIND v(dout0_8) AT=595.025n

.meas tran vdout0_9ck1180 FIND v(dout0_9) AT=595.025n

.meas tran vdout0_10ck1180 FIND v(dout0_10) AT=595.025n

.meas tran vdout0_11ck1180 FIND v(dout0_11) AT=595.025n

.meas tran vdout0_12ck1180 FIND v(dout0_12) AT=595.025n

.meas tran vdout0_13ck1180 FIND v(dout0_13) AT=595.025n

.meas tran vdout0_14ck1180 FIND v(dout0_14) AT=595.025n

.meas tran vdout0_15ck1180 FIND v(dout0_15) AT=595.025n

.meas tran vdout0_16ck1180 FIND v(dout0_16) AT=595.025n

.meas tran vdout0_17ck1180 FIND v(dout0_17) AT=595.025n

.meas tran vdout0_18ck1180 FIND v(dout0_18) AT=595.025n

.meas tran vdout0_19ck1180 FIND v(dout0_19) AT=595.025n

.meas tran vdout0_20ck1180 FIND v(dout0_20) AT=595.025n

.meas tran vdout0_21ck1180 FIND v(dout0_21) AT=595.025n

.meas tran vdout0_22ck1180 FIND v(dout0_22) AT=595.025n

.meas tran vdout0_23ck1180 FIND v(dout0_23) AT=595.025n

.meas tran vdout0_24ck1180 FIND v(dout0_24) AT=595.025n

.meas tran vdout0_25ck1180 FIND v(dout0_25) AT=595.025n

.meas tran vdout0_26ck1180 FIND v(dout0_26) AT=595.025n

.meas tran vdout0_27ck1180 FIND v(dout0_27) AT=595.025n

.meas tran vdout0_28ck1180 FIND v(dout0_28) AT=595.025n

.meas tran vdout0_29ck1180 FIND v(dout0_29) AT=595.025n

.meas tran vdout0_30ck1180 FIND v(dout0_30) AT=595.025n

.meas tran vdout0_31ck1180 FIND v(dout0_31) AT=595.025n

.meas tran vdout0_32ck1180 FIND v(dout0_32) AT=595.025n

.meas tran vdout0_33ck1180 FIND v(dout0_33) AT=595.025n

.meas tran vdout0_34ck1180 FIND v(dout0_34) AT=595.025n

.meas tran vdout0_35ck1180 FIND v(dout0_35) AT=595.025n

.meas tran vdout0_36ck1180 FIND v(dout0_36) AT=595.025n

.meas tran vdout0_37ck1180 FIND v(dout0_37) AT=595.025n

.meas tran vdout0_38ck1180 FIND v(dout0_38) AT=595.025n

.meas tran vdout0_39ck1180 FIND v(dout0_39) AT=595.025n

.meas tran vdout0_40ck1180 FIND v(dout0_40) AT=595.025n

.meas tran vdout0_41ck1180 FIND v(dout0_41) AT=595.025n

.meas tran vdout0_42ck1180 FIND v(dout0_42) AT=595.025n

.meas tran vdout0_43ck1180 FIND v(dout0_43) AT=595.025n

.meas tran vdout0_44ck1180 FIND v(dout0_44) AT=595.025n

.meas tran vdout0_45ck1180 FIND v(dout0_45) AT=595.025n

.meas tran vdout0_46ck1180 FIND v(dout0_46) AT=595.025n

.meas tran vdout0_47ck1180 FIND v(dout0_47) AT=595.025n

.meas tran vdout0_48ck1180 FIND v(dout0_48) AT=595.025n

.meas tran vdout0_49ck1180 FIND v(dout0_49) AT=595.025n

.meas tran vdout0_50ck1180 FIND v(dout0_50) AT=595.025n

.meas tran vdout0_51ck1180 FIND v(dout0_51) AT=595.025n

.meas tran vdout0_52ck1180 FIND v(dout0_52) AT=595.025n

.meas tran vdout0_53ck1180 FIND v(dout0_53) AT=595.025n

.meas tran vdout0_54ck1180 FIND v(dout0_54) AT=595.025n

.meas tran vdout0_55ck1180 FIND v(dout0_55) AT=595.025n

.meas tran vdout0_56ck1180 FIND v(dout0_56) AT=595.025n

.meas tran vdout0_57ck1180 FIND v(dout0_57) AT=595.025n

.meas tran vdout0_58ck1180 FIND v(dout0_58) AT=595.025n

.meas tran vdout0_59ck1180 FIND v(dout0_59) AT=595.025n

.meas tran vdout0_60ck1180 FIND v(dout0_60) AT=595.025n

.meas tran vdout0_61ck1180 FIND v(dout0_61) AT=595.025n

.meas tran vdout0_62ck1180 FIND v(dout0_62) AT=595.025n

.meas tran vdout0_63ck1180 FIND v(dout0_63) AT=595.025n

.meas tran vdout0_64ck1180 FIND v(dout0_64) AT=595.025n

.meas tran vdout0_65ck1180 FIND v(dout0_65) AT=595.025n

.meas tran vdout0_66ck1180 FIND v(dout0_66) AT=595.025n

.meas tran vdout0_67ck1180 FIND v(dout0_67) AT=595.025n

.meas tran vdout0_68ck1180 FIND v(dout0_68) AT=595.025n

.meas tran vdout0_69ck1180 FIND v(dout0_69) AT=595.025n

.meas tran vdout0_70ck1180 FIND v(dout0_70) AT=595.025n

.meas tran vdout0_71ck1180 FIND v(dout0_71) AT=595.025n

.meas tran vdout0_72ck1180 FIND v(dout0_72) AT=595.025n

.meas tran vdout0_73ck1180 FIND v(dout0_73) AT=595.025n

.meas tran vdout0_74ck1180 FIND v(dout0_74) AT=595.025n

.meas tran vdout0_75ck1180 FIND v(dout0_75) AT=595.025n

.meas tran vdout0_76ck1180 FIND v(dout0_76) AT=595.025n

.meas tran vdout0_77ck1180 FIND v(dout0_77) AT=595.025n

.meas tran vdout0_78ck1180 FIND v(dout0_78) AT=595.025n

.meas tran vdout0_79ck1180 FIND v(dout0_79) AT=595.025n

.meas tran vdout0_80ck1180 FIND v(dout0_80) AT=595.025n

.meas tran vdout0_81ck1180 FIND v(dout0_81) AT=595.025n

.meas tran vdout0_82ck1180 FIND v(dout0_82) AT=595.025n

.meas tran vdout0_83ck1180 FIND v(dout0_83) AT=595.025n

.meas tran vdout0_84ck1180 FIND v(dout0_84) AT=595.025n

.meas tran vdout0_85ck1180 FIND v(dout0_85) AT=595.025n

.meas tran vdout0_86ck1180 FIND v(dout0_86) AT=595.025n

.meas tran vdout0_87ck1180 FIND v(dout0_87) AT=595.025n

.meas tran vdout0_88ck1180 FIND v(dout0_88) AT=595.025n

.meas tran vdout0_89ck1180 FIND v(dout0_89) AT=595.025n

.meas tran vdout0_90ck1180 FIND v(dout0_90) AT=595.025n

.meas tran vdout0_91ck1180 FIND v(dout0_91) AT=595.025n

.meas tran vdout0_92ck1180 FIND v(dout0_92) AT=595.025n

.meas tran vdout0_93ck1180 FIND v(dout0_93) AT=595.025n

.meas tran vdout0_94ck1180 FIND v(dout0_94) AT=595.025n

.meas tran vdout0_95ck1180 FIND v(dout0_95) AT=595.025n

.meas tran vdout0_96ck1180 FIND v(dout0_96) AT=595.025n

.meas tran vdout0_97ck1180 FIND v(dout0_97) AT=595.025n

.meas tran vdout0_98ck1180 FIND v(dout0_98) AT=595.025n

.meas tran vdout0_99ck1180 FIND v(dout0_99) AT=595.025n

.meas tran vdout0_100ck1180 FIND v(dout0_100) AT=595.025n

.meas tran vdout0_101ck1180 FIND v(dout0_101) AT=595.025n

.meas tran vdout0_102ck1180 FIND v(dout0_102) AT=595.025n

.meas tran vdout0_103ck1180 FIND v(dout0_103) AT=595.025n

.meas tran vdout0_104ck1180 FIND v(dout0_104) AT=595.025n

.meas tran vdout0_105ck1180 FIND v(dout0_105) AT=595.025n

.meas tran vdout0_106ck1180 FIND v(dout0_106) AT=595.025n

.meas tran vdout0_107ck1180 FIND v(dout0_107) AT=595.025n

.meas tran vdout0_108ck1180 FIND v(dout0_108) AT=595.025n

.meas tran vdout0_109ck1180 FIND v(dout0_109) AT=595.025n

.meas tran vdout0_110ck1180 FIND v(dout0_110) AT=595.025n

.meas tran vdout0_111ck1180 FIND v(dout0_111) AT=595.025n

.meas tran vdout0_112ck1180 FIND v(dout0_112) AT=595.025n

.meas tran vdout0_113ck1180 FIND v(dout0_113) AT=595.025n

.meas tran vdout0_114ck1180 FIND v(dout0_114) AT=595.025n

.meas tran vdout0_115ck1180 FIND v(dout0_115) AT=595.025n

.meas tran vdout0_116ck1180 FIND v(dout0_116) AT=595.025n

.meas tran vdout0_117ck1180 FIND v(dout0_117) AT=595.025n

.meas tran vdout0_118ck1180 FIND v(dout0_118) AT=595.025n

.meas tran vdout0_119ck1180 FIND v(dout0_119) AT=595.025n

.meas tran vdout0_120ck1180 FIND v(dout0_120) AT=595.025n

.meas tran vdout0_121ck1180 FIND v(dout0_121) AT=595.025n

.meas tran vdout0_122ck1180 FIND v(dout0_122) AT=595.025n

.meas tran vdout0_123ck1180 FIND v(dout0_123) AT=595.025n

.meas tran vdout0_124ck1180 FIND v(dout0_124) AT=595.025n

.meas tran vdout0_125ck1180 FIND v(dout0_125) AT=595.025n

.meas tran vdout0_126ck1180 FIND v(dout0_126) AT=595.025n

.meas tran vdout0_127ck1180 FIND v(dout0_127) AT=595.025n

.meas tran vdout0_0ck1200 FIND v(dout0_0) AT=605.025n

.meas tran vdout0_1ck1200 FIND v(dout0_1) AT=605.025n

.meas tran vdout0_2ck1200 FIND v(dout0_2) AT=605.025n

.meas tran vdout0_3ck1200 FIND v(dout0_3) AT=605.025n

.meas tran vdout0_4ck1200 FIND v(dout0_4) AT=605.025n

.meas tran vdout0_5ck1200 FIND v(dout0_5) AT=605.025n

.meas tran vdout0_6ck1200 FIND v(dout0_6) AT=605.025n

.meas tran vdout0_7ck1200 FIND v(dout0_7) AT=605.025n

.meas tran vdout0_8ck1200 FIND v(dout0_8) AT=605.025n

.meas tran vdout0_9ck1200 FIND v(dout0_9) AT=605.025n

.meas tran vdout0_10ck1200 FIND v(dout0_10) AT=605.025n

.meas tran vdout0_11ck1200 FIND v(dout0_11) AT=605.025n

.meas tran vdout0_12ck1200 FIND v(dout0_12) AT=605.025n

.meas tran vdout0_13ck1200 FIND v(dout0_13) AT=605.025n

.meas tran vdout0_14ck1200 FIND v(dout0_14) AT=605.025n

.meas tran vdout0_15ck1200 FIND v(dout0_15) AT=605.025n

.meas tran vdout0_16ck1200 FIND v(dout0_16) AT=605.025n

.meas tran vdout0_17ck1200 FIND v(dout0_17) AT=605.025n

.meas tran vdout0_18ck1200 FIND v(dout0_18) AT=605.025n

.meas tran vdout0_19ck1200 FIND v(dout0_19) AT=605.025n

.meas tran vdout0_20ck1200 FIND v(dout0_20) AT=605.025n

.meas tran vdout0_21ck1200 FIND v(dout0_21) AT=605.025n

.meas tran vdout0_22ck1200 FIND v(dout0_22) AT=605.025n

.meas tran vdout0_23ck1200 FIND v(dout0_23) AT=605.025n

.meas tran vdout0_24ck1200 FIND v(dout0_24) AT=605.025n

.meas tran vdout0_25ck1200 FIND v(dout0_25) AT=605.025n

.meas tran vdout0_26ck1200 FIND v(dout0_26) AT=605.025n

.meas tran vdout0_27ck1200 FIND v(dout0_27) AT=605.025n

.meas tran vdout0_28ck1200 FIND v(dout0_28) AT=605.025n

.meas tran vdout0_29ck1200 FIND v(dout0_29) AT=605.025n

.meas tran vdout0_30ck1200 FIND v(dout0_30) AT=605.025n

.meas tran vdout0_31ck1200 FIND v(dout0_31) AT=605.025n

.meas tran vdout0_32ck1200 FIND v(dout0_32) AT=605.025n

.meas tran vdout0_33ck1200 FIND v(dout0_33) AT=605.025n

.meas tran vdout0_34ck1200 FIND v(dout0_34) AT=605.025n

.meas tran vdout0_35ck1200 FIND v(dout0_35) AT=605.025n

.meas tran vdout0_36ck1200 FIND v(dout0_36) AT=605.025n

.meas tran vdout0_37ck1200 FIND v(dout0_37) AT=605.025n

.meas tran vdout0_38ck1200 FIND v(dout0_38) AT=605.025n

.meas tran vdout0_39ck1200 FIND v(dout0_39) AT=605.025n

.meas tran vdout0_40ck1200 FIND v(dout0_40) AT=605.025n

.meas tran vdout0_41ck1200 FIND v(dout0_41) AT=605.025n

.meas tran vdout0_42ck1200 FIND v(dout0_42) AT=605.025n

.meas tran vdout0_43ck1200 FIND v(dout0_43) AT=605.025n

.meas tran vdout0_44ck1200 FIND v(dout0_44) AT=605.025n

.meas tran vdout0_45ck1200 FIND v(dout0_45) AT=605.025n

.meas tran vdout0_46ck1200 FIND v(dout0_46) AT=605.025n

.meas tran vdout0_47ck1200 FIND v(dout0_47) AT=605.025n

.meas tran vdout0_48ck1200 FIND v(dout0_48) AT=605.025n

.meas tran vdout0_49ck1200 FIND v(dout0_49) AT=605.025n

.meas tran vdout0_50ck1200 FIND v(dout0_50) AT=605.025n

.meas tran vdout0_51ck1200 FIND v(dout0_51) AT=605.025n

.meas tran vdout0_52ck1200 FIND v(dout0_52) AT=605.025n

.meas tran vdout0_53ck1200 FIND v(dout0_53) AT=605.025n

.meas tran vdout0_54ck1200 FIND v(dout0_54) AT=605.025n

.meas tran vdout0_55ck1200 FIND v(dout0_55) AT=605.025n

.meas tran vdout0_56ck1200 FIND v(dout0_56) AT=605.025n

.meas tran vdout0_57ck1200 FIND v(dout0_57) AT=605.025n

.meas tran vdout0_58ck1200 FIND v(dout0_58) AT=605.025n

.meas tran vdout0_59ck1200 FIND v(dout0_59) AT=605.025n

.meas tran vdout0_60ck1200 FIND v(dout0_60) AT=605.025n

.meas tran vdout0_61ck1200 FIND v(dout0_61) AT=605.025n

.meas tran vdout0_62ck1200 FIND v(dout0_62) AT=605.025n

.meas tran vdout0_63ck1200 FIND v(dout0_63) AT=605.025n

.meas tran vdout0_64ck1200 FIND v(dout0_64) AT=605.025n

.meas tran vdout0_65ck1200 FIND v(dout0_65) AT=605.025n

.meas tran vdout0_66ck1200 FIND v(dout0_66) AT=605.025n

.meas tran vdout0_67ck1200 FIND v(dout0_67) AT=605.025n

.meas tran vdout0_68ck1200 FIND v(dout0_68) AT=605.025n

.meas tran vdout0_69ck1200 FIND v(dout0_69) AT=605.025n

.meas tran vdout0_70ck1200 FIND v(dout0_70) AT=605.025n

.meas tran vdout0_71ck1200 FIND v(dout0_71) AT=605.025n

.meas tran vdout0_72ck1200 FIND v(dout0_72) AT=605.025n

.meas tran vdout0_73ck1200 FIND v(dout0_73) AT=605.025n

.meas tran vdout0_74ck1200 FIND v(dout0_74) AT=605.025n

.meas tran vdout0_75ck1200 FIND v(dout0_75) AT=605.025n

.meas tran vdout0_76ck1200 FIND v(dout0_76) AT=605.025n

.meas tran vdout0_77ck1200 FIND v(dout0_77) AT=605.025n

.meas tran vdout0_78ck1200 FIND v(dout0_78) AT=605.025n

.meas tran vdout0_79ck1200 FIND v(dout0_79) AT=605.025n

.meas tran vdout0_80ck1200 FIND v(dout0_80) AT=605.025n

.meas tran vdout0_81ck1200 FIND v(dout0_81) AT=605.025n

.meas tran vdout0_82ck1200 FIND v(dout0_82) AT=605.025n

.meas tran vdout0_83ck1200 FIND v(dout0_83) AT=605.025n

.meas tran vdout0_84ck1200 FIND v(dout0_84) AT=605.025n

.meas tran vdout0_85ck1200 FIND v(dout0_85) AT=605.025n

.meas tran vdout0_86ck1200 FIND v(dout0_86) AT=605.025n

.meas tran vdout0_87ck1200 FIND v(dout0_87) AT=605.025n

.meas tran vdout0_88ck1200 FIND v(dout0_88) AT=605.025n

.meas tran vdout0_89ck1200 FIND v(dout0_89) AT=605.025n

.meas tran vdout0_90ck1200 FIND v(dout0_90) AT=605.025n

.meas tran vdout0_91ck1200 FIND v(dout0_91) AT=605.025n

.meas tran vdout0_92ck1200 FIND v(dout0_92) AT=605.025n

.meas tran vdout0_93ck1200 FIND v(dout0_93) AT=605.025n

.meas tran vdout0_94ck1200 FIND v(dout0_94) AT=605.025n

.meas tran vdout0_95ck1200 FIND v(dout0_95) AT=605.025n

.meas tran vdout0_96ck1200 FIND v(dout0_96) AT=605.025n

.meas tran vdout0_97ck1200 FIND v(dout0_97) AT=605.025n

.meas tran vdout0_98ck1200 FIND v(dout0_98) AT=605.025n

.meas tran vdout0_99ck1200 FIND v(dout0_99) AT=605.025n

.meas tran vdout0_100ck1200 FIND v(dout0_100) AT=605.025n

.meas tran vdout0_101ck1200 FIND v(dout0_101) AT=605.025n

.meas tran vdout0_102ck1200 FIND v(dout0_102) AT=605.025n

.meas tran vdout0_103ck1200 FIND v(dout0_103) AT=605.025n

.meas tran vdout0_104ck1200 FIND v(dout0_104) AT=605.025n

.meas tran vdout0_105ck1200 FIND v(dout0_105) AT=605.025n

.meas tran vdout0_106ck1200 FIND v(dout0_106) AT=605.025n

.meas tran vdout0_107ck1200 FIND v(dout0_107) AT=605.025n

.meas tran vdout0_108ck1200 FIND v(dout0_108) AT=605.025n

.meas tran vdout0_109ck1200 FIND v(dout0_109) AT=605.025n

.meas tran vdout0_110ck1200 FIND v(dout0_110) AT=605.025n

.meas tran vdout0_111ck1200 FIND v(dout0_111) AT=605.025n

.meas tran vdout0_112ck1200 FIND v(dout0_112) AT=605.025n

.meas tran vdout0_113ck1200 FIND v(dout0_113) AT=605.025n

.meas tran vdout0_114ck1200 FIND v(dout0_114) AT=605.025n

.meas tran vdout0_115ck1200 FIND v(dout0_115) AT=605.025n

.meas tran vdout0_116ck1200 FIND v(dout0_116) AT=605.025n

.meas tran vdout0_117ck1200 FIND v(dout0_117) AT=605.025n

.meas tran vdout0_118ck1200 FIND v(dout0_118) AT=605.025n

.meas tran vdout0_119ck1200 FIND v(dout0_119) AT=605.025n

.meas tran vdout0_120ck1200 FIND v(dout0_120) AT=605.025n

.meas tran vdout0_121ck1200 FIND v(dout0_121) AT=605.025n

.meas tran vdout0_122ck1200 FIND v(dout0_122) AT=605.025n

.meas tran vdout0_123ck1200 FIND v(dout0_123) AT=605.025n

.meas tran vdout0_124ck1200 FIND v(dout0_124) AT=605.025n

.meas tran vdout0_125ck1200 FIND v(dout0_125) AT=605.025n

.meas tran vdout0_126ck1200 FIND v(dout0_126) AT=605.025n

.meas tran vdout0_127ck1200 FIND v(dout0_127) AT=605.025n

.meas tran vdout0_0ck1210 FIND v(dout0_0) AT=610.025n

.meas tran vdout0_1ck1210 FIND v(dout0_1) AT=610.025n

.meas tran vdout0_2ck1210 FIND v(dout0_2) AT=610.025n

.meas tran vdout0_3ck1210 FIND v(dout0_3) AT=610.025n

.meas tran vdout0_4ck1210 FIND v(dout0_4) AT=610.025n

.meas tran vdout0_5ck1210 FIND v(dout0_5) AT=610.025n

.meas tran vdout0_6ck1210 FIND v(dout0_6) AT=610.025n

.meas tran vdout0_7ck1210 FIND v(dout0_7) AT=610.025n

.meas tran vdout0_8ck1210 FIND v(dout0_8) AT=610.025n

.meas tran vdout0_9ck1210 FIND v(dout0_9) AT=610.025n

.meas tran vdout0_10ck1210 FIND v(dout0_10) AT=610.025n

.meas tran vdout0_11ck1210 FIND v(dout0_11) AT=610.025n

.meas tran vdout0_12ck1210 FIND v(dout0_12) AT=610.025n

.meas tran vdout0_13ck1210 FIND v(dout0_13) AT=610.025n

.meas tran vdout0_14ck1210 FIND v(dout0_14) AT=610.025n

.meas tran vdout0_15ck1210 FIND v(dout0_15) AT=610.025n

.meas tran vdout0_16ck1210 FIND v(dout0_16) AT=610.025n

.meas tran vdout0_17ck1210 FIND v(dout0_17) AT=610.025n

.meas tran vdout0_18ck1210 FIND v(dout0_18) AT=610.025n

.meas tran vdout0_19ck1210 FIND v(dout0_19) AT=610.025n

.meas tran vdout0_20ck1210 FIND v(dout0_20) AT=610.025n

.meas tran vdout0_21ck1210 FIND v(dout0_21) AT=610.025n

.meas tran vdout0_22ck1210 FIND v(dout0_22) AT=610.025n

.meas tran vdout0_23ck1210 FIND v(dout0_23) AT=610.025n

.meas tran vdout0_24ck1210 FIND v(dout0_24) AT=610.025n

.meas tran vdout0_25ck1210 FIND v(dout0_25) AT=610.025n

.meas tran vdout0_26ck1210 FIND v(dout0_26) AT=610.025n

.meas tran vdout0_27ck1210 FIND v(dout0_27) AT=610.025n

.meas tran vdout0_28ck1210 FIND v(dout0_28) AT=610.025n

.meas tran vdout0_29ck1210 FIND v(dout0_29) AT=610.025n

.meas tran vdout0_30ck1210 FIND v(dout0_30) AT=610.025n

.meas tran vdout0_31ck1210 FIND v(dout0_31) AT=610.025n

.meas tran vdout0_32ck1210 FIND v(dout0_32) AT=610.025n

.meas tran vdout0_33ck1210 FIND v(dout0_33) AT=610.025n

.meas tran vdout0_34ck1210 FIND v(dout0_34) AT=610.025n

.meas tran vdout0_35ck1210 FIND v(dout0_35) AT=610.025n

.meas tran vdout0_36ck1210 FIND v(dout0_36) AT=610.025n

.meas tran vdout0_37ck1210 FIND v(dout0_37) AT=610.025n

.meas tran vdout0_38ck1210 FIND v(dout0_38) AT=610.025n

.meas tran vdout0_39ck1210 FIND v(dout0_39) AT=610.025n

.meas tran vdout0_40ck1210 FIND v(dout0_40) AT=610.025n

.meas tran vdout0_41ck1210 FIND v(dout0_41) AT=610.025n

.meas tran vdout0_42ck1210 FIND v(dout0_42) AT=610.025n

.meas tran vdout0_43ck1210 FIND v(dout0_43) AT=610.025n

.meas tran vdout0_44ck1210 FIND v(dout0_44) AT=610.025n

.meas tran vdout0_45ck1210 FIND v(dout0_45) AT=610.025n

.meas tran vdout0_46ck1210 FIND v(dout0_46) AT=610.025n

.meas tran vdout0_47ck1210 FIND v(dout0_47) AT=610.025n

.meas tran vdout0_48ck1210 FIND v(dout0_48) AT=610.025n

.meas tran vdout0_49ck1210 FIND v(dout0_49) AT=610.025n

.meas tran vdout0_50ck1210 FIND v(dout0_50) AT=610.025n

.meas tran vdout0_51ck1210 FIND v(dout0_51) AT=610.025n

.meas tran vdout0_52ck1210 FIND v(dout0_52) AT=610.025n

.meas tran vdout0_53ck1210 FIND v(dout0_53) AT=610.025n

.meas tran vdout0_54ck1210 FIND v(dout0_54) AT=610.025n

.meas tran vdout0_55ck1210 FIND v(dout0_55) AT=610.025n

.meas tran vdout0_56ck1210 FIND v(dout0_56) AT=610.025n

.meas tran vdout0_57ck1210 FIND v(dout0_57) AT=610.025n

.meas tran vdout0_58ck1210 FIND v(dout0_58) AT=610.025n

.meas tran vdout0_59ck1210 FIND v(dout0_59) AT=610.025n

.meas tran vdout0_60ck1210 FIND v(dout0_60) AT=610.025n

.meas tran vdout0_61ck1210 FIND v(dout0_61) AT=610.025n

.meas tran vdout0_62ck1210 FIND v(dout0_62) AT=610.025n

.meas tran vdout0_63ck1210 FIND v(dout0_63) AT=610.025n

.meas tran vdout0_64ck1210 FIND v(dout0_64) AT=610.025n

.meas tran vdout0_65ck1210 FIND v(dout0_65) AT=610.025n

.meas tran vdout0_66ck1210 FIND v(dout0_66) AT=610.025n

.meas tran vdout0_67ck1210 FIND v(dout0_67) AT=610.025n

.meas tran vdout0_68ck1210 FIND v(dout0_68) AT=610.025n

.meas tran vdout0_69ck1210 FIND v(dout0_69) AT=610.025n

.meas tran vdout0_70ck1210 FIND v(dout0_70) AT=610.025n

.meas tran vdout0_71ck1210 FIND v(dout0_71) AT=610.025n

.meas tran vdout0_72ck1210 FIND v(dout0_72) AT=610.025n

.meas tran vdout0_73ck1210 FIND v(dout0_73) AT=610.025n

.meas tran vdout0_74ck1210 FIND v(dout0_74) AT=610.025n

.meas tran vdout0_75ck1210 FIND v(dout0_75) AT=610.025n

.meas tran vdout0_76ck1210 FIND v(dout0_76) AT=610.025n

.meas tran vdout0_77ck1210 FIND v(dout0_77) AT=610.025n

.meas tran vdout0_78ck1210 FIND v(dout0_78) AT=610.025n

.meas tran vdout0_79ck1210 FIND v(dout0_79) AT=610.025n

.meas tran vdout0_80ck1210 FIND v(dout0_80) AT=610.025n

.meas tran vdout0_81ck1210 FIND v(dout0_81) AT=610.025n

.meas tran vdout0_82ck1210 FIND v(dout0_82) AT=610.025n

.meas tran vdout0_83ck1210 FIND v(dout0_83) AT=610.025n

.meas tran vdout0_84ck1210 FIND v(dout0_84) AT=610.025n

.meas tran vdout0_85ck1210 FIND v(dout0_85) AT=610.025n

.meas tran vdout0_86ck1210 FIND v(dout0_86) AT=610.025n

.meas tran vdout0_87ck1210 FIND v(dout0_87) AT=610.025n

.meas tran vdout0_88ck1210 FIND v(dout0_88) AT=610.025n

.meas tran vdout0_89ck1210 FIND v(dout0_89) AT=610.025n

.meas tran vdout0_90ck1210 FIND v(dout0_90) AT=610.025n

.meas tran vdout0_91ck1210 FIND v(dout0_91) AT=610.025n

.meas tran vdout0_92ck1210 FIND v(dout0_92) AT=610.025n

.meas tran vdout0_93ck1210 FIND v(dout0_93) AT=610.025n

.meas tran vdout0_94ck1210 FIND v(dout0_94) AT=610.025n

.meas tran vdout0_95ck1210 FIND v(dout0_95) AT=610.025n

.meas tran vdout0_96ck1210 FIND v(dout0_96) AT=610.025n

.meas tran vdout0_97ck1210 FIND v(dout0_97) AT=610.025n

.meas tran vdout0_98ck1210 FIND v(dout0_98) AT=610.025n

.meas tran vdout0_99ck1210 FIND v(dout0_99) AT=610.025n

.meas tran vdout0_100ck1210 FIND v(dout0_100) AT=610.025n

.meas tran vdout0_101ck1210 FIND v(dout0_101) AT=610.025n

.meas tran vdout0_102ck1210 FIND v(dout0_102) AT=610.025n

.meas tran vdout0_103ck1210 FIND v(dout0_103) AT=610.025n

.meas tran vdout0_104ck1210 FIND v(dout0_104) AT=610.025n

.meas tran vdout0_105ck1210 FIND v(dout0_105) AT=610.025n

.meas tran vdout0_106ck1210 FIND v(dout0_106) AT=610.025n

.meas tran vdout0_107ck1210 FIND v(dout0_107) AT=610.025n

.meas tran vdout0_108ck1210 FIND v(dout0_108) AT=610.025n

.meas tran vdout0_109ck1210 FIND v(dout0_109) AT=610.025n

.meas tran vdout0_110ck1210 FIND v(dout0_110) AT=610.025n

.meas tran vdout0_111ck1210 FIND v(dout0_111) AT=610.025n

.meas tran vdout0_112ck1210 FIND v(dout0_112) AT=610.025n

.meas tran vdout0_113ck1210 FIND v(dout0_113) AT=610.025n

.meas tran vdout0_114ck1210 FIND v(dout0_114) AT=610.025n

.meas tran vdout0_115ck1210 FIND v(dout0_115) AT=610.025n

.meas tran vdout0_116ck1210 FIND v(dout0_116) AT=610.025n

.meas tran vdout0_117ck1210 FIND v(dout0_117) AT=610.025n

.meas tran vdout0_118ck1210 FIND v(dout0_118) AT=610.025n

.meas tran vdout0_119ck1210 FIND v(dout0_119) AT=610.025n

.meas tran vdout0_120ck1210 FIND v(dout0_120) AT=610.025n

.meas tran vdout0_121ck1210 FIND v(dout0_121) AT=610.025n

.meas tran vdout0_122ck1210 FIND v(dout0_122) AT=610.025n

.meas tran vdout0_123ck1210 FIND v(dout0_123) AT=610.025n

.meas tran vdout0_124ck1210 FIND v(dout0_124) AT=610.025n

.meas tran vdout0_125ck1210 FIND v(dout0_125) AT=610.025n

.meas tran vdout0_126ck1210 FIND v(dout0_126) AT=610.025n

.meas tran vdout0_127ck1210 FIND v(dout0_127) AT=610.025n

.meas tran vdout0_0ck1250 FIND v(dout0_0) AT=630.025n

.meas tran vdout0_1ck1250 FIND v(dout0_1) AT=630.025n

.meas tran vdout0_2ck1250 FIND v(dout0_2) AT=630.025n

.meas tran vdout0_3ck1250 FIND v(dout0_3) AT=630.025n

.meas tran vdout0_4ck1250 FIND v(dout0_4) AT=630.025n

.meas tran vdout0_5ck1250 FIND v(dout0_5) AT=630.025n

.meas tran vdout0_6ck1250 FIND v(dout0_6) AT=630.025n

.meas tran vdout0_7ck1250 FIND v(dout0_7) AT=630.025n

.meas tran vdout0_8ck1250 FIND v(dout0_8) AT=630.025n

.meas tran vdout0_9ck1250 FIND v(dout0_9) AT=630.025n

.meas tran vdout0_10ck1250 FIND v(dout0_10) AT=630.025n

.meas tran vdout0_11ck1250 FIND v(dout0_11) AT=630.025n

.meas tran vdout0_12ck1250 FIND v(dout0_12) AT=630.025n

.meas tran vdout0_13ck1250 FIND v(dout0_13) AT=630.025n

.meas tran vdout0_14ck1250 FIND v(dout0_14) AT=630.025n

.meas tran vdout0_15ck1250 FIND v(dout0_15) AT=630.025n

.meas tran vdout0_16ck1250 FIND v(dout0_16) AT=630.025n

.meas tran vdout0_17ck1250 FIND v(dout0_17) AT=630.025n

.meas tran vdout0_18ck1250 FIND v(dout0_18) AT=630.025n

.meas tran vdout0_19ck1250 FIND v(dout0_19) AT=630.025n

.meas tran vdout0_20ck1250 FIND v(dout0_20) AT=630.025n

.meas tran vdout0_21ck1250 FIND v(dout0_21) AT=630.025n

.meas tran vdout0_22ck1250 FIND v(dout0_22) AT=630.025n

.meas tran vdout0_23ck1250 FIND v(dout0_23) AT=630.025n

.meas tran vdout0_24ck1250 FIND v(dout0_24) AT=630.025n

.meas tran vdout0_25ck1250 FIND v(dout0_25) AT=630.025n

.meas tran vdout0_26ck1250 FIND v(dout0_26) AT=630.025n

.meas tran vdout0_27ck1250 FIND v(dout0_27) AT=630.025n

.meas tran vdout0_28ck1250 FIND v(dout0_28) AT=630.025n

.meas tran vdout0_29ck1250 FIND v(dout0_29) AT=630.025n

.meas tran vdout0_30ck1250 FIND v(dout0_30) AT=630.025n

.meas tran vdout0_31ck1250 FIND v(dout0_31) AT=630.025n

.meas tran vdout0_32ck1250 FIND v(dout0_32) AT=630.025n

.meas tran vdout0_33ck1250 FIND v(dout0_33) AT=630.025n

.meas tran vdout0_34ck1250 FIND v(dout0_34) AT=630.025n

.meas tran vdout0_35ck1250 FIND v(dout0_35) AT=630.025n

.meas tran vdout0_36ck1250 FIND v(dout0_36) AT=630.025n

.meas tran vdout0_37ck1250 FIND v(dout0_37) AT=630.025n

.meas tran vdout0_38ck1250 FIND v(dout0_38) AT=630.025n

.meas tran vdout0_39ck1250 FIND v(dout0_39) AT=630.025n

.meas tran vdout0_40ck1250 FIND v(dout0_40) AT=630.025n

.meas tran vdout0_41ck1250 FIND v(dout0_41) AT=630.025n

.meas tran vdout0_42ck1250 FIND v(dout0_42) AT=630.025n

.meas tran vdout0_43ck1250 FIND v(dout0_43) AT=630.025n

.meas tran vdout0_44ck1250 FIND v(dout0_44) AT=630.025n

.meas tran vdout0_45ck1250 FIND v(dout0_45) AT=630.025n

.meas tran vdout0_46ck1250 FIND v(dout0_46) AT=630.025n

.meas tran vdout0_47ck1250 FIND v(dout0_47) AT=630.025n

.meas tran vdout0_48ck1250 FIND v(dout0_48) AT=630.025n

.meas tran vdout0_49ck1250 FIND v(dout0_49) AT=630.025n

.meas tran vdout0_50ck1250 FIND v(dout0_50) AT=630.025n

.meas tran vdout0_51ck1250 FIND v(dout0_51) AT=630.025n

.meas tran vdout0_52ck1250 FIND v(dout0_52) AT=630.025n

.meas tran vdout0_53ck1250 FIND v(dout0_53) AT=630.025n

.meas tran vdout0_54ck1250 FIND v(dout0_54) AT=630.025n

.meas tran vdout0_55ck1250 FIND v(dout0_55) AT=630.025n

.meas tran vdout0_56ck1250 FIND v(dout0_56) AT=630.025n

.meas tran vdout0_57ck1250 FIND v(dout0_57) AT=630.025n

.meas tran vdout0_58ck1250 FIND v(dout0_58) AT=630.025n

.meas tran vdout0_59ck1250 FIND v(dout0_59) AT=630.025n

.meas tran vdout0_60ck1250 FIND v(dout0_60) AT=630.025n

.meas tran vdout0_61ck1250 FIND v(dout0_61) AT=630.025n

.meas tran vdout0_62ck1250 FIND v(dout0_62) AT=630.025n

.meas tran vdout0_63ck1250 FIND v(dout0_63) AT=630.025n

.meas tran vdout0_64ck1250 FIND v(dout0_64) AT=630.025n

.meas tran vdout0_65ck1250 FIND v(dout0_65) AT=630.025n

.meas tran vdout0_66ck1250 FIND v(dout0_66) AT=630.025n

.meas tran vdout0_67ck1250 FIND v(dout0_67) AT=630.025n

.meas tran vdout0_68ck1250 FIND v(dout0_68) AT=630.025n

.meas tran vdout0_69ck1250 FIND v(dout0_69) AT=630.025n

.meas tran vdout0_70ck1250 FIND v(dout0_70) AT=630.025n

.meas tran vdout0_71ck1250 FIND v(dout0_71) AT=630.025n

.meas tran vdout0_72ck1250 FIND v(dout0_72) AT=630.025n

.meas tran vdout0_73ck1250 FIND v(dout0_73) AT=630.025n

.meas tran vdout0_74ck1250 FIND v(dout0_74) AT=630.025n

.meas tran vdout0_75ck1250 FIND v(dout0_75) AT=630.025n

.meas tran vdout0_76ck1250 FIND v(dout0_76) AT=630.025n

.meas tran vdout0_77ck1250 FIND v(dout0_77) AT=630.025n

.meas tran vdout0_78ck1250 FIND v(dout0_78) AT=630.025n

.meas tran vdout0_79ck1250 FIND v(dout0_79) AT=630.025n

.meas tran vdout0_80ck1250 FIND v(dout0_80) AT=630.025n

.meas tran vdout0_81ck1250 FIND v(dout0_81) AT=630.025n

.meas tran vdout0_82ck1250 FIND v(dout0_82) AT=630.025n

.meas tran vdout0_83ck1250 FIND v(dout0_83) AT=630.025n

.meas tran vdout0_84ck1250 FIND v(dout0_84) AT=630.025n

.meas tran vdout0_85ck1250 FIND v(dout0_85) AT=630.025n

.meas tran vdout0_86ck1250 FIND v(dout0_86) AT=630.025n

.meas tran vdout0_87ck1250 FIND v(dout0_87) AT=630.025n

.meas tran vdout0_88ck1250 FIND v(dout0_88) AT=630.025n

.meas tran vdout0_89ck1250 FIND v(dout0_89) AT=630.025n

.meas tran vdout0_90ck1250 FIND v(dout0_90) AT=630.025n

.meas tran vdout0_91ck1250 FIND v(dout0_91) AT=630.025n

.meas tran vdout0_92ck1250 FIND v(dout0_92) AT=630.025n

.meas tran vdout0_93ck1250 FIND v(dout0_93) AT=630.025n

.meas tran vdout0_94ck1250 FIND v(dout0_94) AT=630.025n

.meas tran vdout0_95ck1250 FIND v(dout0_95) AT=630.025n

.meas tran vdout0_96ck1250 FIND v(dout0_96) AT=630.025n

.meas tran vdout0_97ck1250 FIND v(dout0_97) AT=630.025n

.meas tran vdout0_98ck1250 FIND v(dout0_98) AT=630.025n

.meas tran vdout0_99ck1250 FIND v(dout0_99) AT=630.025n

.meas tran vdout0_100ck1250 FIND v(dout0_100) AT=630.025n

.meas tran vdout0_101ck1250 FIND v(dout0_101) AT=630.025n

.meas tran vdout0_102ck1250 FIND v(dout0_102) AT=630.025n

.meas tran vdout0_103ck1250 FIND v(dout0_103) AT=630.025n

.meas tran vdout0_104ck1250 FIND v(dout0_104) AT=630.025n

.meas tran vdout0_105ck1250 FIND v(dout0_105) AT=630.025n

.meas tran vdout0_106ck1250 FIND v(dout0_106) AT=630.025n

.meas tran vdout0_107ck1250 FIND v(dout0_107) AT=630.025n

.meas tran vdout0_108ck1250 FIND v(dout0_108) AT=630.025n

.meas tran vdout0_109ck1250 FIND v(dout0_109) AT=630.025n

.meas tran vdout0_110ck1250 FIND v(dout0_110) AT=630.025n

.meas tran vdout0_111ck1250 FIND v(dout0_111) AT=630.025n

.meas tran vdout0_112ck1250 FIND v(dout0_112) AT=630.025n

.meas tran vdout0_113ck1250 FIND v(dout0_113) AT=630.025n

.meas tran vdout0_114ck1250 FIND v(dout0_114) AT=630.025n

.meas tran vdout0_115ck1250 FIND v(dout0_115) AT=630.025n

.meas tran vdout0_116ck1250 FIND v(dout0_116) AT=630.025n

.meas tran vdout0_117ck1250 FIND v(dout0_117) AT=630.025n

.meas tran vdout0_118ck1250 FIND v(dout0_118) AT=630.025n

.meas tran vdout0_119ck1250 FIND v(dout0_119) AT=630.025n

.meas tran vdout0_120ck1250 FIND v(dout0_120) AT=630.025n

.meas tran vdout0_121ck1250 FIND v(dout0_121) AT=630.025n

.meas tran vdout0_122ck1250 FIND v(dout0_122) AT=630.025n

.meas tran vdout0_123ck1250 FIND v(dout0_123) AT=630.025n

.meas tran vdout0_124ck1250 FIND v(dout0_124) AT=630.025n

.meas tran vdout0_125ck1250 FIND v(dout0_125) AT=630.025n

.meas tran vdout0_126ck1250 FIND v(dout0_126) AT=630.025n

.meas tran vdout0_127ck1250 FIND v(dout0_127) AT=630.025n

.meas tran vdout0_0ck1320 FIND v(dout0_0) AT=665.025n

.meas tran vdout0_1ck1320 FIND v(dout0_1) AT=665.025n

.meas tran vdout0_2ck1320 FIND v(dout0_2) AT=665.025n

.meas tran vdout0_3ck1320 FIND v(dout0_3) AT=665.025n

.meas tran vdout0_4ck1320 FIND v(dout0_4) AT=665.025n

.meas tran vdout0_5ck1320 FIND v(dout0_5) AT=665.025n

.meas tran vdout0_6ck1320 FIND v(dout0_6) AT=665.025n

.meas tran vdout0_7ck1320 FIND v(dout0_7) AT=665.025n

.meas tran vdout0_8ck1320 FIND v(dout0_8) AT=665.025n

.meas tran vdout0_9ck1320 FIND v(dout0_9) AT=665.025n

.meas tran vdout0_10ck1320 FIND v(dout0_10) AT=665.025n

.meas tran vdout0_11ck1320 FIND v(dout0_11) AT=665.025n

.meas tran vdout0_12ck1320 FIND v(dout0_12) AT=665.025n

.meas tran vdout0_13ck1320 FIND v(dout0_13) AT=665.025n

.meas tran vdout0_14ck1320 FIND v(dout0_14) AT=665.025n

.meas tran vdout0_15ck1320 FIND v(dout0_15) AT=665.025n

.meas tran vdout0_16ck1320 FIND v(dout0_16) AT=665.025n

.meas tran vdout0_17ck1320 FIND v(dout0_17) AT=665.025n

.meas tran vdout0_18ck1320 FIND v(dout0_18) AT=665.025n

.meas tran vdout0_19ck1320 FIND v(dout0_19) AT=665.025n

.meas tran vdout0_20ck1320 FIND v(dout0_20) AT=665.025n

.meas tran vdout0_21ck1320 FIND v(dout0_21) AT=665.025n

.meas tran vdout0_22ck1320 FIND v(dout0_22) AT=665.025n

.meas tran vdout0_23ck1320 FIND v(dout0_23) AT=665.025n

.meas tran vdout0_24ck1320 FIND v(dout0_24) AT=665.025n

.meas tran vdout0_25ck1320 FIND v(dout0_25) AT=665.025n

.meas tran vdout0_26ck1320 FIND v(dout0_26) AT=665.025n

.meas tran vdout0_27ck1320 FIND v(dout0_27) AT=665.025n

.meas tran vdout0_28ck1320 FIND v(dout0_28) AT=665.025n

.meas tran vdout0_29ck1320 FIND v(dout0_29) AT=665.025n

.meas tran vdout0_30ck1320 FIND v(dout0_30) AT=665.025n

.meas tran vdout0_31ck1320 FIND v(dout0_31) AT=665.025n

.meas tran vdout0_32ck1320 FIND v(dout0_32) AT=665.025n

.meas tran vdout0_33ck1320 FIND v(dout0_33) AT=665.025n

.meas tran vdout0_34ck1320 FIND v(dout0_34) AT=665.025n

.meas tran vdout0_35ck1320 FIND v(dout0_35) AT=665.025n

.meas tran vdout0_36ck1320 FIND v(dout0_36) AT=665.025n

.meas tran vdout0_37ck1320 FIND v(dout0_37) AT=665.025n

.meas tran vdout0_38ck1320 FIND v(dout0_38) AT=665.025n

.meas tran vdout0_39ck1320 FIND v(dout0_39) AT=665.025n

.meas tran vdout0_40ck1320 FIND v(dout0_40) AT=665.025n

.meas tran vdout0_41ck1320 FIND v(dout0_41) AT=665.025n

.meas tran vdout0_42ck1320 FIND v(dout0_42) AT=665.025n

.meas tran vdout0_43ck1320 FIND v(dout0_43) AT=665.025n

.meas tran vdout0_44ck1320 FIND v(dout0_44) AT=665.025n

.meas tran vdout0_45ck1320 FIND v(dout0_45) AT=665.025n

.meas tran vdout0_46ck1320 FIND v(dout0_46) AT=665.025n

.meas tran vdout0_47ck1320 FIND v(dout0_47) AT=665.025n

.meas tran vdout0_48ck1320 FIND v(dout0_48) AT=665.025n

.meas tran vdout0_49ck1320 FIND v(dout0_49) AT=665.025n

.meas tran vdout0_50ck1320 FIND v(dout0_50) AT=665.025n

.meas tran vdout0_51ck1320 FIND v(dout0_51) AT=665.025n

.meas tran vdout0_52ck1320 FIND v(dout0_52) AT=665.025n

.meas tran vdout0_53ck1320 FIND v(dout0_53) AT=665.025n

.meas tran vdout0_54ck1320 FIND v(dout0_54) AT=665.025n

.meas tran vdout0_55ck1320 FIND v(dout0_55) AT=665.025n

.meas tran vdout0_56ck1320 FIND v(dout0_56) AT=665.025n

.meas tran vdout0_57ck1320 FIND v(dout0_57) AT=665.025n

.meas tran vdout0_58ck1320 FIND v(dout0_58) AT=665.025n

.meas tran vdout0_59ck1320 FIND v(dout0_59) AT=665.025n

.meas tran vdout0_60ck1320 FIND v(dout0_60) AT=665.025n

.meas tran vdout0_61ck1320 FIND v(dout0_61) AT=665.025n

.meas tran vdout0_62ck1320 FIND v(dout0_62) AT=665.025n

.meas tran vdout0_63ck1320 FIND v(dout0_63) AT=665.025n

.meas tran vdout0_64ck1320 FIND v(dout0_64) AT=665.025n

.meas tran vdout0_65ck1320 FIND v(dout0_65) AT=665.025n

.meas tran vdout0_66ck1320 FIND v(dout0_66) AT=665.025n

.meas tran vdout0_67ck1320 FIND v(dout0_67) AT=665.025n

.meas tran vdout0_68ck1320 FIND v(dout0_68) AT=665.025n

.meas tran vdout0_69ck1320 FIND v(dout0_69) AT=665.025n

.meas tran vdout0_70ck1320 FIND v(dout0_70) AT=665.025n

.meas tran vdout0_71ck1320 FIND v(dout0_71) AT=665.025n

.meas tran vdout0_72ck1320 FIND v(dout0_72) AT=665.025n

.meas tran vdout0_73ck1320 FIND v(dout0_73) AT=665.025n

.meas tran vdout0_74ck1320 FIND v(dout0_74) AT=665.025n

.meas tran vdout0_75ck1320 FIND v(dout0_75) AT=665.025n

.meas tran vdout0_76ck1320 FIND v(dout0_76) AT=665.025n

.meas tran vdout0_77ck1320 FIND v(dout0_77) AT=665.025n

.meas tran vdout0_78ck1320 FIND v(dout0_78) AT=665.025n

.meas tran vdout0_79ck1320 FIND v(dout0_79) AT=665.025n

.meas tran vdout0_80ck1320 FIND v(dout0_80) AT=665.025n

.meas tran vdout0_81ck1320 FIND v(dout0_81) AT=665.025n

.meas tran vdout0_82ck1320 FIND v(dout0_82) AT=665.025n

.meas tran vdout0_83ck1320 FIND v(dout0_83) AT=665.025n

.meas tran vdout0_84ck1320 FIND v(dout0_84) AT=665.025n

.meas tran vdout0_85ck1320 FIND v(dout0_85) AT=665.025n

.meas tran vdout0_86ck1320 FIND v(dout0_86) AT=665.025n

.meas tran vdout0_87ck1320 FIND v(dout0_87) AT=665.025n

.meas tran vdout0_88ck1320 FIND v(dout0_88) AT=665.025n

.meas tran vdout0_89ck1320 FIND v(dout0_89) AT=665.025n

.meas tran vdout0_90ck1320 FIND v(dout0_90) AT=665.025n

.meas tran vdout0_91ck1320 FIND v(dout0_91) AT=665.025n

.meas tran vdout0_92ck1320 FIND v(dout0_92) AT=665.025n

.meas tran vdout0_93ck1320 FIND v(dout0_93) AT=665.025n

.meas tran vdout0_94ck1320 FIND v(dout0_94) AT=665.025n

.meas tran vdout0_95ck1320 FIND v(dout0_95) AT=665.025n

.meas tran vdout0_96ck1320 FIND v(dout0_96) AT=665.025n

.meas tran vdout0_97ck1320 FIND v(dout0_97) AT=665.025n

.meas tran vdout0_98ck1320 FIND v(dout0_98) AT=665.025n

.meas tran vdout0_99ck1320 FIND v(dout0_99) AT=665.025n

.meas tran vdout0_100ck1320 FIND v(dout0_100) AT=665.025n

.meas tran vdout0_101ck1320 FIND v(dout0_101) AT=665.025n

.meas tran vdout0_102ck1320 FIND v(dout0_102) AT=665.025n

.meas tran vdout0_103ck1320 FIND v(dout0_103) AT=665.025n

.meas tran vdout0_104ck1320 FIND v(dout0_104) AT=665.025n

.meas tran vdout0_105ck1320 FIND v(dout0_105) AT=665.025n

.meas tran vdout0_106ck1320 FIND v(dout0_106) AT=665.025n

.meas tran vdout0_107ck1320 FIND v(dout0_107) AT=665.025n

.meas tran vdout0_108ck1320 FIND v(dout0_108) AT=665.025n

.meas tran vdout0_109ck1320 FIND v(dout0_109) AT=665.025n

.meas tran vdout0_110ck1320 FIND v(dout0_110) AT=665.025n

.meas tran vdout0_111ck1320 FIND v(dout0_111) AT=665.025n

.meas tran vdout0_112ck1320 FIND v(dout0_112) AT=665.025n

.meas tran vdout0_113ck1320 FIND v(dout0_113) AT=665.025n

.meas tran vdout0_114ck1320 FIND v(dout0_114) AT=665.025n

.meas tran vdout0_115ck1320 FIND v(dout0_115) AT=665.025n

.meas tran vdout0_116ck1320 FIND v(dout0_116) AT=665.025n

.meas tran vdout0_117ck1320 FIND v(dout0_117) AT=665.025n

.meas tran vdout0_118ck1320 FIND v(dout0_118) AT=665.025n

.meas tran vdout0_119ck1320 FIND v(dout0_119) AT=665.025n

.meas tran vdout0_120ck1320 FIND v(dout0_120) AT=665.025n

.meas tran vdout0_121ck1320 FIND v(dout0_121) AT=665.025n

.meas tran vdout0_122ck1320 FIND v(dout0_122) AT=665.025n

.meas tran vdout0_123ck1320 FIND v(dout0_123) AT=665.025n

.meas tran vdout0_124ck1320 FIND v(dout0_124) AT=665.025n

.meas tran vdout0_125ck1320 FIND v(dout0_125) AT=665.025n

.meas tran vdout0_126ck1320 FIND v(dout0_126) AT=665.025n

.meas tran vdout0_127ck1320 FIND v(dout0_127) AT=665.025n

.meas tran vdout0_0ck1330 FIND v(dout0_0) AT=670.025n

.meas tran vdout0_1ck1330 FIND v(dout0_1) AT=670.025n

.meas tran vdout0_2ck1330 FIND v(dout0_2) AT=670.025n

.meas tran vdout0_3ck1330 FIND v(dout0_3) AT=670.025n

.meas tran vdout0_4ck1330 FIND v(dout0_4) AT=670.025n

.meas tran vdout0_5ck1330 FIND v(dout0_5) AT=670.025n

.meas tran vdout0_6ck1330 FIND v(dout0_6) AT=670.025n

.meas tran vdout0_7ck1330 FIND v(dout0_7) AT=670.025n

.meas tran vdout0_8ck1330 FIND v(dout0_8) AT=670.025n

.meas tran vdout0_9ck1330 FIND v(dout0_9) AT=670.025n

.meas tran vdout0_10ck1330 FIND v(dout0_10) AT=670.025n

.meas tran vdout0_11ck1330 FIND v(dout0_11) AT=670.025n

.meas tran vdout0_12ck1330 FIND v(dout0_12) AT=670.025n

.meas tran vdout0_13ck1330 FIND v(dout0_13) AT=670.025n

.meas tran vdout0_14ck1330 FIND v(dout0_14) AT=670.025n

.meas tran vdout0_15ck1330 FIND v(dout0_15) AT=670.025n

.meas tran vdout0_16ck1330 FIND v(dout0_16) AT=670.025n

.meas tran vdout0_17ck1330 FIND v(dout0_17) AT=670.025n

.meas tran vdout0_18ck1330 FIND v(dout0_18) AT=670.025n

.meas tran vdout0_19ck1330 FIND v(dout0_19) AT=670.025n

.meas tran vdout0_20ck1330 FIND v(dout0_20) AT=670.025n

.meas tran vdout0_21ck1330 FIND v(dout0_21) AT=670.025n

.meas tran vdout0_22ck1330 FIND v(dout0_22) AT=670.025n

.meas tran vdout0_23ck1330 FIND v(dout0_23) AT=670.025n

.meas tran vdout0_24ck1330 FIND v(dout0_24) AT=670.025n

.meas tran vdout0_25ck1330 FIND v(dout0_25) AT=670.025n

.meas tran vdout0_26ck1330 FIND v(dout0_26) AT=670.025n

.meas tran vdout0_27ck1330 FIND v(dout0_27) AT=670.025n

.meas tran vdout0_28ck1330 FIND v(dout0_28) AT=670.025n

.meas tran vdout0_29ck1330 FIND v(dout0_29) AT=670.025n

.meas tran vdout0_30ck1330 FIND v(dout0_30) AT=670.025n

.meas tran vdout0_31ck1330 FIND v(dout0_31) AT=670.025n

.meas tran vdout0_32ck1330 FIND v(dout0_32) AT=670.025n

.meas tran vdout0_33ck1330 FIND v(dout0_33) AT=670.025n

.meas tran vdout0_34ck1330 FIND v(dout0_34) AT=670.025n

.meas tran vdout0_35ck1330 FIND v(dout0_35) AT=670.025n

.meas tran vdout0_36ck1330 FIND v(dout0_36) AT=670.025n

.meas tran vdout0_37ck1330 FIND v(dout0_37) AT=670.025n

.meas tran vdout0_38ck1330 FIND v(dout0_38) AT=670.025n

.meas tran vdout0_39ck1330 FIND v(dout0_39) AT=670.025n

.meas tran vdout0_40ck1330 FIND v(dout0_40) AT=670.025n

.meas tran vdout0_41ck1330 FIND v(dout0_41) AT=670.025n

.meas tran vdout0_42ck1330 FIND v(dout0_42) AT=670.025n

.meas tran vdout0_43ck1330 FIND v(dout0_43) AT=670.025n

.meas tran vdout0_44ck1330 FIND v(dout0_44) AT=670.025n

.meas tran vdout0_45ck1330 FIND v(dout0_45) AT=670.025n

.meas tran vdout0_46ck1330 FIND v(dout0_46) AT=670.025n

.meas tran vdout0_47ck1330 FIND v(dout0_47) AT=670.025n

.meas tran vdout0_48ck1330 FIND v(dout0_48) AT=670.025n

.meas tran vdout0_49ck1330 FIND v(dout0_49) AT=670.025n

.meas tran vdout0_50ck1330 FIND v(dout0_50) AT=670.025n

.meas tran vdout0_51ck1330 FIND v(dout0_51) AT=670.025n

.meas tran vdout0_52ck1330 FIND v(dout0_52) AT=670.025n

.meas tran vdout0_53ck1330 FIND v(dout0_53) AT=670.025n

.meas tran vdout0_54ck1330 FIND v(dout0_54) AT=670.025n

.meas tran vdout0_55ck1330 FIND v(dout0_55) AT=670.025n

.meas tran vdout0_56ck1330 FIND v(dout0_56) AT=670.025n

.meas tran vdout0_57ck1330 FIND v(dout0_57) AT=670.025n

.meas tran vdout0_58ck1330 FIND v(dout0_58) AT=670.025n

.meas tran vdout0_59ck1330 FIND v(dout0_59) AT=670.025n

.meas tran vdout0_60ck1330 FIND v(dout0_60) AT=670.025n

.meas tran vdout0_61ck1330 FIND v(dout0_61) AT=670.025n

.meas tran vdout0_62ck1330 FIND v(dout0_62) AT=670.025n

.meas tran vdout0_63ck1330 FIND v(dout0_63) AT=670.025n

.meas tran vdout0_64ck1330 FIND v(dout0_64) AT=670.025n

.meas tran vdout0_65ck1330 FIND v(dout0_65) AT=670.025n

.meas tran vdout0_66ck1330 FIND v(dout0_66) AT=670.025n

.meas tran vdout0_67ck1330 FIND v(dout0_67) AT=670.025n

.meas tran vdout0_68ck1330 FIND v(dout0_68) AT=670.025n

.meas tran vdout0_69ck1330 FIND v(dout0_69) AT=670.025n

.meas tran vdout0_70ck1330 FIND v(dout0_70) AT=670.025n

.meas tran vdout0_71ck1330 FIND v(dout0_71) AT=670.025n

.meas tran vdout0_72ck1330 FIND v(dout0_72) AT=670.025n

.meas tran vdout0_73ck1330 FIND v(dout0_73) AT=670.025n

.meas tran vdout0_74ck1330 FIND v(dout0_74) AT=670.025n

.meas tran vdout0_75ck1330 FIND v(dout0_75) AT=670.025n

.meas tran vdout0_76ck1330 FIND v(dout0_76) AT=670.025n

.meas tran vdout0_77ck1330 FIND v(dout0_77) AT=670.025n

.meas tran vdout0_78ck1330 FIND v(dout0_78) AT=670.025n

.meas tran vdout0_79ck1330 FIND v(dout0_79) AT=670.025n

.meas tran vdout0_80ck1330 FIND v(dout0_80) AT=670.025n

.meas tran vdout0_81ck1330 FIND v(dout0_81) AT=670.025n

.meas tran vdout0_82ck1330 FIND v(dout0_82) AT=670.025n

.meas tran vdout0_83ck1330 FIND v(dout0_83) AT=670.025n

.meas tran vdout0_84ck1330 FIND v(dout0_84) AT=670.025n

.meas tran vdout0_85ck1330 FIND v(dout0_85) AT=670.025n

.meas tran vdout0_86ck1330 FIND v(dout0_86) AT=670.025n

.meas tran vdout0_87ck1330 FIND v(dout0_87) AT=670.025n

.meas tran vdout0_88ck1330 FIND v(dout0_88) AT=670.025n

.meas tran vdout0_89ck1330 FIND v(dout0_89) AT=670.025n

.meas tran vdout0_90ck1330 FIND v(dout0_90) AT=670.025n

.meas tran vdout0_91ck1330 FIND v(dout0_91) AT=670.025n

.meas tran vdout0_92ck1330 FIND v(dout0_92) AT=670.025n

.meas tran vdout0_93ck1330 FIND v(dout0_93) AT=670.025n

.meas tran vdout0_94ck1330 FIND v(dout0_94) AT=670.025n

.meas tran vdout0_95ck1330 FIND v(dout0_95) AT=670.025n

.meas tran vdout0_96ck1330 FIND v(dout0_96) AT=670.025n

.meas tran vdout0_97ck1330 FIND v(dout0_97) AT=670.025n

.meas tran vdout0_98ck1330 FIND v(dout0_98) AT=670.025n

.meas tran vdout0_99ck1330 FIND v(dout0_99) AT=670.025n

.meas tran vdout0_100ck1330 FIND v(dout0_100) AT=670.025n

.meas tran vdout0_101ck1330 FIND v(dout0_101) AT=670.025n

.meas tran vdout0_102ck1330 FIND v(dout0_102) AT=670.025n

.meas tran vdout0_103ck1330 FIND v(dout0_103) AT=670.025n

.meas tran vdout0_104ck1330 FIND v(dout0_104) AT=670.025n

.meas tran vdout0_105ck1330 FIND v(dout0_105) AT=670.025n

.meas tran vdout0_106ck1330 FIND v(dout0_106) AT=670.025n

.meas tran vdout0_107ck1330 FIND v(dout0_107) AT=670.025n

.meas tran vdout0_108ck1330 FIND v(dout0_108) AT=670.025n

.meas tran vdout0_109ck1330 FIND v(dout0_109) AT=670.025n

.meas tran vdout0_110ck1330 FIND v(dout0_110) AT=670.025n

.meas tran vdout0_111ck1330 FIND v(dout0_111) AT=670.025n

.meas tran vdout0_112ck1330 FIND v(dout0_112) AT=670.025n

.meas tran vdout0_113ck1330 FIND v(dout0_113) AT=670.025n

.meas tran vdout0_114ck1330 FIND v(dout0_114) AT=670.025n

.meas tran vdout0_115ck1330 FIND v(dout0_115) AT=670.025n

.meas tran vdout0_116ck1330 FIND v(dout0_116) AT=670.025n

.meas tran vdout0_117ck1330 FIND v(dout0_117) AT=670.025n

.meas tran vdout0_118ck1330 FIND v(dout0_118) AT=670.025n

.meas tran vdout0_119ck1330 FIND v(dout0_119) AT=670.025n

.meas tran vdout0_120ck1330 FIND v(dout0_120) AT=670.025n

.meas tran vdout0_121ck1330 FIND v(dout0_121) AT=670.025n

.meas tran vdout0_122ck1330 FIND v(dout0_122) AT=670.025n

.meas tran vdout0_123ck1330 FIND v(dout0_123) AT=670.025n

.meas tran vdout0_124ck1330 FIND v(dout0_124) AT=670.025n

.meas tran vdout0_125ck1330 FIND v(dout0_125) AT=670.025n

.meas tran vdout0_126ck1330 FIND v(dout0_126) AT=670.025n

.meas tran vdout0_127ck1330 FIND v(dout0_127) AT=670.025n

.meas tran vdout0_0ck1340 FIND v(dout0_0) AT=675.025n

.meas tran vdout0_1ck1340 FIND v(dout0_1) AT=675.025n

.meas tran vdout0_2ck1340 FIND v(dout0_2) AT=675.025n

.meas tran vdout0_3ck1340 FIND v(dout0_3) AT=675.025n

.meas tran vdout0_4ck1340 FIND v(dout0_4) AT=675.025n

.meas tran vdout0_5ck1340 FIND v(dout0_5) AT=675.025n

.meas tran vdout0_6ck1340 FIND v(dout0_6) AT=675.025n

.meas tran vdout0_7ck1340 FIND v(dout0_7) AT=675.025n

.meas tran vdout0_8ck1340 FIND v(dout0_8) AT=675.025n

.meas tran vdout0_9ck1340 FIND v(dout0_9) AT=675.025n

.meas tran vdout0_10ck1340 FIND v(dout0_10) AT=675.025n

.meas tran vdout0_11ck1340 FIND v(dout0_11) AT=675.025n

.meas tran vdout0_12ck1340 FIND v(dout0_12) AT=675.025n

.meas tran vdout0_13ck1340 FIND v(dout0_13) AT=675.025n

.meas tran vdout0_14ck1340 FIND v(dout0_14) AT=675.025n

.meas tran vdout0_15ck1340 FIND v(dout0_15) AT=675.025n

.meas tran vdout0_16ck1340 FIND v(dout0_16) AT=675.025n

.meas tran vdout0_17ck1340 FIND v(dout0_17) AT=675.025n

.meas tran vdout0_18ck1340 FIND v(dout0_18) AT=675.025n

.meas tran vdout0_19ck1340 FIND v(dout0_19) AT=675.025n

.meas tran vdout0_20ck1340 FIND v(dout0_20) AT=675.025n

.meas tran vdout0_21ck1340 FIND v(dout0_21) AT=675.025n

.meas tran vdout0_22ck1340 FIND v(dout0_22) AT=675.025n

.meas tran vdout0_23ck1340 FIND v(dout0_23) AT=675.025n

.meas tran vdout0_24ck1340 FIND v(dout0_24) AT=675.025n

.meas tran vdout0_25ck1340 FIND v(dout0_25) AT=675.025n

.meas tran vdout0_26ck1340 FIND v(dout0_26) AT=675.025n

.meas tran vdout0_27ck1340 FIND v(dout0_27) AT=675.025n

.meas tran vdout0_28ck1340 FIND v(dout0_28) AT=675.025n

.meas tran vdout0_29ck1340 FIND v(dout0_29) AT=675.025n

.meas tran vdout0_30ck1340 FIND v(dout0_30) AT=675.025n

.meas tran vdout0_31ck1340 FIND v(dout0_31) AT=675.025n

.meas tran vdout0_32ck1340 FIND v(dout0_32) AT=675.025n

.meas tran vdout0_33ck1340 FIND v(dout0_33) AT=675.025n

.meas tran vdout0_34ck1340 FIND v(dout0_34) AT=675.025n

.meas tran vdout0_35ck1340 FIND v(dout0_35) AT=675.025n

.meas tran vdout0_36ck1340 FIND v(dout0_36) AT=675.025n

.meas tran vdout0_37ck1340 FIND v(dout0_37) AT=675.025n

.meas tran vdout0_38ck1340 FIND v(dout0_38) AT=675.025n

.meas tran vdout0_39ck1340 FIND v(dout0_39) AT=675.025n

.meas tran vdout0_40ck1340 FIND v(dout0_40) AT=675.025n

.meas tran vdout0_41ck1340 FIND v(dout0_41) AT=675.025n

.meas tran vdout0_42ck1340 FIND v(dout0_42) AT=675.025n

.meas tran vdout0_43ck1340 FIND v(dout0_43) AT=675.025n

.meas tran vdout0_44ck1340 FIND v(dout0_44) AT=675.025n

.meas tran vdout0_45ck1340 FIND v(dout0_45) AT=675.025n

.meas tran vdout0_46ck1340 FIND v(dout0_46) AT=675.025n

.meas tran vdout0_47ck1340 FIND v(dout0_47) AT=675.025n

.meas tran vdout0_48ck1340 FIND v(dout0_48) AT=675.025n

.meas tran vdout0_49ck1340 FIND v(dout0_49) AT=675.025n

.meas tran vdout0_50ck1340 FIND v(dout0_50) AT=675.025n

.meas tran vdout0_51ck1340 FIND v(dout0_51) AT=675.025n

.meas tran vdout0_52ck1340 FIND v(dout0_52) AT=675.025n

.meas tran vdout0_53ck1340 FIND v(dout0_53) AT=675.025n

.meas tran vdout0_54ck1340 FIND v(dout0_54) AT=675.025n

.meas tran vdout0_55ck1340 FIND v(dout0_55) AT=675.025n

.meas tran vdout0_56ck1340 FIND v(dout0_56) AT=675.025n

.meas tran vdout0_57ck1340 FIND v(dout0_57) AT=675.025n

.meas tran vdout0_58ck1340 FIND v(dout0_58) AT=675.025n

.meas tran vdout0_59ck1340 FIND v(dout0_59) AT=675.025n

.meas tran vdout0_60ck1340 FIND v(dout0_60) AT=675.025n

.meas tran vdout0_61ck1340 FIND v(dout0_61) AT=675.025n

.meas tran vdout0_62ck1340 FIND v(dout0_62) AT=675.025n

.meas tran vdout0_63ck1340 FIND v(dout0_63) AT=675.025n

.meas tran vdout0_64ck1340 FIND v(dout0_64) AT=675.025n

.meas tran vdout0_65ck1340 FIND v(dout0_65) AT=675.025n

.meas tran vdout0_66ck1340 FIND v(dout0_66) AT=675.025n

.meas tran vdout0_67ck1340 FIND v(dout0_67) AT=675.025n

.meas tran vdout0_68ck1340 FIND v(dout0_68) AT=675.025n

.meas tran vdout0_69ck1340 FIND v(dout0_69) AT=675.025n

.meas tran vdout0_70ck1340 FIND v(dout0_70) AT=675.025n

.meas tran vdout0_71ck1340 FIND v(dout0_71) AT=675.025n

.meas tran vdout0_72ck1340 FIND v(dout0_72) AT=675.025n

.meas tran vdout0_73ck1340 FIND v(dout0_73) AT=675.025n

.meas tran vdout0_74ck1340 FIND v(dout0_74) AT=675.025n

.meas tran vdout0_75ck1340 FIND v(dout0_75) AT=675.025n

.meas tran vdout0_76ck1340 FIND v(dout0_76) AT=675.025n

.meas tran vdout0_77ck1340 FIND v(dout0_77) AT=675.025n

.meas tran vdout0_78ck1340 FIND v(dout0_78) AT=675.025n

.meas tran vdout0_79ck1340 FIND v(dout0_79) AT=675.025n

.meas tran vdout0_80ck1340 FIND v(dout0_80) AT=675.025n

.meas tran vdout0_81ck1340 FIND v(dout0_81) AT=675.025n

.meas tran vdout0_82ck1340 FIND v(dout0_82) AT=675.025n

.meas tran vdout0_83ck1340 FIND v(dout0_83) AT=675.025n

.meas tran vdout0_84ck1340 FIND v(dout0_84) AT=675.025n

.meas tran vdout0_85ck1340 FIND v(dout0_85) AT=675.025n

.meas tran vdout0_86ck1340 FIND v(dout0_86) AT=675.025n

.meas tran vdout0_87ck1340 FIND v(dout0_87) AT=675.025n

.meas tran vdout0_88ck1340 FIND v(dout0_88) AT=675.025n

.meas tran vdout0_89ck1340 FIND v(dout0_89) AT=675.025n

.meas tran vdout0_90ck1340 FIND v(dout0_90) AT=675.025n

.meas tran vdout0_91ck1340 FIND v(dout0_91) AT=675.025n

.meas tran vdout0_92ck1340 FIND v(dout0_92) AT=675.025n

.meas tran vdout0_93ck1340 FIND v(dout0_93) AT=675.025n

.meas tran vdout0_94ck1340 FIND v(dout0_94) AT=675.025n

.meas tran vdout0_95ck1340 FIND v(dout0_95) AT=675.025n

.meas tran vdout0_96ck1340 FIND v(dout0_96) AT=675.025n

.meas tran vdout0_97ck1340 FIND v(dout0_97) AT=675.025n

.meas tran vdout0_98ck1340 FIND v(dout0_98) AT=675.025n

.meas tran vdout0_99ck1340 FIND v(dout0_99) AT=675.025n

.meas tran vdout0_100ck1340 FIND v(dout0_100) AT=675.025n

.meas tran vdout0_101ck1340 FIND v(dout0_101) AT=675.025n

.meas tran vdout0_102ck1340 FIND v(dout0_102) AT=675.025n

.meas tran vdout0_103ck1340 FIND v(dout0_103) AT=675.025n

.meas tran vdout0_104ck1340 FIND v(dout0_104) AT=675.025n

.meas tran vdout0_105ck1340 FIND v(dout0_105) AT=675.025n

.meas tran vdout0_106ck1340 FIND v(dout0_106) AT=675.025n

.meas tran vdout0_107ck1340 FIND v(dout0_107) AT=675.025n

.meas tran vdout0_108ck1340 FIND v(dout0_108) AT=675.025n

.meas tran vdout0_109ck1340 FIND v(dout0_109) AT=675.025n

.meas tran vdout0_110ck1340 FIND v(dout0_110) AT=675.025n

.meas tran vdout0_111ck1340 FIND v(dout0_111) AT=675.025n

.meas tran vdout0_112ck1340 FIND v(dout0_112) AT=675.025n

.meas tran vdout0_113ck1340 FIND v(dout0_113) AT=675.025n

.meas tran vdout0_114ck1340 FIND v(dout0_114) AT=675.025n

.meas tran vdout0_115ck1340 FIND v(dout0_115) AT=675.025n

.meas tran vdout0_116ck1340 FIND v(dout0_116) AT=675.025n

.meas tran vdout0_117ck1340 FIND v(dout0_117) AT=675.025n

.meas tran vdout0_118ck1340 FIND v(dout0_118) AT=675.025n

.meas tran vdout0_119ck1340 FIND v(dout0_119) AT=675.025n

.meas tran vdout0_120ck1340 FIND v(dout0_120) AT=675.025n

.meas tran vdout0_121ck1340 FIND v(dout0_121) AT=675.025n

.meas tran vdout0_122ck1340 FIND v(dout0_122) AT=675.025n

.meas tran vdout0_123ck1340 FIND v(dout0_123) AT=675.025n

.meas tran vdout0_124ck1340 FIND v(dout0_124) AT=675.025n

.meas tran vdout0_125ck1340 FIND v(dout0_125) AT=675.025n

.meas tran vdout0_126ck1340 FIND v(dout0_126) AT=675.025n

.meas tran vdout0_127ck1340 FIND v(dout0_127) AT=675.025n

.meas tran vdout0_0ck1370 FIND v(dout0_0) AT=690.025n

.meas tran vdout0_1ck1370 FIND v(dout0_1) AT=690.025n

.meas tran vdout0_2ck1370 FIND v(dout0_2) AT=690.025n

.meas tran vdout0_3ck1370 FIND v(dout0_3) AT=690.025n

.meas tran vdout0_4ck1370 FIND v(dout0_4) AT=690.025n

.meas tran vdout0_5ck1370 FIND v(dout0_5) AT=690.025n

.meas tran vdout0_6ck1370 FIND v(dout0_6) AT=690.025n

.meas tran vdout0_7ck1370 FIND v(dout0_7) AT=690.025n

.meas tran vdout0_8ck1370 FIND v(dout0_8) AT=690.025n

.meas tran vdout0_9ck1370 FIND v(dout0_9) AT=690.025n

.meas tran vdout0_10ck1370 FIND v(dout0_10) AT=690.025n

.meas tran vdout0_11ck1370 FIND v(dout0_11) AT=690.025n

.meas tran vdout0_12ck1370 FIND v(dout0_12) AT=690.025n

.meas tran vdout0_13ck1370 FIND v(dout0_13) AT=690.025n

.meas tran vdout0_14ck1370 FIND v(dout0_14) AT=690.025n

.meas tran vdout0_15ck1370 FIND v(dout0_15) AT=690.025n

.meas tran vdout0_16ck1370 FIND v(dout0_16) AT=690.025n

.meas tran vdout0_17ck1370 FIND v(dout0_17) AT=690.025n

.meas tran vdout0_18ck1370 FIND v(dout0_18) AT=690.025n

.meas tran vdout0_19ck1370 FIND v(dout0_19) AT=690.025n

.meas tran vdout0_20ck1370 FIND v(dout0_20) AT=690.025n

.meas tran vdout0_21ck1370 FIND v(dout0_21) AT=690.025n

.meas tran vdout0_22ck1370 FIND v(dout0_22) AT=690.025n

.meas tran vdout0_23ck1370 FIND v(dout0_23) AT=690.025n

.meas tran vdout0_24ck1370 FIND v(dout0_24) AT=690.025n

.meas tran vdout0_25ck1370 FIND v(dout0_25) AT=690.025n

.meas tran vdout0_26ck1370 FIND v(dout0_26) AT=690.025n

.meas tran vdout0_27ck1370 FIND v(dout0_27) AT=690.025n

.meas tran vdout0_28ck1370 FIND v(dout0_28) AT=690.025n

.meas tran vdout0_29ck1370 FIND v(dout0_29) AT=690.025n

.meas tran vdout0_30ck1370 FIND v(dout0_30) AT=690.025n

.meas tran vdout0_31ck1370 FIND v(dout0_31) AT=690.025n

.meas tran vdout0_32ck1370 FIND v(dout0_32) AT=690.025n

.meas tran vdout0_33ck1370 FIND v(dout0_33) AT=690.025n

.meas tran vdout0_34ck1370 FIND v(dout0_34) AT=690.025n

.meas tran vdout0_35ck1370 FIND v(dout0_35) AT=690.025n

.meas tran vdout0_36ck1370 FIND v(dout0_36) AT=690.025n

.meas tran vdout0_37ck1370 FIND v(dout0_37) AT=690.025n

.meas tran vdout0_38ck1370 FIND v(dout0_38) AT=690.025n

.meas tran vdout0_39ck1370 FIND v(dout0_39) AT=690.025n

.meas tran vdout0_40ck1370 FIND v(dout0_40) AT=690.025n

.meas tran vdout0_41ck1370 FIND v(dout0_41) AT=690.025n

.meas tran vdout0_42ck1370 FIND v(dout0_42) AT=690.025n

.meas tran vdout0_43ck1370 FIND v(dout0_43) AT=690.025n

.meas tran vdout0_44ck1370 FIND v(dout0_44) AT=690.025n

.meas tran vdout0_45ck1370 FIND v(dout0_45) AT=690.025n

.meas tran vdout0_46ck1370 FIND v(dout0_46) AT=690.025n

.meas tran vdout0_47ck1370 FIND v(dout0_47) AT=690.025n

.meas tran vdout0_48ck1370 FIND v(dout0_48) AT=690.025n

.meas tran vdout0_49ck1370 FIND v(dout0_49) AT=690.025n

.meas tran vdout0_50ck1370 FIND v(dout0_50) AT=690.025n

.meas tran vdout0_51ck1370 FIND v(dout0_51) AT=690.025n

.meas tran vdout0_52ck1370 FIND v(dout0_52) AT=690.025n

.meas tran vdout0_53ck1370 FIND v(dout0_53) AT=690.025n

.meas tran vdout0_54ck1370 FIND v(dout0_54) AT=690.025n

.meas tran vdout0_55ck1370 FIND v(dout0_55) AT=690.025n

.meas tran vdout0_56ck1370 FIND v(dout0_56) AT=690.025n

.meas tran vdout0_57ck1370 FIND v(dout0_57) AT=690.025n

.meas tran vdout0_58ck1370 FIND v(dout0_58) AT=690.025n

.meas tran vdout0_59ck1370 FIND v(dout0_59) AT=690.025n

.meas tran vdout0_60ck1370 FIND v(dout0_60) AT=690.025n

.meas tran vdout0_61ck1370 FIND v(dout0_61) AT=690.025n

.meas tran vdout0_62ck1370 FIND v(dout0_62) AT=690.025n

.meas tran vdout0_63ck1370 FIND v(dout0_63) AT=690.025n

.meas tran vdout0_64ck1370 FIND v(dout0_64) AT=690.025n

.meas tran vdout0_65ck1370 FIND v(dout0_65) AT=690.025n

.meas tran vdout0_66ck1370 FIND v(dout0_66) AT=690.025n

.meas tran vdout0_67ck1370 FIND v(dout0_67) AT=690.025n

.meas tran vdout0_68ck1370 FIND v(dout0_68) AT=690.025n

.meas tran vdout0_69ck1370 FIND v(dout0_69) AT=690.025n

.meas tran vdout0_70ck1370 FIND v(dout0_70) AT=690.025n

.meas tran vdout0_71ck1370 FIND v(dout0_71) AT=690.025n

.meas tran vdout0_72ck1370 FIND v(dout0_72) AT=690.025n

.meas tran vdout0_73ck1370 FIND v(dout0_73) AT=690.025n

.meas tran vdout0_74ck1370 FIND v(dout0_74) AT=690.025n

.meas tran vdout0_75ck1370 FIND v(dout0_75) AT=690.025n

.meas tran vdout0_76ck1370 FIND v(dout0_76) AT=690.025n

.meas tran vdout0_77ck1370 FIND v(dout0_77) AT=690.025n

.meas tran vdout0_78ck1370 FIND v(dout0_78) AT=690.025n

.meas tran vdout0_79ck1370 FIND v(dout0_79) AT=690.025n

.meas tran vdout0_80ck1370 FIND v(dout0_80) AT=690.025n

.meas tran vdout0_81ck1370 FIND v(dout0_81) AT=690.025n

.meas tran vdout0_82ck1370 FIND v(dout0_82) AT=690.025n

.meas tran vdout0_83ck1370 FIND v(dout0_83) AT=690.025n

.meas tran vdout0_84ck1370 FIND v(dout0_84) AT=690.025n

.meas tran vdout0_85ck1370 FIND v(dout0_85) AT=690.025n

.meas tran vdout0_86ck1370 FIND v(dout0_86) AT=690.025n

.meas tran vdout0_87ck1370 FIND v(dout0_87) AT=690.025n

.meas tran vdout0_88ck1370 FIND v(dout0_88) AT=690.025n

.meas tran vdout0_89ck1370 FIND v(dout0_89) AT=690.025n

.meas tran vdout0_90ck1370 FIND v(dout0_90) AT=690.025n

.meas tran vdout0_91ck1370 FIND v(dout0_91) AT=690.025n

.meas tran vdout0_92ck1370 FIND v(dout0_92) AT=690.025n

.meas tran vdout0_93ck1370 FIND v(dout0_93) AT=690.025n

.meas tran vdout0_94ck1370 FIND v(dout0_94) AT=690.025n

.meas tran vdout0_95ck1370 FIND v(dout0_95) AT=690.025n

.meas tran vdout0_96ck1370 FIND v(dout0_96) AT=690.025n

.meas tran vdout0_97ck1370 FIND v(dout0_97) AT=690.025n

.meas tran vdout0_98ck1370 FIND v(dout0_98) AT=690.025n

.meas tran vdout0_99ck1370 FIND v(dout0_99) AT=690.025n

.meas tran vdout0_100ck1370 FIND v(dout0_100) AT=690.025n

.meas tran vdout0_101ck1370 FIND v(dout0_101) AT=690.025n

.meas tran vdout0_102ck1370 FIND v(dout0_102) AT=690.025n

.meas tran vdout0_103ck1370 FIND v(dout0_103) AT=690.025n

.meas tran vdout0_104ck1370 FIND v(dout0_104) AT=690.025n

.meas tran vdout0_105ck1370 FIND v(dout0_105) AT=690.025n

.meas tran vdout0_106ck1370 FIND v(dout0_106) AT=690.025n

.meas tran vdout0_107ck1370 FIND v(dout0_107) AT=690.025n

.meas tran vdout0_108ck1370 FIND v(dout0_108) AT=690.025n

.meas tran vdout0_109ck1370 FIND v(dout0_109) AT=690.025n

.meas tran vdout0_110ck1370 FIND v(dout0_110) AT=690.025n

.meas tran vdout0_111ck1370 FIND v(dout0_111) AT=690.025n

.meas tran vdout0_112ck1370 FIND v(dout0_112) AT=690.025n

.meas tran vdout0_113ck1370 FIND v(dout0_113) AT=690.025n

.meas tran vdout0_114ck1370 FIND v(dout0_114) AT=690.025n

.meas tran vdout0_115ck1370 FIND v(dout0_115) AT=690.025n

.meas tran vdout0_116ck1370 FIND v(dout0_116) AT=690.025n

.meas tran vdout0_117ck1370 FIND v(dout0_117) AT=690.025n

.meas tran vdout0_118ck1370 FIND v(dout0_118) AT=690.025n

.meas tran vdout0_119ck1370 FIND v(dout0_119) AT=690.025n

.meas tran vdout0_120ck1370 FIND v(dout0_120) AT=690.025n

.meas tran vdout0_121ck1370 FIND v(dout0_121) AT=690.025n

.meas tran vdout0_122ck1370 FIND v(dout0_122) AT=690.025n

.meas tran vdout0_123ck1370 FIND v(dout0_123) AT=690.025n

.meas tran vdout0_124ck1370 FIND v(dout0_124) AT=690.025n

.meas tran vdout0_125ck1370 FIND v(dout0_125) AT=690.025n

.meas tran vdout0_126ck1370 FIND v(dout0_126) AT=690.025n

.meas tran vdout0_127ck1370 FIND v(dout0_127) AT=690.025n

.meas tran vdout0_0ck1380 FIND v(dout0_0) AT=695.025n

.meas tran vdout0_1ck1380 FIND v(dout0_1) AT=695.025n

.meas tran vdout0_2ck1380 FIND v(dout0_2) AT=695.025n

.meas tran vdout0_3ck1380 FIND v(dout0_3) AT=695.025n

.meas tran vdout0_4ck1380 FIND v(dout0_4) AT=695.025n

.meas tran vdout0_5ck1380 FIND v(dout0_5) AT=695.025n

.meas tran vdout0_6ck1380 FIND v(dout0_6) AT=695.025n

.meas tran vdout0_7ck1380 FIND v(dout0_7) AT=695.025n

.meas tran vdout0_8ck1380 FIND v(dout0_8) AT=695.025n

.meas tran vdout0_9ck1380 FIND v(dout0_9) AT=695.025n

.meas tran vdout0_10ck1380 FIND v(dout0_10) AT=695.025n

.meas tran vdout0_11ck1380 FIND v(dout0_11) AT=695.025n

.meas tran vdout0_12ck1380 FIND v(dout0_12) AT=695.025n

.meas tran vdout0_13ck1380 FIND v(dout0_13) AT=695.025n

.meas tran vdout0_14ck1380 FIND v(dout0_14) AT=695.025n

.meas tran vdout0_15ck1380 FIND v(dout0_15) AT=695.025n

.meas tran vdout0_16ck1380 FIND v(dout0_16) AT=695.025n

.meas tran vdout0_17ck1380 FIND v(dout0_17) AT=695.025n

.meas tran vdout0_18ck1380 FIND v(dout0_18) AT=695.025n

.meas tran vdout0_19ck1380 FIND v(dout0_19) AT=695.025n

.meas tran vdout0_20ck1380 FIND v(dout0_20) AT=695.025n

.meas tran vdout0_21ck1380 FIND v(dout0_21) AT=695.025n

.meas tran vdout0_22ck1380 FIND v(dout0_22) AT=695.025n

.meas tran vdout0_23ck1380 FIND v(dout0_23) AT=695.025n

.meas tran vdout0_24ck1380 FIND v(dout0_24) AT=695.025n

.meas tran vdout0_25ck1380 FIND v(dout0_25) AT=695.025n

.meas tran vdout0_26ck1380 FIND v(dout0_26) AT=695.025n

.meas tran vdout0_27ck1380 FIND v(dout0_27) AT=695.025n

.meas tran vdout0_28ck1380 FIND v(dout0_28) AT=695.025n

.meas tran vdout0_29ck1380 FIND v(dout0_29) AT=695.025n

.meas tran vdout0_30ck1380 FIND v(dout0_30) AT=695.025n

.meas tran vdout0_31ck1380 FIND v(dout0_31) AT=695.025n

.meas tran vdout0_32ck1380 FIND v(dout0_32) AT=695.025n

.meas tran vdout0_33ck1380 FIND v(dout0_33) AT=695.025n

.meas tran vdout0_34ck1380 FIND v(dout0_34) AT=695.025n

.meas tran vdout0_35ck1380 FIND v(dout0_35) AT=695.025n

.meas tran vdout0_36ck1380 FIND v(dout0_36) AT=695.025n

.meas tran vdout0_37ck1380 FIND v(dout0_37) AT=695.025n

.meas tran vdout0_38ck1380 FIND v(dout0_38) AT=695.025n

.meas tran vdout0_39ck1380 FIND v(dout0_39) AT=695.025n

.meas tran vdout0_40ck1380 FIND v(dout0_40) AT=695.025n

.meas tran vdout0_41ck1380 FIND v(dout0_41) AT=695.025n

.meas tran vdout0_42ck1380 FIND v(dout0_42) AT=695.025n

.meas tran vdout0_43ck1380 FIND v(dout0_43) AT=695.025n

.meas tran vdout0_44ck1380 FIND v(dout0_44) AT=695.025n

.meas tran vdout0_45ck1380 FIND v(dout0_45) AT=695.025n

.meas tran vdout0_46ck1380 FIND v(dout0_46) AT=695.025n

.meas tran vdout0_47ck1380 FIND v(dout0_47) AT=695.025n

.meas tran vdout0_48ck1380 FIND v(dout0_48) AT=695.025n

.meas tran vdout0_49ck1380 FIND v(dout0_49) AT=695.025n

.meas tran vdout0_50ck1380 FIND v(dout0_50) AT=695.025n

.meas tran vdout0_51ck1380 FIND v(dout0_51) AT=695.025n

.meas tran vdout0_52ck1380 FIND v(dout0_52) AT=695.025n

.meas tran vdout0_53ck1380 FIND v(dout0_53) AT=695.025n

.meas tran vdout0_54ck1380 FIND v(dout0_54) AT=695.025n

.meas tran vdout0_55ck1380 FIND v(dout0_55) AT=695.025n

.meas tran vdout0_56ck1380 FIND v(dout0_56) AT=695.025n

.meas tran vdout0_57ck1380 FIND v(dout0_57) AT=695.025n

.meas tran vdout0_58ck1380 FIND v(dout0_58) AT=695.025n

.meas tran vdout0_59ck1380 FIND v(dout0_59) AT=695.025n

.meas tran vdout0_60ck1380 FIND v(dout0_60) AT=695.025n

.meas tran vdout0_61ck1380 FIND v(dout0_61) AT=695.025n

.meas tran vdout0_62ck1380 FIND v(dout0_62) AT=695.025n

.meas tran vdout0_63ck1380 FIND v(dout0_63) AT=695.025n

.meas tran vdout0_64ck1380 FIND v(dout0_64) AT=695.025n

.meas tran vdout0_65ck1380 FIND v(dout0_65) AT=695.025n

.meas tran vdout0_66ck1380 FIND v(dout0_66) AT=695.025n

.meas tran vdout0_67ck1380 FIND v(dout0_67) AT=695.025n

.meas tran vdout0_68ck1380 FIND v(dout0_68) AT=695.025n

.meas tran vdout0_69ck1380 FIND v(dout0_69) AT=695.025n

.meas tran vdout0_70ck1380 FIND v(dout0_70) AT=695.025n

.meas tran vdout0_71ck1380 FIND v(dout0_71) AT=695.025n

.meas tran vdout0_72ck1380 FIND v(dout0_72) AT=695.025n

.meas tran vdout0_73ck1380 FIND v(dout0_73) AT=695.025n

.meas tran vdout0_74ck1380 FIND v(dout0_74) AT=695.025n

.meas tran vdout0_75ck1380 FIND v(dout0_75) AT=695.025n

.meas tran vdout0_76ck1380 FIND v(dout0_76) AT=695.025n

.meas tran vdout0_77ck1380 FIND v(dout0_77) AT=695.025n

.meas tran vdout0_78ck1380 FIND v(dout0_78) AT=695.025n

.meas tran vdout0_79ck1380 FIND v(dout0_79) AT=695.025n

.meas tran vdout0_80ck1380 FIND v(dout0_80) AT=695.025n

.meas tran vdout0_81ck1380 FIND v(dout0_81) AT=695.025n

.meas tran vdout0_82ck1380 FIND v(dout0_82) AT=695.025n

.meas tran vdout0_83ck1380 FIND v(dout0_83) AT=695.025n

.meas tran vdout0_84ck1380 FIND v(dout0_84) AT=695.025n

.meas tran vdout0_85ck1380 FIND v(dout0_85) AT=695.025n

.meas tran vdout0_86ck1380 FIND v(dout0_86) AT=695.025n

.meas tran vdout0_87ck1380 FIND v(dout0_87) AT=695.025n

.meas tran vdout0_88ck1380 FIND v(dout0_88) AT=695.025n

.meas tran vdout0_89ck1380 FIND v(dout0_89) AT=695.025n

.meas tran vdout0_90ck1380 FIND v(dout0_90) AT=695.025n

.meas tran vdout0_91ck1380 FIND v(dout0_91) AT=695.025n

.meas tran vdout0_92ck1380 FIND v(dout0_92) AT=695.025n

.meas tran vdout0_93ck1380 FIND v(dout0_93) AT=695.025n

.meas tran vdout0_94ck1380 FIND v(dout0_94) AT=695.025n

.meas tran vdout0_95ck1380 FIND v(dout0_95) AT=695.025n

.meas tran vdout0_96ck1380 FIND v(dout0_96) AT=695.025n

.meas tran vdout0_97ck1380 FIND v(dout0_97) AT=695.025n

.meas tran vdout0_98ck1380 FIND v(dout0_98) AT=695.025n

.meas tran vdout0_99ck1380 FIND v(dout0_99) AT=695.025n

.meas tran vdout0_100ck1380 FIND v(dout0_100) AT=695.025n

.meas tran vdout0_101ck1380 FIND v(dout0_101) AT=695.025n

.meas tran vdout0_102ck1380 FIND v(dout0_102) AT=695.025n

.meas tran vdout0_103ck1380 FIND v(dout0_103) AT=695.025n

.meas tran vdout0_104ck1380 FIND v(dout0_104) AT=695.025n

.meas tran vdout0_105ck1380 FIND v(dout0_105) AT=695.025n

.meas tran vdout0_106ck1380 FIND v(dout0_106) AT=695.025n

.meas tran vdout0_107ck1380 FIND v(dout0_107) AT=695.025n

.meas tran vdout0_108ck1380 FIND v(dout0_108) AT=695.025n

.meas tran vdout0_109ck1380 FIND v(dout0_109) AT=695.025n

.meas tran vdout0_110ck1380 FIND v(dout0_110) AT=695.025n

.meas tran vdout0_111ck1380 FIND v(dout0_111) AT=695.025n

.meas tran vdout0_112ck1380 FIND v(dout0_112) AT=695.025n

.meas tran vdout0_113ck1380 FIND v(dout0_113) AT=695.025n

.meas tran vdout0_114ck1380 FIND v(dout0_114) AT=695.025n

.meas tran vdout0_115ck1380 FIND v(dout0_115) AT=695.025n

.meas tran vdout0_116ck1380 FIND v(dout0_116) AT=695.025n

.meas tran vdout0_117ck1380 FIND v(dout0_117) AT=695.025n

.meas tran vdout0_118ck1380 FIND v(dout0_118) AT=695.025n

.meas tran vdout0_119ck1380 FIND v(dout0_119) AT=695.025n

.meas tran vdout0_120ck1380 FIND v(dout0_120) AT=695.025n

.meas tran vdout0_121ck1380 FIND v(dout0_121) AT=695.025n

.meas tran vdout0_122ck1380 FIND v(dout0_122) AT=695.025n

.meas tran vdout0_123ck1380 FIND v(dout0_123) AT=695.025n

.meas tran vdout0_124ck1380 FIND v(dout0_124) AT=695.025n

.meas tran vdout0_125ck1380 FIND v(dout0_125) AT=695.025n

.meas tran vdout0_126ck1380 FIND v(dout0_126) AT=695.025n

.meas tran vdout0_127ck1380 FIND v(dout0_127) AT=695.025n

.meas tran vdout0_0ck1400 FIND v(dout0_0) AT=705.025n

.meas tran vdout0_1ck1400 FIND v(dout0_1) AT=705.025n

.meas tran vdout0_2ck1400 FIND v(dout0_2) AT=705.025n

.meas tran vdout0_3ck1400 FIND v(dout0_3) AT=705.025n

.meas tran vdout0_4ck1400 FIND v(dout0_4) AT=705.025n

.meas tran vdout0_5ck1400 FIND v(dout0_5) AT=705.025n

.meas tran vdout0_6ck1400 FIND v(dout0_6) AT=705.025n

.meas tran vdout0_7ck1400 FIND v(dout0_7) AT=705.025n

.meas tran vdout0_8ck1400 FIND v(dout0_8) AT=705.025n

.meas tran vdout0_9ck1400 FIND v(dout0_9) AT=705.025n

.meas tran vdout0_10ck1400 FIND v(dout0_10) AT=705.025n

.meas tran vdout0_11ck1400 FIND v(dout0_11) AT=705.025n

.meas tran vdout0_12ck1400 FIND v(dout0_12) AT=705.025n

.meas tran vdout0_13ck1400 FIND v(dout0_13) AT=705.025n

.meas tran vdout0_14ck1400 FIND v(dout0_14) AT=705.025n

.meas tran vdout0_15ck1400 FIND v(dout0_15) AT=705.025n

.meas tran vdout0_16ck1400 FIND v(dout0_16) AT=705.025n

.meas tran vdout0_17ck1400 FIND v(dout0_17) AT=705.025n

.meas tran vdout0_18ck1400 FIND v(dout0_18) AT=705.025n

.meas tran vdout0_19ck1400 FIND v(dout0_19) AT=705.025n

.meas tran vdout0_20ck1400 FIND v(dout0_20) AT=705.025n

.meas tran vdout0_21ck1400 FIND v(dout0_21) AT=705.025n

.meas tran vdout0_22ck1400 FIND v(dout0_22) AT=705.025n

.meas tran vdout0_23ck1400 FIND v(dout0_23) AT=705.025n

.meas tran vdout0_24ck1400 FIND v(dout0_24) AT=705.025n

.meas tran vdout0_25ck1400 FIND v(dout0_25) AT=705.025n

.meas tran vdout0_26ck1400 FIND v(dout0_26) AT=705.025n

.meas tran vdout0_27ck1400 FIND v(dout0_27) AT=705.025n

.meas tran vdout0_28ck1400 FIND v(dout0_28) AT=705.025n

.meas tran vdout0_29ck1400 FIND v(dout0_29) AT=705.025n

.meas tran vdout0_30ck1400 FIND v(dout0_30) AT=705.025n

.meas tran vdout0_31ck1400 FIND v(dout0_31) AT=705.025n

.meas tran vdout0_32ck1400 FIND v(dout0_32) AT=705.025n

.meas tran vdout0_33ck1400 FIND v(dout0_33) AT=705.025n

.meas tran vdout0_34ck1400 FIND v(dout0_34) AT=705.025n

.meas tran vdout0_35ck1400 FIND v(dout0_35) AT=705.025n

.meas tran vdout0_36ck1400 FIND v(dout0_36) AT=705.025n

.meas tran vdout0_37ck1400 FIND v(dout0_37) AT=705.025n

.meas tran vdout0_38ck1400 FIND v(dout0_38) AT=705.025n

.meas tran vdout0_39ck1400 FIND v(dout0_39) AT=705.025n

.meas tran vdout0_40ck1400 FIND v(dout0_40) AT=705.025n

.meas tran vdout0_41ck1400 FIND v(dout0_41) AT=705.025n

.meas tran vdout0_42ck1400 FIND v(dout0_42) AT=705.025n

.meas tran vdout0_43ck1400 FIND v(dout0_43) AT=705.025n

.meas tran vdout0_44ck1400 FIND v(dout0_44) AT=705.025n

.meas tran vdout0_45ck1400 FIND v(dout0_45) AT=705.025n

.meas tran vdout0_46ck1400 FIND v(dout0_46) AT=705.025n

.meas tran vdout0_47ck1400 FIND v(dout0_47) AT=705.025n

.meas tran vdout0_48ck1400 FIND v(dout0_48) AT=705.025n

.meas tran vdout0_49ck1400 FIND v(dout0_49) AT=705.025n

.meas tran vdout0_50ck1400 FIND v(dout0_50) AT=705.025n

.meas tran vdout0_51ck1400 FIND v(dout0_51) AT=705.025n

.meas tran vdout0_52ck1400 FIND v(dout0_52) AT=705.025n

.meas tran vdout0_53ck1400 FIND v(dout0_53) AT=705.025n

.meas tran vdout0_54ck1400 FIND v(dout0_54) AT=705.025n

.meas tran vdout0_55ck1400 FIND v(dout0_55) AT=705.025n

.meas tran vdout0_56ck1400 FIND v(dout0_56) AT=705.025n

.meas tran vdout0_57ck1400 FIND v(dout0_57) AT=705.025n

.meas tran vdout0_58ck1400 FIND v(dout0_58) AT=705.025n

.meas tran vdout0_59ck1400 FIND v(dout0_59) AT=705.025n

.meas tran vdout0_60ck1400 FIND v(dout0_60) AT=705.025n

.meas tran vdout0_61ck1400 FIND v(dout0_61) AT=705.025n

.meas tran vdout0_62ck1400 FIND v(dout0_62) AT=705.025n

.meas tran vdout0_63ck1400 FIND v(dout0_63) AT=705.025n

.meas tran vdout0_64ck1400 FIND v(dout0_64) AT=705.025n

.meas tran vdout0_65ck1400 FIND v(dout0_65) AT=705.025n

.meas tran vdout0_66ck1400 FIND v(dout0_66) AT=705.025n

.meas tran vdout0_67ck1400 FIND v(dout0_67) AT=705.025n

.meas tran vdout0_68ck1400 FIND v(dout0_68) AT=705.025n

.meas tran vdout0_69ck1400 FIND v(dout0_69) AT=705.025n

.meas tran vdout0_70ck1400 FIND v(dout0_70) AT=705.025n

.meas tran vdout0_71ck1400 FIND v(dout0_71) AT=705.025n

.meas tran vdout0_72ck1400 FIND v(dout0_72) AT=705.025n

.meas tran vdout0_73ck1400 FIND v(dout0_73) AT=705.025n

.meas tran vdout0_74ck1400 FIND v(dout0_74) AT=705.025n

.meas tran vdout0_75ck1400 FIND v(dout0_75) AT=705.025n

.meas tran vdout0_76ck1400 FIND v(dout0_76) AT=705.025n

.meas tran vdout0_77ck1400 FIND v(dout0_77) AT=705.025n

.meas tran vdout0_78ck1400 FIND v(dout0_78) AT=705.025n

.meas tran vdout0_79ck1400 FIND v(dout0_79) AT=705.025n

.meas tran vdout0_80ck1400 FIND v(dout0_80) AT=705.025n

.meas tran vdout0_81ck1400 FIND v(dout0_81) AT=705.025n

.meas tran vdout0_82ck1400 FIND v(dout0_82) AT=705.025n

.meas tran vdout0_83ck1400 FIND v(dout0_83) AT=705.025n

.meas tran vdout0_84ck1400 FIND v(dout0_84) AT=705.025n

.meas tran vdout0_85ck1400 FIND v(dout0_85) AT=705.025n

.meas tran vdout0_86ck1400 FIND v(dout0_86) AT=705.025n

.meas tran vdout0_87ck1400 FIND v(dout0_87) AT=705.025n

.meas tran vdout0_88ck1400 FIND v(dout0_88) AT=705.025n

.meas tran vdout0_89ck1400 FIND v(dout0_89) AT=705.025n

.meas tran vdout0_90ck1400 FIND v(dout0_90) AT=705.025n

.meas tran vdout0_91ck1400 FIND v(dout0_91) AT=705.025n

.meas tran vdout0_92ck1400 FIND v(dout0_92) AT=705.025n

.meas tran vdout0_93ck1400 FIND v(dout0_93) AT=705.025n

.meas tran vdout0_94ck1400 FIND v(dout0_94) AT=705.025n

.meas tran vdout0_95ck1400 FIND v(dout0_95) AT=705.025n

.meas tran vdout0_96ck1400 FIND v(dout0_96) AT=705.025n

.meas tran vdout0_97ck1400 FIND v(dout0_97) AT=705.025n

.meas tran vdout0_98ck1400 FIND v(dout0_98) AT=705.025n

.meas tran vdout0_99ck1400 FIND v(dout0_99) AT=705.025n

.meas tran vdout0_100ck1400 FIND v(dout0_100) AT=705.025n

.meas tran vdout0_101ck1400 FIND v(dout0_101) AT=705.025n

.meas tran vdout0_102ck1400 FIND v(dout0_102) AT=705.025n

.meas tran vdout0_103ck1400 FIND v(dout0_103) AT=705.025n

.meas tran vdout0_104ck1400 FIND v(dout0_104) AT=705.025n

.meas tran vdout0_105ck1400 FIND v(dout0_105) AT=705.025n

.meas tran vdout0_106ck1400 FIND v(dout0_106) AT=705.025n

.meas tran vdout0_107ck1400 FIND v(dout0_107) AT=705.025n

.meas tran vdout0_108ck1400 FIND v(dout0_108) AT=705.025n

.meas tran vdout0_109ck1400 FIND v(dout0_109) AT=705.025n

.meas tran vdout0_110ck1400 FIND v(dout0_110) AT=705.025n

.meas tran vdout0_111ck1400 FIND v(dout0_111) AT=705.025n

.meas tran vdout0_112ck1400 FIND v(dout0_112) AT=705.025n

.meas tran vdout0_113ck1400 FIND v(dout0_113) AT=705.025n

.meas tran vdout0_114ck1400 FIND v(dout0_114) AT=705.025n

.meas tran vdout0_115ck1400 FIND v(dout0_115) AT=705.025n

.meas tran vdout0_116ck1400 FIND v(dout0_116) AT=705.025n

.meas tran vdout0_117ck1400 FIND v(dout0_117) AT=705.025n

.meas tran vdout0_118ck1400 FIND v(dout0_118) AT=705.025n

.meas tran vdout0_119ck1400 FIND v(dout0_119) AT=705.025n

.meas tran vdout0_120ck1400 FIND v(dout0_120) AT=705.025n

.meas tran vdout0_121ck1400 FIND v(dout0_121) AT=705.025n

.meas tran vdout0_122ck1400 FIND v(dout0_122) AT=705.025n

.meas tran vdout0_123ck1400 FIND v(dout0_123) AT=705.025n

.meas tran vdout0_124ck1400 FIND v(dout0_124) AT=705.025n

.meas tran vdout0_125ck1400 FIND v(dout0_125) AT=705.025n

.meas tran vdout0_126ck1400 FIND v(dout0_126) AT=705.025n

.meas tran vdout0_127ck1400 FIND v(dout0_127) AT=705.025n

.meas tran vdout0_0ck1410 FIND v(dout0_0) AT=710.025n

.meas tran vdout0_1ck1410 FIND v(dout0_1) AT=710.025n

.meas tran vdout0_2ck1410 FIND v(dout0_2) AT=710.025n

.meas tran vdout0_3ck1410 FIND v(dout0_3) AT=710.025n

.meas tran vdout0_4ck1410 FIND v(dout0_4) AT=710.025n

.meas tran vdout0_5ck1410 FIND v(dout0_5) AT=710.025n

.meas tran vdout0_6ck1410 FIND v(dout0_6) AT=710.025n

.meas tran vdout0_7ck1410 FIND v(dout0_7) AT=710.025n

.meas tran vdout0_8ck1410 FIND v(dout0_8) AT=710.025n

.meas tran vdout0_9ck1410 FIND v(dout0_9) AT=710.025n

.meas tran vdout0_10ck1410 FIND v(dout0_10) AT=710.025n

.meas tran vdout0_11ck1410 FIND v(dout0_11) AT=710.025n

.meas tran vdout0_12ck1410 FIND v(dout0_12) AT=710.025n

.meas tran vdout0_13ck1410 FIND v(dout0_13) AT=710.025n

.meas tran vdout0_14ck1410 FIND v(dout0_14) AT=710.025n

.meas tran vdout0_15ck1410 FIND v(dout0_15) AT=710.025n

.meas tran vdout0_16ck1410 FIND v(dout0_16) AT=710.025n

.meas tran vdout0_17ck1410 FIND v(dout0_17) AT=710.025n

.meas tran vdout0_18ck1410 FIND v(dout0_18) AT=710.025n

.meas tran vdout0_19ck1410 FIND v(dout0_19) AT=710.025n

.meas tran vdout0_20ck1410 FIND v(dout0_20) AT=710.025n

.meas tran vdout0_21ck1410 FIND v(dout0_21) AT=710.025n

.meas tran vdout0_22ck1410 FIND v(dout0_22) AT=710.025n

.meas tran vdout0_23ck1410 FIND v(dout0_23) AT=710.025n

.meas tran vdout0_24ck1410 FIND v(dout0_24) AT=710.025n

.meas tran vdout0_25ck1410 FIND v(dout0_25) AT=710.025n

.meas tran vdout0_26ck1410 FIND v(dout0_26) AT=710.025n

.meas tran vdout0_27ck1410 FIND v(dout0_27) AT=710.025n

.meas tran vdout0_28ck1410 FIND v(dout0_28) AT=710.025n

.meas tran vdout0_29ck1410 FIND v(dout0_29) AT=710.025n

.meas tran vdout0_30ck1410 FIND v(dout0_30) AT=710.025n

.meas tran vdout0_31ck1410 FIND v(dout0_31) AT=710.025n

.meas tran vdout0_32ck1410 FIND v(dout0_32) AT=710.025n

.meas tran vdout0_33ck1410 FIND v(dout0_33) AT=710.025n

.meas tran vdout0_34ck1410 FIND v(dout0_34) AT=710.025n

.meas tran vdout0_35ck1410 FIND v(dout0_35) AT=710.025n

.meas tran vdout0_36ck1410 FIND v(dout0_36) AT=710.025n

.meas tran vdout0_37ck1410 FIND v(dout0_37) AT=710.025n

.meas tran vdout0_38ck1410 FIND v(dout0_38) AT=710.025n

.meas tran vdout0_39ck1410 FIND v(dout0_39) AT=710.025n

.meas tran vdout0_40ck1410 FIND v(dout0_40) AT=710.025n

.meas tran vdout0_41ck1410 FIND v(dout0_41) AT=710.025n

.meas tran vdout0_42ck1410 FIND v(dout0_42) AT=710.025n

.meas tran vdout0_43ck1410 FIND v(dout0_43) AT=710.025n

.meas tran vdout0_44ck1410 FIND v(dout0_44) AT=710.025n

.meas tran vdout0_45ck1410 FIND v(dout0_45) AT=710.025n

.meas tran vdout0_46ck1410 FIND v(dout0_46) AT=710.025n

.meas tran vdout0_47ck1410 FIND v(dout0_47) AT=710.025n

.meas tran vdout0_48ck1410 FIND v(dout0_48) AT=710.025n

.meas tran vdout0_49ck1410 FIND v(dout0_49) AT=710.025n

.meas tran vdout0_50ck1410 FIND v(dout0_50) AT=710.025n

.meas tran vdout0_51ck1410 FIND v(dout0_51) AT=710.025n

.meas tran vdout0_52ck1410 FIND v(dout0_52) AT=710.025n

.meas tran vdout0_53ck1410 FIND v(dout0_53) AT=710.025n

.meas tran vdout0_54ck1410 FIND v(dout0_54) AT=710.025n

.meas tran vdout0_55ck1410 FIND v(dout0_55) AT=710.025n

.meas tran vdout0_56ck1410 FIND v(dout0_56) AT=710.025n

.meas tran vdout0_57ck1410 FIND v(dout0_57) AT=710.025n

.meas tran vdout0_58ck1410 FIND v(dout0_58) AT=710.025n

.meas tran vdout0_59ck1410 FIND v(dout0_59) AT=710.025n

.meas tran vdout0_60ck1410 FIND v(dout0_60) AT=710.025n

.meas tran vdout0_61ck1410 FIND v(dout0_61) AT=710.025n

.meas tran vdout0_62ck1410 FIND v(dout0_62) AT=710.025n

.meas tran vdout0_63ck1410 FIND v(dout0_63) AT=710.025n

.meas tran vdout0_64ck1410 FIND v(dout0_64) AT=710.025n

.meas tran vdout0_65ck1410 FIND v(dout0_65) AT=710.025n

.meas tran vdout0_66ck1410 FIND v(dout0_66) AT=710.025n

.meas tran vdout0_67ck1410 FIND v(dout0_67) AT=710.025n

.meas tran vdout0_68ck1410 FIND v(dout0_68) AT=710.025n

.meas tran vdout0_69ck1410 FIND v(dout0_69) AT=710.025n

.meas tran vdout0_70ck1410 FIND v(dout0_70) AT=710.025n

.meas tran vdout0_71ck1410 FIND v(dout0_71) AT=710.025n

.meas tran vdout0_72ck1410 FIND v(dout0_72) AT=710.025n

.meas tran vdout0_73ck1410 FIND v(dout0_73) AT=710.025n

.meas tran vdout0_74ck1410 FIND v(dout0_74) AT=710.025n

.meas tran vdout0_75ck1410 FIND v(dout0_75) AT=710.025n

.meas tran vdout0_76ck1410 FIND v(dout0_76) AT=710.025n

.meas tran vdout0_77ck1410 FIND v(dout0_77) AT=710.025n

.meas tran vdout0_78ck1410 FIND v(dout0_78) AT=710.025n

.meas tran vdout0_79ck1410 FIND v(dout0_79) AT=710.025n

.meas tran vdout0_80ck1410 FIND v(dout0_80) AT=710.025n

.meas tran vdout0_81ck1410 FIND v(dout0_81) AT=710.025n

.meas tran vdout0_82ck1410 FIND v(dout0_82) AT=710.025n

.meas tran vdout0_83ck1410 FIND v(dout0_83) AT=710.025n

.meas tran vdout0_84ck1410 FIND v(dout0_84) AT=710.025n

.meas tran vdout0_85ck1410 FIND v(dout0_85) AT=710.025n

.meas tran vdout0_86ck1410 FIND v(dout0_86) AT=710.025n

.meas tran vdout0_87ck1410 FIND v(dout0_87) AT=710.025n

.meas tran vdout0_88ck1410 FIND v(dout0_88) AT=710.025n

.meas tran vdout0_89ck1410 FIND v(dout0_89) AT=710.025n

.meas tran vdout0_90ck1410 FIND v(dout0_90) AT=710.025n

.meas tran vdout0_91ck1410 FIND v(dout0_91) AT=710.025n

.meas tran vdout0_92ck1410 FIND v(dout0_92) AT=710.025n

.meas tran vdout0_93ck1410 FIND v(dout0_93) AT=710.025n

.meas tran vdout0_94ck1410 FIND v(dout0_94) AT=710.025n

.meas tran vdout0_95ck1410 FIND v(dout0_95) AT=710.025n

.meas tran vdout0_96ck1410 FIND v(dout0_96) AT=710.025n

.meas tran vdout0_97ck1410 FIND v(dout0_97) AT=710.025n

.meas tran vdout0_98ck1410 FIND v(dout0_98) AT=710.025n

.meas tran vdout0_99ck1410 FIND v(dout0_99) AT=710.025n

.meas tran vdout0_100ck1410 FIND v(dout0_100) AT=710.025n

.meas tran vdout0_101ck1410 FIND v(dout0_101) AT=710.025n

.meas tran vdout0_102ck1410 FIND v(dout0_102) AT=710.025n

.meas tran vdout0_103ck1410 FIND v(dout0_103) AT=710.025n

.meas tran vdout0_104ck1410 FIND v(dout0_104) AT=710.025n

.meas tran vdout0_105ck1410 FIND v(dout0_105) AT=710.025n

.meas tran vdout0_106ck1410 FIND v(dout0_106) AT=710.025n

.meas tran vdout0_107ck1410 FIND v(dout0_107) AT=710.025n

.meas tran vdout0_108ck1410 FIND v(dout0_108) AT=710.025n

.meas tran vdout0_109ck1410 FIND v(dout0_109) AT=710.025n

.meas tran vdout0_110ck1410 FIND v(dout0_110) AT=710.025n

.meas tran vdout0_111ck1410 FIND v(dout0_111) AT=710.025n

.meas tran vdout0_112ck1410 FIND v(dout0_112) AT=710.025n

.meas tran vdout0_113ck1410 FIND v(dout0_113) AT=710.025n

.meas tran vdout0_114ck1410 FIND v(dout0_114) AT=710.025n

.meas tran vdout0_115ck1410 FIND v(dout0_115) AT=710.025n

.meas tran vdout0_116ck1410 FIND v(dout0_116) AT=710.025n

.meas tran vdout0_117ck1410 FIND v(dout0_117) AT=710.025n

.meas tran vdout0_118ck1410 FIND v(dout0_118) AT=710.025n

.meas tran vdout0_119ck1410 FIND v(dout0_119) AT=710.025n

.meas tran vdout0_120ck1410 FIND v(dout0_120) AT=710.025n

.meas tran vdout0_121ck1410 FIND v(dout0_121) AT=710.025n

.meas tran vdout0_122ck1410 FIND v(dout0_122) AT=710.025n

.meas tran vdout0_123ck1410 FIND v(dout0_123) AT=710.025n

.meas tran vdout0_124ck1410 FIND v(dout0_124) AT=710.025n

.meas tran vdout0_125ck1410 FIND v(dout0_125) AT=710.025n

.meas tran vdout0_126ck1410 FIND v(dout0_126) AT=710.025n

.meas tran vdout0_127ck1410 FIND v(dout0_127) AT=710.025n

.meas tran vdout0_0ck1430 FIND v(dout0_0) AT=720.025n

.meas tran vdout0_1ck1430 FIND v(dout0_1) AT=720.025n

.meas tran vdout0_2ck1430 FIND v(dout0_2) AT=720.025n

.meas tran vdout0_3ck1430 FIND v(dout0_3) AT=720.025n

.meas tran vdout0_4ck1430 FIND v(dout0_4) AT=720.025n

.meas tran vdout0_5ck1430 FIND v(dout0_5) AT=720.025n

.meas tran vdout0_6ck1430 FIND v(dout0_6) AT=720.025n

.meas tran vdout0_7ck1430 FIND v(dout0_7) AT=720.025n

.meas tran vdout0_8ck1430 FIND v(dout0_8) AT=720.025n

.meas tran vdout0_9ck1430 FIND v(dout0_9) AT=720.025n

.meas tran vdout0_10ck1430 FIND v(dout0_10) AT=720.025n

.meas tran vdout0_11ck1430 FIND v(dout0_11) AT=720.025n

.meas tran vdout0_12ck1430 FIND v(dout0_12) AT=720.025n

.meas tran vdout0_13ck1430 FIND v(dout0_13) AT=720.025n

.meas tran vdout0_14ck1430 FIND v(dout0_14) AT=720.025n

.meas tran vdout0_15ck1430 FIND v(dout0_15) AT=720.025n

.meas tran vdout0_16ck1430 FIND v(dout0_16) AT=720.025n

.meas tran vdout0_17ck1430 FIND v(dout0_17) AT=720.025n

.meas tran vdout0_18ck1430 FIND v(dout0_18) AT=720.025n

.meas tran vdout0_19ck1430 FIND v(dout0_19) AT=720.025n

.meas tran vdout0_20ck1430 FIND v(dout0_20) AT=720.025n

.meas tran vdout0_21ck1430 FIND v(dout0_21) AT=720.025n

.meas tran vdout0_22ck1430 FIND v(dout0_22) AT=720.025n

.meas tran vdout0_23ck1430 FIND v(dout0_23) AT=720.025n

.meas tran vdout0_24ck1430 FIND v(dout0_24) AT=720.025n

.meas tran vdout0_25ck1430 FIND v(dout0_25) AT=720.025n

.meas tran vdout0_26ck1430 FIND v(dout0_26) AT=720.025n

.meas tran vdout0_27ck1430 FIND v(dout0_27) AT=720.025n

.meas tran vdout0_28ck1430 FIND v(dout0_28) AT=720.025n

.meas tran vdout0_29ck1430 FIND v(dout0_29) AT=720.025n

.meas tran vdout0_30ck1430 FIND v(dout0_30) AT=720.025n

.meas tran vdout0_31ck1430 FIND v(dout0_31) AT=720.025n

.meas tran vdout0_32ck1430 FIND v(dout0_32) AT=720.025n

.meas tran vdout0_33ck1430 FIND v(dout0_33) AT=720.025n

.meas tran vdout0_34ck1430 FIND v(dout0_34) AT=720.025n

.meas tran vdout0_35ck1430 FIND v(dout0_35) AT=720.025n

.meas tran vdout0_36ck1430 FIND v(dout0_36) AT=720.025n

.meas tran vdout0_37ck1430 FIND v(dout0_37) AT=720.025n

.meas tran vdout0_38ck1430 FIND v(dout0_38) AT=720.025n

.meas tran vdout0_39ck1430 FIND v(dout0_39) AT=720.025n

.meas tran vdout0_40ck1430 FIND v(dout0_40) AT=720.025n

.meas tran vdout0_41ck1430 FIND v(dout0_41) AT=720.025n

.meas tran vdout0_42ck1430 FIND v(dout0_42) AT=720.025n

.meas tran vdout0_43ck1430 FIND v(dout0_43) AT=720.025n

.meas tran vdout0_44ck1430 FIND v(dout0_44) AT=720.025n

.meas tran vdout0_45ck1430 FIND v(dout0_45) AT=720.025n

.meas tran vdout0_46ck1430 FIND v(dout0_46) AT=720.025n

.meas tran vdout0_47ck1430 FIND v(dout0_47) AT=720.025n

.meas tran vdout0_48ck1430 FIND v(dout0_48) AT=720.025n

.meas tran vdout0_49ck1430 FIND v(dout0_49) AT=720.025n

.meas tran vdout0_50ck1430 FIND v(dout0_50) AT=720.025n

.meas tran vdout0_51ck1430 FIND v(dout0_51) AT=720.025n

.meas tran vdout0_52ck1430 FIND v(dout0_52) AT=720.025n

.meas tran vdout0_53ck1430 FIND v(dout0_53) AT=720.025n

.meas tran vdout0_54ck1430 FIND v(dout0_54) AT=720.025n

.meas tran vdout0_55ck1430 FIND v(dout0_55) AT=720.025n

.meas tran vdout0_56ck1430 FIND v(dout0_56) AT=720.025n

.meas tran vdout0_57ck1430 FIND v(dout0_57) AT=720.025n

.meas tran vdout0_58ck1430 FIND v(dout0_58) AT=720.025n

.meas tran vdout0_59ck1430 FIND v(dout0_59) AT=720.025n

.meas tran vdout0_60ck1430 FIND v(dout0_60) AT=720.025n

.meas tran vdout0_61ck1430 FIND v(dout0_61) AT=720.025n

.meas tran vdout0_62ck1430 FIND v(dout0_62) AT=720.025n

.meas tran vdout0_63ck1430 FIND v(dout0_63) AT=720.025n

.meas tran vdout0_64ck1430 FIND v(dout0_64) AT=720.025n

.meas tran vdout0_65ck1430 FIND v(dout0_65) AT=720.025n

.meas tran vdout0_66ck1430 FIND v(dout0_66) AT=720.025n

.meas tran vdout0_67ck1430 FIND v(dout0_67) AT=720.025n

.meas tran vdout0_68ck1430 FIND v(dout0_68) AT=720.025n

.meas tran vdout0_69ck1430 FIND v(dout0_69) AT=720.025n

.meas tran vdout0_70ck1430 FIND v(dout0_70) AT=720.025n

.meas tran vdout0_71ck1430 FIND v(dout0_71) AT=720.025n

.meas tran vdout0_72ck1430 FIND v(dout0_72) AT=720.025n

.meas tran vdout0_73ck1430 FIND v(dout0_73) AT=720.025n

.meas tran vdout0_74ck1430 FIND v(dout0_74) AT=720.025n

.meas tran vdout0_75ck1430 FIND v(dout0_75) AT=720.025n

.meas tran vdout0_76ck1430 FIND v(dout0_76) AT=720.025n

.meas tran vdout0_77ck1430 FIND v(dout0_77) AT=720.025n

.meas tran vdout0_78ck1430 FIND v(dout0_78) AT=720.025n

.meas tran vdout0_79ck1430 FIND v(dout0_79) AT=720.025n

.meas tran vdout0_80ck1430 FIND v(dout0_80) AT=720.025n

.meas tran vdout0_81ck1430 FIND v(dout0_81) AT=720.025n

.meas tran vdout0_82ck1430 FIND v(dout0_82) AT=720.025n

.meas tran vdout0_83ck1430 FIND v(dout0_83) AT=720.025n

.meas tran vdout0_84ck1430 FIND v(dout0_84) AT=720.025n

.meas tran vdout0_85ck1430 FIND v(dout0_85) AT=720.025n

.meas tran vdout0_86ck1430 FIND v(dout0_86) AT=720.025n

.meas tran vdout0_87ck1430 FIND v(dout0_87) AT=720.025n

.meas tran vdout0_88ck1430 FIND v(dout0_88) AT=720.025n

.meas tran vdout0_89ck1430 FIND v(dout0_89) AT=720.025n

.meas tran vdout0_90ck1430 FIND v(dout0_90) AT=720.025n

.meas tran vdout0_91ck1430 FIND v(dout0_91) AT=720.025n

.meas tran vdout0_92ck1430 FIND v(dout0_92) AT=720.025n

.meas tran vdout0_93ck1430 FIND v(dout0_93) AT=720.025n

.meas tran vdout0_94ck1430 FIND v(dout0_94) AT=720.025n

.meas tran vdout0_95ck1430 FIND v(dout0_95) AT=720.025n

.meas tran vdout0_96ck1430 FIND v(dout0_96) AT=720.025n

.meas tran vdout0_97ck1430 FIND v(dout0_97) AT=720.025n

.meas tran vdout0_98ck1430 FIND v(dout0_98) AT=720.025n

.meas tran vdout0_99ck1430 FIND v(dout0_99) AT=720.025n

.meas tran vdout0_100ck1430 FIND v(dout0_100) AT=720.025n

.meas tran vdout0_101ck1430 FIND v(dout0_101) AT=720.025n

.meas tran vdout0_102ck1430 FIND v(dout0_102) AT=720.025n

.meas tran vdout0_103ck1430 FIND v(dout0_103) AT=720.025n

.meas tran vdout0_104ck1430 FIND v(dout0_104) AT=720.025n

.meas tran vdout0_105ck1430 FIND v(dout0_105) AT=720.025n

.meas tran vdout0_106ck1430 FIND v(dout0_106) AT=720.025n

.meas tran vdout0_107ck1430 FIND v(dout0_107) AT=720.025n

.meas tran vdout0_108ck1430 FIND v(dout0_108) AT=720.025n

.meas tran vdout0_109ck1430 FIND v(dout0_109) AT=720.025n

.meas tran vdout0_110ck1430 FIND v(dout0_110) AT=720.025n

.meas tran vdout0_111ck1430 FIND v(dout0_111) AT=720.025n

.meas tran vdout0_112ck1430 FIND v(dout0_112) AT=720.025n

.meas tran vdout0_113ck1430 FIND v(dout0_113) AT=720.025n

.meas tran vdout0_114ck1430 FIND v(dout0_114) AT=720.025n

.meas tran vdout0_115ck1430 FIND v(dout0_115) AT=720.025n

.meas tran vdout0_116ck1430 FIND v(dout0_116) AT=720.025n

.meas tran vdout0_117ck1430 FIND v(dout0_117) AT=720.025n

.meas tran vdout0_118ck1430 FIND v(dout0_118) AT=720.025n

.meas tran vdout0_119ck1430 FIND v(dout0_119) AT=720.025n

.meas tran vdout0_120ck1430 FIND v(dout0_120) AT=720.025n

.meas tran vdout0_121ck1430 FIND v(dout0_121) AT=720.025n

.meas tran vdout0_122ck1430 FIND v(dout0_122) AT=720.025n

.meas tran vdout0_123ck1430 FIND v(dout0_123) AT=720.025n

.meas tran vdout0_124ck1430 FIND v(dout0_124) AT=720.025n

.meas tran vdout0_125ck1430 FIND v(dout0_125) AT=720.025n

.meas tran vdout0_126ck1430 FIND v(dout0_126) AT=720.025n

.meas tran vdout0_127ck1430 FIND v(dout0_127) AT=720.025n

.meas tran vdout0_0ck1440 FIND v(dout0_0) AT=725.025n

.meas tran vdout0_1ck1440 FIND v(dout0_1) AT=725.025n

.meas tran vdout0_2ck1440 FIND v(dout0_2) AT=725.025n

.meas tran vdout0_3ck1440 FIND v(dout0_3) AT=725.025n

.meas tran vdout0_4ck1440 FIND v(dout0_4) AT=725.025n

.meas tran vdout0_5ck1440 FIND v(dout0_5) AT=725.025n

.meas tran vdout0_6ck1440 FIND v(dout0_6) AT=725.025n

.meas tran vdout0_7ck1440 FIND v(dout0_7) AT=725.025n

.meas tran vdout0_8ck1440 FIND v(dout0_8) AT=725.025n

.meas tran vdout0_9ck1440 FIND v(dout0_9) AT=725.025n

.meas tran vdout0_10ck1440 FIND v(dout0_10) AT=725.025n

.meas tran vdout0_11ck1440 FIND v(dout0_11) AT=725.025n

.meas tran vdout0_12ck1440 FIND v(dout0_12) AT=725.025n

.meas tran vdout0_13ck1440 FIND v(dout0_13) AT=725.025n

.meas tran vdout0_14ck1440 FIND v(dout0_14) AT=725.025n

.meas tran vdout0_15ck1440 FIND v(dout0_15) AT=725.025n

.meas tran vdout0_16ck1440 FIND v(dout0_16) AT=725.025n

.meas tran vdout0_17ck1440 FIND v(dout0_17) AT=725.025n

.meas tran vdout0_18ck1440 FIND v(dout0_18) AT=725.025n

.meas tran vdout0_19ck1440 FIND v(dout0_19) AT=725.025n

.meas tran vdout0_20ck1440 FIND v(dout0_20) AT=725.025n

.meas tran vdout0_21ck1440 FIND v(dout0_21) AT=725.025n

.meas tran vdout0_22ck1440 FIND v(dout0_22) AT=725.025n

.meas tran vdout0_23ck1440 FIND v(dout0_23) AT=725.025n

.meas tran vdout0_24ck1440 FIND v(dout0_24) AT=725.025n

.meas tran vdout0_25ck1440 FIND v(dout0_25) AT=725.025n

.meas tran vdout0_26ck1440 FIND v(dout0_26) AT=725.025n

.meas tran vdout0_27ck1440 FIND v(dout0_27) AT=725.025n

.meas tran vdout0_28ck1440 FIND v(dout0_28) AT=725.025n

.meas tran vdout0_29ck1440 FIND v(dout0_29) AT=725.025n

.meas tran vdout0_30ck1440 FIND v(dout0_30) AT=725.025n

.meas tran vdout0_31ck1440 FIND v(dout0_31) AT=725.025n

.meas tran vdout0_32ck1440 FIND v(dout0_32) AT=725.025n

.meas tran vdout0_33ck1440 FIND v(dout0_33) AT=725.025n

.meas tran vdout0_34ck1440 FIND v(dout0_34) AT=725.025n

.meas tran vdout0_35ck1440 FIND v(dout0_35) AT=725.025n

.meas tran vdout0_36ck1440 FIND v(dout0_36) AT=725.025n

.meas tran vdout0_37ck1440 FIND v(dout0_37) AT=725.025n

.meas tran vdout0_38ck1440 FIND v(dout0_38) AT=725.025n

.meas tran vdout0_39ck1440 FIND v(dout0_39) AT=725.025n

.meas tran vdout0_40ck1440 FIND v(dout0_40) AT=725.025n

.meas tran vdout0_41ck1440 FIND v(dout0_41) AT=725.025n

.meas tran vdout0_42ck1440 FIND v(dout0_42) AT=725.025n

.meas tran vdout0_43ck1440 FIND v(dout0_43) AT=725.025n

.meas tran vdout0_44ck1440 FIND v(dout0_44) AT=725.025n

.meas tran vdout0_45ck1440 FIND v(dout0_45) AT=725.025n

.meas tran vdout0_46ck1440 FIND v(dout0_46) AT=725.025n

.meas tran vdout0_47ck1440 FIND v(dout0_47) AT=725.025n

.meas tran vdout0_48ck1440 FIND v(dout0_48) AT=725.025n

.meas tran vdout0_49ck1440 FIND v(dout0_49) AT=725.025n

.meas tran vdout0_50ck1440 FIND v(dout0_50) AT=725.025n

.meas tran vdout0_51ck1440 FIND v(dout0_51) AT=725.025n

.meas tran vdout0_52ck1440 FIND v(dout0_52) AT=725.025n

.meas tran vdout0_53ck1440 FIND v(dout0_53) AT=725.025n

.meas tran vdout0_54ck1440 FIND v(dout0_54) AT=725.025n

.meas tran vdout0_55ck1440 FIND v(dout0_55) AT=725.025n

.meas tran vdout0_56ck1440 FIND v(dout0_56) AT=725.025n

.meas tran vdout0_57ck1440 FIND v(dout0_57) AT=725.025n

.meas tran vdout0_58ck1440 FIND v(dout0_58) AT=725.025n

.meas tran vdout0_59ck1440 FIND v(dout0_59) AT=725.025n

.meas tran vdout0_60ck1440 FIND v(dout0_60) AT=725.025n

.meas tran vdout0_61ck1440 FIND v(dout0_61) AT=725.025n

.meas tran vdout0_62ck1440 FIND v(dout0_62) AT=725.025n

.meas tran vdout0_63ck1440 FIND v(dout0_63) AT=725.025n

.meas tran vdout0_64ck1440 FIND v(dout0_64) AT=725.025n

.meas tran vdout0_65ck1440 FIND v(dout0_65) AT=725.025n

.meas tran vdout0_66ck1440 FIND v(dout0_66) AT=725.025n

.meas tran vdout0_67ck1440 FIND v(dout0_67) AT=725.025n

.meas tran vdout0_68ck1440 FIND v(dout0_68) AT=725.025n

.meas tran vdout0_69ck1440 FIND v(dout0_69) AT=725.025n

.meas tran vdout0_70ck1440 FIND v(dout0_70) AT=725.025n

.meas tran vdout0_71ck1440 FIND v(dout0_71) AT=725.025n

.meas tran vdout0_72ck1440 FIND v(dout0_72) AT=725.025n

.meas tran vdout0_73ck1440 FIND v(dout0_73) AT=725.025n

.meas tran vdout0_74ck1440 FIND v(dout0_74) AT=725.025n

.meas tran vdout0_75ck1440 FIND v(dout0_75) AT=725.025n

.meas tran vdout0_76ck1440 FIND v(dout0_76) AT=725.025n

.meas tran vdout0_77ck1440 FIND v(dout0_77) AT=725.025n

.meas tran vdout0_78ck1440 FIND v(dout0_78) AT=725.025n

.meas tran vdout0_79ck1440 FIND v(dout0_79) AT=725.025n

.meas tran vdout0_80ck1440 FIND v(dout0_80) AT=725.025n

.meas tran vdout0_81ck1440 FIND v(dout0_81) AT=725.025n

.meas tran vdout0_82ck1440 FIND v(dout0_82) AT=725.025n

.meas tran vdout0_83ck1440 FIND v(dout0_83) AT=725.025n

.meas tran vdout0_84ck1440 FIND v(dout0_84) AT=725.025n

.meas tran vdout0_85ck1440 FIND v(dout0_85) AT=725.025n

.meas tran vdout0_86ck1440 FIND v(dout0_86) AT=725.025n

.meas tran vdout0_87ck1440 FIND v(dout0_87) AT=725.025n

.meas tran vdout0_88ck1440 FIND v(dout0_88) AT=725.025n

.meas tran vdout0_89ck1440 FIND v(dout0_89) AT=725.025n

.meas tran vdout0_90ck1440 FIND v(dout0_90) AT=725.025n

.meas tran vdout0_91ck1440 FIND v(dout0_91) AT=725.025n

.meas tran vdout0_92ck1440 FIND v(dout0_92) AT=725.025n

.meas tran vdout0_93ck1440 FIND v(dout0_93) AT=725.025n

.meas tran vdout0_94ck1440 FIND v(dout0_94) AT=725.025n

.meas tran vdout0_95ck1440 FIND v(dout0_95) AT=725.025n

.meas tran vdout0_96ck1440 FIND v(dout0_96) AT=725.025n

.meas tran vdout0_97ck1440 FIND v(dout0_97) AT=725.025n

.meas tran vdout0_98ck1440 FIND v(dout0_98) AT=725.025n

.meas tran vdout0_99ck1440 FIND v(dout0_99) AT=725.025n

.meas tran vdout0_100ck1440 FIND v(dout0_100) AT=725.025n

.meas tran vdout0_101ck1440 FIND v(dout0_101) AT=725.025n

.meas tran vdout0_102ck1440 FIND v(dout0_102) AT=725.025n

.meas tran vdout0_103ck1440 FIND v(dout0_103) AT=725.025n

.meas tran vdout0_104ck1440 FIND v(dout0_104) AT=725.025n

.meas tran vdout0_105ck1440 FIND v(dout0_105) AT=725.025n

.meas tran vdout0_106ck1440 FIND v(dout0_106) AT=725.025n

.meas tran vdout0_107ck1440 FIND v(dout0_107) AT=725.025n

.meas tran vdout0_108ck1440 FIND v(dout0_108) AT=725.025n

.meas tran vdout0_109ck1440 FIND v(dout0_109) AT=725.025n

.meas tran vdout0_110ck1440 FIND v(dout0_110) AT=725.025n

.meas tran vdout0_111ck1440 FIND v(dout0_111) AT=725.025n

.meas tran vdout0_112ck1440 FIND v(dout0_112) AT=725.025n

.meas tran vdout0_113ck1440 FIND v(dout0_113) AT=725.025n

.meas tran vdout0_114ck1440 FIND v(dout0_114) AT=725.025n

.meas tran vdout0_115ck1440 FIND v(dout0_115) AT=725.025n

.meas tran vdout0_116ck1440 FIND v(dout0_116) AT=725.025n

.meas tran vdout0_117ck1440 FIND v(dout0_117) AT=725.025n

.meas tran vdout0_118ck1440 FIND v(dout0_118) AT=725.025n

.meas tran vdout0_119ck1440 FIND v(dout0_119) AT=725.025n

.meas tran vdout0_120ck1440 FIND v(dout0_120) AT=725.025n

.meas tran vdout0_121ck1440 FIND v(dout0_121) AT=725.025n

.meas tran vdout0_122ck1440 FIND v(dout0_122) AT=725.025n

.meas tran vdout0_123ck1440 FIND v(dout0_123) AT=725.025n

.meas tran vdout0_124ck1440 FIND v(dout0_124) AT=725.025n

.meas tran vdout0_125ck1440 FIND v(dout0_125) AT=725.025n

.meas tran vdout0_126ck1440 FIND v(dout0_126) AT=725.025n

.meas tran vdout0_127ck1440 FIND v(dout0_127) AT=725.025n

.meas tran vdout0_0ck1460 FIND v(dout0_0) AT=735.025n

.meas tran vdout0_1ck1460 FIND v(dout0_1) AT=735.025n

.meas tran vdout0_2ck1460 FIND v(dout0_2) AT=735.025n

.meas tran vdout0_3ck1460 FIND v(dout0_3) AT=735.025n

.meas tran vdout0_4ck1460 FIND v(dout0_4) AT=735.025n

.meas tran vdout0_5ck1460 FIND v(dout0_5) AT=735.025n

.meas tran vdout0_6ck1460 FIND v(dout0_6) AT=735.025n

.meas tran vdout0_7ck1460 FIND v(dout0_7) AT=735.025n

.meas tran vdout0_8ck1460 FIND v(dout0_8) AT=735.025n

.meas tran vdout0_9ck1460 FIND v(dout0_9) AT=735.025n

.meas tran vdout0_10ck1460 FIND v(dout0_10) AT=735.025n

.meas tran vdout0_11ck1460 FIND v(dout0_11) AT=735.025n

.meas tran vdout0_12ck1460 FIND v(dout0_12) AT=735.025n

.meas tran vdout0_13ck1460 FIND v(dout0_13) AT=735.025n

.meas tran vdout0_14ck1460 FIND v(dout0_14) AT=735.025n

.meas tran vdout0_15ck1460 FIND v(dout0_15) AT=735.025n

.meas tran vdout0_16ck1460 FIND v(dout0_16) AT=735.025n

.meas tran vdout0_17ck1460 FIND v(dout0_17) AT=735.025n

.meas tran vdout0_18ck1460 FIND v(dout0_18) AT=735.025n

.meas tran vdout0_19ck1460 FIND v(dout0_19) AT=735.025n

.meas tran vdout0_20ck1460 FIND v(dout0_20) AT=735.025n

.meas tran vdout0_21ck1460 FIND v(dout0_21) AT=735.025n

.meas tran vdout0_22ck1460 FIND v(dout0_22) AT=735.025n

.meas tran vdout0_23ck1460 FIND v(dout0_23) AT=735.025n

.meas tran vdout0_24ck1460 FIND v(dout0_24) AT=735.025n

.meas tran vdout0_25ck1460 FIND v(dout0_25) AT=735.025n

.meas tran vdout0_26ck1460 FIND v(dout0_26) AT=735.025n

.meas tran vdout0_27ck1460 FIND v(dout0_27) AT=735.025n

.meas tran vdout0_28ck1460 FIND v(dout0_28) AT=735.025n

.meas tran vdout0_29ck1460 FIND v(dout0_29) AT=735.025n

.meas tran vdout0_30ck1460 FIND v(dout0_30) AT=735.025n

.meas tran vdout0_31ck1460 FIND v(dout0_31) AT=735.025n

.meas tran vdout0_32ck1460 FIND v(dout0_32) AT=735.025n

.meas tran vdout0_33ck1460 FIND v(dout0_33) AT=735.025n

.meas tran vdout0_34ck1460 FIND v(dout0_34) AT=735.025n

.meas tran vdout0_35ck1460 FIND v(dout0_35) AT=735.025n

.meas tran vdout0_36ck1460 FIND v(dout0_36) AT=735.025n

.meas tran vdout0_37ck1460 FIND v(dout0_37) AT=735.025n

.meas tran vdout0_38ck1460 FIND v(dout0_38) AT=735.025n

.meas tran vdout0_39ck1460 FIND v(dout0_39) AT=735.025n

.meas tran vdout0_40ck1460 FIND v(dout0_40) AT=735.025n

.meas tran vdout0_41ck1460 FIND v(dout0_41) AT=735.025n

.meas tran vdout0_42ck1460 FIND v(dout0_42) AT=735.025n

.meas tran vdout0_43ck1460 FIND v(dout0_43) AT=735.025n

.meas tran vdout0_44ck1460 FIND v(dout0_44) AT=735.025n

.meas tran vdout0_45ck1460 FIND v(dout0_45) AT=735.025n

.meas tran vdout0_46ck1460 FIND v(dout0_46) AT=735.025n

.meas tran vdout0_47ck1460 FIND v(dout0_47) AT=735.025n

.meas tran vdout0_48ck1460 FIND v(dout0_48) AT=735.025n

.meas tran vdout0_49ck1460 FIND v(dout0_49) AT=735.025n

.meas tran vdout0_50ck1460 FIND v(dout0_50) AT=735.025n

.meas tran vdout0_51ck1460 FIND v(dout0_51) AT=735.025n

.meas tran vdout0_52ck1460 FIND v(dout0_52) AT=735.025n

.meas tran vdout0_53ck1460 FIND v(dout0_53) AT=735.025n

.meas tran vdout0_54ck1460 FIND v(dout0_54) AT=735.025n

.meas tran vdout0_55ck1460 FIND v(dout0_55) AT=735.025n

.meas tran vdout0_56ck1460 FIND v(dout0_56) AT=735.025n

.meas tran vdout0_57ck1460 FIND v(dout0_57) AT=735.025n

.meas tran vdout0_58ck1460 FIND v(dout0_58) AT=735.025n

.meas tran vdout0_59ck1460 FIND v(dout0_59) AT=735.025n

.meas tran vdout0_60ck1460 FIND v(dout0_60) AT=735.025n

.meas tran vdout0_61ck1460 FIND v(dout0_61) AT=735.025n

.meas tran vdout0_62ck1460 FIND v(dout0_62) AT=735.025n

.meas tran vdout0_63ck1460 FIND v(dout0_63) AT=735.025n

.meas tran vdout0_64ck1460 FIND v(dout0_64) AT=735.025n

.meas tran vdout0_65ck1460 FIND v(dout0_65) AT=735.025n

.meas tran vdout0_66ck1460 FIND v(dout0_66) AT=735.025n

.meas tran vdout0_67ck1460 FIND v(dout0_67) AT=735.025n

.meas tran vdout0_68ck1460 FIND v(dout0_68) AT=735.025n

.meas tran vdout0_69ck1460 FIND v(dout0_69) AT=735.025n

.meas tran vdout0_70ck1460 FIND v(dout0_70) AT=735.025n

.meas tran vdout0_71ck1460 FIND v(dout0_71) AT=735.025n

.meas tran vdout0_72ck1460 FIND v(dout0_72) AT=735.025n

.meas tran vdout0_73ck1460 FIND v(dout0_73) AT=735.025n

.meas tran vdout0_74ck1460 FIND v(dout0_74) AT=735.025n

.meas tran vdout0_75ck1460 FIND v(dout0_75) AT=735.025n

.meas tran vdout0_76ck1460 FIND v(dout0_76) AT=735.025n

.meas tran vdout0_77ck1460 FIND v(dout0_77) AT=735.025n

.meas tran vdout0_78ck1460 FIND v(dout0_78) AT=735.025n

.meas tran vdout0_79ck1460 FIND v(dout0_79) AT=735.025n

.meas tran vdout0_80ck1460 FIND v(dout0_80) AT=735.025n

.meas tran vdout0_81ck1460 FIND v(dout0_81) AT=735.025n

.meas tran vdout0_82ck1460 FIND v(dout0_82) AT=735.025n

.meas tran vdout0_83ck1460 FIND v(dout0_83) AT=735.025n

.meas tran vdout0_84ck1460 FIND v(dout0_84) AT=735.025n

.meas tran vdout0_85ck1460 FIND v(dout0_85) AT=735.025n

.meas tran vdout0_86ck1460 FIND v(dout0_86) AT=735.025n

.meas tran vdout0_87ck1460 FIND v(dout0_87) AT=735.025n

.meas tran vdout0_88ck1460 FIND v(dout0_88) AT=735.025n

.meas tran vdout0_89ck1460 FIND v(dout0_89) AT=735.025n

.meas tran vdout0_90ck1460 FIND v(dout0_90) AT=735.025n

.meas tran vdout0_91ck1460 FIND v(dout0_91) AT=735.025n

.meas tran vdout0_92ck1460 FIND v(dout0_92) AT=735.025n

.meas tran vdout0_93ck1460 FIND v(dout0_93) AT=735.025n

.meas tran vdout0_94ck1460 FIND v(dout0_94) AT=735.025n

.meas tran vdout0_95ck1460 FIND v(dout0_95) AT=735.025n

.meas tran vdout0_96ck1460 FIND v(dout0_96) AT=735.025n

.meas tran vdout0_97ck1460 FIND v(dout0_97) AT=735.025n

.meas tran vdout0_98ck1460 FIND v(dout0_98) AT=735.025n

.meas tran vdout0_99ck1460 FIND v(dout0_99) AT=735.025n

.meas tran vdout0_100ck1460 FIND v(dout0_100) AT=735.025n

.meas tran vdout0_101ck1460 FIND v(dout0_101) AT=735.025n

.meas tran vdout0_102ck1460 FIND v(dout0_102) AT=735.025n

.meas tran vdout0_103ck1460 FIND v(dout0_103) AT=735.025n

.meas tran vdout0_104ck1460 FIND v(dout0_104) AT=735.025n

.meas tran vdout0_105ck1460 FIND v(dout0_105) AT=735.025n

.meas tran vdout0_106ck1460 FIND v(dout0_106) AT=735.025n

.meas tran vdout0_107ck1460 FIND v(dout0_107) AT=735.025n

.meas tran vdout0_108ck1460 FIND v(dout0_108) AT=735.025n

.meas tran vdout0_109ck1460 FIND v(dout0_109) AT=735.025n

.meas tran vdout0_110ck1460 FIND v(dout0_110) AT=735.025n

.meas tran vdout0_111ck1460 FIND v(dout0_111) AT=735.025n

.meas tran vdout0_112ck1460 FIND v(dout0_112) AT=735.025n

.meas tran vdout0_113ck1460 FIND v(dout0_113) AT=735.025n

.meas tran vdout0_114ck1460 FIND v(dout0_114) AT=735.025n

.meas tran vdout0_115ck1460 FIND v(dout0_115) AT=735.025n

.meas tran vdout0_116ck1460 FIND v(dout0_116) AT=735.025n

.meas tran vdout0_117ck1460 FIND v(dout0_117) AT=735.025n

.meas tran vdout0_118ck1460 FIND v(dout0_118) AT=735.025n

.meas tran vdout0_119ck1460 FIND v(dout0_119) AT=735.025n

.meas tran vdout0_120ck1460 FIND v(dout0_120) AT=735.025n

.meas tran vdout0_121ck1460 FIND v(dout0_121) AT=735.025n

.meas tran vdout0_122ck1460 FIND v(dout0_122) AT=735.025n

.meas tran vdout0_123ck1460 FIND v(dout0_123) AT=735.025n

.meas tran vdout0_124ck1460 FIND v(dout0_124) AT=735.025n

.meas tran vdout0_125ck1460 FIND v(dout0_125) AT=735.025n

.meas tran vdout0_126ck1460 FIND v(dout0_126) AT=735.025n

.meas tran vdout0_127ck1460 FIND v(dout0_127) AT=735.025n

.meas tran vdout0_0ck1520 FIND v(dout0_0) AT=765.025n

.meas tran vdout0_1ck1520 FIND v(dout0_1) AT=765.025n

.meas tran vdout0_2ck1520 FIND v(dout0_2) AT=765.025n

.meas tran vdout0_3ck1520 FIND v(dout0_3) AT=765.025n

.meas tran vdout0_4ck1520 FIND v(dout0_4) AT=765.025n

.meas tran vdout0_5ck1520 FIND v(dout0_5) AT=765.025n

.meas tran vdout0_6ck1520 FIND v(dout0_6) AT=765.025n

.meas tran vdout0_7ck1520 FIND v(dout0_7) AT=765.025n

.meas tran vdout0_8ck1520 FIND v(dout0_8) AT=765.025n

.meas tran vdout0_9ck1520 FIND v(dout0_9) AT=765.025n

.meas tran vdout0_10ck1520 FIND v(dout0_10) AT=765.025n

.meas tran vdout0_11ck1520 FIND v(dout0_11) AT=765.025n

.meas tran vdout0_12ck1520 FIND v(dout0_12) AT=765.025n

.meas tran vdout0_13ck1520 FIND v(dout0_13) AT=765.025n

.meas tran vdout0_14ck1520 FIND v(dout0_14) AT=765.025n

.meas tran vdout0_15ck1520 FIND v(dout0_15) AT=765.025n

.meas tran vdout0_16ck1520 FIND v(dout0_16) AT=765.025n

.meas tran vdout0_17ck1520 FIND v(dout0_17) AT=765.025n

.meas tran vdout0_18ck1520 FIND v(dout0_18) AT=765.025n

.meas tran vdout0_19ck1520 FIND v(dout0_19) AT=765.025n

.meas tran vdout0_20ck1520 FIND v(dout0_20) AT=765.025n

.meas tran vdout0_21ck1520 FIND v(dout0_21) AT=765.025n

.meas tran vdout0_22ck1520 FIND v(dout0_22) AT=765.025n

.meas tran vdout0_23ck1520 FIND v(dout0_23) AT=765.025n

.meas tran vdout0_24ck1520 FIND v(dout0_24) AT=765.025n

.meas tran vdout0_25ck1520 FIND v(dout0_25) AT=765.025n

.meas tran vdout0_26ck1520 FIND v(dout0_26) AT=765.025n

.meas tran vdout0_27ck1520 FIND v(dout0_27) AT=765.025n

.meas tran vdout0_28ck1520 FIND v(dout0_28) AT=765.025n

.meas tran vdout0_29ck1520 FIND v(dout0_29) AT=765.025n

.meas tran vdout0_30ck1520 FIND v(dout0_30) AT=765.025n

.meas tran vdout0_31ck1520 FIND v(dout0_31) AT=765.025n

.meas tran vdout0_32ck1520 FIND v(dout0_32) AT=765.025n

.meas tran vdout0_33ck1520 FIND v(dout0_33) AT=765.025n

.meas tran vdout0_34ck1520 FIND v(dout0_34) AT=765.025n

.meas tran vdout0_35ck1520 FIND v(dout0_35) AT=765.025n

.meas tran vdout0_36ck1520 FIND v(dout0_36) AT=765.025n

.meas tran vdout0_37ck1520 FIND v(dout0_37) AT=765.025n

.meas tran vdout0_38ck1520 FIND v(dout0_38) AT=765.025n

.meas tran vdout0_39ck1520 FIND v(dout0_39) AT=765.025n

.meas tran vdout0_40ck1520 FIND v(dout0_40) AT=765.025n

.meas tran vdout0_41ck1520 FIND v(dout0_41) AT=765.025n

.meas tran vdout0_42ck1520 FIND v(dout0_42) AT=765.025n

.meas tran vdout0_43ck1520 FIND v(dout0_43) AT=765.025n

.meas tran vdout0_44ck1520 FIND v(dout0_44) AT=765.025n

.meas tran vdout0_45ck1520 FIND v(dout0_45) AT=765.025n

.meas tran vdout0_46ck1520 FIND v(dout0_46) AT=765.025n

.meas tran vdout0_47ck1520 FIND v(dout0_47) AT=765.025n

.meas tran vdout0_48ck1520 FIND v(dout0_48) AT=765.025n

.meas tran vdout0_49ck1520 FIND v(dout0_49) AT=765.025n

.meas tran vdout0_50ck1520 FIND v(dout0_50) AT=765.025n

.meas tran vdout0_51ck1520 FIND v(dout0_51) AT=765.025n

.meas tran vdout0_52ck1520 FIND v(dout0_52) AT=765.025n

.meas tran vdout0_53ck1520 FIND v(dout0_53) AT=765.025n

.meas tran vdout0_54ck1520 FIND v(dout0_54) AT=765.025n

.meas tran vdout0_55ck1520 FIND v(dout0_55) AT=765.025n

.meas tran vdout0_56ck1520 FIND v(dout0_56) AT=765.025n

.meas tran vdout0_57ck1520 FIND v(dout0_57) AT=765.025n

.meas tran vdout0_58ck1520 FIND v(dout0_58) AT=765.025n

.meas tran vdout0_59ck1520 FIND v(dout0_59) AT=765.025n

.meas tran vdout0_60ck1520 FIND v(dout0_60) AT=765.025n

.meas tran vdout0_61ck1520 FIND v(dout0_61) AT=765.025n

.meas tran vdout0_62ck1520 FIND v(dout0_62) AT=765.025n

.meas tran vdout0_63ck1520 FIND v(dout0_63) AT=765.025n

.meas tran vdout0_64ck1520 FIND v(dout0_64) AT=765.025n

.meas tran vdout0_65ck1520 FIND v(dout0_65) AT=765.025n

.meas tran vdout0_66ck1520 FIND v(dout0_66) AT=765.025n

.meas tran vdout0_67ck1520 FIND v(dout0_67) AT=765.025n

.meas tran vdout0_68ck1520 FIND v(dout0_68) AT=765.025n

.meas tran vdout0_69ck1520 FIND v(dout0_69) AT=765.025n

.meas tran vdout0_70ck1520 FIND v(dout0_70) AT=765.025n

.meas tran vdout0_71ck1520 FIND v(dout0_71) AT=765.025n

.meas tran vdout0_72ck1520 FIND v(dout0_72) AT=765.025n

.meas tran vdout0_73ck1520 FIND v(dout0_73) AT=765.025n

.meas tran vdout0_74ck1520 FIND v(dout0_74) AT=765.025n

.meas tran vdout0_75ck1520 FIND v(dout0_75) AT=765.025n

.meas tran vdout0_76ck1520 FIND v(dout0_76) AT=765.025n

.meas tran vdout0_77ck1520 FIND v(dout0_77) AT=765.025n

.meas tran vdout0_78ck1520 FIND v(dout0_78) AT=765.025n

.meas tran vdout0_79ck1520 FIND v(dout0_79) AT=765.025n

.meas tran vdout0_80ck1520 FIND v(dout0_80) AT=765.025n

.meas tran vdout0_81ck1520 FIND v(dout0_81) AT=765.025n

.meas tran vdout0_82ck1520 FIND v(dout0_82) AT=765.025n

.meas tran vdout0_83ck1520 FIND v(dout0_83) AT=765.025n

.meas tran vdout0_84ck1520 FIND v(dout0_84) AT=765.025n

.meas tran vdout0_85ck1520 FIND v(dout0_85) AT=765.025n

.meas tran vdout0_86ck1520 FIND v(dout0_86) AT=765.025n

.meas tran vdout0_87ck1520 FIND v(dout0_87) AT=765.025n

.meas tran vdout0_88ck1520 FIND v(dout0_88) AT=765.025n

.meas tran vdout0_89ck1520 FIND v(dout0_89) AT=765.025n

.meas tran vdout0_90ck1520 FIND v(dout0_90) AT=765.025n

.meas tran vdout0_91ck1520 FIND v(dout0_91) AT=765.025n

.meas tran vdout0_92ck1520 FIND v(dout0_92) AT=765.025n

.meas tran vdout0_93ck1520 FIND v(dout0_93) AT=765.025n

.meas tran vdout0_94ck1520 FIND v(dout0_94) AT=765.025n

.meas tran vdout0_95ck1520 FIND v(dout0_95) AT=765.025n

.meas tran vdout0_96ck1520 FIND v(dout0_96) AT=765.025n

.meas tran vdout0_97ck1520 FIND v(dout0_97) AT=765.025n

.meas tran vdout0_98ck1520 FIND v(dout0_98) AT=765.025n

.meas tran vdout0_99ck1520 FIND v(dout0_99) AT=765.025n

.meas tran vdout0_100ck1520 FIND v(dout0_100) AT=765.025n

.meas tran vdout0_101ck1520 FIND v(dout0_101) AT=765.025n

.meas tran vdout0_102ck1520 FIND v(dout0_102) AT=765.025n

.meas tran vdout0_103ck1520 FIND v(dout0_103) AT=765.025n

.meas tran vdout0_104ck1520 FIND v(dout0_104) AT=765.025n

.meas tran vdout0_105ck1520 FIND v(dout0_105) AT=765.025n

.meas tran vdout0_106ck1520 FIND v(dout0_106) AT=765.025n

.meas tran vdout0_107ck1520 FIND v(dout0_107) AT=765.025n

.meas tran vdout0_108ck1520 FIND v(dout0_108) AT=765.025n

.meas tran vdout0_109ck1520 FIND v(dout0_109) AT=765.025n

.meas tran vdout0_110ck1520 FIND v(dout0_110) AT=765.025n

.meas tran vdout0_111ck1520 FIND v(dout0_111) AT=765.025n

.meas tran vdout0_112ck1520 FIND v(dout0_112) AT=765.025n

.meas tran vdout0_113ck1520 FIND v(dout0_113) AT=765.025n

.meas tran vdout0_114ck1520 FIND v(dout0_114) AT=765.025n

.meas tran vdout0_115ck1520 FIND v(dout0_115) AT=765.025n

.meas tran vdout0_116ck1520 FIND v(dout0_116) AT=765.025n

.meas tran vdout0_117ck1520 FIND v(dout0_117) AT=765.025n

.meas tran vdout0_118ck1520 FIND v(dout0_118) AT=765.025n

.meas tran vdout0_119ck1520 FIND v(dout0_119) AT=765.025n

.meas tran vdout0_120ck1520 FIND v(dout0_120) AT=765.025n

.meas tran vdout0_121ck1520 FIND v(dout0_121) AT=765.025n

.meas tran vdout0_122ck1520 FIND v(dout0_122) AT=765.025n

.meas tran vdout0_123ck1520 FIND v(dout0_123) AT=765.025n

.meas tran vdout0_124ck1520 FIND v(dout0_124) AT=765.025n

.meas tran vdout0_125ck1520 FIND v(dout0_125) AT=765.025n

.meas tran vdout0_126ck1520 FIND v(dout0_126) AT=765.025n

.meas tran vdout0_127ck1520 FIND v(dout0_127) AT=765.025n

.meas tran vdout0_0ck1540 FIND v(dout0_0) AT=775.025n

.meas tran vdout0_1ck1540 FIND v(dout0_1) AT=775.025n

.meas tran vdout0_2ck1540 FIND v(dout0_2) AT=775.025n

.meas tran vdout0_3ck1540 FIND v(dout0_3) AT=775.025n

.meas tran vdout0_4ck1540 FIND v(dout0_4) AT=775.025n

.meas tran vdout0_5ck1540 FIND v(dout0_5) AT=775.025n

.meas tran vdout0_6ck1540 FIND v(dout0_6) AT=775.025n

.meas tran vdout0_7ck1540 FIND v(dout0_7) AT=775.025n

.meas tran vdout0_8ck1540 FIND v(dout0_8) AT=775.025n

.meas tran vdout0_9ck1540 FIND v(dout0_9) AT=775.025n

.meas tran vdout0_10ck1540 FIND v(dout0_10) AT=775.025n

.meas tran vdout0_11ck1540 FIND v(dout0_11) AT=775.025n

.meas tran vdout0_12ck1540 FIND v(dout0_12) AT=775.025n

.meas tran vdout0_13ck1540 FIND v(dout0_13) AT=775.025n

.meas tran vdout0_14ck1540 FIND v(dout0_14) AT=775.025n

.meas tran vdout0_15ck1540 FIND v(dout0_15) AT=775.025n

.meas tran vdout0_16ck1540 FIND v(dout0_16) AT=775.025n

.meas tran vdout0_17ck1540 FIND v(dout0_17) AT=775.025n

.meas tran vdout0_18ck1540 FIND v(dout0_18) AT=775.025n

.meas tran vdout0_19ck1540 FIND v(dout0_19) AT=775.025n

.meas tran vdout0_20ck1540 FIND v(dout0_20) AT=775.025n

.meas tran vdout0_21ck1540 FIND v(dout0_21) AT=775.025n

.meas tran vdout0_22ck1540 FIND v(dout0_22) AT=775.025n

.meas tran vdout0_23ck1540 FIND v(dout0_23) AT=775.025n

.meas tran vdout0_24ck1540 FIND v(dout0_24) AT=775.025n

.meas tran vdout0_25ck1540 FIND v(dout0_25) AT=775.025n

.meas tran vdout0_26ck1540 FIND v(dout0_26) AT=775.025n

.meas tran vdout0_27ck1540 FIND v(dout0_27) AT=775.025n

.meas tran vdout0_28ck1540 FIND v(dout0_28) AT=775.025n

.meas tran vdout0_29ck1540 FIND v(dout0_29) AT=775.025n

.meas tran vdout0_30ck1540 FIND v(dout0_30) AT=775.025n

.meas tran vdout0_31ck1540 FIND v(dout0_31) AT=775.025n

.meas tran vdout0_32ck1540 FIND v(dout0_32) AT=775.025n

.meas tran vdout0_33ck1540 FIND v(dout0_33) AT=775.025n

.meas tran vdout0_34ck1540 FIND v(dout0_34) AT=775.025n

.meas tran vdout0_35ck1540 FIND v(dout0_35) AT=775.025n

.meas tran vdout0_36ck1540 FIND v(dout0_36) AT=775.025n

.meas tran vdout0_37ck1540 FIND v(dout0_37) AT=775.025n

.meas tran vdout0_38ck1540 FIND v(dout0_38) AT=775.025n

.meas tran vdout0_39ck1540 FIND v(dout0_39) AT=775.025n

.meas tran vdout0_40ck1540 FIND v(dout0_40) AT=775.025n

.meas tran vdout0_41ck1540 FIND v(dout0_41) AT=775.025n

.meas tran vdout0_42ck1540 FIND v(dout0_42) AT=775.025n

.meas tran vdout0_43ck1540 FIND v(dout0_43) AT=775.025n

.meas tran vdout0_44ck1540 FIND v(dout0_44) AT=775.025n

.meas tran vdout0_45ck1540 FIND v(dout0_45) AT=775.025n

.meas tran vdout0_46ck1540 FIND v(dout0_46) AT=775.025n

.meas tran vdout0_47ck1540 FIND v(dout0_47) AT=775.025n

.meas tran vdout0_48ck1540 FIND v(dout0_48) AT=775.025n

.meas tran vdout0_49ck1540 FIND v(dout0_49) AT=775.025n

.meas tran vdout0_50ck1540 FIND v(dout0_50) AT=775.025n

.meas tran vdout0_51ck1540 FIND v(dout0_51) AT=775.025n

.meas tran vdout0_52ck1540 FIND v(dout0_52) AT=775.025n

.meas tran vdout0_53ck1540 FIND v(dout0_53) AT=775.025n

.meas tran vdout0_54ck1540 FIND v(dout0_54) AT=775.025n

.meas tran vdout0_55ck1540 FIND v(dout0_55) AT=775.025n

.meas tran vdout0_56ck1540 FIND v(dout0_56) AT=775.025n

.meas tran vdout0_57ck1540 FIND v(dout0_57) AT=775.025n

.meas tran vdout0_58ck1540 FIND v(dout0_58) AT=775.025n

.meas tran vdout0_59ck1540 FIND v(dout0_59) AT=775.025n

.meas tran vdout0_60ck1540 FIND v(dout0_60) AT=775.025n

.meas tran vdout0_61ck1540 FIND v(dout0_61) AT=775.025n

.meas tran vdout0_62ck1540 FIND v(dout0_62) AT=775.025n

.meas tran vdout0_63ck1540 FIND v(dout0_63) AT=775.025n

.meas tran vdout0_64ck1540 FIND v(dout0_64) AT=775.025n

.meas tran vdout0_65ck1540 FIND v(dout0_65) AT=775.025n

.meas tran vdout0_66ck1540 FIND v(dout0_66) AT=775.025n

.meas tran vdout0_67ck1540 FIND v(dout0_67) AT=775.025n

.meas tran vdout0_68ck1540 FIND v(dout0_68) AT=775.025n

.meas tran vdout0_69ck1540 FIND v(dout0_69) AT=775.025n

.meas tran vdout0_70ck1540 FIND v(dout0_70) AT=775.025n

.meas tran vdout0_71ck1540 FIND v(dout0_71) AT=775.025n

.meas tran vdout0_72ck1540 FIND v(dout0_72) AT=775.025n

.meas tran vdout0_73ck1540 FIND v(dout0_73) AT=775.025n

.meas tran vdout0_74ck1540 FIND v(dout0_74) AT=775.025n

.meas tran vdout0_75ck1540 FIND v(dout0_75) AT=775.025n

.meas tran vdout0_76ck1540 FIND v(dout0_76) AT=775.025n

.meas tran vdout0_77ck1540 FIND v(dout0_77) AT=775.025n

.meas tran vdout0_78ck1540 FIND v(dout0_78) AT=775.025n

.meas tran vdout0_79ck1540 FIND v(dout0_79) AT=775.025n

.meas tran vdout0_80ck1540 FIND v(dout0_80) AT=775.025n

.meas tran vdout0_81ck1540 FIND v(dout0_81) AT=775.025n

.meas tran vdout0_82ck1540 FIND v(dout0_82) AT=775.025n

.meas tran vdout0_83ck1540 FIND v(dout0_83) AT=775.025n

.meas tran vdout0_84ck1540 FIND v(dout0_84) AT=775.025n

.meas tran vdout0_85ck1540 FIND v(dout0_85) AT=775.025n

.meas tran vdout0_86ck1540 FIND v(dout0_86) AT=775.025n

.meas tran vdout0_87ck1540 FIND v(dout0_87) AT=775.025n

.meas tran vdout0_88ck1540 FIND v(dout0_88) AT=775.025n

.meas tran vdout0_89ck1540 FIND v(dout0_89) AT=775.025n

.meas tran vdout0_90ck1540 FIND v(dout0_90) AT=775.025n

.meas tran vdout0_91ck1540 FIND v(dout0_91) AT=775.025n

.meas tran vdout0_92ck1540 FIND v(dout0_92) AT=775.025n

.meas tran vdout0_93ck1540 FIND v(dout0_93) AT=775.025n

.meas tran vdout0_94ck1540 FIND v(dout0_94) AT=775.025n

.meas tran vdout0_95ck1540 FIND v(dout0_95) AT=775.025n

.meas tran vdout0_96ck1540 FIND v(dout0_96) AT=775.025n

.meas tran vdout0_97ck1540 FIND v(dout0_97) AT=775.025n

.meas tran vdout0_98ck1540 FIND v(dout0_98) AT=775.025n

.meas tran vdout0_99ck1540 FIND v(dout0_99) AT=775.025n

.meas tran vdout0_100ck1540 FIND v(dout0_100) AT=775.025n

.meas tran vdout0_101ck1540 FIND v(dout0_101) AT=775.025n

.meas tran vdout0_102ck1540 FIND v(dout0_102) AT=775.025n

.meas tran vdout0_103ck1540 FIND v(dout0_103) AT=775.025n

.meas tran vdout0_104ck1540 FIND v(dout0_104) AT=775.025n

.meas tran vdout0_105ck1540 FIND v(dout0_105) AT=775.025n

.meas tran vdout0_106ck1540 FIND v(dout0_106) AT=775.025n

.meas tran vdout0_107ck1540 FIND v(dout0_107) AT=775.025n

.meas tran vdout0_108ck1540 FIND v(dout0_108) AT=775.025n

.meas tran vdout0_109ck1540 FIND v(dout0_109) AT=775.025n

.meas tran vdout0_110ck1540 FIND v(dout0_110) AT=775.025n

.meas tran vdout0_111ck1540 FIND v(dout0_111) AT=775.025n

.meas tran vdout0_112ck1540 FIND v(dout0_112) AT=775.025n

.meas tran vdout0_113ck1540 FIND v(dout0_113) AT=775.025n

.meas tran vdout0_114ck1540 FIND v(dout0_114) AT=775.025n

.meas tran vdout0_115ck1540 FIND v(dout0_115) AT=775.025n

.meas tran vdout0_116ck1540 FIND v(dout0_116) AT=775.025n

.meas tran vdout0_117ck1540 FIND v(dout0_117) AT=775.025n

.meas tran vdout0_118ck1540 FIND v(dout0_118) AT=775.025n

.meas tran vdout0_119ck1540 FIND v(dout0_119) AT=775.025n

.meas tran vdout0_120ck1540 FIND v(dout0_120) AT=775.025n

.meas tran vdout0_121ck1540 FIND v(dout0_121) AT=775.025n

.meas tran vdout0_122ck1540 FIND v(dout0_122) AT=775.025n

.meas tran vdout0_123ck1540 FIND v(dout0_123) AT=775.025n

.meas tran vdout0_124ck1540 FIND v(dout0_124) AT=775.025n

.meas tran vdout0_125ck1540 FIND v(dout0_125) AT=775.025n

.meas tran vdout0_126ck1540 FIND v(dout0_126) AT=775.025n

.meas tran vdout0_127ck1540 FIND v(dout0_127) AT=775.025n

.meas tran vdout0_0ck1620 FIND v(dout0_0) AT=815.025n

.meas tran vdout0_1ck1620 FIND v(dout0_1) AT=815.025n

.meas tran vdout0_2ck1620 FIND v(dout0_2) AT=815.025n

.meas tran vdout0_3ck1620 FIND v(dout0_3) AT=815.025n

.meas tran vdout0_4ck1620 FIND v(dout0_4) AT=815.025n

.meas tran vdout0_5ck1620 FIND v(dout0_5) AT=815.025n

.meas tran vdout0_6ck1620 FIND v(dout0_6) AT=815.025n

.meas tran vdout0_7ck1620 FIND v(dout0_7) AT=815.025n

.meas tran vdout0_8ck1620 FIND v(dout0_8) AT=815.025n

.meas tran vdout0_9ck1620 FIND v(dout0_9) AT=815.025n

.meas tran vdout0_10ck1620 FIND v(dout0_10) AT=815.025n

.meas tran vdout0_11ck1620 FIND v(dout0_11) AT=815.025n

.meas tran vdout0_12ck1620 FIND v(dout0_12) AT=815.025n

.meas tran vdout0_13ck1620 FIND v(dout0_13) AT=815.025n

.meas tran vdout0_14ck1620 FIND v(dout0_14) AT=815.025n

.meas tran vdout0_15ck1620 FIND v(dout0_15) AT=815.025n

.meas tran vdout0_16ck1620 FIND v(dout0_16) AT=815.025n

.meas tran vdout0_17ck1620 FIND v(dout0_17) AT=815.025n

.meas tran vdout0_18ck1620 FIND v(dout0_18) AT=815.025n

.meas tran vdout0_19ck1620 FIND v(dout0_19) AT=815.025n

.meas tran vdout0_20ck1620 FIND v(dout0_20) AT=815.025n

.meas tran vdout0_21ck1620 FIND v(dout0_21) AT=815.025n

.meas tran vdout0_22ck1620 FIND v(dout0_22) AT=815.025n

.meas tran vdout0_23ck1620 FIND v(dout0_23) AT=815.025n

.meas tran vdout0_24ck1620 FIND v(dout0_24) AT=815.025n

.meas tran vdout0_25ck1620 FIND v(dout0_25) AT=815.025n

.meas tran vdout0_26ck1620 FIND v(dout0_26) AT=815.025n

.meas tran vdout0_27ck1620 FIND v(dout0_27) AT=815.025n

.meas tran vdout0_28ck1620 FIND v(dout0_28) AT=815.025n

.meas tran vdout0_29ck1620 FIND v(dout0_29) AT=815.025n

.meas tran vdout0_30ck1620 FIND v(dout0_30) AT=815.025n

.meas tran vdout0_31ck1620 FIND v(dout0_31) AT=815.025n

.meas tran vdout0_32ck1620 FIND v(dout0_32) AT=815.025n

.meas tran vdout0_33ck1620 FIND v(dout0_33) AT=815.025n

.meas tran vdout0_34ck1620 FIND v(dout0_34) AT=815.025n

.meas tran vdout0_35ck1620 FIND v(dout0_35) AT=815.025n

.meas tran vdout0_36ck1620 FIND v(dout0_36) AT=815.025n

.meas tran vdout0_37ck1620 FIND v(dout0_37) AT=815.025n

.meas tran vdout0_38ck1620 FIND v(dout0_38) AT=815.025n

.meas tran vdout0_39ck1620 FIND v(dout0_39) AT=815.025n

.meas tran vdout0_40ck1620 FIND v(dout0_40) AT=815.025n

.meas tran vdout0_41ck1620 FIND v(dout0_41) AT=815.025n

.meas tran vdout0_42ck1620 FIND v(dout0_42) AT=815.025n

.meas tran vdout0_43ck1620 FIND v(dout0_43) AT=815.025n

.meas tran vdout0_44ck1620 FIND v(dout0_44) AT=815.025n

.meas tran vdout0_45ck1620 FIND v(dout0_45) AT=815.025n

.meas tran vdout0_46ck1620 FIND v(dout0_46) AT=815.025n

.meas tran vdout0_47ck1620 FIND v(dout0_47) AT=815.025n

.meas tran vdout0_48ck1620 FIND v(dout0_48) AT=815.025n

.meas tran vdout0_49ck1620 FIND v(dout0_49) AT=815.025n

.meas tran vdout0_50ck1620 FIND v(dout0_50) AT=815.025n

.meas tran vdout0_51ck1620 FIND v(dout0_51) AT=815.025n

.meas tran vdout0_52ck1620 FIND v(dout0_52) AT=815.025n

.meas tran vdout0_53ck1620 FIND v(dout0_53) AT=815.025n

.meas tran vdout0_54ck1620 FIND v(dout0_54) AT=815.025n

.meas tran vdout0_55ck1620 FIND v(dout0_55) AT=815.025n

.meas tran vdout0_56ck1620 FIND v(dout0_56) AT=815.025n

.meas tran vdout0_57ck1620 FIND v(dout0_57) AT=815.025n

.meas tran vdout0_58ck1620 FIND v(dout0_58) AT=815.025n

.meas tran vdout0_59ck1620 FIND v(dout0_59) AT=815.025n

.meas tran vdout0_60ck1620 FIND v(dout0_60) AT=815.025n

.meas tran vdout0_61ck1620 FIND v(dout0_61) AT=815.025n

.meas tran vdout0_62ck1620 FIND v(dout0_62) AT=815.025n

.meas tran vdout0_63ck1620 FIND v(dout0_63) AT=815.025n

.meas tran vdout0_64ck1620 FIND v(dout0_64) AT=815.025n

.meas tran vdout0_65ck1620 FIND v(dout0_65) AT=815.025n

.meas tran vdout0_66ck1620 FIND v(dout0_66) AT=815.025n

.meas tran vdout0_67ck1620 FIND v(dout0_67) AT=815.025n

.meas tran vdout0_68ck1620 FIND v(dout0_68) AT=815.025n

.meas tran vdout0_69ck1620 FIND v(dout0_69) AT=815.025n

.meas tran vdout0_70ck1620 FIND v(dout0_70) AT=815.025n

.meas tran vdout0_71ck1620 FIND v(dout0_71) AT=815.025n

.meas tran vdout0_72ck1620 FIND v(dout0_72) AT=815.025n

.meas tran vdout0_73ck1620 FIND v(dout0_73) AT=815.025n

.meas tran vdout0_74ck1620 FIND v(dout0_74) AT=815.025n

.meas tran vdout0_75ck1620 FIND v(dout0_75) AT=815.025n

.meas tran vdout0_76ck1620 FIND v(dout0_76) AT=815.025n

.meas tran vdout0_77ck1620 FIND v(dout0_77) AT=815.025n

.meas tran vdout0_78ck1620 FIND v(dout0_78) AT=815.025n

.meas tran vdout0_79ck1620 FIND v(dout0_79) AT=815.025n

.meas tran vdout0_80ck1620 FIND v(dout0_80) AT=815.025n

.meas tran vdout0_81ck1620 FIND v(dout0_81) AT=815.025n

.meas tran vdout0_82ck1620 FIND v(dout0_82) AT=815.025n

.meas tran vdout0_83ck1620 FIND v(dout0_83) AT=815.025n

.meas tran vdout0_84ck1620 FIND v(dout0_84) AT=815.025n

.meas tran vdout0_85ck1620 FIND v(dout0_85) AT=815.025n

.meas tran vdout0_86ck1620 FIND v(dout0_86) AT=815.025n

.meas tran vdout0_87ck1620 FIND v(dout0_87) AT=815.025n

.meas tran vdout0_88ck1620 FIND v(dout0_88) AT=815.025n

.meas tran vdout0_89ck1620 FIND v(dout0_89) AT=815.025n

.meas tran vdout0_90ck1620 FIND v(dout0_90) AT=815.025n

.meas tran vdout0_91ck1620 FIND v(dout0_91) AT=815.025n

.meas tran vdout0_92ck1620 FIND v(dout0_92) AT=815.025n

.meas tran vdout0_93ck1620 FIND v(dout0_93) AT=815.025n

.meas tran vdout0_94ck1620 FIND v(dout0_94) AT=815.025n

.meas tran vdout0_95ck1620 FIND v(dout0_95) AT=815.025n

.meas tran vdout0_96ck1620 FIND v(dout0_96) AT=815.025n

.meas tran vdout0_97ck1620 FIND v(dout0_97) AT=815.025n

.meas tran vdout0_98ck1620 FIND v(dout0_98) AT=815.025n

.meas tran vdout0_99ck1620 FIND v(dout0_99) AT=815.025n

.meas tran vdout0_100ck1620 FIND v(dout0_100) AT=815.025n

.meas tran vdout0_101ck1620 FIND v(dout0_101) AT=815.025n

.meas tran vdout0_102ck1620 FIND v(dout0_102) AT=815.025n

.meas tran vdout0_103ck1620 FIND v(dout0_103) AT=815.025n

.meas tran vdout0_104ck1620 FIND v(dout0_104) AT=815.025n

.meas tran vdout0_105ck1620 FIND v(dout0_105) AT=815.025n

.meas tran vdout0_106ck1620 FIND v(dout0_106) AT=815.025n

.meas tran vdout0_107ck1620 FIND v(dout0_107) AT=815.025n

.meas tran vdout0_108ck1620 FIND v(dout0_108) AT=815.025n

.meas tran vdout0_109ck1620 FIND v(dout0_109) AT=815.025n

.meas tran vdout0_110ck1620 FIND v(dout0_110) AT=815.025n

.meas tran vdout0_111ck1620 FIND v(dout0_111) AT=815.025n

.meas tran vdout0_112ck1620 FIND v(dout0_112) AT=815.025n

.meas tran vdout0_113ck1620 FIND v(dout0_113) AT=815.025n

.meas tran vdout0_114ck1620 FIND v(dout0_114) AT=815.025n

.meas tran vdout0_115ck1620 FIND v(dout0_115) AT=815.025n

.meas tran vdout0_116ck1620 FIND v(dout0_116) AT=815.025n

.meas tran vdout0_117ck1620 FIND v(dout0_117) AT=815.025n

.meas tran vdout0_118ck1620 FIND v(dout0_118) AT=815.025n

.meas tran vdout0_119ck1620 FIND v(dout0_119) AT=815.025n

.meas tran vdout0_120ck1620 FIND v(dout0_120) AT=815.025n

.meas tran vdout0_121ck1620 FIND v(dout0_121) AT=815.025n

.meas tran vdout0_122ck1620 FIND v(dout0_122) AT=815.025n

.meas tran vdout0_123ck1620 FIND v(dout0_123) AT=815.025n

.meas tran vdout0_124ck1620 FIND v(dout0_124) AT=815.025n

.meas tran vdout0_125ck1620 FIND v(dout0_125) AT=815.025n

.meas tran vdout0_126ck1620 FIND v(dout0_126) AT=815.025n

.meas tran vdout0_127ck1620 FIND v(dout0_127) AT=815.025n

.meas tran vdout0_0ck1630 FIND v(dout0_0) AT=820.025n

.meas tran vdout0_1ck1630 FIND v(dout0_1) AT=820.025n

.meas tran vdout0_2ck1630 FIND v(dout0_2) AT=820.025n

.meas tran vdout0_3ck1630 FIND v(dout0_3) AT=820.025n

.meas tran vdout0_4ck1630 FIND v(dout0_4) AT=820.025n

.meas tran vdout0_5ck1630 FIND v(dout0_5) AT=820.025n

.meas tran vdout0_6ck1630 FIND v(dout0_6) AT=820.025n

.meas tran vdout0_7ck1630 FIND v(dout0_7) AT=820.025n

.meas tran vdout0_8ck1630 FIND v(dout0_8) AT=820.025n

.meas tran vdout0_9ck1630 FIND v(dout0_9) AT=820.025n

.meas tran vdout0_10ck1630 FIND v(dout0_10) AT=820.025n

.meas tran vdout0_11ck1630 FIND v(dout0_11) AT=820.025n

.meas tran vdout0_12ck1630 FIND v(dout0_12) AT=820.025n

.meas tran vdout0_13ck1630 FIND v(dout0_13) AT=820.025n

.meas tran vdout0_14ck1630 FIND v(dout0_14) AT=820.025n

.meas tran vdout0_15ck1630 FIND v(dout0_15) AT=820.025n

.meas tran vdout0_16ck1630 FIND v(dout0_16) AT=820.025n

.meas tran vdout0_17ck1630 FIND v(dout0_17) AT=820.025n

.meas tran vdout0_18ck1630 FIND v(dout0_18) AT=820.025n

.meas tran vdout0_19ck1630 FIND v(dout0_19) AT=820.025n

.meas tran vdout0_20ck1630 FIND v(dout0_20) AT=820.025n

.meas tran vdout0_21ck1630 FIND v(dout0_21) AT=820.025n

.meas tran vdout0_22ck1630 FIND v(dout0_22) AT=820.025n

.meas tran vdout0_23ck1630 FIND v(dout0_23) AT=820.025n

.meas tran vdout0_24ck1630 FIND v(dout0_24) AT=820.025n

.meas tran vdout0_25ck1630 FIND v(dout0_25) AT=820.025n

.meas tran vdout0_26ck1630 FIND v(dout0_26) AT=820.025n

.meas tran vdout0_27ck1630 FIND v(dout0_27) AT=820.025n

.meas tran vdout0_28ck1630 FIND v(dout0_28) AT=820.025n

.meas tran vdout0_29ck1630 FIND v(dout0_29) AT=820.025n

.meas tran vdout0_30ck1630 FIND v(dout0_30) AT=820.025n

.meas tran vdout0_31ck1630 FIND v(dout0_31) AT=820.025n

.meas tran vdout0_32ck1630 FIND v(dout0_32) AT=820.025n

.meas tran vdout0_33ck1630 FIND v(dout0_33) AT=820.025n

.meas tran vdout0_34ck1630 FIND v(dout0_34) AT=820.025n

.meas tran vdout0_35ck1630 FIND v(dout0_35) AT=820.025n

.meas tran vdout0_36ck1630 FIND v(dout0_36) AT=820.025n

.meas tran vdout0_37ck1630 FIND v(dout0_37) AT=820.025n

.meas tran vdout0_38ck1630 FIND v(dout0_38) AT=820.025n

.meas tran vdout0_39ck1630 FIND v(dout0_39) AT=820.025n

.meas tran vdout0_40ck1630 FIND v(dout0_40) AT=820.025n

.meas tran vdout0_41ck1630 FIND v(dout0_41) AT=820.025n

.meas tran vdout0_42ck1630 FIND v(dout0_42) AT=820.025n

.meas tran vdout0_43ck1630 FIND v(dout0_43) AT=820.025n

.meas tran vdout0_44ck1630 FIND v(dout0_44) AT=820.025n

.meas tran vdout0_45ck1630 FIND v(dout0_45) AT=820.025n

.meas tran vdout0_46ck1630 FIND v(dout0_46) AT=820.025n

.meas tran vdout0_47ck1630 FIND v(dout0_47) AT=820.025n

.meas tran vdout0_48ck1630 FIND v(dout0_48) AT=820.025n

.meas tran vdout0_49ck1630 FIND v(dout0_49) AT=820.025n

.meas tran vdout0_50ck1630 FIND v(dout0_50) AT=820.025n

.meas tran vdout0_51ck1630 FIND v(dout0_51) AT=820.025n

.meas tran vdout0_52ck1630 FIND v(dout0_52) AT=820.025n

.meas tran vdout0_53ck1630 FIND v(dout0_53) AT=820.025n

.meas tran vdout0_54ck1630 FIND v(dout0_54) AT=820.025n

.meas tran vdout0_55ck1630 FIND v(dout0_55) AT=820.025n

.meas tran vdout0_56ck1630 FIND v(dout0_56) AT=820.025n

.meas tran vdout0_57ck1630 FIND v(dout0_57) AT=820.025n

.meas tran vdout0_58ck1630 FIND v(dout0_58) AT=820.025n

.meas tran vdout0_59ck1630 FIND v(dout0_59) AT=820.025n

.meas tran vdout0_60ck1630 FIND v(dout0_60) AT=820.025n

.meas tran vdout0_61ck1630 FIND v(dout0_61) AT=820.025n

.meas tran vdout0_62ck1630 FIND v(dout0_62) AT=820.025n

.meas tran vdout0_63ck1630 FIND v(dout0_63) AT=820.025n

.meas tran vdout0_64ck1630 FIND v(dout0_64) AT=820.025n

.meas tran vdout0_65ck1630 FIND v(dout0_65) AT=820.025n

.meas tran vdout0_66ck1630 FIND v(dout0_66) AT=820.025n

.meas tran vdout0_67ck1630 FIND v(dout0_67) AT=820.025n

.meas tran vdout0_68ck1630 FIND v(dout0_68) AT=820.025n

.meas tran vdout0_69ck1630 FIND v(dout0_69) AT=820.025n

.meas tran vdout0_70ck1630 FIND v(dout0_70) AT=820.025n

.meas tran vdout0_71ck1630 FIND v(dout0_71) AT=820.025n

.meas tran vdout0_72ck1630 FIND v(dout0_72) AT=820.025n

.meas tran vdout0_73ck1630 FIND v(dout0_73) AT=820.025n

.meas tran vdout0_74ck1630 FIND v(dout0_74) AT=820.025n

.meas tran vdout0_75ck1630 FIND v(dout0_75) AT=820.025n

.meas tran vdout0_76ck1630 FIND v(dout0_76) AT=820.025n

.meas tran vdout0_77ck1630 FIND v(dout0_77) AT=820.025n

.meas tran vdout0_78ck1630 FIND v(dout0_78) AT=820.025n

.meas tran vdout0_79ck1630 FIND v(dout0_79) AT=820.025n

.meas tran vdout0_80ck1630 FIND v(dout0_80) AT=820.025n

.meas tran vdout0_81ck1630 FIND v(dout0_81) AT=820.025n

.meas tran vdout0_82ck1630 FIND v(dout0_82) AT=820.025n

.meas tran vdout0_83ck1630 FIND v(dout0_83) AT=820.025n

.meas tran vdout0_84ck1630 FIND v(dout0_84) AT=820.025n

.meas tran vdout0_85ck1630 FIND v(dout0_85) AT=820.025n

.meas tran vdout0_86ck1630 FIND v(dout0_86) AT=820.025n

.meas tran vdout0_87ck1630 FIND v(dout0_87) AT=820.025n

.meas tran vdout0_88ck1630 FIND v(dout0_88) AT=820.025n

.meas tran vdout0_89ck1630 FIND v(dout0_89) AT=820.025n

.meas tran vdout0_90ck1630 FIND v(dout0_90) AT=820.025n

.meas tran vdout0_91ck1630 FIND v(dout0_91) AT=820.025n

.meas tran vdout0_92ck1630 FIND v(dout0_92) AT=820.025n

.meas tran vdout0_93ck1630 FIND v(dout0_93) AT=820.025n

.meas tran vdout0_94ck1630 FIND v(dout0_94) AT=820.025n

.meas tran vdout0_95ck1630 FIND v(dout0_95) AT=820.025n

.meas tran vdout0_96ck1630 FIND v(dout0_96) AT=820.025n

.meas tran vdout0_97ck1630 FIND v(dout0_97) AT=820.025n

.meas tran vdout0_98ck1630 FIND v(dout0_98) AT=820.025n

.meas tran vdout0_99ck1630 FIND v(dout0_99) AT=820.025n

.meas tran vdout0_100ck1630 FIND v(dout0_100) AT=820.025n

.meas tran vdout0_101ck1630 FIND v(dout0_101) AT=820.025n

.meas tran vdout0_102ck1630 FIND v(dout0_102) AT=820.025n

.meas tran vdout0_103ck1630 FIND v(dout0_103) AT=820.025n

.meas tran vdout0_104ck1630 FIND v(dout0_104) AT=820.025n

.meas tran vdout0_105ck1630 FIND v(dout0_105) AT=820.025n

.meas tran vdout0_106ck1630 FIND v(dout0_106) AT=820.025n

.meas tran vdout0_107ck1630 FIND v(dout0_107) AT=820.025n

.meas tran vdout0_108ck1630 FIND v(dout0_108) AT=820.025n

.meas tran vdout0_109ck1630 FIND v(dout0_109) AT=820.025n

.meas tran vdout0_110ck1630 FIND v(dout0_110) AT=820.025n

.meas tran vdout0_111ck1630 FIND v(dout0_111) AT=820.025n

.meas tran vdout0_112ck1630 FIND v(dout0_112) AT=820.025n

.meas tran vdout0_113ck1630 FIND v(dout0_113) AT=820.025n

.meas tran vdout0_114ck1630 FIND v(dout0_114) AT=820.025n

.meas tran vdout0_115ck1630 FIND v(dout0_115) AT=820.025n

.meas tran vdout0_116ck1630 FIND v(dout0_116) AT=820.025n

.meas tran vdout0_117ck1630 FIND v(dout0_117) AT=820.025n

.meas tran vdout0_118ck1630 FIND v(dout0_118) AT=820.025n

.meas tran vdout0_119ck1630 FIND v(dout0_119) AT=820.025n

.meas tran vdout0_120ck1630 FIND v(dout0_120) AT=820.025n

.meas tran vdout0_121ck1630 FIND v(dout0_121) AT=820.025n

.meas tran vdout0_122ck1630 FIND v(dout0_122) AT=820.025n

.meas tran vdout0_123ck1630 FIND v(dout0_123) AT=820.025n

.meas tran vdout0_124ck1630 FIND v(dout0_124) AT=820.025n

.meas tran vdout0_125ck1630 FIND v(dout0_125) AT=820.025n

.meas tran vdout0_126ck1630 FIND v(dout0_126) AT=820.025n

.meas tran vdout0_127ck1630 FIND v(dout0_127) AT=820.025n

.meas tran vdout0_0ck1660 FIND v(dout0_0) AT=835.025n

.meas tran vdout0_1ck1660 FIND v(dout0_1) AT=835.025n

.meas tran vdout0_2ck1660 FIND v(dout0_2) AT=835.025n

.meas tran vdout0_3ck1660 FIND v(dout0_3) AT=835.025n

.meas tran vdout0_4ck1660 FIND v(dout0_4) AT=835.025n

.meas tran vdout0_5ck1660 FIND v(dout0_5) AT=835.025n

.meas tran vdout0_6ck1660 FIND v(dout0_6) AT=835.025n

.meas tran vdout0_7ck1660 FIND v(dout0_7) AT=835.025n

.meas tran vdout0_8ck1660 FIND v(dout0_8) AT=835.025n

.meas tran vdout0_9ck1660 FIND v(dout0_9) AT=835.025n

.meas tran vdout0_10ck1660 FIND v(dout0_10) AT=835.025n

.meas tran vdout0_11ck1660 FIND v(dout0_11) AT=835.025n

.meas tran vdout0_12ck1660 FIND v(dout0_12) AT=835.025n

.meas tran vdout0_13ck1660 FIND v(dout0_13) AT=835.025n

.meas tran vdout0_14ck1660 FIND v(dout0_14) AT=835.025n

.meas tran vdout0_15ck1660 FIND v(dout0_15) AT=835.025n

.meas tran vdout0_16ck1660 FIND v(dout0_16) AT=835.025n

.meas tran vdout0_17ck1660 FIND v(dout0_17) AT=835.025n

.meas tran vdout0_18ck1660 FIND v(dout0_18) AT=835.025n

.meas tran vdout0_19ck1660 FIND v(dout0_19) AT=835.025n

.meas tran vdout0_20ck1660 FIND v(dout0_20) AT=835.025n

.meas tran vdout0_21ck1660 FIND v(dout0_21) AT=835.025n

.meas tran vdout0_22ck1660 FIND v(dout0_22) AT=835.025n

.meas tran vdout0_23ck1660 FIND v(dout0_23) AT=835.025n

.meas tran vdout0_24ck1660 FIND v(dout0_24) AT=835.025n

.meas tran vdout0_25ck1660 FIND v(dout0_25) AT=835.025n

.meas tran vdout0_26ck1660 FIND v(dout0_26) AT=835.025n

.meas tran vdout0_27ck1660 FIND v(dout0_27) AT=835.025n

.meas tran vdout0_28ck1660 FIND v(dout0_28) AT=835.025n

.meas tran vdout0_29ck1660 FIND v(dout0_29) AT=835.025n

.meas tran vdout0_30ck1660 FIND v(dout0_30) AT=835.025n

.meas tran vdout0_31ck1660 FIND v(dout0_31) AT=835.025n

.meas tran vdout0_32ck1660 FIND v(dout0_32) AT=835.025n

.meas tran vdout0_33ck1660 FIND v(dout0_33) AT=835.025n

.meas tran vdout0_34ck1660 FIND v(dout0_34) AT=835.025n

.meas tran vdout0_35ck1660 FIND v(dout0_35) AT=835.025n

.meas tran vdout0_36ck1660 FIND v(dout0_36) AT=835.025n

.meas tran vdout0_37ck1660 FIND v(dout0_37) AT=835.025n

.meas tran vdout0_38ck1660 FIND v(dout0_38) AT=835.025n

.meas tran vdout0_39ck1660 FIND v(dout0_39) AT=835.025n

.meas tran vdout0_40ck1660 FIND v(dout0_40) AT=835.025n

.meas tran vdout0_41ck1660 FIND v(dout0_41) AT=835.025n

.meas tran vdout0_42ck1660 FIND v(dout0_42) AT=835.025n

.meas tran vdout0_43ck1660 FIND v(dout0_43) AT=835.025n

.meas tran vdout0_44ck1660 FIND v(dout0_44) AT=835.025n

.meas tran vdout0_45ck1660 FIND v(dout0_45) AT=835.025n

.meas tran vdout0_46ck1660 FIND v(dout0_46) AT=835.025n

.meas tran vdout0_47ck1660 FIND v(dout0_47) AT=835.025n

.meas tran vdout0_48ck1660 FIND v(dout0_48) AT=835.025n

.meas tran vdout0_49ck1660 FIND v(dout0_49) AT=835.025n

.meas tran vdout0_50ck1660 FIND v(dout0_50) AT=835.025n

.meas tran vdout0_51ck1660 FIND v(dout0_51) AT=835.025n

.meas tran vdout0_52ck1660 FIND v(dout0_52) AT=835.025n

.meas tran vdout0_53ck1660 FIND v(dout0_53) AT=835.025n

.meas tran vdout0_54ck1660 FIND v(dout0_54) AT=835.025n

.meas tran vdout0_55ck1660 FIND v(dout0_55) AT=835.025n

.meas tran vdout0_56ck1660 FIND v(dout0_56) AT=835.025n

.meas tran vdout0_57ck1660 FIND v(dout0_57) AT=835.025n

.meas tran vdout0_58ck1660 FIND v(dout0_58) AT=835.025n

.meas tran vdout0_59ck1660 FIND v(dout0_59) AT=835.025n

.meas tran vdout0_60ck1660 FIND v(dout0_60) AT=835.025n

.meas tran vdout0_61ck1660 FIND v(dout0_61) AT=835.025n

.meas tran vdout0_62ck1660 FIND v(dout0_62) AT=835.025n

.meas tran vdout0_63ck1660 FIND v(dout0_63) AT=835.025n

.meas tran vdout0_64ck1660 FIND v(dout0_64) AT=835.025n

.meas tran vdout0_65ck1660 FIND v(dout0_65) AT=835.025n

.meas tran vdout0_66ck1660 FIND v(dout0_66) AT=835.025n

.meas tran vdout0_67ck1660 FIND v(dout0_67) AT=835.025n

.meas tran vdout0_68ck1660 FIND v(dout0_68) AT=835.025n

.meas tran vdout0_69ck1660 FIND v(dout0_69) AT=835.025n

.meas tran vdout0_70ck1660 FIND v(dout0_70) AT=835.025n

.meas tran vdout0_71ck1660 FIND v(dout0_71) AT=835.025n

.meas tran vdout0_72ck1660 FIND v(dout0_72) AT=835.025n

.meas tran vdout0_73ck1660 FIND v(dout0_73) AT=835.025n

.meas tran vdout0_74ck1660 FIND v(dout0_74) AT=835.025n

.meas tran vdout0_75ck1660 FIND v(dout0_75) AT=835.025n

.meas tran vdout0_76ck1660 FIND v(dout0_76) AT=835.025n

.meas tran vdout0_77ck1660 FIND v(dout0_77) AT=835.025n

.meas tran vdout0_78ck1660 FIND v(dout0_78) AT=835.025n

.meas tran vdout0_79ck1660 FIND v(dout0_79) AT=835.025n

.meas tran vdout0_80ck1660 FIND v(dout0_80) AT=835.025n

.meas tran vdout0_81ck1660 FIND v(dout0_81) AT=835.025n

.meas tran vdout0_82ck1660 FIND v(dout0_82) AT=835.025n

.meas tran vdout0_83ck1660 FIND v(dout0_83) AT=835.025n

.meas tran vdout0_84ck1660 FIND v(dout0_84) AT=835.025n

.meas tran vdout0_85ck1660 FIND v(dout0_85) AT=835.025n

.meas tran vdout0_86ck1660 FIND v(dout0_86) AT=835.025n

.meas tran vdout0_87ck1660 FIND v(dout0_87) AT=835.025n

.meas tran vdout0_88ck1660 FIND v(dout0_88) AT=835.025n

.meas tran vdout0_89ck1660 FIND v(dout0_89) AT=835.025n

.meas tran vdout0_90ck1660 FIND v(dout0_90) AT=835.025n

.meas tran vdout0_91ck1660 FIND v(dout0_91) AT=835.025n

.meas tran vdout0_92ck1660 FIND v(dout0_92) AT=835.025n

.meas tran vdout0_93ck1660 FIND v(dout0_93) AT=835.025n

.meas tran vdout0_94ck1660 FIND v(dout0_94) AT=835.025n

.meas tran vdout0_95ck1660 FIND v(dout0_95) AT=835.025n

.meas tran vdout0_96ck1660 FIND v(dout0_96) AT=835.025n

.meas tran vdout0_97ck1660 FIND v(dout0_97) AT=835.025n

.meas tran vdout0_98ck1660 FIND v(dout0_98) AT=835.025n

.meas tran vdout0_99ck1660 FIND v(dout0_99) AT=835.025n

.meas tran vdout0_100ck1660 FIND v(dout0_100) AT=835.025n

.meas tran vdout0_101ck1660 FIND v(dout0_101) AT=835.025n

.meas tran vdout0_102ck1660 FIND v(dout0_102) AT=835.025n

.meas tran vdout0_103ck1660 FIND v(dout0_103) AT=835.025n

.meas tran vdout0_104ck1660 FIND v(dout0_104) AT=835.025n

.meas tran vdout0_105ck1660 FIND v(dout0_105) AT=835.025n

.meas tran vdout0_106ck1660 FIND v(dout0_106) AT=835.025n

.meas tran vdout0_107ck1660 FIND v(dout0_107) AT=835.025n

.meas tran vdout0_108ck1660 FIND v(dout0_108) AT=835.025n

.meas tran vdout0_109ck1660 FIND v(dout0_109) AT=835.025n

.meas tran vdout0_110ck1660 FIND v(dout0_110) AT=835.025n

.meas tran vdout0_111ck1660 FIND v(dout0_111) AT=835.025n

.meas tran vdout0_112ck1660 FIND v(dout0_112) AT=835.025n

.meas tran vdout0_113ck1660 FIND v(dout0_113) AT=835.025n

.meas tran vdout0_114ck1660 FIND v(dout0_114) AT=835.025n

.meas tran vdout0_115ck1660 FIND v(dout0_115) AT=835.025n

.meas tran vdout0_116ck1660 FIND v(dout0_116) AT=835.025n

.meas tran vdout0_117ck1660 FIND v(dout0_117) AT=835.025n

.meas tran vdout0_118ck1660 FIND v(dout0_118) AT=835.025n

.meas tran vdout0_119ck1660 FIND v(dout0_119) AT=835.025n

.meas tran vdout0_120ck1660 FIND v(dout0_120) AT=835.025n

.meas tran vdout0_121ck1660 FIND v(dout0_121) AT=835.025n

.meas tran vdout0_122ck1660 FIND v(dout0_122) AT=835.025n

.meas tran vdout0_123ck1660 FIND v(dout0_123) AT=835.025n

.meas tran vdout0_124ck1660 FIND v(dout0_124) AT=835.025n

.meas tran vdout0_125ck1660 FIND v(dout0_125) AT=835.025n

.meas tran vdout0_126ck1660 FIND v(dout0_126) AT=835.025n

.meas tran vdout0_127ck1660 FIND v(dout0_127) AT=835.025n

.meas tran vdout0_0ck1680 FIND v(dout0_0) AT=845.025n

.meas tran vdout0_1ck1680 FIND v(dout0_1) AT=845.025n

.meas tran vdout0_2ck1680 FIND v(dout0_2) AT=845.025n

.meas tran vdout0_3ck1680 FIND v(dout0_3) AT=845.025n

.meas tran vdout0_4ck1680 FIND v(dout0_4) AT=845.025n

.meas tran vdout0_5ck1680 FIND v(dout0_5) AT=845.025n

.meas tran vdout0_6ck1680 FIND v(dout0_6) AT=845.025n

.meas tran vdout0_7ck1680 FIND v(dout0_7) AT=845.025n

.meas tran vdout0_8ck1680 FIND v(dout0_8) AT=845.025n

.meas tran vdout0_9ck1680 FIND v(dout0_9) AT=845.025n

.meas tran vdout0_10ck1680 FIND v(dout0_10) AT=845.025n

.meas tran vdout0_11ck1680 FIND v(dout0_11) AT=845.025n

.meas tran vdout0_12ck1680 FIND v(dout0_12) AT=845.025n

.meas tran vdout0_13ck1680 FIND v(dout0_13) AT=845.025n

.meas tran vdout0_14ck1680 FIND v(dout0_14) AT=845.025n

.meas tran vdout0_15ck1680 FIND v(dout0_15) AT=845.025n

.meas tran vdout0_16ck1680 FIND v(dout0_16) AT=845.025n

.meas tran vdout0_17ck1680 FIND v(dout0_17) AT=845.025n

.meas tran vdout0_18ck1680 FIND v(dout0_18) AT=845.025n

.meas tran vdout0_19ck1680 FIND v(dout0_19) AT=845.025n

.meas tran vdout0_20ck1680 FIND v(dout0_20) AT=845.025n

.meas tran vdout0_21ck1680 FIND v(dout0_21) AT=845.025n

.meas tran vdout0_22ck1680 FIND v(dout0_22) AT=845.025n

.meas tran vdout0_23ck1680 FIND v(dout0_23) AT=845.025n

.meas tran vdout0_24ck1680 FIND v(dout0_24) AT=845.025n

.meas tran vdout0_25ck1680 FIND v(dout0_25) AT=845.025n

.meas tran vdout0_26ck1680 FIND v(dout0_26) AT=845.025n

.meas tran vdout0_27ck1680 FIND v(dout0_27) AT=845.025n

.meas tran vdout0_28ck1680 FIND v(dout0_28) AT=845.025n

.meas tran vdout0_29ck1680 FIND v(dout0_29) AT=845.025n

.meas tran vdout0_30ck1680 FIND v(dout0_30) AT=845.025n

.meas tran vdout0_31ck1680 FIND v(dout0_31) AT=845.025n

.meas tran vdout0_32ck1680 FIND v(dout0_32) AT=845.025n

.meas tran vdout0_33ck1680 FIND v(dout0_33) AT=845.025n

.meas tran vdout0_34ck1680 FIND v(dout0_34) AT=845.025n

.meas tran vdout0_35ck1680 FIND v(dout0_35) AT=845.025n

.meas tran vdout0_36ck1680 FIND v(dout0_36) AT=845.025n

.meas tran vdout0_37ck1680 FIND v(dout0_37) AT=845.025n

.meas tran vdout0_38ck1680 FIND v(dout0_38) AT=845.025n

.meas tran vdout0_39ck1680 FIND v(dout0_39) AT=845.025n

.meas tran vdout0_40ck1680 FIND v(dout0_40) AT=845.025n

.meas tran vdout0_41ck1680 FIND v(dout0_41) AT=845.025n

.meas tran vdout0_42ck1680 FIND v(dout0_42) AT=845.025n

.meas tran vdout0_43ck1680 FIND v(dout0_43) AT=845.025n

.meas tran vdout0_44ck1680 FIND v(dout0_44) AT=845.025n

.meas tran vdout0_45ck1680 FIND v(dout0_45) AT=845.025n

.meas tran vdout0_46ck1680 FIND v(dout0_46) AT=845.025n

.meas tran vdout0_47ck1680 FIND v(dout0_47) AT=845.025n

.meas tran vdout0_48ck1680 FIND v(dout0_48) AT=845.025n

.meas tran vdout0_49ck1680 FIND v(dout0_49) AT=845.025n

.meas tran vdout0_50ck1680 FIND v(dout0_50) AT=845.025n

.meas tran vdout0_51ck1680 FIND v(dout0_51) AT=845.025n

.meas tran vdout0_52ck1680 FIND v(dout0_52) AT=845.025n

.meas tran vdout0_53ck1680 FIND v(dout0_53) AT=845.025n

.meas tran vdout0_54ck1680 FIND v(dout0_54) AT=845.025n

.meas tran vdout0_55ck1680 FIND v(dout0_55) AT=845.025n

.meas tran vdout0_56ck1680 FIND v(dout0_56) AT=845.025n

.meas tran vdout0_57ck1680 FIND v(dout0_57) AT=845.025n

.meas tran vdout0_58ck1680 FIND v(dout0_58) AT=845.025n

.meas tran vdout0_59ck1680 FIND v(dout0_59) AT=845.025n

.meas tran vdout0_60ck1680 FIND v(dout0_60) AT=845.025n

.meas tran vdout0_61ck1680 FIND v(dout0_61) AT=845.025n

.meas tran vdout0_62ck1680 FIND v(dout0_62) AT=845.025n

.meas tran vdout0_63ck1680 FIND v(dout0_63) AT=845.025n

.meas tran vdout0_64ck1680 FIND v(dout0_64) AT=845.025n

.meas tran vdout0_65ck1680 FIND v(dout0_65) AT=845.025n

.meas tran vdout0_66ck1680 FIND v(dout0_66) AT=845.025n

.meas tran vdout0_67ck1680 FIND v(dout0_67) AT=845.025n

.meas tran vdout0_68ck1680 FIND v(dout0_68) AT=845.025n

.meas tran vdout0_69ck1680 FIND v(dout0_69) AT=845.025n

.meas tran vdout0_70ck1680 FIND v(dout0_70) AT=845.025n

.meas tran vdout0_71ck1680 FIND v(dout0_71) AT=845.025n

.meas tran vdout0_72ck1680 FIND v(dout0_72) AT=845.025n

.meas tran vdout0_73ck1680 FIND v(dout0_73) AT=845.025n

.meas tran vdout0_74ck1680 FIND v(dout0_74) AT=845.025n

.meas tran vdout0_75ck1680 FIND v(dout0_75) AT=845.025n

.meas tran vdout0_76ck1680 FIND v(dout0_76) AT=845.025n

.meas tran vdout0_77ck1680 FIND v(dout0_77) AT=845.025n

.meas tran vdout0_78ck1680 FIND v(dout0_78) AT=845.025n

.meas tran vdout0_79ck1680 FIND v(dout0_79) AT=845.025n

.meas tran vdout0_80ck1680 FIND v(dout0_80) AT=845.025n

.meas tran vdout0_81ck1680 FIND v(dout0_81) AT=845.025n

.meas tran vdout0_82ck1680 FIND v(dout0_82) AT=845.025n

.meas tran vdout0_83ck1680 FIND v(dout0_83) AT=845.025n

.meas tran vdout0_84ck1680 FIND v(dout0_84) AT=845.025n

.meas tran vdout0_85ck1680 FIND v(dout0_85) AT=845.025n

.meas tran vdout0_86ck1680 FIND v(dout0_86) AT=845.025n

.meas tran vdout0_87ck1680 FIND v(dout0_87) AT=845.025n

.meas tran vdout0_88ck1680 FIND v(dout0_88) AT=845.025n

.meas tran vdout0_89ck1680 FIND v(dout0_89) AT=845.025n

.meas tran vdout0_90ck1680 FIND v(dout0_90) AT=845.025n

.meas tran vdout0_91ck1680 FIND v(dout0_91) AT=845.025n

.meas tran vdout0_92ck1680 FIND v(dout0_92) AT=845.025n

.meas tran vdout0_93ck1680 FIND v(dout0_93) AT=845.025n

.meas tran vdout0_94ck1680 FIND v(dout0_94) AT=845.025n

.meas tran vdout0_95ck1680 FIND v(dout0_95) AT=845.025n

.meas tran vdout0_96ck1680 FIND v(dout0_96) AT=845.025n

.meas tran vdout0_97ck1680 FIND v(dout0_97) AT=845.025n

.meas tran vdout0_98ck1680 FIND v(dout0_98) AT=845.025n

.meas tran vdout0_99ck1680 FIND v(dout0_99) AT=845.025n

.meas tran vdout0_100ck1680 FIND v(dout0_100) AT=845.025n

.meas tran vdout0_101ck1680 FIND v(dout0_101) AT=845.025n

.meas tran vdout0_102ck1680 FIND v(dout0_102) AT=845.025n

.meas tran vdout0_103ck1680 FIND v(dout0_103) AT=845.025n

.meas tran vdout0_104ck1680 FIND v(dout0_104) AT=845.025n

.meas tran vdout0_105ck1680 FIND v(dout0_105) AT=845.025n

.meas tran vdout0_106ck1680 FIND v(dout0_106) AT=845.025n

.meas tran vdout0_107ck1680 FIND v(dout0_107) AT=845.025n

.meas tran vdout0_108ck1680 FIND v(dout0_108) AT=845.025n

.meas tran vdout0_109ck1680 FIND v(dout0_109) AT=845.025n

.meas tran vdout0_110ck1680 FIND v(dout0_110) AT=845.025n

.meas tran vdout0_111ck1680 FIND v(dout0_111) AT=845.025n

.meas tran vdout0_112ck1680 FIND v(dout0_112) AT=845.025n

.meas tran vdout0_113ck1680 FIND v(dout0_113) AT=845.025n

.meas tran vdout0_114ck1680 FIND v(dout0_114) AT=845.025n

.meas tran vdout0_115ck1680 FIND v(dout0_115) AT=845.025n

.meas tran vdout0_116ck1680 FIND v(dout0_116) AT=845.025n

.meas tran vdout0_117ck1680 FIND v(dout0_117) AT=845.025n

.meas tran vdout0_118ck1680 FIND v(dout0_118) AT=845.025n

.meas tran vdout0_119ck1680 FIND v(dout0_119) AT=845.025n

.meas tran vdout0_120ck1680 FIND v(dout0_120) AT=845.025n

.meas tran vdout0_121ck1680 FIND v(dout0_121) AT=845.025n

.meas tran vdout0_122ck1680 FIND v(dout0_122) AT=845.025n

.meas tran vdout0_123ck1680 FIND v(dout0_123) AT=845.025n

.meas tran vdout0_124ck1680 FIND v(dout0_124) AT=845.025n

.meas tran vdout0_125ck1680 FIND v(dout0_125) AT=845.025n

.meas tran vdout0_126ck1680 FIND v(dout0_126) AT=845.025n

.meas tran vdout0_127ck1680 FIND v(dout0_127) AT=845.025n

.meas tran vdout0_0ck1710 FIND v(dout0_0) AT=860.025n

.meas tran vdout0_1ck1710 FIND v(dout0_1) AT=860.025n

.meas tran vdout0_2ck1710 FIND v(dout0_2) AT=860.025n

.meas tran vdout0_3ck1710 FIND v(dout0_3) AT=860.025n

.meas tran vdout0_4ck1710 FIND v(dout0_4) AT=860.025n

.meas tran vdout0_5ck1710 FIND v(dout0_5) AT=860.025n

.meas tran vdout0_6ck1710 FIND v(dout0_6) AT=860.025n

.meas tran vdout0_7ck1710 FIND v(dout0_7) AT=860.025n

.meas tran vdout0_8ck1710 FIND v(dout0_8) AT=860.025n

.meas tran vdout0_9ck1710 FIND v(dout0_9) AT=860.025n

.meas tran vdout0_10ck1710 FIND v(dout0_10) AT=860.025n

.meas tran vdout0_11ck1710 FIND v(dout0_11) AT=860.025n

.meas tran vdout0_12ck1710 FIND v(dout0_12) AT=860.025n

.meas tran vdout0_13ck1710 FIND v(dout0_13) AT=860.025n

.meas tran vdout0_14ck1710 FIND v(dout0_14) AT=860.025n

.meas tran vdout0_15ck1710 FIND v(dout0_15) AT=860.025n

.meas tran vdout0_16ck1710 FIND v(dout0_16) AT=860.025n

.meas tran vdout0_17ck1710 FIND v(dout0_17) AT=860.025n

.meas tran vdout0_18ck1710 FIND v(dout0_18) AT=860.025n

.meas tran vdout0_19ck1710 FIND v(dout0_19) AT=860.025n

.meas tran vdout0_20ck1710 FIND v(dout0_20) AT=860.025n

.meas tran vdout0_21ck1710 FIND v(dout0_21) AT=860.025n

.meas tran vdout0_22ck1710 FIND v(dout0_22) AT=860.025n

.meas tran vdout0_23ck1710 FIND v(dout0_23) AT=860.025n

.meas tran vdout0_24ck1710 FIND v(dout0_24) AT=860.025n

.meas tran vdout0_25ck1710 FIND v(dout0_25) AT=860.025n

.meas tran vdout0_26ck1710 FIND v(dout0_26) AT=860.025n

.meas tran vdout0_27ck1710 FIND v(dout0_27) AT=860.025n

.meas tran vdout0_28ck1710 FIND v(dout0_28) AT=860.025n

.meas tran vdout0_29ck1710 FIND v(dout0_29) AT=860.025n

.meas tran vdout0_30ck1710 FIND v(dout0_30) AT=860.025n

.meas tran vdout0_31ck1710 FIND v(dout0_31) AT=860.025n

.meas tran vdout0_32ck1710 FIND v(dout0_32) AT=860.025n

.meas tran vdout0_33ck1710 FIND v(dout0_33) AT=860.025n

.meas tran vdout0_34ck1710 FIND v(dout0_34) AT=860.025n

.meas tran vdout0_35ck1710 FIND v(dout0_35) AT=860.025n

.meas tran vdout0_36ck1710 FIND v(dout0_36) AT=860.025n

.meas tran vdout0_37ck1710 FIND v(dout0_37) AT=860.025n

.meas tran vdout0_38ck1710 FIND v(dout0_38) AT=860.025n

.meas tran vdout0_39ck1710 FIND v(dout0_39) AT=860.025n

.meas tran vdout0_40ck1710 FIND v(dout0_40) AT=860.025n

.meas tran vdout0_41ck1710 FIND v(dout0_41) AT=860.025n

.meas tran vdout0_42ck1710 FIND v(dout0_42) AT=860.025n

.meas tran vdout0_43ck1710 FIND v(dout0_43) AT=860.025n

.meas tran vdout0_44ck1710 FIND v(dout0_44) AT=860.025n

.meas tran vdout0_45ck1710 FIND v(dout0_45) AT=860.025n

.meas tran vdout0_46ck1710 FIND v(dout0_46) AT=860.025n

.meas tran vdout0_47ck1710 FIND v(dout0_47) AT=860.025n

.meas tran vdout0_48ck1710 FIND v(dout0_48) AT=860.025n

.meas tran vdout0_49ck1710 FIND v(dout0_49) AT=860.025n

.meas tran vdout0_50ck1710 FIND v(dout0_50) AT=860.025n

.meas tran vdout0_51ck1710 FIND v(dout0_51) AT=860.025n

.meas tran vdout0_52ck1710 FIND v(dout0_52) AT=860.025n

.meas tran vdout0_53ck1710 FIND v(dout0_53) AT=860.025n

.meas tran vdout0_54ck1710 FIND v(dout0_54) AT=860.025n

.meas tran vdout0_55ck1710 FIND v(dout0_55) AT=860.025n

.meas tran vdout0_56ck1710 FIND v(dout0_56) AT=860.025n

.meas tran vdout0_57ck1710 FIND v(dout0_57) AT=860.025n

.meas tran vdout0_58ck1710 FIND v(dout0_58) AT=860.025n

.meas tran vdout0_59ck1710 FIND v(dout0_59) AT=860.025n

.meas tran vdout0_60ck1710 FIND v(dout0_60) AT=860.025n

.meas tran vdout0_61ck1710 FIND v(dout0_61) AT=860.025n

.meas tran vdout0_62ck1710 FIND v(dout0_62) AT=860.025n

.meas tran vdout0_63ck1710 FIND v(dout0_63) AT=860.025n

.meas tran vdout0_64ck1710 FIND v(dout0_64) AT=860.025n

.meas tran vdout0_65ck1710 FIND v(dout0_65) AT=860.025n

.meas tran vdout0_66ck1710 FIND v(dout0_66) AT=860.025n

.meas tran vdout0_67ck1710 FIND v(dout0_67) AT=860.025n

.meas tran vdout0_68ck1710 FIND v(dout0_68) AT=860.025n

.meas tran vdout0_69ck1710 FIND v(dout0_69) AT=860.025n

.meas tran vdout0_70ck1710 FIND v(dout0_70) AT=860.025n

.meas tran vdout0_71ck1710 FIND v(dout0_71) AT=860.025n

.meas tran vdout0_72ck1710 FIND v(dout0_72) AT=860.025n

.meas tran vdout0_73ck1710 FIND v(dout0_73) AT=860.025n

.meas tran vdout0_74ck1710 FIND v(dout0_74) AT=860.025n

.meas tran vdout0_75ck1710 FIND v(dout0_75) AT=860.025n

.meas tran vdout0_76ck1710 FIND v(dout0_76) AT=860.025n

.meas tran vdout0_77ck1710 FIND v(dout0_77) AT=860.025n

.meas tran vdout0_78ck1710 FIND v(dout0_78) AT=860.025n

.meas tran vdout0_79ck1710 FIND v(dout0_79) AT=860.025n

.meas tran vdout0_80ck1710 FIND v(dout0_80) AT=860.025n

.meas tran vdout0_81ck1710 FIND v(dout0_81) AT=860.025n

.meas tran vdout0_82ck1710 FIND v(dout0_82) AT=860.025n

.meas tran vdout0_83ck1710 FIND v(dout0_83) AT=860.025n

.meas tran vdout0_84ck1710 FIND v(dout0_84) AT=860.025n

.meas tran vdout0_85ck1710 FIND v(dout0_85) AT=860.025n

.meas tran vdout0_86ck1710 FIND v(dout0_86) AT=860.025n

.meas tran vdout0_87ck1710 FIND v(dout0_87) AT=860.025n

.meas tran vdout0_88ck1710 FIND v(dout0_88) AT=860.025n

.meas tran vdout0_89ck1710 FIND v(dout0_89) AT=860.025n

.meas tran vdout0_90ck1710 FIND v(dout0_90) AT=860.025n

.meas tran vdout0_91ck1710 FIND v(dout0_91) AT=860.025n

.meas tran vdout0_92ck1710 FIND v(dout0_92) AT=860.025n

.meas tran vdout0_93ck1710 FIND v(dout0_93) AT=860.025n

.meas tran vdout0_94ck1710 FIND v(dout0_94) AT=860.025n

.meas tran vdout0_95ck1710 FIND v(dout0_95) AT=860.025n

.meas tran vdout0_96ck1710 FIND v(dout0_96) AT=860.025n

.meas tran vdout0_97ck1710 FIND v(dout0_97) AT=860.025n

.meas tran vdout0_98ck1710 FIND v(dout0_98) AT=860.025n

.meas tran vdout0_99ck1710 FIND v(dout0_99) AT=860.025n

.meas tran vdout0_100ck1710 FIND v(dout0_100) AT=860.025n

.meas tran vdout0_101ck1710 FIND v(dout0_101) AT=860.025n

.meas tran vdout0_102ck1710 FIND v(dout0_102) AT=860.025n

.meas tran vdout0_103ck1710 FIND v(dout0_103) AT=860.025n

.meas tran vdout0_104ck1710 FIND v(dout0_104) AT=860.025n

.meas tran vdout0_105ck1710 FIND v(dout0_105) AT=860.025n

.meas tran vdout0_106ck1710 FIND v(dout0_106) AT=860.025n

.meas tran vdout0_107ck1710 FIND v(dout0_107) AT=860.025n

.meas tran vdout0_108ck1710 FIND v(dout0_108) AT=860.025n

.meas tran vdout0_109ck1710 FIND v(dout0_109) AT=860.025n

.meas tran vdout0_110ck1710 FIND v(dout0_110) AT=860.025n

.meas tran vdout0_111ck1710 FIND v(dout0_111) AT=860.025n

.meas tran vdout0_112ck1710 FIND v(dout0_112) AT=860.025n

.meas tran vdout0_113ck1710 FIND v(dout0_113) AT=860.025n

.meas tran vdout0_114ck1710 FIND v(dout0_114) AT=860.025n

.meas tran vdout0_115ck1710 FIND v(dout0_115) AT=860.025n

.meas tran vdout0_116ck1710 FIND v(dout0_116) AT=860.025n

.meas tran vdout0_117ck1710 FIND v(dout0_117) AT=860.025n

.meas tran vdout0_118ck1710 FIND v(dout0_118) AT=860.025n

.meas tran vdout0_119ck1710 FIND v(dout0_119) AT=860.025n

.meas tran vdout0_120ck1710 FIND v(dout0_120) AT=860.025n

.meas tran vdout0_121ck1710 FIND v(dout0_121) AT=860.025n

.meas tran vdout0_122ck1710 FIND v(dout0_122) AT=860.025n

.meas tran vdout0_123ck1710 FIND v(dout0_123) AT=860.025n

.meas tran vdout0_124ck1710 FIND v(dout0_124) AT=860.025n

.meas tran vdout0_125ck1710 FIND v(dout0_125) AT=860.025n

.meas tran vdout0_126ck1710 FIND v(dout0_126) AT=860.025n

.meas tran vdout0_127ck1710 FIND v(dout0_127) AT=860.025n

.meas tran vdout0_0ck1730 FIND v(dout0_0) AT=870.025n

.meas tran vdout0_1ck1730 FIND v(dout0_1) AT=870.025n

.meas tran vdout0_2ck1730 FIND v(dout0_2) AT=870.025n

.meas tran vdout0_3ck1730 FIND v(dout0_3) AT=870.025n

.meas tran vdout0_4ck1730 FIND v(dout0_4) AT=870.025n

.meas tran vdout0_5ck1730 FIND v(dout0_5) AT=870.025n

.meas tran vdout0_6ck1730 FIND v(dout0_6) AT=870.025n

.meas tran vdout0_7ck1730 FIND v(dout0_7) AT=870.025n

.meas tran vdout0_8ck1730 FIND v(dout0_8) AT=870.025n

.meas tran vdout0_9ck1730 FIND v(dout0_9) AT=870.025n

.meas tran vdout0_10ck1730 FIND v(dout0_10) AT=870.025n

.meas tran vdout0_11ck1730 FIND v(dout0_11) AT=870.025n

.meas tran vdout0_12ck1730 FIND v(dout0_12) AT=870.025n

.meas tran vdout0_13ck1730 FIND v(dout0_13) AT=870.025n

.meas tran vdout0_14ck1730 FIND v(dout0_14) AT=870.025n

.meas tran vdout0_15ck1730 FIND v(dout0_15) AT=870.025n

.meas tran vdout0_16ck1730 FIND v(dout0_16) AT=870.025n

.meas tran vdout0_17ck1730 FIND v(dout0_17) AT=870.025n

.meas tran vdout0_18ck1730 FIND v(dout0_18) AT=870.025n

.meas tran vdout0_19ck1730 FIND v(dout0_19) AT=870.025n

.meas tran vdout0_20ck1730 FIND v(dout0_20) AT=870.025n

.meas tran vdout0_21ck1730 FIND v(dout0_21) AT=870.025n

.meas tran vdout0_22ck1730 FIND v(dout0_22) AT=870.025n

.meas tran vdout0_23ck1730 FIND v(dout0_23) AT=870.025n

.meas tran vdout0_24ck1730 FIND v(dout0_24) AT=870.025n

.meas tran vdout0_25ck1730 FIND v(dout0_25) AT=870.025n

.meas tran vdout0_26ck1730 FIND v(dout0_26) AT=870.025n

.meas tran vdout0_27ck1730 FIND v(dout0_27) AT=870.025n

.meas tran vdout0_28ck1730 FIND v(dout0_28) AT=870.025n

.meas tran vdout0_29ck1730 FIND v(dout0_29) AT=870.025n

.meas tran vdout0_30ck1730 FIND v(dout0_30) AT=870.025n

.meas tran vdout0_31ck1730 FIND v(dout0_31) AT=870.025n

.meas tran vdout0_32ck1730 FIND v(dout0_32) AT=870.025n

.meas tran vdout0_33ck1730 FIND v(dout0_33) AT=870.025n

.meas tran vdout0_34ck1730 FIND v(dout0_34) AT=870.025n

.meas tran vdout0_35ck1730 FIND v(dout0_35) AT=870.025n

.meas tran vdout0_36ck1730 FIND v(dout0_36) AT=870.025n

.meas tran vdout0_37ck1730 FIND v(dout0_37) AT=870.025n

.meas tran vdout0_38ck1730 FIND v(dout0_38) AT=870.025n

.meas tran vdout0_39ck1730 FIND v(dout0_39) AT=870.025n

.meas tran vdout0_40ck1730 FIND v(dout0_40) AT=870.025n

.meas tran vdout0_41ck1730 FIND v(dout0_41) AT=870.025n

.meas tran vdout0_42ck1730 FIND v(dout0_42) AT=870.025n

.meas tran vdout0_43ck1730 FIND v(dout0_43) AT=870.025n

.meas tran vdout0_44ck1730 FIND v(dout0_44) AT=870.025n

.meas tran vdout0_45ck1730 FIND v(dout0_45) AT=870.025n

.meas tran vdout0_46ck1730 FIND v(dout0_46) AT=870.025n

.meas tran vdout0_47ck1730 FIND v(dout0_47) AT=870.025n

.meas tran vdout0_48ck1730 FIND v(dout0_48) AT=870.025n

.meas tran vdout0_49ck1730 FIND v(dout0_49) AT=870.025n

.meas tran vdout0_50ck1730 FIND v(dout0_50) AT=870.025n

.meas tran vdout0_51ck1730 FIND v(dout0_51) AT=870.025n

.meas tran vdout0_52ck1730 FIND v(dout0_52) AT=870.025n

.meas tran vdout0_53ck1730 FIND v(dout0_53) AT=870.025n

.meas tran vdout0_54ck1730 FIND v(dout0_54) AT=870.025n

.meas tran vdout0_55ck1730 FIND v(dout0_55) AT=870.025n

.meas tran vdout0_56ck1730 FIND v(dout0_56) AT=870.025n

.meas tran vdout0_57ck1730 FIND v(dout0_57) AT=870.025n

.meas tran vdout0_58ck1730 FIND v(dout0_58) AT=870.025n

.meas tran vdout0_59ck1730 FIND v(dout0_59) AT=870.025n

.meas tran vdout0_60ck1730 FIND v(dout0_60) AT=870.025n

.meas tran vdout0_61ck1730 FIND v(dout0_61) AT=870.025n

.meas tran vdout0_62ck1730 FIND v(dout0_62) AT=870.025n

.meas tran vdout0_63ck1730 FIND v(dout0_63) AT=870.025n

.meas tran vdout0_64ck1730 FIND v(dout0_64) AT=870.025n

.meas tran vdout0_65ck1730 FIND v(dout0_65) AT=870.025n

.meas tran vdout0_66ck1730 FIND v(dout0_66) AT=870.025n

.meas tran vdout0_67ck1730 FIND v(dout0_67) AT=870.025n

.meas tran vdout0_68ck1730 FIND v(dout0_68) AT=870.025n

.meas tran vdout0_69ck1730 FIND v(dout0_69) AT=870.025n

.meas tran vdout0_70ck1730 FIND v(dout0_70) AT=870.025n

.meas tran vdout0_71ck1730 FIND v(dout0_71) AT=870.025n

.meas tran vdout0_72ck1730 FIND v(dout0_72) AT=870.025n

.meas tran vdout0_73ck1730 FIND v(dout0_73) AT=870.025n

.meas tran vdout0_74ck1730 FIND v(dout0_74) AT=870.025n

.meas tran vdout0_75ck1730 FIND v(dout0_75) AT=870.025n

.meas tran vdout0_76ck1730 FIND v(dout0_76) AT=870.025n

.meas tran vdout0_77ck1730 FIND v(dout0_77) AT=870.025n

.meas tran vdout0_78ck1730 FIND v(dout0_78) AT=870.025n

.meas tran vdout0_79ck1730 FIND v(dout0_79) AT=870.025n

.meas tran vdout0_80ck1730 FIND v(dout0_80) AT=870.025n

.meas tran vdout0_81ck1730 FIND v(dout0_81) AT=870.025n

.meas tran vdout0_82ck1730 FIND v(dout0_82) AT=870.025n

.meas tran vdout0_83ck1730 FIND v(dout0_83) AT=870.025n

.meas tran vdout0_84ck1730 FIND v(dout0_84) AT=870.025n

.meas tran vdout0_85ck1730 FIND v(dout0_85) AT=870.025n

.meas tran vdout0_86ck1730 FIND v(dout0_86) AT=870.025n

.meas tran vdout0_87ck1730 FIND v(dout0_87) AT=870.025n

.meas tran vdout0_88ck1730 FIND v(dout0_88) AT=870.025n

.meas tran vdout0_89ck1730 FIND v(dout0_89) AT=870.025n

.meas tran vdout0_90ck1730 FIND v(dout0_90) AT=870.025n

.meas tran vdout0_91ck1730 FIND v(dout0_91) AT=870.025n

.meas tran vdout0_92ck1730 FIND v(dout0_92) AT=870.025n

.meas tran vdout0_93ck1730 FIND v(dout0_93) AT=870.025n

.meas tran vdout0_94ck1730 FIND v(dout0_94) AT=870.025n

.meas tran vdout0_95ck1730 FIND v(dout0_95) AT=870.025n

.meas tran vdout0_96ck1730 FIND v(dout0_96) AT=870.025n

.meas tran vdout0_97ck1730 FIND v(dout0_97) AT=870.025n

.meas tran vdout0_98ck1730 FIND v(dout0_98) AT=870.025n

.meas tran vdout0_99ck1730 FIND v(dout0_99) AT=870.025n

.meas tran vdout0_100ck1730 FIND v(dout0_100) AT=870.025n

.meas tran vdout0_101ck1730 FIND v(dout0_101) AT=870.025n

.meas tran vdout0_102ck1730 FIND v(dout0_102) AT=870.025n

.meas tran vdout0_103ck1730 FIND v(dout0_103) AT=870.025n

.meas tran vdout0_104ck1730 FIND v(dout0_104) AT=870.025n

.meas tran vdout0_105ck1730 FIND v(dout0_105) AT=870.025n

.meas tran vdout0_106ck1730 FIND v(dout0_106) AT=870.025n

.meas tran vdout0_107ck1730 FIND v(dout0_107) AT=870.025n

.meas tran vdout0_108ck1730 FIND v(dout0_108) AT=870.025n

.meas tran vdout0_109ck1730 FIND v(dout0_109) AT=870.025n

.meas tran vdout0_110ck1730 FIND v(dout0_110) AT=870.025n

.meas tran vdout0_111ck1730 FIND v(dout0_111) AT=870.025n

.meas tran vdout0_112ck1730 FIND v(dout0_112) AT=870.025n

.meas tran vdout0_113ck1730 FIND v(dout0_113) AT=870.025n

.meas tran vdout0_114ck1730 FIND v(dout0_114) AT=870.025n

.meas tran vdout0_115ck1730 FIND v(dout0_115) AT=870.025n

.meas tran vdout0_116ck1730 FIND v(dout0_116) AT=870.025n

.meas tran vdout0_117ck1730 FIND v(dout0_117) AT=870.025n

.meas tran vdout0_118ck1730 FIND v(dout0_118) AT=870.025n

.meas tran vdout0_119ck1730 FIND v(dout0_119) AT=870.025n

.meas tran vdout0_120ck1730 FIND v(dout0_120) AT=870.025n

.meas tran vdout0_121ck1730 FIND v(dout0_121) AT=870.025n

.meas tran vdout0_122ck1730 FIND v(dout0_122) AT=870.025n

.meas tran vdout0_123ck1730 FIND v(dout0_123) AT=870.025n

.meas tran vdout0_124ck1730 FIND v(dout0_124) AT=870.025n

.meas tran vdout0_125ck1730 FIND v(dout0_125) AT=870.025n

.meas tran vdout0_126ck1730 FIND v(dout0_126) AT=870.025n

.meas tran vdout0_127ck1730 FIND v(dout0_127) AT=870.025n

.meas tran vdout0_0ck1740 FIND v(dout0_0) AT=875.025n

.meas tran vdout0_1ck1740 FIND v(dout0_1) AT=875.025n

.meas tran vdout0_2ck1740 FIND v(dout0_2) AT=875.025n

.meas tran vdout0_3ck1740 FIND v(dout0_3) AT=875.025n

.meas tran vdout0_4ck1740 FIND v(dout0_4) AT=875.025n

.meas tran vdout0_5ck1740 FIND v(dout0_5) AT=875.025n

.meas tran vdout0_6ck1740 FIND v(dout0_6) AT=875.025n

.meas tran vdout0_7ck1740 FIND v(dout0_7) AT=875.025n

.meas tran vdout0_8ck1740 FIND v(dout0_8) AT=875.025n

.meas tran vdout0_9ck1740 FIND v(dout0_9) AT=875.025n

.meas tran vdout0_10ck1740 FIND v(dout0_10) AT=875.025n

.meas tran vdout0_11ck1740 FIND v(dout0_11) AT=875.025n

.meas tran vdout0_12ck1740 FIND v(dout0_12) AT=875.025n

.meas tran vdout0_13ck1740 FIND v(dout0_13) AT=875.025n

.meas tran vdout0_14ck1740 FIND v(dout0_14) AT=875.025n

.meas tran vdout0_15ck1740 FIND v(dout0_15) AT=875.025n

.meas tran vdout0_16ck1740 FIND v(dout0_16) AT=875.025n

.meas tran vdout0_17ck1740 FIND v(dout0_17) AT=875.025n

.meas tran vdout0_18ck1740 FIND v(dout0_18) AT=875.025n

.meas tran vdout0_19ck1740 FIND v(dout0_19) AT=875.025n

.meas tran vdout0_20ck1740 FIND v(dout0_20) AT=875.025n

.meas tran vdout0_21ck1740 FIND v(dout0_21) AT=875.025n

.meas tran vdout0_22ck1740 FIND v(dout0_22) AT=875.025n

.meas tran vdout0_23ck1740 FIND v(dout0_23) AT=875.025n

.meas tran vdout0_24ck1740 FIND v(dout0_24) AT=875.025n

.meas tran vdout0_25ck1740 FIND v(dout0_25) AT=875.025n

.meas tran vdout0_26ck1740 FIND v(dout0_26) AT=875.025n

.meas tran vdout0_27ck1740 FIND v(dout0_27) AT=875.025n

.meas tran vdout0_28ck1740 FIND v(dout0_28) AT=875.025n

.meas tran vdout0_29ck1740 FIND v(dout0_29) AT=875.025n

.meas tran vdout0_30ck1740 FIND v(dout0_30) AT=875.025n

.meas tran vdout0_31ck1740 FIND v(dout0_31) AT=875.025n

.meas tran vdout0_32ck1740 FIND v(dout0_32) AT=875.025n

.meas tran vdout0_33ck1740 FIND v(dout0_33) AT=875.025n

.meas tran vdout0_34ck1740 FIND v(dout0_34) AT=875.025n

.meas tran vdout0_35ck1740 FIND v(dout0_35) AT=875.025n

.meas tran vdout0_36ck1740 FIND v(dout0_36) AT=875.025n

.meas tran vdout0_37ck1740 FIND v(dout0_37) AT=875.025n

.meas tran vdout0_38ck1740 FIND v(dout0_38) AT=875.025n

.meas tran vdout0_39ck1740 FIND v(dout0_39) AT=875.025n

.meas tran vdout0_40ck1740 FIND v(dout0_40) AT=875.025n

.meas tran vdout0_41ck1740 FIND v(dout0_41) AT=875.025n

.meas tran vdout0_42ck1740 FIND v(dout0_42) AT=875.025n

.meas tran vdout0_43ck1740 FIND v(dout0_43) AT=875.025n

.meas tran vdout0_44ck1740 FIND v(dout0_44) AT=875.025n

.meas tran vdout0_45ck1740 FIND v(dout0_45) AT=875.025n

.meas tran vdout0_46ck1740 FIND v(dout0_46) AT=875.025n

.meas tran vdout0_47ck1740 FIND v(dout0_47) AT=875.025n

.meas tran vdout0_48ck1740 FIND v(dout0_48) AT=875.025n

.meas tran vdout0_49ck1740 FIND v(dout0_49) AT=875.025n

.meas tran vdout0_50ck1740 FIND v(dout0_50) AT=875.025n

.meas tran vdout0_51ck1740 FIND v(dout0_51) AT=875.025n

.meas tran vdout0_52ck1740 FIND v(dout0_52) AT=875.025n

.meas tran vdout0_53ck1740 FIND v(dout0_53) AT=875.025n

.meas tran vdout0_54ck1740 FIND v(dout0_54) AT=875.025n

.meas tran vdout0_55ck1740 FIND v(dout0_55) AT=875.025n

.meas tran vdout0_56ck1740 FIND v(dout0_56) AT=875.025n

.meas tran vdout0_57ck1740 FIND v(dout0_57) AT=875.025n

.meas tran vdout0_58ck1740 FIND v(dout0_58) AT=875.025n

.meas tran vdout0_59ck1740 FIND v(dout0_59) AT=875.025n

.meas tran vdout0_60ck1740 FIND v(dout0_60) AT=875.025n

.meas tran vdout0_61ck1740 FIND v(dout0_61) AT=875.025n

.meas tran vdout0_62ck1740 FIND v(dout0_62) AT=875.025n

.meas tran vdout0_63ck1740 FIND v(dout0_63) AT=875.025n

.meas tran vdout0_64ck1740 FIND v(dout0_64) AT=875.025n

.meas tran vdout0_65ck1740 FIND v(dout0_65) AT=875.025n

.meas tran vdout0_66ck1740 FIND v(dout0_66) AT=875.025n

.meas tran vdout0_67ck1740 FIND v(dout0_67) AT=875.025n

.meas tran vdout0_68ck1740 FIND v(dout0_68) AT=875.025n

.meas tran vdout0_69ck1740 FIND v(dout0_69) AT=875.025n

.meas tran vdout0_70ck1740 FIND v(dout0_70) AT=875.025n

.meas tran vdout0_71ck1740 FIND v(dout0_71) AT=875.025n

.meas tran vdout0_72ck1740 FIND v(dout0_72) AT=875.025n

.meas tran vdout0_73ck1740 FIND v(dout0_73) AT=875.025n

.meas tran vdout0_74ck1740 FIND v(dout0_74) AT=875.025n

.meas tran vdout0_75ck1740 FIND v(dout0_75) AT=875.025n

.meas tran vdout0_76ck1740 FIND v(dout0_76) AT=875.025n

.meas tran vdout0_77ck1740 FIND v(dout0_77) AT=875.025n

.meas tran vdout0_78ck1740 FIND v(dout0_78) AT=875.025n

.meas tran vdout0_79ck1740 FIND v(dout0_79) AT=875.025n

.meas tran vdout0_80ck1740 FIND v(dout0_80) AT=875.025n

.meas tran vdout0_81ck1740 FIND v(dout0_81) AT=875.025n

.meas tran vdout0_82ck1740 FIND v(dout0_82) AT=875.025n

.meas tran vdout0_83ck1740 FIND v(dout0_83) AT=875.025n

.meas tran vdout0_84ck1740 FIND v(dout0_84) AT=875.025n

.meas tran vdout0_85ck1740 FIND v(dout0_85) AT=875.025n

.meas tran vdout0_86ck1740 FIND v(dout0_86) AT=875.025n

.meas tran vdout0_87ck1740 FIND v(dout0_87) AT=875.025n

.meas tran vdout0_88ck1740 FIND v(dout0_88) AT=875.025n

.meas tran vdout0_89ck1740 FIND v(dout0_89) AT=875.025n

.meas tran vdout0_90ck1740 FIND v(dout0_90) AT=875.025n

.meas tran vdout0_91ck1740 FIND v(dout0_91) AT=875.025n

.meas tran vdout0_92ck1740 FIND v(dout0_92) AT=875.025n

.meas tran vdout0_93ck1740 FIND v(dout0_93) AT=875.025n

.meas tran vdout0_94ck1740 FIND v(dout0_94) AT=875.025n

.meas tran vdout0_95ck1740 FIND v(dout0_95) AT=875.025n

.meas tran vdout0_96ck1740 FIND v(dout0_96) AT=875.025n

.meas tran vdout0_97ck1740 FIND v(dout0_97) AT=875.025n

.meas tran vdout0_98ck1740 FIND v(dout0_98) AT=875.025n

.meas tran vdout0_99ck1740 FIND v(dout0_99) AT=875.025n

.meas tran vdout0_100ck1740 FIND v(dout0_100) AT=875.025n

.meas tran vdout0_101ck1740 FIND v(dout0_101) AT=875.025n

.meas tran vdout0_102ck1740 FIND v(dout0_102) AT=875.025n

.meas tran vdout0_103ck1740 FIND v(dout0_103) AT=875.025n

.meas tran vdout0_104ck1740 FIND v(dout0_104) AT=875.025n

.meas tran vdout0_105ck1740 FIND v(dout0_105) AT=875.025n

.meas tran vdout0_106ck1740 FIND v(dout0_106) AT=875.025n

.meas tran vdout0_107ck1740 FIND v(dout0_107) AT=875.025n

.meas tran vdout0_108ck1740 FIND v(dout0_108) AT=875.025n

.meas tran vdout0_109ck1740 FIND v(dout0_109) AT=875.025n

.meas tran vdout0_110ck1740 FIND v(dout0_110) AT=875.025n

.meas tran vdout0_111ck1740 FIND v(dout0_111) AT=875.025n

.meas tran vdout0_112ck1740 FIND v(dout0_112) AT=875.025n

.meas tran vdout0_113ck1740 FIND v(dout0_113) AT=875.025n

.meas tran vdout0_114ck1740 FIND v(dout0_114) AT=875.025n

.meas tran vdout0_115ck1740 FIND v(dout0_115) AT=875.025n

.meas tran vdout0_116ck1740 FIND v(dout0_116) AT=875.025n

.meas tran vdout0_117ck1740 FIND v(dout0_117) AT=875.025n

.meas tran vdout0_118ck1740 FIND v(dout0_118) AT=875.025n

.meas tran vdout0_119ck1740 FIND v(dout0_119) AT=875.025n

.meas tran vdout0_120ck1740 FIND v(dout0_120) AT=875.025n

.meas tran vdout0_121ck1740 FIND v(dout0_121) AT=875.025n

.meas tran vdout0_122ck1740 FIND v(dout0_122) AT=875.025n

.meas tran vdout0_123ck1740 FIND v(dout0_123) AT=875.025n

.meas tran vdout0_124ck1740 FIND v(dout0_124) AT=875.025n

.meas tran vdout0_125ck1740 FIND v(dout0_125) AT=875.025n

.meas tran vdout0_126ck1740 FIND v(dout0_126) AT=875.025n

.meas tran vdout0_127ck1740 FIND v(dout0_127) AT=875.025n

.meas tran vdout0_0ck1750 FIND v(dout0_0) AT=880.025n

.meas tran vdout0_1ck1750 FIND v(dout0_1) AT=880.025n

.meas tran vdout0_2ck1750 FIND v(dout0_2) AT=880.025n

.meas tran vdout0_3ck1750 FIND v(dout0_3) AT=880.025n

.meas tran vdout0_4ck1750 FIND v(dout0_4) AT=880.025n

.meas tran vdout0_5ck1750 FIND v(dout0_5) AT=880.025n

.meas tran vdout0_6ck1750 FIND v(dout0_6) AT=880.025n

.meas tran vdout0_7ck1750 FIND v(dout0_7) AT=880.025n

.meas tran vdout0_8ck1750 FIND v(dout0_8) AT=880.025n

.meas tran vdout0_9ck1750 FIND v(dout0_9) AT=880.025n

.meas tran vdout0_10ck1750 FIND v(dout0_10) AT=880.025n

.meas tran vdout0_11ck1750 FIND v(dout0_11) AT=880.025n

.meas tran vdout0_12ck1750 FIND v(dout0_12) AT=880.025n

.meas tran vdout0_13ck1750 FIND v(dout0_13) AT=880.025n

.meas tran vdout0_14ck1750 FIND v(dout0_14) AT=880.025n

.meas tran vdout0_15ck1750 FIND v(dout0_15) AT=880.025n

.meas tran vdout0_16ck1750 FIND v(dout0_16) AT=880.025n

.meas tran vdout0_17ck1750 FIND v(dout0_17) AT=880.025n

.meas tran vdout0_18ck1750 FIND v(dout0_18) AT=880.025n

.meas tran vdout0_19ck1750 FIND v(dout0_19) AT=880.025n

.meas tran vdout0_20ck1750 FIND v(dout0_20) AT=880.025n

.meas tran vdout0_21ck1750 FIND v(dout0_21) AT=880.025n

.meas tran vdout0_22ck1750 FIND v(dout0_22) AT=880.025n

.meas tran vdout0_23ck1750 FIND v(dout0_23) AT=880.025n

.meas tran vdout0_24ck1750 FIND v(dout0_24) AT=880.025n

.meas tran vdout0_25ck1750 FIND v(dout0_25) AT=880.025n

.meas tran vdout0_26ck1750 FIND v(dout0_26) AT=880.025n

.meas tran vdout0_27ck1750 FIND v(dout0_27) AT=880.025n

.meas tran vdout0_28ck1750 FIND v(dout0_28) AT=880.025n

.meas tran vdout0_29ck1750 FIND v(dout0_29) AT=880.025n

.meas tran vdout0_30ck1750 FIND v(dout0_30) AT=880.025n

.meas tran vdout0_31ck1750 FIND v(dout0_31) AT=880.025n

.meas tran vdout0_32ck1750 FIND v(dout0_32) AT=880.025n

.meas tran vdout0_33ck1750 FIND v(dout0_33) AT=880.025n

.meas tran vdout0_34ck1750 FIND v(dout0_34) AT=880.025n

.meas tran vdout0_35ck1750 FIND v(dout0_35) AT=880.025n

.meas tran vdout0_36ck1750 FIND v(dout0_36) AT=880.025n

.meas tran vdout0_37ck1750 FIND v(dout0_37) AT=880.025n

.meas tran vdout0_38ck1750 FIND v(dout0_38) AT=880.025n

.meas tran vdout0_39ck1750 FIND v(dout0_39) AT=880.025n

.meas tran vdout0_40ck1750 FIND v(dout0_40) AT=880.025n

.meas tran vdout0_41ck1750 FIND v(dout0_41) AT=880.025n

.meas tran vdout0_42ck1750 FIND v(dout0_42) AT=880.025n

.meas tran vdout0_43ck1750 FIND v(dout0_43) AT=880.025n

.meas tran vdout0_44ck1750 FIND v(dout0_44) AT=880.025n

.meas tran vdout0_45ck1750 FIND v(dout0_45) AT=880.025n

.meas tran vdout0_46ck1750 FIND v(dout0_46) AT=880.025n

.meas tran vdout0_47ck1750 FIND v(dout0_47) AT=880.025n

.meas tran vdout0_48ck1750 FIND v(dout0_48) AT=880.025n

.meas tran vdout0_49ck1750 FIND v(dout0_49) AT=880.025n

.meas tran vdout0_50ck1750 FIND v(dout0_50) AT=880.025n

.meas tran vdout0_51ck1750 FIND v(dout0_51) AT=880.025n

.meas tran vdout0_52ck1750 FIND v(dout0_52) AT=880.025n

.meas tran vdout0_53ck1750 FIND v(dout0_53) AT=880.025n

.meas tran vdout0_54ck1750 FIND v(dout0_54) AT=880.025n

.meas tran vdout0_55ck1750 FIND v(dout0_55) AT=880.025n

.meas tran vdout0_56ck1750 FIND v(dout0_56) AT=880.025n

.meas tran vdout0_57ck1750 FIND v(dout0_57) AT=880.025n

.meas tran vdout0_58ck1750 FIND v(dout0_58) AT=880.025n

.meas tran vdout0_59ck1750 FIND v(dout0_59) AT=880.025n

.meas tran vdout0_60ck1750 FIND v(dout0_60) AT=880.025n

.meas tran vdout0_61ck1750 FIND v(dout0_61) AT=880.025n

.meas tran vdout0_62ck1750 FIND v(dout0_62) AT=880.025n

.meas tran vdout0_63ck1750 FIND v(dout0_63) AT=880.025n

.meas tran vdout0_64ck1750 FIND v(dout0_64) AT=880.025n

.meas tran vdout0_65ck1750 FIND v(dout0_65) AT=880.025n

.meas tran vdout0_66ck1750 FIND v(dout0_66) AT=880.025n

.meas tran vdout0_67ck1750 FIND v(dout0_67) AT=880.025n

.meas tran vdout0_68ck1750 FIND v(dout0_68) AT=880.025n

.meas tran vdout0_69ck1750 FIND v(dout0_69) AT=880.025n

.meas tran vdout0_70ck1750 FIND v(dout0_70) AT=880.025n

.meas tran vdout0_71ck1750 FIND v(dout0_71) AT=880.025n

.meas tran vdout0_72ck1750 FIND v(dout0_72) AT=880.025n

.meas tran vdout0_73ck1750 FIND v(dout0_73) AT=880.025n

.meas tran vdout0_74ck1750 FIND v(dout0_74) AT=880.025n

.meas tran vdout0_75ck1750 FIND v(dout0_75) AT=880.025n

.meas tran vdout0_76ck1750 FIND v(dout0_76) AT=880.025n

.meas tran vdout0_77ck1750 FIND v(dout0_77) AT=880.025n

.meas tran vdout0_78ck1750 FIND v(dout0_78) AT=880.025n

.meas tran vdout0_79ck1750 FIND v(dout0_79) AT=880.025n

.meas tran vdout0_80ck1750 FIND v(dout0_80) AT=880.025n

.meas tran vdout0_81ck1750 FIND v(dout0_81) AT=880.025n

.meas tran vdout0_82ck1750 FIND v(dout0_82) AT=880.025n

.meas tran vdout0_83ck1750 FIND v(dout0_83) AT=880.025n

.meas tran vdout0_84ck1750 FIND v(dout0_84) AT=880.025n

.meas tran vdout0_85ck1750 FIND v(dout0_85) AT=880.025n

.meas tran vdout0_86ck1750 FIND v(dout0_86) AT=880.025n

.meas tran vdout0_87ck1750 FIND v(dout0_87) AT=880.025n

.meas tran vdout0_88ck1750 FIND v(dout0_88) AT=880.025n

.meas tran vdout0_89ck1750 FIND v(dout0_89) AT=880.025n

.meas tran vdout0_90ck1750 FIND v(dout0_90) AT=880.025n

.meas tran vdout0_91ck1750 FIND v(dout0_91) AT=880.025n

.meas tran vdout0_92ck1750 FIND v(dout0_92) AT=880.025n

.meas tran vdout0_93ck1750 FIND v(dout0_93) AT=880.025n

.meas tran vdout0_94ck1750 FIND v(dout0_94) AT=880.025n

.meas tran vdout0_95ck1750 FIND v(dout0_95) AT=880.025n

.meas tran vdout0_96ck1750 FIND v(dout0_96) AT=880.025n

.meas tran vdout0_97ck1750 FIND v(dout0_97) AT=880.025n

.meas tran vdout0_98ck1750 FIND v(dout0_98) AT=880.025n

.meas tran vdout0_99ck1750 FIND v(dout0_99) AT=880.025n

.meas tran vdout0_100ck1750 FIND v(dout0_100) AT=880.025n

.meas tran vdout0_101ck1750 FIND v(dout0_101) AT=880.025n

.meas tran vdout0_102ck1750 FIND v(dout0_102) AT=880.025n

.meas tran vdout0_103ck1750 FIND v(dout0_103) AT=880.025n

.meas tran vdout0_104ck1750 FIND v(dout0_104) AT=880.025n

.meas tran vdout0_105ck1750 FIND v(dout0_105) AT=880.025n

.meas tran vdout0_106ck1750 FIND v(dout0_106) AT=880.025n

.meas tran vdout0_107ck1750 FIND v(dout0_107) AT=880.025n

.meas tran vdout0_108ck1750 FIND v(dout0_108) AT=880.025n

.meas tran vdout0_109ck1750 FIND v(dout0_109) AT=880.025n

.meas tran vdout0_110ck1750 FIND v(dout0_110) AT=880.025n

.meas tran vdout0_111ck1750 FIND v(dout0_111) AT=880.025n

.meas tran vdout0_112ck1750 FIND v(dout0_112) AT=880.025n

.meas tran vdout0_113ck1750 FIND v(dout0_113) AT=880.025n

.meas tran vdout0_114ck1750 FIND v(dout0_114) AT=880.025n

.meas tran vdout0_115ck1750 FIND v(dout0_115) AT=880.025n

.meas tran vdout0_116ck1750 FIND v(dout0_116) AT=880.025n

.meas tran vdout0_117ck1750 FIND v(dout0_117) AT=880.025n

.meas tran vdout0_118ck1750 FIND v(dout0_118) AT=880.025n

.meas tran vdout0_119ck1750 FIND v(dout0_119) AT=880.025n

.meas tran vdout0_120ck1750 FIND v(dout0_120) AT=880.025n

.meas tran vdout0_121ck1750 FIND v(dout0_121) AT=880.025n

.meas tran vdout0_122ck1750 FIND v(dout0_122) AT=880.025n

.meas tran vdout0_123ck1750 FIND v(dout0_123) AT=880.025n

.meas tran vdout0_124ck1750 FIND v(dout0_124) AT=880.025n

.meas tran vdout0_125ck1750 FIND v(dout0_125) AT=880.025n

.meas tran vdout0_126ck1750 FIND v(dout0_126) AT=880.025n

.meas tran vdout0_127ck1750 FIND v(dout0_127) AT=880.025n

.meas tran vdout0_0ck1760 FIND v(dout0_0) AT=885.025n

.meas tran vdout0_1ck1760 FIND v(dout0_1) AT=885.025n

.meas tran vdout0_2ck1760 FIND v(dout0_2) AT=885.025n

.meas tran vdout0_3ck1760 FIND v(dout0_3) AT=885.025n

.meas tran vdout0_4ck1760 FIND v(dout0_4) AT=885.025n

.meas tran vdout0_5ck1760 FIND v(dout0_5) AT=885.025n

.meas tran vdout0_6ck1760 FIND v(dout0_6) AT=885.025n

.meas tran vdout0_7ck1760 FIND v(dout0_7) AT=885.025n

.meas tran vdout0_8ck1760 FIND v(dout0_8) AT=885.025n

.meas tran vdout0_9ck1760 FIND v(dout0_9) AT=885.025n

.meas tran vdout0_10ck1760 FIND v(dout0_10) AT=885.025n

.meas tran vdout0_11ck1760 FIND v(dout0_11) AT=885.025n

.meas tran vdout0_12ck1760 FIND v(dout0_12) AT=885.025n

.meas tran vdout0_13ck1760 FIND v(dout0_13) AT=885.025n

.meas tran vdout0_14ck1760 FIND v(dout0_14) AT=885.025n

.meas tran vdout0_15ck1760 FIND v(dout0_15) AT=885.025n

.meas tran vdout0_16ck1760 FIND v(dout0_16) AT=885.025n

.meas tran vdout0_17ck1760 FIND v(dout0_17) AT=885.025n

.meas tran vdout0_18ck1760 FIND v(dout0_18) AT=885.025n

.meas tran vdout0_19ck1760 FIND v(dout0_19) AT=885.025n

.meas tran vdout0_20ck1760 FIND v(dout0_20) AT=885.025n

.meas tran vdout0_21ck1760 FIND v(dout0_21) AT=885.025n

.meas tran vdout0_22ck1760 FIND v(dout0_22) AT=885.025n

.meas tran vdout0_23ck1760 FIND v(dout0_23) AT=885.025n

.meas tran vdout0_24ck1760 FIND v(dout0_24) AT=885.025n

.meas tran vdout0_25ck1760 FIND v(dout0_25) AT=885.025n

.meas tran vdout0_26ck1760 FIND v(dout0_26) AT=885.025n

.meas tran vdout0_27ck1760 FIND v(dout0_27) AT=885.025n

.meas tran vdout0_28ck1760 FIND v(dout0_28) AT=885.025n

.meas tran vdout0_29ck1760 FIND v(dout0_29) AT=885.025n

.meas tran vdout0_30ck1760 FIND v(dout0_30) AT=885.025n

.meas tran vdout0_31ck1760 FIND v(dout0_31) AT=885.025n

.meas tran vdout0_32ck1760 FIND v(dout0_32) AT=885.025n

.meas tran vdout0_33ck1760 FIND v(dout0_33) AT=885.025n

.meas tran vdout0_34ck1760 FIND v(dout0_34) AT=885.025n

.meas tran vdout0_35ck1760 FIND v(dout0_35) AT=885.025n

.meas tran vdout0_36ck1760 FIND v(dout0_36) AT=885.025n

.meas tran vdout0_37ck1760 FIND v(dout0_37) AT=885.025n

.meas tran vdout0_38ck1760 FIND v(dout0_38) AT=885.025n

.meas tran vdout0_39ck1760 FIND v(dout0_39) AT=885.025n

.meas tran vdout0_40ck1760 FIND v(dout0_40) AT=885.025n

.meas tran vdout0_41ck1760 FIND v(dout0_41) AT=885.025n

.meas tran vdout0_42ck1760 FIND v(dout0_42) AT=885.025n

.meas tran vdout0_43ck1760 FIND v(dout0_43) AT=885.025n

.meas tran vdout0_44ck1760 FIND v(dout0_44) AT=885.025n

.meas tran vdout0_45ck1760 FIND v(dout0_45) AT=885.025n

.meas tran vdout0_46ck1760 FIND v(dout0_46) AT=885.025n

.meas tran vdout0_47ck1760 FIND v(dout0_47) AT=885.025n

.meas tran vdout0_48ck1760 FIND v(dout0_48) AT=885.025n

.meas tran vdout0_49ck1760 FIND v(dout0_49) AT=885.025n

.meas tran vdout0_50ck1760 FIND v(dout0_50) AT=885.025n

.meas tran vdout0_51ck1760 FIND v(dout0_51) AT=885.025n

.meas tran vdout0_52ck1760 FIND v(dout0_52) AT=885.025n

.meas tran vdout0_53ck1760 FIND v(dout0_53) AT=885.025n

.meas tran vdout0_54ck1760 FIND v(dout0_54) AT=885.025n

.meas tran vdout0_55ck1760 FIND v(dout0_55) AT=885.025n

.meas tran vdout0_56ck1760 FIND v(dout0_56) AT=885.025n

.meas tran vdout0_57ck1760 FIND v(dout0_57) AT=885.025n

.meas tran vdout0_58ck1760 FIND v(dout0_58) AT=885.025n

.meas tran vdout0_59ck1760 FIND v(dout0_59) AT=885.025n

.meas tran vdout0_60ck1760 FIND v(dout0_60) AT=885.025n

.meas tran vdout0_61ck1760 FIND v(dout0_61) AT=885.025n

.meas tran vdout0_62ck1760 FIND v(dout0_62) AT=885.025n

.meas tran vdout0_63ck1760 FIND v(dout0_63) AT=885.025n

.meas tran vdout0_64ck1760 FIND v(dout0_64) AT=885.025n

.meas tran vdout0_65ck1760 FIND v(dout0_65) AT=885.025n

.meas tran vdout0_66ck1760 FIND v(dout0_66) AT=885.025n

.meas tran vdout0_67ck1760 FIND v(dout0_67) AT=885.025n

.meas tran vdout0_68ck1760 FIND v(dout0_68) AT=885.025n

.meas tran vdout0_69ck1760 FIND v(dout0_69) AT=885.025n

.meas tran vdout0_70ck1760 FIND v(dout0_70) AT=885.025n

.meas tran vdout0_71ck1760 FIND v(dout0_71) AT=885.025n

.meas tran vdout0_72ck1760 FIND v(dout0_72) AT=885.025n

.meas tran vdout0_73ck1760 FIND v(dout0_73) AT=885.025n

.meas tran vdout0_74ck1760 FIND v(dout0_74) AT=885.025n

.meas tran vdout0_75ck1760 FIND v(dout0_75) AT=885.025n

.meas tran vdout0_76ck1760 FIND v(dout0_76) AT=885.025n

.meas tran vdout0_77ck1760 FIND v(dout0_77) AT=885.025n

.meas tran vdout0_78ck1760 FIND v(dout0_78) AT=885.025n

.meas tran vdout0_79ck1760 FIND v(dout0_79) AT=885.025n

.meas tran vdout0_80ck1760 FIND v(dout0_80) AT=885.025n

.meas tran vdout0_81ck1760 FIND v(dout0_81) AT=885.025n

.meas tran vdout0_82ck1760 FIND v(dout0_82) AT=885.025n

.meas tran vdout0_83ck1760 FIND v(dout0_83) AT=885.025n

.meas tran vdout0_84ck1760 FIND v(dout0_84) AT=885.025n

.meas tran vdout0_85ck1760 FIND v(dout0_85) AT=885.025n

.meas tran vdout0_86ck1760 FIND v(dout0_86) AT=885.025n

.meas tran vdout0_87ck1760 FIND v(dout0_87) AT=885.025n

.meas tran vdout0_88ck1760 FIND v(dout0_88) AT=885.025n

.meas tran vdout0_89ck1760 FIND v(dout0_89) AT=885.025n

.meas tran vdout0_90ck1760 FIND v(dout0_90) AT=885.025n

.meas tran vdout0_91ck1760 FIND v(dout0_91) AT=885.025n

.meas tran vdout0_92ck1760 FIND v(dout0_92) AT=885.025n

.meas tran vdout0_93ck1760 FIND v(dout0_93) AT=885.025n

.meas tran vdout0_94ck1760 FIND v(dout0_94) AT=885.025n

.meas tran vdout0_95ck1760 FIND v(dout0_95) AT=885.025n

.meas tran vdout0_96ck1760 FIND v(dout0_96) AT=885.025n

.meas tran vdout0_97ck1760 FIND v(dout0_97) AT=885.025n

.meas tran vdout0_98ck1760 FIND v(dout0_98) AT=885.025n

.meas tran vdout0_99ck1760 FIND v(dout0_99) AT=885.025n

.meas tran vdout0_100ck1760 FIND v(dout0_100) AT=885.025n

.meas tran vdout0_101ck1760 FIND v(dout0_101) AT=885.025n

.meas tran vdout0_102ck1760 FIND v(dout0_102) AT=885.025n

.meas tran vdout0_103ck1760 FIND v(dout0_103) AT=885.025n

.meas tran vdout0_104ck1760 FIND v(dout0_104) AT=885.025n

.meas tran vdout0_105ck1760 FIND v(dout0_105) AT=885.025n

.meas tran vdout0_106ck1760 FIND v(dout0_106) AT=885.025n

.meas tran vdout0_107ck1760 FIND v(dout0_107) AT=885.025n

.meas tran vdout0_108ck1760 FIND v(dout0_108) AT=885.025n

.meas tran vdout0_109ck1760 FIND v(dout0_109) AT=885.025n

.meas tran vdout0_110ck1760 FIND v(dout0_110) AT=885.025n

.meas tran vdout0_111ck1760 FIND v(dout0_111) AT=885.025n

.meas tran vdout0_112ck1760 FIND v(dout0_112) AT=885.025n

.meas tran vdout0_113ck1760 FIND v(dout0_113) AT=885.025n

.meas tran vdout0_114ck1760 FIND v(dout0_114) AT=885.025n

.meas tran vdout0_115ck1760 FIND v(dout0_115) AT=885.025n

.meas tran vdout0_116ck1760 FIND v(dout0_116) AT=885.025n

.meas tran vdout0_117ck1760 FIND v(dout0_117) AT=885.025n

.meas tran vdout0_118ck1760 FIND v(dout0_118) AT=885.025n

.meas tran vdout0_119ck1760 FIND v(dout0_119) AT=885.025n

.meas tran vdout0_120ck1760 FIND v(dout0_120) AT=885.025n

.meas tran vdout0_121ck1760 FIND v(dout0_121) AT=885.025n

.meas tran vdout0_122ck1760 FIND v(dout0_122) AT=885.025n

.meas tran vdout0_123ck1760 FIND v(dout0_123) AT=885.025n

.meas tran vdout0_124ck1760 FIND v(dout0_124) AT=885.025n

.meas tran vdout0_125ck1760 FIND v(dout0_125) AT=885.025n

.meas tran vdout0_126ck1760 FIND v(dout0_126) AT=885.025n

.meas tran vdout0_127ck1760 FIND v(dout0_127) AT=885.025n

.meas tran vdout0_0ck1770 FIND v(dout0_0) AT=890.025n

.meas tran vdout0_1ck1770 FIND v(dout0_1) AT=890.025n

.meas tran vdout0_2ck1770 FIND v(dout0_2) AT=890.025n

.meas tran vdout0_3ck1770 FIND v(dout0_3) AT=890.025n

.meas tran vdout0_4ck1770 FIND v(dout0_4) AT=890.025n

.meas tran vdout0_5ck1770 FIND v(dout0_5) AT=890.025n

.meas tran vdout0_6ck1770 FIND v(dout0_6) AT=890.025n

.meas tran vdout0_7ck1770 FIND v(dout0_7) AT=890.025n

.meas tran vdout0_8ck1770 FIND v(dout0_8) AT=890.025n

.meas tran vdout0_9ck1770 FIND v(dout0_9) AT=890.025n

.meas tran vdout0_10ck1770 FIND v(dout0_10) AT=890.025n

.meas tran vdout0_11ck1770 FIND v(dout0_11) AT=890.025n

.meas tran vdout0_12ck1770 FIND v(dout0_12) AT=890.025n

.meas tran vdout0_13ck1770 FIND v(dout0_13) AT=890.025n

.meas tran vdout0_14ck1770 FIND v(dout0_14) AT=890.025n

.meas tran vdout0_15ck1770 FIND v(dout0_15) AT=890.025n

.meas tran vdout0_16ck1770 FIND v(dout0_16) AT=890.025n

.meas tran vdout0_17ck1770 FIND v(dout0_17) AT=890.025n

.meas tran vdout0_18ck1770 FIND v(dout0_18) AT=890.025n

.meas tran vdout0_19ck1770 FIND v(dout0_19) AT=890.025n

.meas tran vdout0_20ck1770 FIND v(dout0_20) AT=890.025n

.meas tran vdout0_21ck1770 FIND v(dout0_21) AT=890.025n

.meas tran vdout0_22ck1770 FIND v(dout0_22) AT=890.025n

.meas tran vdout0_23ck1770 FIND v(dout0_23) AT=890.025n

.meas tran vdout0_24ck1770 FIND v(dout0_24) AT=890.025n

.meas tran vdout0_25ck1770 FIND v(dout0_25) AT=890.025n

.meas tran vdout0_26ck1770 FIND v(dout0_26) AT=890.025n

.meas tran vdout0_27ck1770 FIND v(dout0_27) AT=890.025n

.meas tran vdout0_28ck1770 FIND v(dout0_28) AT=890.025n

.meas tran vdout0_29ck1770 FIND v(dout0_29) AT=890.025n

.meas tran vdout0_30ck1770 FIND v(dout0_30) AT=890.025n

.meas tran vdout0_31ck1770 FIND v(dout0_31) AT=890.025n

.meas tran vdout0_32ck1770 FIND v(dout0_32) AT=890.025n

.meas tran vdout0_33ck1770 FIND v(dout0_33) AT=890.025n

.meas tran vdout0_34ck1770 FIND v(dout0_34) AT=890.025n

.meas tran vdout0_35ck1770 FIND v(dout0_35) AT=890.025n

.meas tran vdout0_36ck1770 FIND v(dout0_36) AT=890.025n

.meas tran vdout0_37ck1770 FIND v(dout0_37) AT=890.025n

.meas tran vdout0_38ck1770 FIND v(dout0_38) AT=890.025n

.meas tran vdout0_39ck1770 FIND v(dout0_39) AT=890.025n

.meas tran vdout0_40ck1770 FIND v(dout0_40) AT=890.025n

.meas tran vdout0_41ck1770 FIND v(dout0_41) AT=890.025n

.meas tran vdout0_42ck1770 FIND v(dout0_42) AT=890.025n

.meas tran vdout0_43ck1770 FIND v(dout0_43) AT=890.025n

.meas tran vdout0_44ck1770 FIND v(dout0_44) AT=890.025n

.meas tran vdout0_45ck1770 FIND v(dout0_45) AT=890.025n

.meas tran vdout0_46ck1770 FIND v(dout0_46) AT=890.025n

.meas tran vdout0_47ck1770 FIND v(dout0_47) AT=890.025n

.meas tran vdout0_48ck1770 FIND v(dout0_48) AT=890.025n

.meas tran vdout0_49ck1770 FIND v(dout0_49) AT=890.025n

.meas tran vdout0_50ck1770 FIND v(dout0_50) AT=890.025n

.meas tran vdout0_51ck1770 FIND v(dout0_51) AT=890.025n

.meas tran vdout0_52ck1770 FIND v(dout0_52) AT=890.025n

.meas tran vdout0_53ck1770 FIND v(dout0_53) AT=890.025n

.meas tran vdout0_54ck1770 FIND v(dout0_54) AT=890.025n

.meas tran vdout0_55ck1770 FIND v(dout0_55) AT=890.025n

.meas tran vdout0_56ck1770 FIND v(dout0_56) AT=890.025n

.meas tran vdout0_57ck1770 FIND v(dout0_57) AT=890.025n

.meas tran vdout0_58ck1770 FIND v(dout0_58) AT=890.025n

.meas tran vdout0_59ck1770 FIND v(dout0_59) AT=890.025n

.meas tran vdout0_60ck1770 FIND v(dout0_60) AT=890.025n

.meas tran vdout0_61ck1770 FIND v(dout0_61) AT=890.025n

.meas tran vdout0_62ck1770 FIND v(dout0_62) AT=890.025n

.meas tran vdout0_63ck1770 FIND v(dout0_63) AT=890.025n

.meas tran vdout0_64ck1770 FIND v(dout0_64) AT=890.025n

.meas tran vdout0_65ck1770 FIND v(dout0_65) AT=890.025n

.meas tran vdout0_66ck1770 FIND v(dout0_66) AT=890.025n

.meas tran vdout0_67ck1770 FIND v(dout0_67) AT=890.025n

.meas tran vdout0_68ck1770 FIND v(dout0_68) AT=890.025n

.meas tran vdout0_69ck1770 FIND v(dout0_69) AT=890.025n

.meas tran vdout0_70ck1770 FIND v(dout0_70) AT=890.025n

.meas tran vdout0_71ck1770 FIND v(dout0_71) AT=890.025n

.meas tran vdout0_72ck1770 FIND v(dout0_72) AT=890.025n

.meas tran vdout0_73ck1770 FIND v(dout0_73) AT=890.025n

.meas tran vdout0_74ck1770 FIND v(dout0_74) AT=890.025n

.meas tran vdout0_75ck1770 FIND v(dout0_75) AT=890.025n

.meas tran vdout0_76ck1770 FIND v(dout0_76) AT=890.025n

.meas tran vdout0_77ck1770 FIND v(dout0_77) AT=890.025n

.meas tran vdout0_78ck1770 FIND v(dout0_78) AT=890.025n

.meas tran vdout0_79ck1770 FIND v(dout0_79) AT=890.025n

.meas tran vdout0_80ck1770 FIND v(dout0_80) AT=890.025n

.meas tran vdout0_81ck1770 FIND v(dout0_81) AT=890.025n

.meas tran vdout0_82ck1770 FIND v(dout0_82) AT=890.025n

.meas tran vdout0_83ck1770 FIND v(dout0_83) AT=890.025n

.meas tran vdout0_84ck1770 FIND v(dout0_84) AT=890.025n

.meas tran vdout0_85ck1770 FIND v(dout0_85) AT=890.025n

.meas tran vdout0_86ck1770 FIND v(dout0_86) AT=890.025n

.meas tran vdout0_87ck1770 FIND v(dout0_87) AT=890.025n

.meas tran vdout0_88ck1770 FIND v(dout0_88) AT=890.025n

.meas tran vdout0_89ck1770 FIND v(dout0_89) AT=890.025n

.meas tran vdout0_90ck1770 FIND v(dout0_90) AT=890.025n

.meas tran vdout0_91ck1770 FIND v(dout0_91) AT=890.025n

.meas tran vdout0_92ck1770 FIND v(dout0_92) AT=890.025n

.meas tran vdout0_93ck1770 FIND v(dout0_93) AT=890.025n

.meas tran vdout0_94ck1770 FIND v(dout0_94) AT=890.025n

.meas tran vdout0_95ck1770 FIND v(dout0_95) AT=890.025n

.meas tran vdout0_96ck1770 FIND v(dout0_96) AT=890.025n

.meas tran vdout0_97ck1770 FIND v(dout0_97) AT=890.025n

.meas tran vdout0_98ck1770 FIND v(dout0_98) AT=890.025n

.meas tran vdout0_99ck1770 FIND v(dout0_99) AT=890.025n

.meas tran vdout0_100ck1770 FIND v(dout0_100) AT=890.025n

.meas tran vdout0_101ck1770 FIND v(dout0_101) AT=890.025n

.meas tran vdout0_102ck1770 FIND v(dout0_102) AT=890.025n

.meas tran vdout0_103ck1770 FIND v(dout0_103) AT=890.025n

.meas tran vdout0_104ck1770 FIND v(dout0_104) AT=890.025n

.meas tran vdout0_105ck1770 FIND v(dout0_105) AT=890.025n

.meas tran vdout0_106ck1770 FIND v(dout0_106) AT=890.025n

.meas tran vdout0_107ck1770 FIND v(dout0_107) AT=890.025n

.meas tran vdout0_108ck1770 FIND v(dout0_108) AT=890.025n

.meas tran vdout0_109ck1770 FIND v(dout0_109) AT=890.025n

.meas tran vdout0_110ck1770 FIND v(dout0_110) AT=890.025n

.meas tran vdout0_111ck1770 FIND v(dout0_111) AT=890.025n

.meas tran vdout0_112ck1770 FIND v(dout0_112) AT=890.025n

.meas tran vdout0_113ck1770 FIND v(dout0_113) AT=890.025n

.meas tran vdout0_114ck1770 FIND v(dout0_114) AT=890.025n

.meas tran vdout0_115ck1770 FIND v(dout0_115) AT=890.025n

.meas tran vdout0_116ck1770 FIND v(dout0_116) AT=890.025n

.meas tran vdout0_117ck1770 FIND v(dout0_117) AT=890.025n

.meas tran vdout0_118ck1770 FIND v(dout0_118) AT=890.025n

.meas tran vdout0_119ck1770 FIND v(dout0_119) AT=890.025n

.meas tran vdout0_120ck1770 FIND v(dout0_120) AT=890.025n

.meas tran vdout0_121ck1770 FIND v(dout0_121) AT=890.025n

.meas tran vdout0_122ck1770 FIND v(dout0_122) AT=890.025n

.meas tran vdout0_123ck1770 FIND v(dout0_123) AT=890.025n

.meas tran vdout0_124ck1770 FIND v(dout0_124) AT=890.025n

.meas tran vdout0_125ck1770 FIND v(dout0_125) AT=890.025n

.meas tran vdout0_126ck1770 FIND v(dout0_126) AT=890.025n

.meas tran vdout0_127ck1770 FIND v(dout0_127) AT=890.025n

.meas tran vdout0_0ck1780 FIND v(dout0_0) AT=895.025n

.meas tran vdout0_1ck1780 FIND v(dout0_1) AT=895.025n

.meas tran vdout0_2ck1780 FIND v(dout0_2) AT=895.025n

.meas tran vdout0_3ck1780 FIND v(dout0_3) AT=895.025n

.meas tran vdout0_4ck1780 FIND v(dout0_4) AT=895.025n

.meas tran vdout0_5ck1780 FIND v(dout0_5) AT=895.025n

.meas tran vdout0_6ck1780 FIND v(dout0_6) AT=895.025n

.meas tran vdout0_7ck1780 FIND v(dout0_7) AT=895.025n

.meas tran vdout0_8ck1780 FIND v(dout0_8) AT=895.025n

.meas tran vdout0_9ck1780 FIND v(dout0_9) AT=895.025n

.meas tran vdout0_10ck1780 FIND v(dout0_10) AT=895.025n

.meas tran vdout0_11ck1780 FIND v(dout0_11) AT=895.025n

.meas tran vdout0_12ck1780 FIND v(dout0_12) AT=895.025n

.meas tran vdout0_13ck1780 FIND v(dout0_13) AT=895.025n

.meas tran vdout0_14ck1780 FIND v(dout0_14) AT=895.025n

.meas tran vdout0_15ck1780 FIND v(dout0_15) AT=895.025n

.meas tran vdout0_16ck1780 FIND v(dout0_16) AT=895.025n

.meas tran vdout0_17ck1780 FIND v(dout0_17) AT=895.025n

.meas tran vdout0_18ck1780 FIND v(dout0_18) AT=895.025n

.meas tran vdout0_19ck1780 FIND v(dout0_19) AT=895.025n

.meas tran vdout0_20ck1780 FIND v(dout0_20) AT=895.025n

.meas tran vdout0_21ck1780 FIND v(dout0_21) AT=895.025n

.meas tran vdout0_22ck1780 FIND v(dout0_22) AT=895.025n

.meas tran vdout0_23ck1780 FIND v(dout0_23) AT=895.025n

.meas tran vdout0_24ck1780 FIND v(dout0_24) AT=895.025n

.meas tran vdout0_25ck1780 FIND v(dout0_25) AT=895.025n

.meas tran vdout0_26ck1780 FIND v(dout0_26) AT=895.025n

.meas tran vdout0_27ck1780 FIND v(dout0_27) AT=895.025n

.meas tran vdout0_28ck1780 FIND v(dout0_28) AT=895.025n

.meas tran vdout0_29ck1780 FIND v(dout0_29) AT=895.025n

.meas tran vdout0_30ck1780 FIND v(dout0_30) AT=895.025n

.meas tran vdout0_31ck1780 FIND v(dout0_31) AT=895.025n

.meas tran vdout0_32ck1780 FIND v(dout0_32) AT=895.025n

.meas tran vdout0_33ck1780 FIND v(dout0_33) AT=895.025n

.meas tran vdout0_34ck1780 FIND v(dout0_34) AT=895.025n

.meas tran vdout0_35ck1780 FIND v(dout0_35) AT=895.025n

.meas tran vdout0_36ck1780 FIND v(dout0_36) AT=895.025n

.meas tran vdout0_37ck1780 FIND v(dout0_37) AT=895.025n

.meas tran vdout0_38ck1780 FIND v(dout0_38) AT=895.025n

.meas tran vdout0_39ck1780 FIND v(dout0_39) AT=895.025n

.meas tran vdout0_40ck1780 FIND v(dout0_40) AT=895.025n

.meas tran vdout0_41ck1780 FIND v(dout0_41) AT=895.025n

.meas tran vdout0_42ck1780 FIND v(dout0_42) AT=895.025n

.meas tran vdout0_43ck1780 FIND v(dout0_43) AT=895.025n

.meas tran vdout0_44ck1780 FIND v(dout0_44) AT=895.025n

.meas tran vdout0_45ck1780 FIND v(dout0_45) AT=895.025n

.meas tran vdout0_46ck1780 FIND v(dout0_46) AT=895.025n

.meas tran vdout0_47ck1780 FIND v(dout0_47) AT=895.025n

.meas tran vdout0_48ck1780 FIND v(dout0_48) AT=895.025n

.meas tran vdout0_49ck1780 FIND v(dout0_49) AT=895.025n

.meas tran vdout0_50ck1780 FIND v(dout0_50) AT=895.025n

.meas tran vdout0_51ck1780 FIND v(dout0_51) AT=895.025n

.meas tran vdout0_52ck1780 FIND v(dout0_52) AT=895.025n

.meas tran vdout0_53ck1780 FIND v(dout0_53) AT=895.025n

.meas tran vdout0_54ck1780 FIND v(dout0_54) AT=895.025n

.meas tran vdout0_55ck1780 FIND v(dout0_55) AT=895.025n

.meas tran vdout0_56ck1780 FIND v(dout0_56) AT=895.025n

.meas tran vdout0_57ck1780 FIND v(dout0_57) AT=895.025n

.meas tran vdout0_58ck1780 FIND v(dout0_58) AT=895.025n

.meas tran vdout0_59ck1780 FIND v(dout0_59) AT=895.025n

.meas tran vdout0_60ck1780 FIND v(dout0_60) AT=895.025n

.meas tran vdout0_61ck1780 FIND v(dout0_61) AT=895.025n

.meas tran vdout0_62ck1780 FIND v(dout0_62) AT=895.025n

.meas tran vdout0_63ck1780 FIND v(dout0_63) AT=895.025n

.meas tran vdout0_64ck1780 FIND v(dout0_64) AT=895.025n

.meas tran vdout0_65ck1780 FIND v(dout0_65) AT=895.025n

.meas tran vdout0_66ck1780 FIND v(dout0_66) AT=895.025n

.meas tran vdout0_67ck1780 FIND v(dout0_67) AT=895.025n

.meas tran vdout0_68ck1780 FIND v(dout0_68) AT=895.025n

.meas tran vdout0_69ck1780 FIND v(dout0_69) AT=895.025n

.meas tran vdout0_70ck1780 FIND v(dout0_70) AT=895.025n

.meas tran vdout0_71ck1780 FIND v(dout0_71) AT=895.025n

.meas tran vdout0_72ck1780 FIND v(dout0_72) AT=895.025n

.meas tran vdout0_73ck1780 FIND v(dout0_73) AT=895.025n

.meas tran vdout0_74ck1780 FIND v(dout0_74) AT=895.025n

.meas tran vdout0_75ck1780 FIND v(dout0_75) AT=895.025n

.meas tran vdout0_76ck1780 FIND v(dout0_76) AT=895.025n

.meas tran vdout0_77ck1780 FIND v(dout0_77) AT=895.025n

.meas tran vdout0_78ck1780 FIND v(dout0_78) AT=895.025n

.meas tran vdout0_79ck1780 FIND v(dout0_79) AT=895.025n

.meas tran vdout0_80ck1780 FIND v(dout0_80) AT=895.025n

.meas tran vdout0_81ck1780 FIND v(dout0_81) AT=895.025n

.meas tran vdout0_82ck1780 FIND v(dout0_82) AT=895.025n

.meas tran vdout0_83ck1780 FIND v(dout0_83) AT=895.025n

.meas tran vdout0_84ck1780 FIND v(dout0_84) AT=895.025n

.meas tran vdout0_85ck1780 FIND v(dout0_85) AT=895.025n

.meas tran vdout0_86ck1780 FIND v(dout0_86) AT=895.025n

.meas tran vdout0_87ck1780 FIND v(dout0_87) AT=895.025n

.meas tran vdout0_88ck1780 FIND v(dout0_88) AT=895.025n

.meas tran vdout0_89ck1780 FIND v(dout0_89) AT=895.025n

.meas tran vdout0_90ck1780 FIND v(dout0_90) AT=895.025n

.meas tran vdout0_91ck1780 FIND v(dout0_91) AT=895.025n

.meas tran vdout0_92ck1780 FIND v(dout0_92) AT=895.025n

.meas tran vdout0_93ck1780 FIND v(dout0_93) AT=895.025n

.meas tran vdout0_94ck1780 FIND v(dout0_94) AT=895.025n

.meas tran vdout0_95ck1780 FIND v(dout0_95) AT=895.025n

.meas tran vdout0_96ck1780 FIND v(dout0_96) AT=895.025n

.meas tran vdout0_97ck1780 FIND v(dout0_97) AT=895.025n

.meas tran vdout0_98ck1780 FIND v(dout0_98) AT=895.025n

.meas tran vdout0_99ck1780 FIND v(dout0_99) AT=895.025n

.meas tran vdout0_100ck1780 FIND v(dout0_100) AT=895.025n

.meas tran vdout0_101ck1780 FIND v(dout0_101) AT=895.025n

.meas tran vdout0_102ck1780 FIND v(dout0_102) AT=895.025n

.meas tran vdout0_103ck1780 FIND v(dout0_103) AT=895.025n

.meas tran vdout0_104ck1780 FIND v(dout0_104) AT=895.025n

.meas tran vdout0_105ck1780 FIND v(dout0_105) AT=895.025n

.meas tran vdout0_106ck1780 FIND v(dout0_106) AT=895.025n

.meas tran vdout0_107ck1780 FIND v(dout0_107) AT=895.025n

.meas tran vdout0_108ck1780 FIND v(dout0_108) AT=895.025n

.meas tran vdout0_109ck1780 FIND v(dout0_109) AT=895.025n

.meas tran vdout0_110ck1780 FIND v(dout0_110) AT=895.025n

.meas tran vdout0_111ck1780 FIND v(dout0_111) AT=895.025n

.meas tran vdout0_112ck1780 FIND v(dout0_112) AT=895.025n

.meas tran vdout0_113ck1780 FIND v(dout0_113) AT=895.025n

.meas tran vdout0_114ck1780 FIND v(dout0_114) AT=895.025n

.meas tran vdout0_115ck1780 FIND v(dout0_115) AT=895.025n

.meas tran vdout0_116ck1780 FIND v(dout0_116) AT=895.025n

.meas tran vdout0_117ck1780 FIND v(dout0_117) AT=895.025n

.meas tran vdout0_118ck1780 FIND v(dout0_118) AT=895.025n

.meas tran vdout0_119ck1780 FIND v(dout0_119) AT=895.025n

.meas tran vdout0_120ck1780 FIND v(dout0_120) AT=895.025n

.meas tran vdout0_121ck1780 FIND v(dout0_121) AT=895.025n

.meas tran vdout0_122ck1780 FIND v(dout0_122) AT=895.025n

.meas tran vdout0_123ck1780 FIND v(dout0_123) AT=895.025n

.meas tran vdout0_124ck1780 FIND v(dout0_124) AT=895.025n

.meas tran vdout0_125ck1780 FIND v(dout0_125) AT=895.025n

.meas tran vdout0_126ck1780 FIND v(dout0_126) AT=895.025n

.meas tran vdout0_127ck1780 FIND v(dout0_127) AT=895.025n

.meas tran vdout0_0ck1800 FIND v(dout0_0) AT=905.025n

.meas tran vdout0_1ck1800 FIND v(dout0_1) AT=905.025n

.meas tran vdout0_2ck1800 FIND v(dout0_2) AT=905.025n

.meas tran vdout0_3ck1800 FIND v(dout0_3) AT=905.025n

.meas tran vdout0_4ck1800 FIND v(dout0_4) AT=905.025n

.meas tran vdout0_5ck1800 FIND v(dout0_5) AT=905.025n

.meas tran vdout0_6ck1800 FIND v(dout0_6) AT=905.025n

.meas tran vdout0_7ck1800 FIND v(dout0_7) AT=905.025n

.meas tran vdout0_8ck1800 FIND v(dout0_8) AT=905.025n

.meas tran vdout0_9ck1800 FIND v(dout0_9) AT=905.025n

.meas tran vdout0_10ck1800 FIND v(dout0_10) AT=905.025n

.meas tran vdout0_11ck1800 FIND v(dout0_11) AT=905.025n

.meas tran vdout0_12ck1800 FIND v(dout0_12) AT=905.025n

.meas tran vdout0_13ck1800 FIND v(dout0_13) AT=905.025n

.meas tran vdout0_14ck1800 FIND v(dout0_14) AT=905.025n

.meas tran vdout0_15ck1800 FIND v(dout0_15) AT=905.025n

.meas tran vdout0_16ck1800 FIND v(dout0_16) AT=905.025n

.meas tran vdout0_17ck1800 FIND v(dout0_17) AT=905.025n

.meas tran vdout0_18ck1800 FIND v(dout0_18) AT=905.025n

.meas tran vdout0_19ck1800 FIND v(dout0_19) AT=905.025n

.meas tran vdout0_20ck1800 FIND v(dout0_20) AT=905.025n

.meas tran vdout0_21ck1800 FIND v(dout0_21) AT=905.025n

.meas tran vdout0_22ck1800 FIND v(dout0_22) AT=905.025n

.meas tran vdout0_23ck1800 FIND v(dout0_23) AT=905.025n

.meas tran vdout0_24ck1800 FIND v(dout0_24) AT=905.025n

.meas tran vdout0_25ck1800 FIND v(dout0_25) AT=905.025n

.meas tran vdout0_26ck1800 FIND v(dout0_26) AT=905.025n

.meas tran vdout0_27ck1800 FIND v(dout0_27) AT=905.025n

.meas tran vdout0_28ck1800 FIND v(dout0_28) AT=905.025n

.meas tran vdout0_29ck1800 FIND v(dout0_29) AT=905.025n

.meas tran vdout0_30ck1800 FIND v(dout0_30) AT=905.025n

.meas tran vdout0_31ck1800 FIND v(dout0_31) AT=905.025n

.meas tran vdout0_32ck1800 FIND v(dout0_32) AT=905.025n

.meas tran vdout0_33ck1800 FIND v(dout0_33) AT=905.025n

.meas tran vdout0_34ck1800 FIND v(dout0_34) AT=905.025n

.meas tran vdout0_35ck1800 FIND v(dout0_35) AT=905.025n

.meas tran vdout0_36ck1800 FIND v(dout0_36) AT=905.025n

.meas tran vdout0_37ck1800 FIND v(dout0_37) AT=905.025n

.meas tran vdout0_38ck1800 FIND v(dout0_38) AT=905.025n

.meas tran vdout0_39ck1800 FIND v(dout0_39) AT=905.025n

.meas tran vdout0_40ck1800 FIND v(dout0_40) AT=905.025n

.meas tran vdout0_41ck1800 FIND v(dout0_41) AT=905.025n

.meas tran vdout0_42ck1800 FIND v(dout0_42) AT=905.025n

.meas tran vdout0_43ck1800 FIND v(dout0_43) AT=905.025n

.meas tran vdout0_44ck1800 FIND v(dout0_44) AT=905.025n

.meas tran vdout0_45ck1800 FIND v(dout0_45) AT=905.025n

.meas tran vdout0_46ck1800 FIND v(dout0_46) AT=905.025n

.meas tran vdout0_47ck1800 FIND v(dout0_47) AT=905.025n

.meas tran vdout0_48ck1800 FIND v(dout0_48) AT=905.025n

.meas tran vdout0_49ck1800 FIND v(dout0_49) AT=905.025n

.meas tran vdout0_50ck1800 FIND v(dout0_50) AT=905.025n

.meas tran vdout0_51ck1800 FIND v(dout0_51) AT=905.025n

.meas tran vdout0_52ck1800 FIND v(dout0_52) AT=905.025n

.meas tran vdout0_53ck1800 FIND v(dout0_53) AT=905.025n

.meas tran vdout0_54ck1800 FIND v(dout0_54) AT=905.025n

.meas tran vdout0_55ck1800 FIND v(dout0_55) AT=905.025n

.meas tran vdout0_56ck1800 FIND v(dout0_56) AT=905.025n

.meas tran vdout0_57ck1800 FIND v(dout0_57) AT=905.025n

.meas tran vdout0_58ck1800 FIND v(dout0_58) AT=905.025n

.meas tran vdout0_59ck1800 FIND v(dout0_59) AT=905.025n

.meas tran vdout0_60ck1800 FIND v(dout0_60) AT=905.025n

.meas tran vdout0_61ck1800 FIND v(dout0_61) AT=905.025n

.meas tran vdout0_62ck1800 FIND v(dout0_62) AT=905.025n

.meas tran vdout0_63ck1800 FIND v(dout0_63) AT=905.025n

.meas tran vdout0_64ck1800 FIND v(dout0_64) AT=905.025n

.meas tran vdout0_65ck1800 FIND v(dout0_65) AT=905.025n

.meas tran vdout0_66ck1800 FIND v(dout0_66) AT=905.025n

.meas tran vdout0_67ck1800 FIND v(dout0_67) AT=905.025n

.meas tran vdout0_68ck1800 FIND v(dout0_68) AT=905.025n

.meas tran vdout0_69ck1800 FIND v(dout0_69) AT=905.025n

.meas tran vdout0_70ck1800 FIND v(dout0_70) AT=905.025n

.meas tran vdout0_71ck1800 FIND v(dout0_71) AT=905.025n

.meas tran vdout0_72ck1800 FIND v(dout0_72) AT=905.025n

.meas tran vdout0_73ck1800 FIND v(dout0_73) AT=905.025n

.meas tran vdout0_74ck1800 FIND v(dout0_74) AT=905.025n

.meas tran vdout0_75ck1800 FIND v(dout0_75) AT=905.025n

.meas tran vdout0_76ck1800 FIND v(dout0_76) AT=905.025n

.meas tran vdout0_77ck1800 FIND v(dout0_77) AT=905.025n

.meas tran vdout0_78ck1800 FIND v(dout0_78) AT=905.025n

.meas tran vdout0_79ck1800 FIND v(dout0_79) AT=905.025n

.meas tran vdout0_80ck1800 FIND v(dout0_80) AT=905.025n

.meas tran vdout0_81ck1800 FIND v(dout0_81) AT=905.025n

.meas tran vdout0_82ck1800 FIND v(dout0_82) AT=905.025n

.meas tran vdout0_83ck1800 FIND v(dout0_83) AT=905.025n

.meas tran vdout0_84ck1800 FIND v(dout0_84) AT=905.025n

.meas tran vdout0_85ck1800 FIND v(dout0_85) AT=905.025n

.meas tran vdout0_86ck1800 FIND v(dout0_86) AT=905.025n

.meas tran vdout0_87ck1800 FIND v(dout0_87) AT=905.025n

.meas tran vdout0_88ck1800 FIND v(dout0_88) AT=905.025n

.meas tran vdout0_89ck1800 FIND v(dout0_89) AT=905.025n

.meas tran vdout0_90ck1800 FIND v(dout0_90) AT=905.025n

.meas tran vdout0_91ck1800 FIND v(dout0_91) AT=905.025n

.meas tran vdout0_92ck1800 FIND v(dout0_92) AT=905.025n

.meas tran vdout0_93ck1800 FIND v(dout0_93) AT=905.025n

.meas tran vdout0_94ck1800 FIND v(dout0_94) AT=905.025n

.meas tran vdout0_95ck1800 FIND v(dout0_95) AT=905.025n

.meas tran vdout0_96ck1800 FIND v(dout0_96) AT=905.025n

.meas tran vdout0_97ck1800 FIND v(dout0_97) AT=905.025n

.meas tran vdout0_98ck1800 FIND v(dout0_98) AT=905.025n

.meas tran vdout0_99ck1800 FIND v(dout0_99) AT=905.025n

.meas tran vdout0_100ck1800 FIND v(dout0_100) AT=905.025n

.meas tran vdout0_101ck1800 FIND v(dout0_101) AT=905.025n

.meas tran vdout0_102ck1800 FIND v(dout0_102) AT=905.025n

.meas tran vdout0_103ck1800 FIND v(dout0_103) AT=905.025n

.meas tran vdout0_104ck1800 FIND v(dout0_104) AT=905.025n

.meas tran vdout0_105ck1800 FIND v(dout0_105) AT=905.025n

.meas tran vdout0_106ck1800 FIND v(dout0_106) AT=905.025n

.meas tran vdout0_107ck1800 FIND v(dout0_107) AT=905.025n

.meas tran vdout0_108ck1800 FIND v(dout0_108) AT=905.025n

.meas tran vdout0_109ck1800 FIND v(dout0_109) AT=905.025n

.meas tran vdout0_110ck1800 FIND v(dout0_110) AT=905.025n

.meas tran vdout0_111ck1800 FIND v(dout0_111) AT=905.025n

.meas tran vdout0_112ck1800 FIND v(dout0_112) AT=905.025n

.meas tran vdout0_113ck1800 FIND v(dout0_113) AT=905.025n

.meas tran vdout0_114ck1800 FIND v(dout0_114) AT=905.025n

.meas tran vdout0_115ck1800 FIND v(dout0_115) AT=905.025n

.meas tran vdout0_116ck1800 FIND v(dout0_116) AT=905.025n

.meas tran vdout0_117ck1800 FIND v(dout0_117) AT=905.025n

.meas tran vdout0_118ck1800 FIND v(dout0_118) AT=905.025n

.meas tran vdout0_119ck1800 FIND v(dout0_119) AT=905.025n

.meas tran vdout0_120ck1800 FIND v(dout0_120) AT=905.025n

.meas tran vdout0_121ck1800 FIND v(dout0_121) AT=905.025n

.meas tran vdout0_122ck1800 FIND v(dout0_122) AT=905.025n

.meas tran vdout0_123ck1800 FIND v(dout0_123) AT=905.025n

.meas tran vdout0_124ck1800 FIND v(dout0_124) AT=905.025n

.meas tran vdout0_125ck1800 FIND v(dout0_125) AT=905.025n

.meas tran vdout0_126ck1800 FIND v(dout0_126) AT=905.025n

.meas tran vdout0_127ck1800 FIND v(dout0_127) AT=905.025n

.meas tran vdout0_0ck1830 FIND v(dout0_0) AT=920.025n

.meas tran vdout0_1ck1830 FIND v(dout0_1) AT=920.025n

.meas tran vdout0_2ck1830 FIND v(dout0_2) AT=920.025n

.meas tran vdout0_3ck1830 FIND v(dout0_3) AT=920.025n

.meas tran vdout0_4ck1830 FIND v(dout0_4) AT=920.025n

.meas tran vdout0_5ck1830 FIND v(dout0_5) AT=920.025n

.meas tran vdout0_6ck1830 FIND v(dout0_6) AT=920.025n

.meas tran vdout0_7ck1830 FIND v(dout0_7) AT=920.025n

.meas tran vdout0_8ck1830 FIND v(dout0_8) AT=920.025n

.meas tran vdout0_9ck1830 FIND v(dout0_9) AT=920.025n

.meas tran vdout0_10ck1830 FIND v(dout0_10) AT=920.025n

.meas tran vdout0_11ck1830 FIND v(dout0_11) AT=920.025n

.meas tran vdout0_12ck1830 FIND v(dout0_12) AT=920.025n

.meas tran vdout0_13ck1830 FIND v(dout0_13) AT=920.025n

.meas tran vdout0_14ck1830 FIND v(dout0_14) AT=920.025n

.meas tran vdout0_15ck1830 FIND v(dout0_15) AT=920.025n

.meas tran vdout0_16ck1830 FIND v(dout0_16) AT=920.025n

.meas tran vdout0_17ck1830 FIND v(dout0_17) AT=920.025n

.meas tran vdout0_18ck1830 FIND v(dout0_18) AT=920.025n

.meas tran vdout0_19ck1830 FIND v(dout0_19) AT=920.025n

.meas tran vdout0_20ck1830 FIND v(dout0_20) AT=920.025n

.meas tran vdout0_21ck1830 FIND v(dout0_21) AT=920.025n

.meas tran vdout0_22ck1830 FIND v(dout0_22) AT=920.025n

.meas tran vdout0_23ck1830 FIND v(dout0_23) AT=920.025n

.meas tran vdout0_24ck1830 FIND v(dout0_24) AT=920.025n

.meas tran vdout0_25ck1830 FIND v(dout0_25) AT=920.025n

.meas tran vdout0_26ck1830 FIND v(dout0_26) AT=920.025n

.meas tran vdout0_27ck1830 FIND v(dout0_27) AT=920.025n

.meas tran vdout0_28ck1830 FIND v(dout0_28) AT=920.025n

.meas tran vdout0_29ck1830 FIND v(dout0_29) AT=920.025n

.meas tran vdout0_30ck1830 FIND v(dout0_30) AT=920.025n

.meas tran vdout0_31ck1830 FIND v(dout0_31) AT=920.025n

.meas tran vdout0_32ck1830 FIND v(dout0_32) AT=920.025n

.meas tran vdout0_33ck1830 FIND v(dout0_33) AT=920.025n

.meas tran vdout0_34ck1830 FIND v(dout0_34) AT=920.025n

.meas tran vdout0_35ck1830 FIND v(dout0_35) AT=920.025n

.meas tran vdout0_36ck1830 FIND v(dout0_36) AT=920.025n

.meas tran vdout0_37ck1830 FIND v(dout0_37) AT=920.025n

.meas tran vdout0_38ck1830 FIND v(dout0_38) AT=920.025n

.meas tran vdout0_39ck1830 FIND v(dout0_39) AT=920.025n

.meas tran vdout0_40ck1830 FIND v(dout0_40) AT=920.025n

.meas tran vdout0_41ck1830 FIND v(dout0_41) AT=920.025n

.meas tran vdout0_42ck1830 FIND v(dout0_42) AT=920.025n

.meas tran vdout0_43ck1830 FIND v(dout0_43) AT=920.025n

.meas tran vdout0_44ck1830 FIND v(dout0_44) AT=920.025n

.meas tran vdout0_45ck1830 FIND v(dout0_45) AT=920.025n

.meas tran vdout0_46ck1830 FIND v(dout0_46) AT=920.025n

.meas tran vdout0_47ck1830 FIND v(dout0_47) AT=920.025n

.meas tran vdout0_48ck1830 FIND v(dout0_48) AT=920.025n

.meas tran vdout0_49ck1830 FIND v(dout0_49) AT=920.025n

.meas tran vdout0_50ck1830 FIND v(dout0_50) AT=920.025n

.meas tran vdout0_51ck1830 FIND v(dout0_51) AT=920.025n

.meas tran vdout0_52ck1830 FIND v(dout0_52) AT=920.025n

.meas tran vdout0_53ck1830 FIND v(dout0_53) AT=920.025n

.meas tran vdout0_54ck1830 FIND v(dout0_54) AT=920.025n

.meas tran vdout0_55ck1830 FIND v(dout0_55) AT=920.025n

.meas tran vdout0_56ck1830 FIND v(dout0_56) AT=920.025n

.meas tran vdout0_57ck1830 FIND v(dout0_57) AT=920.025n

.meas tran vdout0_58ck1830 FIND v(dout0_58) AT=920.025n

.meas tran vdout0_59ck1830 FIND v(dout0_59) AT=920.025n

.meas tran vdout0_60ck1830 FIND v(dout0_60) AT=920.025n

.meas tran vdout0_61ck1830 FIND v(dout0_61) AT=920.025n

.meas tran vdout0_62ck1830 FIND v(dout0_62) AT=920.025n

.meas tran vdout0_63ck1830 FIND v(dout0_63) AT=920.025n

.meas tran vdout0_64ck1830 FIND v(dout0_64) AT=920.025n

.meas tran vdout0_65ck1830 FIND v(dout0_65) AT=920.025n

.meas tran vdout0_66ck1830 FIND v(dout0_66) AT=920.025n

.meas tran vdout0_67ck1830 FIND v(dout0_67) AT=920.025n

.meas tran vdout0_68ck1830 FIND v(dout0_68) AT=920.025n

.meas tran vdout0_69ck1830 FIND v(dout0_69) AT=920.025n

.meas tran vdout0_70ck1830 FIND v(dout0_70) AT=920.025n

.meas tran vdout0_71ck1830 FIND v(dout0_71) AT=920.025n

.meas tran vdout0_72ck1830 FIND v(dout0_72) AT=920.025n

.meas tran vdout0_73ck1830 FIND v(dout0_73) AT=920.025n

.meas tran vdout0_74ck1830 FIND v(dout0_74) AT=920.025n

.meas tran vdout0_75ck1830 FIND v(dout0_75) AT=920.025n

.meas tran vdout0_76ck1830 FIND v(dout0_76) AT=920.025n

.meas tran vdout0_77ck1830 FIND v(dout0_77) AT=920.025n

.meas tran vdout0_78ck1830 FIND v(dout0_78) AT=920.025n

.meas tran vdout0_79ck1830 FIND v(dout0_79) AT=920.025n

.meas tran vdout0_80ck1830 FIND v(dout0_80) AT=920.025n

.meas tran vdout0_81ck1830 FIND v(dout0_81) AT=920.025n

.meas tran vdout0_82ck1830 FIND v(dout0_82) AT=920.025n

.meas tran vdout0_83ck1830 FIND v(dout0_83) AT=920.025n

.meas tran vdout0_84ck1830 FIND v(dout0_84) AT=920.025n

.meas tran vdout0_85ck1830 FIND v(dout0_85) AT=920.025n

.meas tran vdout0_86ck1830 FIND v(dout0_86) AT=920.025n

.meas tran vdout0_87ck1830 FIND v(dout0_87) AT=920.025n

.meas tran vdout0_88ck1830 FIND v(dout0_88) AT=920.025n

.meas tran vdout0_89ck1830 FIND v(dout0_89) AT=920.025n

.meas tran vdout0_90ck1830 FIND v(dout0_90) AT=920.025n

.meas tran vdout0_91ck1830 FIND v(dout0_91) AT=920.025n

.meas tran vdout0_92ck1830 FIND v(dout0_92) AT=920.025n

.meas tran vdout0_93ck1830 FIND v(dout0_93) AT=920.025n

.meas tran vdout0_94ck1830 FIND v(dout0_94) AT=920.025n

.meas tran vdout0_95ck1830 FIND v(dout0_95) AT=920.025n

.meas tran vdout0_96ck1830 FIND v(dout0_96) AT=920.025n

.meas tran vdout0_97ck1830 FIND v(dout0_97) AT=920.025n

.meas tran vdout0_98ck1830 FIND v(dout0_98) AT=920.025n

.meas tran vdout0_99ck1830 FIND v(dout0_99) AT=920.025n

.meas tran vdout0_100ck1830 FIND v(dout0_100) AT=920.025n

.meas tran vdout0_101ck1830 FIND v(dout0_101) AT=920.025n

.meas tran vdout0_102ck1830 FIND v(dout0_102) AT=920.025n

.meas tran vdout0_103ck1830 FIND v(dout0_103) AT=920.025n

.meas tran vdout0_104ck1830 FIND v(dout0_104) AT=920.025n

.meas tran vdout0_105ck1830 FIND v(dout0_105) AT=920.025n

.meas tran vdout0_106ck1830 FIND v(dout0_106) AT=920.025n

.meas tran vdout0_107ck1830 FIND v(dout0_107) AT=920.025n

.meas tran vdout0_108ck1830 FIND v(dout0_108) AT=920.025n

.meas tran vdout0_109ck1830 FIND v(dout0_109) AT=920.025n

.meas tran vdout0_110ck1830 FIND v(dout0_110) AT=920.025n

.meas tran vdout0_111ck1830 FIND v(dout0_111) AT=920.025n

.meas tran vdout0_112ck1830 FIND v(dout0_112) AT=920.025n

.meas tran vdout0_113ck1830 FIND v(dout0_113) AT=920.025n

.meas tran vdout0_114ck1830 FIND v(dout0_114) AT=920.025n

.meas tran vdout0_115ck1830 FIND v(dout0_115) AT=920.025n

.meas tran vdout0_116ck1830 FIND v(dout0_116) AT=920.025n

.meas tran vdout0_117ck1830 FIND v(dout0_117) AT=920.025n

.meas tran vdout0_118ck1830 FIND v(dout0_118) AT=920.025n

.meas tran vdout0_119ck1830 FIND v(dout0_119) AT=920.025n

.meas tran vdout0_120ck1830 FIND v(dout0_120) AT=920.025n

.meas tran vdout0_121ck1830 FIND v(dout0_121) AT=920.025n

.meas tran vdout0_122ck1830 FIND v(dout0_122) AT=920.025n

.meas tran vdout0_123ck1830 FIND v(dout0_123) AT=920.025n

.meas tran vdout0_124ck1830 FIND v(dout0_124) AT=920.025n

.meas tran vdout0_125ck1830 FIND v(dout0_125) AT=920.025n

.meas tran vdout0_126ck1830 FIND v(dout0_126) AT=920.025n

.meas tran vdout0_127ck1830 FIND v(dout0_127) AT=920.025n

.meas tran vdout0_0ck1840 FIND v(dout0_0) AT=925.025n

.meas tran vdout0_1ck1840 FIND v(dout0_1) AT=925.025n

.meas tran vdout0_2ck1840 FIND v(dout0_2) AT=925.025n

.meas tran vdout0_3ck1840 FIND v(dout0_3) AT=925.025n

.meas tran vdout0_4ck1840 FIND v(dout0_4) AT=925.025n

.meas tran vdout0_5ck1840 FIND v(dout0_5) AT=925.025n

.meas tran vdout0_6ck1840 FIND v(dout0_6) AT=925.025n

.meas tran vdout0_7ck1840 FIND v(dout0_7) AT=925.025n

.meas tran vdout0_8ck1840 FIND v(dout0_8) AT=925.025n

.meas tran vdout0_9ck1840 FIND v(dout0_9) AT=925.025n

.meas tran vdout0_10ck1840 FIND v(dout0_10) AT=925.025n

.meas tran vdout0_11ck1840 FIND v(dout0_11) AT=925.025n

.meas tran vdout0_12ck1840 FIND v(dout0_12) AT=925.025n

.meas tran vdout0_13ck1840 FIND v(dout0_13) AT=925.025n

.meas tran vdout0_14ck1840 FIND v(dout0_14) AT=925.025n

.meas tran vdout0_15ck1840 FIND v(dout0_15) AT=925.025n

.meas tran vdout0_16ck1840 FIND v(dout0_16) AT=925.025n

.meas tran vdout0_17ck1840 FIND v(dout0_17) AT=925.025n

.meas tran vdout0_18ck1840 FIND v(dout0_18) AT=925.025n

.meas tran vdout0_19ck1840 FIND v(dout0_19) AT=925.025n

.meas tran vdout0_20ck1840 FIND v(dout0_20) AT=925.025n

.meas tran vdout0_21ck1840 FIND v(dout0_21) AT=925.025n

.meas tran vdout0_22ck1840 FIND v(dout0_22) AT=925.025n

.meas tran vdout0_23ck1840 FIND v(dout0_23) AT=925.025n

.meas tran vdout0_24ck1840 FIND v(dout0_24) AT=925.025n

.meas tran vdout0_25ck1840 FIND v(dout0_25) AT=925.025n

.meas tran vdout0_26ck1840 FIND v(dout0_26) AT=925.025n

.meas tran vdout0_27ck1840 FIND v(dout0_27) AT=925.025n

.meas tran vdout0_28ck1840 FIND v(dout0_28) AT=925.025n

.meas tran vdout0_29ck1840 FIND v(dout0_29) AT=925.025n

.meas tran vdout0_30ck1840 FIND v(dout0_30) AT=925.025n

.meas tran vdout0_31ck1840 FIND v(dout0_31) AT=925.025n

.meas tran vdout0_32ck1840 FIND v(dout0_32) AT=925.025n

.meas tran vdout0_33ck1840 FIND v(dout0_33) AT=925.025n

.meas tran vdout0_34ck1840 FIND v(dout0_34) AT=925.025n

.meas tran vdout0_35ck1840 FIND v(dout0_35) AT=925.025n

.meas tran vdout0_36ck1840 FIND v(dout0_36) AT=925.025n

.meas tran vdout0_37ck1840 FIND v(dout0_37) AT=925.025n

.meas tran vdout0_38ck1840 FIND v(dout0_38) AT=925.025n

.meas tran vdout0_39ck1840 FIND v(dout0_39) AT=925.025n

.meas tran vdout0_40ck1840 FIND v(dout0_40) AT=925.025n

.meas tran vdout0_41ck1840 FIND v(dout0_41) AT=925.025n

.meas tran vdout0_42ck1840 FIND v(dout0_42) AT=925.025n

.meas tran vdout0_43ck1840 FIND v(dout0_43) AT=925.025n

.meas tran vdout0_44ck1840 FIND v(dout0_44) AT=925.025n

.meas tran vdout0_45ck1840 FIND v(dout0_45) AT=925.025n

.meas tran vdout0_46ck1840 FIND v(dout0_46) AT=925.025n

.meas tran vdout0_47ck1840 FIND v(dout0_47) AT=925.025n

.meas tran vdout0_48ck1840 FIND v(dout0_48) AT=925.025n

.meas tran vdout0_49ck1840 FIND v(dout0_49) AT=925.025n

.meas tran vdout0_50ck1840 FIND v(dout0_50) AT=925.025n

.meas tran vdout0_51ck1840 FIND v(dout0_51) AT=925.025n

.meas tran vdout0_52ck1840 FIND v(dout0_52) AT=925.025n

.meas tran vdout0_53ck1840 FIND v(dout0_53) AT=925.025n

.meas tran vdout0_54ck1840 FIND v(dout0_54) AT=925.025n

.meas tran vdout0_55ck1840 FIND v(dout0_55) AT=925.025n

.meas tran vdout0_56ck1840 FIND v(dout0_56) AT=925.025n

.meas tran vdout0_57ck1840 FIND v(dout0_57) AT=925.025n

.meas tran vdout0_58ck1840 FIND v(dout0_58) AT=925.025n

.meas tran vdout0_59ck1840 FIND v(dout0_59) AT=925.025n

.meas tran vdout0_60ck1840 FIND v(dout0_60) AT=925.025n

.meas tran vdout0_61ck1840 FIND v(dout0_61) AT=925.025n

.meas tran vdout0_62ck1840 FIND v(dout0_62) AT=925.025n

.meas tran vdout0_63ck1840 FIND v(dout0_63) AT=925.025n

.meas tran vdout0_64ck1840 FIND v(dout0_64) AT=925.025n

.meas tran vdout0_65ck1840 FIND v(dout0_65) AT=925.025n

.meas tran vdout0_66ck1840 FIND v(dout0_66) AT=925.025n

.meas tran vdout0_67ck1840 FIND v(dout0_67) AT=925.025n

.meas tran vdout0_68ck1840 FIND v(dout0_68) AT=925.025n

.meas tran vdout0_69ck1840 FIND v(dout0_69) AT=925.025n

.meas tran vdout0_70ck1840 FIND v(dout0_70) AT=925.025n

.meas tran vdout0_71ck1840 FIND v(dout0_71) AT=925.025n

.meas tran vdout0_72ck1840 FIND v(dout0_72) AT=925.025n

.meas tran vdout0_73ck1840 FIND v(dout0_73) AT=925.025n

.meas tran vdout0_74ck1840 FIND v(dout0_74) AT=925.025n

.meas tran vdout0_75ck1840 FIND v(dout0_75) AT=925.025n

.meas tran vdout0_76ck1840 FIND v(dout0_76) AT=925.025n

.meas tran vdout0_77ck1840 FIND v(dout0_77) AT=925.025n

.meas tran vdout0_78ck1840 FIND v(dout0_78) AT=925.025n

.meas tran vdout0_79ck1840 FIND v(dout0_79) AT=925.025n

.meas tran vdout0_80ck1840 FIND v(dout0_80) AT=925.025n

.meas tran vdout0_81ck1840 FIND v(dout0_81) AT=925.025n

.meas tran vdout0_82ck1840 FIND v(dout0_82) AT=925.025n

.meas tran vdout0_83ck1840 FIND v(dout0_83) AT=925.025n

.meas tran vdout0_84ck1840 FIND v(dout0_84) AT=925.025n

.meas tran vdout0_85ck1840 FIND v(dout0_85) AT=925.025n

.meas tran vdout0_86ck1840 FIND v(dout0_86) AT=925.025n

.meas tran vdout0_87ck1840 FIND v(dout0_87) AT=925.025n

.meas tran vdout0_88ck1840 FIND v(dout0_88) AT=925.025n

.meas tran vdout0_89ck1840 FIND v(dout0_89) AT=925.025n

.meas tran vdout0_90ck1840 FIND v(dout0_90) AT=925.025n

.meas tran vdout0_91ck1840 FIND v(dout0_91) AT=925.025n

.meas tran vdout0_92ck1840 FIND v(dout0_92) AT=925.025n

.meas tran vdout0_93ck1840 FIND v(dout0_93) AT=925.025n

.meas tran vdout0_94ck1840 FIND v(dout0_94) AT=925.025n

.meas tran vdout0_95ck1840 FIND v(dout0_95) AT=925.025n

.meas tran vdout0_96ck1840 FIND v(dout0_96) AT=925.025n

.meas tran vdout0_97ck1840 FIND v(dout0_97) AT=925.025n

.meas tran vdout0_98ck1840 FIND v(dout0_98) AT=925.025n

.meas tran vdout0_99ck1840 FIND v(dout0_99) AT=925.025n

.meas tran vdout0_100ck1840 FIND v(dout0_100) AT=925.025n

.meas tran vdout0_101ck1840 FIND v(dout0_101) AT=925.025n

.meas tran vdout0_102ck1840 FIND v(dout0_102) AT=925.025n

.meas tran vdout0_103ck1840 FIND v(dout0_103) AT=925.025n

.meas tran vdout0_104ck1840 FIND v(dout0_104) AT=925.025n

.meas tran vdout0_105ck1840 FIND v(dout0_105) AT=925.025n

.meas tran vdout0_106ck1840 FIND v(dout0_106) AT=925.025n

.meas tran vdout0_107ck1840 FIND v(dout0_107) AT=925.025n

.meas tran vdout0_108ck1840 FIND v(dout0_108) AT=925.025n

.meas tran vdout0_109ck1840 FIND v(dout0_109) AT=925.025n

.meas tran vdout0_110ck1840 FIND v(dout0_110) AT=925.025n

.meas tran vdout0_111ck1840 FIND v(dout0_111) AT=925.025n

.meas tran vdout0_112ck1840 FIND v(dout0_112) AT=925.025n

.meas tran vdout0_113ck1840 FIND v(dout0_113) AT=925.025n

.meas tran vdout0_114ck1840 FIND v(dout0_114) AT=925.025n

.meas tran vdout0_115ck1840 FIND v(dout0_115) AT=925.025n

.meas tran vdout0_116ck1840 FIND v(dout0_116) AT=925.025n

.meas tran vdout0_117ck1840 FIND v(dout0_117) AT=925.025n

.meas tran vdout0_118ck1840 FIND v(dout0_118) AT=925.025n

.meas tran vdout0_119ck1840 FIND v(dout0_119) AT=925.025n

.meas tran vdout0_120ck1840 FIND v(dout0_120) AT=925.025n

.meas tran vdout0_121ck1840 FIND v(dout0_121) AT=925.025n

.meas tran vdout0_122ck1840 FIND v(dout0_122) AT=925.025n

.meas tran vdout0_123ck1840 FIND v(dout0_123) AT=925.025n

.meas tran vdout0_124ck1840 FIND v(dout0_124) AT=925.025n

.meas tran vdout0_125ck1840 FIND v(dout0_125) AT=925.025n

.meas tran vdout0_126ck1840 FIND v(dout0_126) AT=925.025n

.meas tran vdout0_127ck1840 FIND v(dout0_127) AT=925.025n

.meas tran vdout0_0ck1850 FIND v(dout0_0) AT=930.025n

.meas tran vdout0_1ck1850 FIND v(dout0_1) AT=930.025n

.meas tran vdout0_2ck1850 FIND v(dout0_2) AT=930.025n

.meas tran vdout0_3ck1850 FIND v(dout0_3) AT=930.025n

.meas tran vdout0_4ck1850 FIND v(dout0_4) AT=930.025n

.meas tran vdout0_5ck1850 FIND v(dout0_5) AT=930.025n

.meas tran vdout0_6ck1850 FIND v(dout0_6) AT=930.025n

.meas tran vdout0_7ck1850 FIND v(dout0_7) AT=930.025n

.meas tran vdout0_8ck1850 FIND v(dout0_8) AT=930.025n

.meas tran vdout0_9ck1850 FIND v(dout0_9) AT=930.025n

.meas tran vdout0_10ck1850 FIND v(dout0_10) AT=930.025n

.meas tran vdout0_11ck1850 FIND v(dout0_11) AT=930.025n

.meas tran vdout0_12ck1850 FIND v(dout0_12) AT=930.025n

.meas tran vdout0_13ck1850 FIND v(dout0_13) AT=930.025n

.meas tran vdout0_14ck1850 FIND v(dout0_14) AT=930.025n

.meas tran vdout0_15ck1850 FIND v(dout0_15) AT=930.025n

.meas tran vdout0_16ck1850 FIND v(dout0_16) AT=930.025n

.meas tran vdout0_17ck1850 FIND v(dout0_17) AT=930.025n

.meas tran vdout0_18ck1850 FIND v(dout0_18) AT=930.025n

.meas tran vdout0_19ck1850 FIND v(dout0_19) AT=930.025n

.meas tran vdout0_20ck1850 FIND v(dout0_20) AT=930.025n

.meas tran vdout0_21ck1850 FIND v(dout0_21) AT=930.025n

.meas tran vdout0_22ck1850 FIND v(dout0_22) AT=930.025n

.meas tran vdout0_23ck1850 FIND v(dout0_23) AT=930.025n

.meas tran vdout0_24ck1850 FIND v(dout0_24) AT=930.025n

.meas tran vdout0_25ck1850 FIND v(dout0_25) AT=930.025n

.meas tran vdout0_26ck1850 FIND v(dout0_26) AT=930.025n

.meas tran vdout0_27ck1850 FIND v(dout0_27) AT=930.025n

.meas tran vdout0_28ck1850 FIND v(dout0_28) AT=930.025n

.meas tran vdout0_29ck1850 FIND v(dout0_29) AT=930.025n

.meas tran vdout0_30ck1850 FIND v(dout0_30) AT=930.025n

.meas tran vdout0_31ck1850 FIND v(dout0_31) AT=930.025n

.meas tran vdout0_32ck1850 FIND v(dout0_32) AT=930.025n

.meas tran vdout0_33ck1850 FIND v(dout0_33) AT=930.025n

.meas tran vdout0_34ck1850 FIND v(dout0_34) AT=930.025n

.meas tran vdout0_35ck1850 FIND v(dout0_35) AT=930.025n

.meas tran vdout0_36ck1850 FIND v(dout0_36) AT=930.025n

.meas tran vdout0_37ck1850 FIND v(dout0_37) AT=930.025n

.meas tran vdout0_38ck1850 FIND v(dout0_38) AT=930.025n

.meas tran vdout0_39ck1850 FIND v(dout0_39) AT=930.025n

.meas tran vdout0_40ck1850 FIND v(dout0_40) AT=930.025n

.meas tran vdout0_41ck1850 FIND v(dout0_41) AT=930.025n

.meas tran vdout0_42ck1850 FIND v(dout0_42) AT=930.025n

.meas tran vdout0_43ck1850 FIND v(dout0_43) AT=930.025n

.meas tran vdout0_44ck1850 FIND v(dout0_44) AT=930.025n

.meas tran vdout0_45ck1850 FIND v(dout0_45) AT=930.025n

.meas tran vdout0_46ck1850 FIND v(dout0_46) AT=930.025n

.meas tran vdout0_47ck1850 FIND v(dout0_47) AT=930.025n

.meas tran vdout0_48ck1850 FIND v(dout0_48) AT=930.025n

.meas tran vdout0_49ck1850 FIND v(dout0_49) AT=930.025n

.meas tran vdout0_50ck1850 FIND v(dout0_50) AT=930.025n

.meas tran vdout0_51ck1850 FIND v(dout0_51) AT=930.025n

.meas tran vdout0_52ck1850 FIND v(dout0_52) AT=930.025n

.meas tran vdout0_53ck1850 FIND v(dout0_53) AT=930.025n

.meas tran vdout0_54ck1850 FIND v(dout0_54) AT=930.025n

.meas tran vdout0_55ck1850 FIND v(dout0_55) AT=930.025n

.meas tran vdout0_56ck1850 FIND v(dout0_56) AT=930.025n

.meas tran vdout0_57ck1850 FIND v(dout0_57) AT=930.025n

.meas tran vdout0_58ck1850 FIND v(dout0_58) AT=930.025n

.meas tran vdout0_59ck1850 FIND v(dout0_59) AT=930.025n

.meas tran vdout0_60ck1850 FIND v(dout0_60) AT=930.025n

.meas tran vdout0_61ck1850 FIND v(dout0_61) AT=930.025n

.meas tran vdout0_62ck1850 FIND v(dout0_62) AT=930.025n

.meas tran vdout0_63ck1850 FIND v(dout0_63) AT=930.025n

.meas tran vdout0_64ck1850 FIND v(dout0_64) AT=930.025n

.meas tran vdout0_65ck1850 FIND v(dout0_65) AT=930.025n

.meas tran vdout0_66ck1850 FIND v(dout0_66) AT=930.025n

.meas tran vdout0_67ck1850 FIND v(dout0_67) AT=930.025n

.meas tran vdout0_68ck1850 FIND v(dout0_68) AT=930.025n

.meas tran vdout0_69ck1850 FIND v(dout0_69) AT=930.025n

.meas tran vdout0_70ck1850 FIND v(dout0_70) AT=930.025n

.meas tran vdout0_71ck1850 FIND v(dout0_71) AT=930.025n

.meas tran vdout0_72ck1850 FIND v(dout0_72) AT=930.025n

.meas tran vdout0_73ck1850 FIND v(dout0_73) AT=930.025n

.meas tran vdout0_74ck1850 FIND v(dout0_74) AT=930.025n

.meas tran vdout0_75ck1850 FIND v(dout0_75) AT=930.025n

.meas tran vdout0_76ck1850 FIND v(dout0_76) AT=930.025n

.meas tran vdout0_77ck1850 FIND v(dout0_77) AT=930.025n

.meas tran vdout0_78ck1850 FIND v(dout0_78) AT=930.025n

.meas tran vdout0_79ck1850 FIND v(dout0_79) AT=930.025n

.meas tran vdout0_80ck1850 FIND v(dout0_80) AT=930.025n

.meas tran vdout0_81ck1850 FIND v(dout0_81) AT=930.025n

.meas tran vdout0_82ck1850 FIND v(dout0_82) AT=930.025n

.meas tran vdout0_83ck1850 FIND v(dout0_83) AT=930.025n

.meas tran vdout0_84ck1850 FIND v(dout0_84) AT=930.025n

.meas tran vdout0_85ck1850 FIND v(dout0_85) AT=930.025n

.meas tran vdout0_86ck1850 FIND v(dout0_86) AT=930.025n

.meas tran vdout0_87ck1850 FIND v(dout0_87) AT=930.025n

.meas tran vdout0_88ck1850 FIND v(dout0_88) AT=930.025n

.meas tran vdout0_89ck1850 FIND v(dout0_89) AT=930.025n

.meas tran vdout0_90ck1850 FIND v(dout0_90) AT=930.025n

.meas tran vdout0_91ck1850 FIND v(dout0_91) AT=930.025n

.meas tran vdout0_92ck1850 FIND v(dout0_92) AT=930.025n

.meas tran vdout0_93ck1850 FIND v(dout0_93) AT=930.025n

.meas tran vdout0_94ck1850 FIND v(dout0_94) AT=930.025n

.meas tran vdout0_95ck1850 FIND v(dout0_95) AT=930.025n

.meas tran vdout0_96ck1850 FIND v(dout0_96) AT=930.025n

.meas tran vdout0_97ck1850 FIND v(dout0_97) AT=930.025n

.meas tran vdout0_98ck1850 FIND v(dout0_98) AT=930.025n

.meas tran vdout0_99ck1850 FIND v(dout0_99) AT=930.025n

.meas tran vdout0_100ck1850 FIND v(dout0_100) AT=930.025n

.meas tran vdout0_101ck1850 FIND v(dout0_101) AT=930.025n

.meas tran vdout0_102ck1850 FIND v(dout0_102) AT=930.025n

.meas tran vdout0_103ck1850 FIND v(dout0_103) AT=930.025n

.meas tran vdout0_104ck1850 FIND v(dout0_104) AT=930.025n

.meas tran vdout0_105ck1850 FIND v(dout0_105) AT=930.025n

.meas tran vdout0_106ck1850 FIND v(dout0_106) AT=930.025n

.meas tran vdout0_107ck1850 FIND v(dout0_107) AT=930.025n

.meas tran vdout0_108ck1850 FIND v(dout0_108) AT=930.025n

.meas tran vdout0_109ck1850 FIND v(dout0_109) AT=930.025n

.meas tran vdout0_110ck1850 FIND v(dout0_110) AT=930.025n

.meas tran vdout0_111ck1850 FIND v(dout0_111) AT=930.025n

.meas tran vdout0_112ck1850 FIND v(dout0_112) AT=930.025n

.meas tran vdout0_113ck1850 FIND v(dout0_113) AT=930.025n

.meas tran vdout0_114ck1850 FIND v(dout0_114) AT=930.025n

.meas tran vdout0_115ck1850 FIND v(dout0_115) AT=930.025n

.meas tran vdout0_116ck1850 FIND v(dout0_116) AT=930.025n

.meas tran vdout0_117ck1850 FIND v(dout0_117) AT=930.025n

.meas tran vdout0_118ck1850 FIND v(dout0_118) AT=930.025n

.meas tran vdout0_119ck1850 FIND v(dout0_119) AT=930.025n

.meas tran vdout0_120ck1850 FIND v(dout0_120) AT=930.025n

.meas tran vdout0_121ck1850 FIND v(dout0_121) AT=930.025n

.meas tran vdout0_122ck1850 FIND v(dout0_122) AT=930.025n

.meas tran vdout0_123ck1850 FIND v(dout0_123) AT=930.025n

.meas tran vdout0_124ck1850 FIND v(dout0_124) AT=930.025n

.meas tran vdout0_125ck1850 FIND v(dout0_125) AT=930.025n

.meas tran vdout0_126ck1850 FIND v(dout0_126) AT=930.025n

.meas tran vdout0_127ck1850 FIND v(dout0_127) AT=930.025n

.meas tran vdout0_0ck1900 FIND v(dout0_0) AT=955.025n

.meas tran vdout0_1ck1900 FIND v(dout0_1) AT=955.025n

.meas tran vdout0_2ck1900 FIND v(dout0_2) AT=955.025n

.meas tran vdout0_3ck1900 FIND v(dout0_3) AT=955.025n

.meas tran vdout0_4ck1900 FIND v(dout0_4) AT=955.025n

.meas tran vdout0_5ck1900 FIND v(dout0_5) AT=955.025n

.meas tran vdout0_6ck1900 FIND v(dout0_6) AT=955.025n

.meas tran vdout0_7ck1900 FIND v(dout0_7) AT=955.025n

.meas tran vdout0_8ck1900 FIND v(dout0_8) AT=955.025n

.meas tran vdout0_9ck1900 FIND v(dout0_9) AT=955.025n

.meas tran vdout0_10ck1900 FIND v(dout0_10) AT=955.025n

.meas tran vdout0_11ck1900 FIND v(dout0_11) AT=955.025n

.meas tran vdout0_12ck1900 FIND v(dout0_12) AT=955.025n

.meas tran vdout0_13ck1900 FIND v(dout0_13) AT=955.025n

.meas tran vdout0_14ck1900 FIND v(dout0_14) AT=955.025n

.meas tran vdout0_15ck1900 FIND v(dout0_15) AT=955.025n

.meas tran vdout0_16ck1900 FIND v(dout0_16) AT=955.025n

.meas tran vdout0_17ck1900 FIND v(dout0_17) AT=955.025n

.meas tran vdout0_18ck1900 FIND v(dout0_18) AT=955.025n

.meas tran vdout0_19ck1900 FIND v(dout0_19) AT=955.025n

.meas tran vdout0_20ck1900 FIND v(dout0_20) AT=955.025n

.meas tran vdout0_21ck1900 FIND v(dout0_21) AT=955.025n

.meas tran vdout0_22ck1900 FIND v(dout0_22) AT=955.025n

.meas tran vdout0_23ck1900 FIND v(dout0_23) AT=955.025n

.meas tran vdout0_24ck1900 FIND v(dout0_24) AT=955.025n

.meas tran vdout0_25ck1900 FIND v(dout0_25) AT=955.025n

.meas tran vdout0_26ck1900 FIND v(dout0_26) AT=955.025n

.meas tran vdout0_27ck1900 FIND v(dout0_27) AT=955.025n

.meas tran vdout0_28ck1900 FIND v(dout0_28) AT=955.025n

.meas tran vdout0_29ck1900 FIND v(dout0_29) AT=955.025n

.meas tran vdout0_30ck1900 FIND v(dout0_30) AT=955.025n

.meas tran vdout0_31ck1900 FIND v(dout0_31) AT=955.025n

.meas tran vdout0_32ck1900 FIND v(dout0_32) AT=955.025n

.meas tran vdout0_33ck1900 FIND v(dout0_33) AT=955.025n

.meas tran vdout0_34ck1900 FIND v(dout0_34) AT=955.025n

.meas tran vdout0_35ck1900 FIND v(dout0_35) AT=955.025n

.meas tran vdout0_36ck1900 FIND v(dout0_36) AT=955.025n

.meas tran vdout0_37ck1900 FIND v(dout0_37) AT=955.025n

.meas tran vdout0_38ck1900 FIND v(dout0_38) AT=955.025n

.meas tran vdout0_39ck1900 FIND v(dout0_39) AT=955.025n

.meas tran vdout0_40ck1900 FIND v(dout0_40) AT=955.025n

.meas tran vdout0_41ck1900 FIND v(dout0_41) AT=955.025n

.meas tran vdout0_42ck1900 FIND v(dout0_42) AT=955.025n

.meas tran vdout0_43ck1900 FIND v(dout0_43) AT=955.025n

.meas tran vdout0_44ck1900 FIND v(dout0_44) AT=955.025n

.meas tran vdout0_45ck1900 FIND v(dout0_45) AT=955.025n

.meas tran vdout0_46ck1900 FIND v(dout0_46) AT=955.025n

.meas tran vdout0_47ck1900 FIND v(dout0_47) AT=955.025n

.meas tran vdout0_48ck1900 FIND v(dout0_48) AT=955.025n

.meas tran vdout0_49ck1900 FIND v(dout0_49) AT=955.025n

.meas tran vdout0_50ck1900 FIND v(dout0_50) AT=955.025n

.meas tran vdout0_51ck1900 FIND v(dout0_51) AT=955.025n

.meas tran vdout0_52ck1900 FIND v(dout0_52) AT=955.025n

.meas tran vdout0_53ck1900 FIND v(dout0_53) AT=955.025n

.meas tran vdout0_54ck1900 FIND v(dout0_54) AT=955.025n

.meas tran vdout0_55ck1900 FIND v(dout0_55) AT=955.025n

.meas tran vdout0_56ck1900 FIND v(dout0_56) AT=955.025n

.meas tran vdout0_57ck1900 FIND v(dout0_57) AT=955.025n

.meas tran vdout0_58ck1900 FIND v(dout0_58) AT=955.025n

.meas tran vdout0_59ck1900 FIND v(dout0_59) AT=955.025n

.meas tran vdout0_60ck1900 FIND v(dout0_60) AT=955.025n

.meas tran vdout0_61ck1900 FIND v(dout0_61) AT=955.025n

.meas tran vdout0_62ck1900 FIND v(dout0_62) AT=955.025n

.meas tran vdout0_63ck1900 FIND v(dout0_63) AT=955.025n

.meas tran vdout0_64ck1900 FIND v(dout0_64) AT=955.025n

.meas tran vdout0_65ck1900 FIND v(dout0_65) AT=955.025n

.meas tran vdout0_66ck1900 FIND v(dout0_66) AT=955.025n

.meas tran vdout0_67ck1900 FIND v(dout0_67) AT=955.025n

.meas tran vdout0_68ck1900 FIND v(dout0_68) AT=955.025n

.meas tran vdout0_69ck1900 FIND v(dout0_69) AT=955.025n

.meas tran vdout0_70ck1900 FIND v(dout0_70) AT=955.025n

.meas tran vdout0_71ck1900 FIND v(dout0_71) AT=955.025n

.meas tran vdout0_72ck1900 FIND v(dout0_72) AT=955.025n

.meas tran vdout0_73ck1900 FIND v(dout0_73) AT=955.025n

.meas tran vdout0_74ck1900 FIND v(dout0_74) AT=955.025n

.meas tran vdout0_75ck1900 FIND v(dout0_75) AT=955.025n

.meas tran vdout0_76ck1900 FIND v(dout0_76) AT=955.025n

.meas tran vdout0_77ck1900 FIND v(dout0_77) AT=955.025n

.meas tran vdout0_78ck1900 FIND v(dout0_78) AT=955.025n

.meas tran vdout0_79ck1900 FIND v(dout0_79) AT=955.025n

.meas tran vdout0_80ck1900 FIND v(dout0_80) AT=955.025n

.meas tran vdout0_81ck1900 FIND v(dout0_81) AT=955.025n

.meas tran vdout0_82ck1900 FIND v(dout0_82) AT=955.025n

.meas tran vdout0_83ck1900 FIND v(dout0_83) AT=955.025n

.meas tran vdout0_84ck1900 FIND v(dout0_84) AT=955.025n

.meas tran vdout0_85ck1900 FIND v(dout0_85) AT=955.025n

.meas tran vdout0_86ck1900 FIND v(dout0_86) AT=955.025n

.meas tran vdout0_87ck1900 FIND v(dout0_87) AT=955.025n

.meas tran vdout0_88ck1900 FIND v(dout0_88) AT=955.025n

.meas tran vdout0_89ck1900 FIND v(dout0_89) AT=955.025n

.meas tran vdout0_90ck1900 FIND v(dout0_90) AT=955.025n

.meas tran vdout0_91ck1900 FIND v(dout0_91) AT=955.025n

.meas tran vdout0_92ck1900 FIND v(dout0_92) AT=955.025n

.meas tran vdout0_93ck1900 FIND v(dout0_93) AT=955.025n

.meas tran vdout0_94ck1900 FIND v(dout0_94) AT=955.025n

.meas tran vdout0_95ck1900 FIND v(dout0_95) AT=955.025n

.meas tran vdout0_96ck1900 FIND v(dout0_96) AT=955.025n

.meas tran vdout0_97ck1900 FIND v(dout0_97) AT=955.025n

.meas tran vdout0_98ck1900 FIND v(dout0_98) AT=955.025n

.meas tran vdout0_99ck1900 FIND v(dout0_99) AT=955.025n

.meas tran vdout0_100ck1900 FIND v(dout0_100) AT=955.025n

.meas tran vdout0_101ck1900 FIND v(dout0_101) AT=955.025n

.meas tran vdout0_102ck1900 FIND v(dout0_102) AT=955.025n

.meas tran vdout0_103ck1900 FIND v(dout0_103) AT=955.025n

.meas tran vdout0_104ck1900 FIND v(dout0_104) AT=955.025n

.meas tran vdout0_105ck1900 FIND v(dout0_105) AT=955.025n

.meas tran vdout0_106ck1900 FIND v(dout0_106) AT=955.025n

.meas tran vdout0_107ck1900 FIND v(dout0_107) AT=955.025n

.meas tran vdout0_108ck1900 FIND v(dout0_108) AT=955.025n

.meas tran vdout0_109ck1900 FIND v(dout0_109) AT=955.025n

.meas tran vdout0_110ck1900 FIND v(dout0_110) AT=955.025n

.meas tran vdout0_111ck1900 FIND v(dout0_111) AT=955.025n

.meas tran vdout0_112ck1900 FIND v(dout0_112) AT=955.025n

.meas tran vdout0_113ck1900 FIND v(dout0_113) AT=955.025n

.meas tran vdout0_114ck1900 FIND v(dout0_114) AT=955.025n

.meas tran vdout0_115ck1900 FIND v(dout0_115) AT=955.025n

.meas tran vdout0_116ck1900 FIND v(dout0_116) AT=955.025n

.meas tran vdout0_117ck1900 FIND v(dout0_117) AT=955.025n

.meas tran vdout0_118ck1900 FIND v(dout0_118) AT=955.025n

.meas tran vdout0_119ck1900 FIND v(dout0_119) AT=955.025n

.meas tran vdout0_120ck1900 FIND v(dout0_120) AT=955.025n

.meas tran vdout0_121ck1900 FIND v(dout0_121) AT=955.025n

.meas tran vdout0_122ck1900 FIND v(dout0_122) AT=955.025n

.meas tran vdout0_123ck1900 FIND v(dout0_123) AT=955.025n

.meas tran vdout0_124ck1900 FIND v(dout0_124) AT=955.025n

.meas tran vdout0_125ck1900 FIND v(dout0_125) AT=955.025n

.meas tran vdout0_126ck1900 FIND v(dout0_126) AT=955.025n

.meas tran vdout0_127ck1900 FIND v(dout0_127) AT=955.025n

.meas tran vdout0_0ck1930 FIND v(dout0_0) AT=970.025n

.meas tran vdout0_1ck1930 FIND v(dout0_1) AT=970.025n

.meas tran vdout0_2ck1930 FIND v(dout0_2) AT=970.025n

.meas tran vdout0_3ck1930 FIND v(dout0_3) AT=970.025n

.meas tran vdout0_4ck1930 FIND v(dout0_4) AT=970.025n

.meas tran vdout0_5ck1930 FIND v(dout0_5) AT=970.025n

.meas tran vdout0_6ck1930 FIND v(dout0_6) AT=970.025n

.meas tran vdout0_7ck1930 FIND v(dout0_7) AT=970.025n

.meas tran vdout0_8ck1930 FIND v(dout0_8) AT=970.025n

.meas tran vdout0_9ck1930 FIND v(dout0_9) AT=970.025n

.meas tran vdout0_10ck1930 FIND v(dout0_10) AT=970.025n

.meas tran vdout0_11ck1930 FIND v(dout0_11) AT=970.025n

.meas tran vdout0_12ck1930 FIND v(dout0_12) AT=970.025n

.meas tran vdout0_13ck1930 FIND v(dout0_13) AT=970.025n

.meas tran vdout0_14ck1930 FIND v(dout0_14) AT=970.025n

.meas tran vdout0_15ck1930 FIND v(dout0_15) AT=970.025n

.meas tran vdout0_16ck1930 FIND v(dout0_16) AT=970.025n

.meas tran vdout0_17ck1930 FIND v(dout0_17) AT=970.025n

.meas tran vdout0_18ck1930 FIND v(dout0_18) AT=970.025n

.meas tran vdout0_19ck1930 FIND v(dout0_19) AT=970.025n

.meas tran vdout0_20ck1930 FIND v(dout0_20) AT=970.025n

.meas tran vdout0_21ck1930 FIND v(dout0_21) AT=970.025n

.meas tran vdout0_22ck1930 FIND v(dout0_22) AT=970.025n

.meas tran vdout0_23ck1930 FIND v(dout0_23) AT=970.025n

.meas tran vdout0_24ck1930 FIND v(dout0_24) AT=970.025n

.meas tran vdout0_25ck1930 FIND v(dout0_25) AT=970.025n

.meas tran vdout0_26ck1930 FIND v(dout0_26) AT=970.025n

.meas tran vdout0_27ck1930 FIND v(dout0_27) AT=970.025n

.meas tran vdout0_28ck1930 FIND v(dout0_28) AT=970.025n

.meas tran vdout0_29ck1930 FIND v(dout0_29) AT=970.025n

.meas tran vdout0_30ck1930 FIND v(dout0_30) AT=970.025n

.meas tran vdout0_31ck1930 FIND v(dout0_31) AT=970.025n

.meas tran vdout0_32ck1930 FIND v(dout0_32) AT=970.025n

.meas tran vdout0_33ck1930 FIND v(dout0_33) AT=970.025n

.meas tran vdout0_34ck1930 FIND v(dout0_34) AT=970.025n

.meas tran vdout0_35ck1930 FIND v(dout0_35) AT=970.025n

.meas tran vdout0_36ck1930 FIND v(dout0_36) AT=970.025n

.meas tran vdout0_37ck1930 FIND v(dout0_37) AT=970.025n

.meas tran vdout0_38ck1930 FIND v(dout0_38) AT=970.025n

.meas tran vdout0_39ck1930 FIND v(dout0_39) AT=970.025n

.meas tran vdout0_40ck1930 FIND v(dout0_40) AT=970.025n

.meas tran vdout0_41ck1930 FIND v(dout0_41) AT=970.025n

.meas tran vdout0_42ck1930 FIND v(dout0_42) AT=970.025n

.meas tran vdout0_43ck1930 FIND v(dout0_43) AT=970.025n

.meas tran vdout0_44ck1930 FIND v(dout0_44) AT=970.025n

.meas tran vdout0_45ck1930 FIND v(dout0_45) AT=970.025n

.meas tran vdout0_46ck1930 FIND v(dout0_46) AT=970.025n

.meas tran vdout0_47ck1930 FIND v(dout0_47) AT=970.025n

.meas tran vdout0_48ck1930 FIND v(dout0_48) AT=970.025n

.meas tran vdout0_49ck1930 FIND v(dout0_49) AT=970.025n

.meas tran vdout0_50ck1930 FIND v(dout0_50) AT=970.025n

.meas tran vdout0_51ck1930 FIND v(dout0_51) AT=970.025n

.meas tran vdout0_52ck1930 FIND v(dout0_52) AT=970.025n

.meas tran vdout0_53ck1930 FIND v(dout0_53) AT=970.025n

.meas tran vdout0_54ck1930 FIND v(dout0_54) AT=970.025n

.meas tran vdout0_55ck1930 FIND v(dout0_55) AT=970.025n

.meas tran vdout0_56ck1930 FIND v(dout0_56) AT=970.025n

.meas tran vdout0_57ck1930 FIND v(dout0_57) AT=970.025n

.meas tran vdout0_58ck1930 FIND v(dout0_58) AT=970.025n

.meas tran vdout0_59ck1930 FIND v(dout0_59) AT=970.025n

.meas tran vdout0_60ck1930 FIND v(dout0_60) AT=970.025n

.meas tran vdout0_61ck1930 FIND v(dout0_61) AT=970.025n

.meas tran vdout0_62ck1930 FIND v(dout0_62) AT=970.025n

.meas tran vdout0_63ck1930 FIND v(dout0_63) AT=970.025n

.meas tran vdout0_64ck1930 FIND v(dout0_64) AT=970.025n

.meas tran vdout0_65ck1930 FIND v(dout0_65) AT=970.025n

.meas tran vdout0_66ck1930 FIND v(dout0_66) AT=970.025n

.meas tran vdout0_67ck1930 FIND v(dout0_67) AT=970.025n

.meas tran vdout0_68ck1930 FIND v(dout0_68) AT=970.025n

.meas tran vdout0_69ck1930 FIND v(dout0_69) AT=970.025n

.meas tran vdout0_70ck1930 FIND v(dout0_70) AT=970.025n

.meas tran vdout0_71ck1930 FIND v(dout0_71) AT=970.025n

.meas tran vdout0_72ck1930 FIND v(dout0_72) AT=970.025n

.meas tran vdout0_73ck1930 FIND v(dout0_73) AT=970.025n

.meas tran vdout0_74ck1930 FIND v(dout0_74) AT=970.025n

.meas tran vdout0_75ck1930 FIND v(dout0_75) AT=970.025n

.meas tran vdout0_76ck1930 FIND v(dout0_76) AT=970.025n

.meas tran vdout0_77ck1930 FIND v(dout0_77) AT=970.025n

.meas tran vdout0_78ck1930 FIND v(dout0_78) AT=970.025n

.meas tran vdout0_79ck1930 FIND v(dout0_79) AT=970.025n

.meas tran vdout0_80ck1930 FIND v(dout0_80) AT=970.025n

.meas tran vdout0_81ck1930 FIND v(dout0_81) AT=970.025n

.meas tran vdout0_82ck1930 FIND v(dout0_82) AT=970.025n

.meas tran vdout0_83ck1930 FIND v(dout0_83) AT=970.025n

.meas tran vdout0_84ck1930 FIND v(dout0_84) AT=970.025n

.meas tran vdout0_85ck1930 FIND v(dout0_85) AT=970.025n

.meas tran vdout0_86ck1930 FIND v(dout0_86) AT=970.025n

.meas tran vdout0_87ck1930 FIND v(dout0_87) AT=970.025n

.meas tran vdout0_88ck1930 FIND v(dout0_88) AT=970.025n

.meas tran vdout0_89ck1930 FIND v(dout0_89) AT=970.025n

.meas tran vdout0_90ck1930 FIND v(dout0_90) AT=970.025n

.meas tran vdout0_91ck1930 FIND v(dout0_91) AT=970.025n

.meas tran vdout0_92ck1930 FIND v(dout0_92) AT=970.025n

.meas tran vdout0_93ck1930 FIND v(dout0_93) AT=970.025n

.meas tran vdout0_94ck1930 FIND v(dout0_94) AT=970.025n

.meas tran vdout0_95ck1930 FIND v(dout0_95) AT=970.025n

.meas tran vdout0_96ck1930 FIND v(dout0_96) AT=970.025n

.meas tran vdout0_97ck1930 FIND v(dout0_97) AT=970.025n

.meas tran vdout0_98ck1930 FIND v(dout0_98) AT=970.025n

.meas tran vdout0_99ck1930 FIND v(dout0_99) AT=970.025n

.meas tran vdout0_100ck1930 FIND v(dout0_100) AT=970.025n

.meas tran vdout0_101ck1930 FIND v(dout0_101) AT=970.025n

.meas tran vdout0_102ck1930 FIND v(dout0_102) AT=970.025n

.meas tran vdout0_103ck1930 FIND v(dout0_103) AT=970.025n

.meas tran vdout0_104ck1930 FIND v(dout0_104) AT=970.025n

.meas tran vdout0_105ck1930 FIND v(dout0_105) AT=970.025n

.meas tran vdout0_106ck1930 FIND v(dout0_106) AT=970.025n

.meas tran vdout0_107ck1930 FIND v(dout0_107) AT=970.025n

.meas tran vdout0_108ck1930 FIND v(dout0_108) AT=970.025n

.meas tran vdout0_109ck1930 FIND v(dout0_109) AT=970.025n

.meas tran vdout0_110ck1930 FIND v(dout0_110) AT=970.025n

.meas tran vdout0_111ck1930 FIND v(dout0_111) AT=970.025n

.meas tran vdout0_112ck1930 FIND v(dout0_112) AT=970.025n

.meas tran vdout0_113ck1930 FIND v(dout0_113) AT=970.025n

.meas tran vdout0_114ck1930 FIND v(dout0_114) AT=970.025n

.meas tran vdout0_115ck1930 FIND v(dout0_115) AT=970.025n

.meas tran vdout0_116ck1930 FIND v(dout0_116) AT=970.025n

.meas tran vdout0_117ck1930 FIND v(dout0_117) AT=970.025n

.meas tran vdout0_118ck1930 FIND v(dout0_118) AT=970.025n

.meas tran vdout0_119ck1930 FIND v(dout0_119) AT=970.025n

.meas tran vdout0_120ck1930 FIND v(dout0_120) AT=970.025n

.meas tran vdout0_121ck1930 FIND v(dout0_121) AT=970.025n

.meas tran vdout0_122ck1930 FIND v(dout0_122) AT=970.025n

.meas tran vdout0_123ck1930 FIND v(dout0_123) AT=970.025n

.meas tran vdout0_124ck1930 FIND v(dout0_124) AT=970.025n

.meas tran vdout0_125ck1930 FIND v(dout0_125) AT=970.025n

.meas tran vdout0_126ck1930 FIND v(dout0_126) AT=970.025n

.meas tran vdout0_127ck1930 FIND v(dout0_127) AT=970.025n

.meas tran vdout0_0ck1950 FIND v(dout0_0) AT=980.025n

.meas tran vdout0_1ck1950 FIND v(dout0_1) AT=980.025n

.meas tran vdout0_2ck1950 FIND v(dout0_2) AT=980.025n

.meas tran vdout0_3ck1950 FIND v(dout0_3) AT=980.025n

.meas tran vdout0_4ck1950 FIND v(dout0_4) AT=980.025n

.meas tran vdout0_5ck1950 FIND v(dout0_5) AT=980.025n

.meas tran vdout0_6ck1950 FIND v(dout0_6) AT=980.025n

.meas tran vdout0_7ck1950 FIND v(dout0_7) AT=980.025n

.meas tran vdout0_8ck1950 FIND v(dout0_8) AT=980.025n

.meas tran vdout0_9ck1950 FIND v(dout0_9) AT=980.025n

.meas tran vdout0_10ck1950 FIND v(dout0_10) AT=980.025n

.meas tran vdout0_11ck1950 FIND v(dout0_11) AT=980.025n

.meas tran vdout0_12ck1950 FIND v(dout0_12) AT=980.025n

.meas tran vdout0_13ck1950 FIND v(dout0_13) AT=980.025n

.meas tran vdout0_14ck1950 FIND v(dout0_14) AT=980.025n

.meas tran vdout0_15ck1950 FIND v(dout0_15) AT=980.025n

.meas tran vdout0_16ck1950 FIND v(dout0_16) AT=980.025n

.meas tran vdout0_17ck1950 FIND v(dout0_17) AT=980.025n

.meas tran vdout0_18ck1950 FIND v(dout0_18) AT=980.025n

.meas tran vdout0_19ck1950 FIND v(dout0_19) AT=980.025n

.meas tran vdout0_20ck1950 FIND v(dout0_20) AT=980.025n

.meas tran vdout0_21ck1950 FIND v(dout0_21) AT=980.025n

.meas tran vdout0_22ck1950 FIND v(dout0_22) AT=980.025n

.meas tran vdout0_23ck1950 FIND v(dout0_23) AT=980.025n

.meas tran vdout0_24ck1950 FIND v(dout0_24) AT=980.025n

.meas tran vdout0_25ck1950 FIND v(dout0_25) AT=980.025n

.meas tran vdout0_26ck1950 FIND v(dout0_26) AT=980.025n

.meas tran vdout0_27ck1950 FIND v(dout0_27) AT=980.025n

.meas tran vdout0_28ck1950 FIND v(dout0_28) AT=980.025n

.meas tran vdout0_29ck1950 FIND v(dout0_29) AT=980.025n

.meas tran vdout0_30ck1950 FIND v(dout0_30) AT=980.025n

.meas tran vdout0_31ck1950 FIND v(dout0_31) AT=980.025n

.meas tran vdout0_32ck1950 FIND v(dout0_32) AT=980.025n

.meas tran vdout0_33ck1950 FIND v(dout0_33) AT=980.025n

.meas tran vdout0_34ck1950 FIND v(dout0_34) AT=980.025n

.meas tran vdout0_35ck1950 FIND v(dout0_35) AT=980.025n

.meas tran vdout0_36ck1950 FIND v(dout0_36) AT=980.025n

.meas tran vdout0_37ck1950 FIND v(dout0_37) AT=980.025n

.meas tran vdout0_38ck1950 FIND v(dout0_38) AT=980.025n

.meas tran vdout0_39ck1950 FIND v(dout0_39) AT=980.025n

.meas tran vdout0_40ck1950 FIND v(dout0_40) AT=980.025n

.meas tran vdout0_41ck1950 FIND v(dout0_41) AT=980.025n

.meas tran vdout0_42ck1950 FIND v(dout0_42) AT=980.025n

.meas tran vdout0_43ck1950 FIND v(dout0_43) AT=980.025n

.meas tran vdout0_44ck1950 FIND v(dout0_44) AT=980.025n

.meas tran vdout0_45ck1950 FIND v(dout0_45) AT=980.025n

.meas tran vdout0_46ck1950 FIND v(dout0_46) AT=980.025n

.meas tran vdout0_47ck1950 FIND v(dout0_47) AT=980.025n

.meas tran vdout0_48ck1950 FIND v(dout0_48) AT=980.025n

.meas tran vdout0_49ck1950 FIND v(dout0_49) AT=980.025n

.meas tran vdout0_50ck1950 FIND v(dout0_50) AT=980.025n

.meas tran vdout0_51ck1950 FIND v(dout0_51) AT=980.025n

.meas tran vdout0_52ck1950 FIND v(dout0_52) AT=980.025n

.meas tran vdout0_53ck1950 FIND v(dout0_53) AT=980.025n

.meas tran vdout0_54ck1950 FIND v(dout0_54) AT=980.025n

.meas tran vdout0_55ck1950 FIND v(dout0_55) AT=980.025n

.meas tran vdout0_56ck1950 FIND v(dout0_56) AT=980.025n

.meas tran vdout0_57ck1950 FIND v(dout0_57) AT=980.025n

.meas tran vdout0_58ck1950 FIND v(dout0_58) AT=980.025n

.meas tran vdout0_59ck1950 FIND v(dout0_59) AT=980.025n

.meas tran vdout0_60ck1950 FIND v(dout0_60) AT=980.025n

.meas tran vdout0_61ck1950 FIND v(dout0_61) AT=980.025n

.meas tran vdout0_62ck1950 FIND v(dout0_62) AT=980.025n

.meas tran vdout0_63ck1950 FIND v(dout0_63) AT=980.025n

.meas tran vdout0_64ck1950 FIND v(dout0_64) AT=980.025n

.meas tran vdout0_65ck1950 FIND v(dout0_65) AT=980.025n

.meas tran vdout0_66ck1950 FIND v(dout0_66) AT=980.025n

.meas tran vdout0_67ck1950 FIND v(dout0_67) AT=980.025n

.meas tran vdout0_68ck1950 FIND v(dout0_68) AT=980.025n

.meas tran vdout0_69ck1950 FIND v(dout0_69) AT=980.025n

.meas tran vdout0_70ck1950 FIND v(dout0_70) AT=980.025n

.meas tran vdout0_71ck1950 FIND v(dout0_71) AT=980.025n

.meas tran vdout0_72ck1950 FIND v(dout0_72) AT=980.025n

.meas tran vdout0_73ck1950 FIND v(dout0_73) AT=980.025n

.meas tran vdout0_74ck1950 FIND v(dout0_74) AT=980.025n

.meas tran vdout0_75ck1950 FIND v(dout0_75) AT=980.025n

.meas tran vdout0_76ck1950 FIND v(dout0_76) AT=980.025n

.meas tran vdout0_77ck1950 FIND v(dout0_77) AT=980.025n

.meas tran vdout0_78ck1950 FIND v(dout0_78) AT=980.025n

.meas tran vdout0_79ck1950 FIND v(dout0_79) AT=980.025n

.meas tran vdout0_80ck1950 FIND v(dout0_80) AT=980.025n

.meas tran vdout0_81ck1950 FIND v(dout0_81) AT=980.025n

.meas tran vdout0_82ck1950 FIND v(dout0_82) AT=980.025n

.meas tran vdout0_83ck1950 FIND v(dout0_83) AT=980.025n

.meas tran vdout0_84ck1950 FIND v(dout0_84) AT=980.025n

.meas tran vdout0_85ck1950 FIND v(dout0_85) AT=980.025n

.meas tran vdout0_86ck1950 FIND v(dout0_86) AT=980.025n

.meas tran vdout0_87ck1950 FIND v(dout0_87) AT=980.025n

.meas tran vdout0_88ck1950 FIND v(dout0_88) AT=980.025n

.meas tran vdout0_89ck1950 FIND v(dout0_89) AT=980.025n

.meas tran vdout0_90ck1950 FIND v(dout0_90) AT=980.025n

.meas tran vdout0_91ck1950 FIND v(dout0_91) AT=980.025n

.meas tran vdout0_92ck1950 FIND v(dout0_92) AT=980.025n

.meas tran vdout0_93ck1950 FIND v(dout0_93) AT=980.025n

.meas tran vdout0_94ck1950 FIND v(dout0_94) AT=980.025n

.meas tran vdout0_95ck1950 FIND v(dout0_95) AT=980.025n

.meas tran vdout0_96ck1950 FIND v(dout0_96) AT=980.025n

.meas tran vdout0_97ck1950 FIND v(dout0_97) AT=980.025n

.meas tran vdout0_98ck1950 FIND v(dout0_98) AT=980.025n

.meas tran vdout0_99ck1950 FIND v(dout0_99) AT=980.025n

.meas tran vdout0_100ck1950 FIND v(dout0_100) AT=980.025n

.meas tran vdout0_101ck1950 FIND v(dout0_101) AT=980.025n

.meas tran vdout0_102ck1950 FIND v(dout0_102) AT=980.025n

.meas tran vdout0_103ck1950 FIND v(dout0_103) AT=980.025n

.meas tran vdout0_104ck1950 FIND v(dout0_104) AT=980.025n

.meas tran vdout0_105ck1950 FIND v(dout0_105) AT=980.025n

.meas tran vdout0_106ck1950 FIND v(dout0_106) AT=980.025n

.meas tran vdout0_107ck1950 FIND v(dout0_107) AT=980.025n

.meas tran vdout0_108ck1950 FIND v(dout0_108) AT=980.025n

.meas tran vdout0_109ck1950 FIND v(dout0_109) AT=980.025n

.meas tran vdout0_110ck1950 FIND v(dout0_110) AT=980.025n

.meas tran vdout0_111ck1950 FIND v(dout0_111) AT=980.025n

.meas tran vdout0_112ck1950 FIND v(dout0_112) AT=980.025n

.meas tran vdout0_113ck1950 FIND v(dout0_113) AT=980.025n

.meas tran vdout0_114ck1950 FIND v(dout0_114) AT=980.025n

.meas tran vdout0_115ck1950 FIND v(dout0_115) AT=980.025n

.meas tran vdout0_116ck1950 FIND v(dout0_116) AT=980.025n

.meas tran vdout0_117ck1950 FIND v(dout0_117) AT=980.025n

.meas tran vdout0_118ck1950 FIND v(dout0_118) AT=980.025n

.meas tran vdout0_119ck1950 FIND v(dout0_119) AT=980.025n

.meas tran vdout0_120ck1950 FIND v(dout0_120) AT=980.025n

.meas tran vdout0_121ck1950 FIND v(dout0_121) AT=980.025n

.meas tran vdout0_122ck1950 FIND v(dout0_122) AT=980.025n

.meas tran vdout0_123ck1950 FIND v(dout0_123) AT=980.025n

.meas tran vdout0_124ck1950 FIND v(dout0_124) AT=980.025n

.meas tran vdout0_125ck1950 FIND v(dout0_125) AT=980.025n

.meas tran vdout0_126ck1950 FIND v(dout0_126) AT=980.025n

.meas tran vdout0_127ck1950 FIND v(dout0_127) AT=980.025n

.meas tran vdout0_0ck1960 FIND v(dout0_0) AT=985.025n

.meas tran vdout0_1ck1960 FIND v(dout0_1) AT=985.025n

.meas tran vdout0_2ck1960 FIND v(dout0_2) AT=985.025n

.meas tran vdout0_3ck1960 FIND v(dout0_3) AT=985.025n

.meas tran vdout0_4ck1960 FIND v(dout0_4) AT=985.025n

.meas tran vdout0_5ck1960 FIND v(dout0_5) AT=985.025n

.meas tran vdout0_6ck1960 FIND v(dout0_6) AT=985.025n

.meas tran vdout0_7ck1960 FIND v(dout0_7) AT=985.025n

.meas tran vdout0_8ck1960 FIND v(dout0_8) AT=985.025n

.meas tran vdout0_9ck1960 FIND v(dout0_9) AT=985.025n

.meas tran vdout0_10ck1960 FIND v(dout0_10) AT=985.025n

.meas tran vdout0_11ck1960 FIND v(dout0_11) AT=985.025n

.meas tran vdout0_12ck1960 FIND v(dout0_12) AT=985.025n

.meas tran vdout0_13ck1960 FIND v(dout0_13) AT=985.025n

.meas tran vdout0_14ck1960 FIND v(dout0_14) AT=985.025n

.meas tran vdout0_15ck1960 FIND v(dout0_15) AT=985.025n

.meas tran vdout0_16ck1960 FIND v(dout0_16) AT=985.025n

.meas tran vdout0_17ck1960 FIND v(dout0_17) AT=985.025n

.meas tran vdout0_18ck1960 FIND v(dout0_18) AT=985.025n

.meas tran vdout0_19ck1960 FIND v(dout0_19) AT=985.025n

.meas tran vdout0_20ck1960 FIND v(dout0_20) AT=985.025n

.meas tran vdout0_21ck1960 FIND v(dout0_21) AT=985.025n

.meas tran vdout0_22ck1960 FIND v(dout0_22) AT=985.025n

.meas tran vdout0_23ck1960 FIND v(dout0_23) AT=985.025n

.meas tran vdout0_24ck1960 FIND v(dout0_24) AT=985.025n

.meas tran vdout0_25ck1960 FIND v(dout0_25) AT=985.025n

.meas tran vdout0_26ck1960 FIND v(dout0_26) AT=985.025n

.meas tran vdout0_27ck1960 FIND v(dout0_27) AT=985.025n

.meas tran vdout0_28ck1960 FIND v(dout0_28) AT=985.025n

.meas tran vdout0_29ck1960 FIND v(dout0_29) AT=985.025n

.meas tran vdout0_30ck1960 FIND v(dout0_30) AT=985.025n

.meas tran vdout0_31ck1960 FIND v(dout0_31) AT=985.025n

.meas tran vdout0_32ck1960 FIND v(dout0_32) AT=985.025n

.meas tran vdout0_33ck1960 FIND v(dout0_33) AT=985.025n

.meas tran vdout0_34ck1960 FIND v(dout0_34) AT=985.025n

.meas tran vdout0_35ck1960 FIND v(dout0_35) AT=985.025n

.meas tran vdout0_36ck1960 FIND v(dout0_36) AT=985.025n

.meas tran vdout0_37ck1960 FIND v(dout0_37) AT=985.025n

.meas tran vdout0_38ck1960 FIND v(dout0_38) AT=985.025n

.meas tran vdout0_39ck1960 FIND v(dout0_39) AT=985.025n

.meas tran vdout0_40ck1960 FIND v(dout0_40) AT=985.025n

.meas tran vdout0_41ck1960 FIND v(dout0_41) AT=985.025n

.meas tran vdout0_42ck1960 FIND v(dout0_42) AT=985.025n

.meas tran vdout0_43ck1960 FIND v(dout0_43) AT=985.025n

.meas tran vdout0_44ck1960 FIND v(dout0_44) AT=985.025n

.meas tran vdout0_45ck1960 FIND v(dout0_45) AT=985.025n

.meas tran vdout0_46ck1960 FIND v(dout0_46) AT=985.025n

.meas tran vdout0_47ck1960 FIND v(dout0_47) AT=985.025n

.meas tran vdout0_48ck1960 FIND v(dout0_48) AT=985.025n

.meas tran vdout0_49ck1960 FIND v(dout0_49) AT=985.025n

.meas tran vdout0_50ck1960 FIND v(dout0_50) AT=985.025n

.meas tran vdout0_51ck1960 FIND v(dout0_51) AT=985.025n

.meas tran vdout0_52ck1960 FIND v(dout0_52) AT=985.025n

.meas tran vdout0_53ck1960 FIND v(dout0_53) AT=985.025n

.meas tran vdout0_54ck1960 FIND v(dout0_54) AT=985.025n

.meas tran vdout0_55ck1960 FIND v(dout0_55) AT=985.025n

.meas tran vdout0_56ck1960 FIND v(dout0_56) AT=985.025n

.meas tran vdout0_57ck1960 FIND v(dout0_57) AT=985.025n

.meas tran vdout0_58ck1960 FIND v(dout0_58) AT=985.025n

.meas tran vdout0_59ck1960 FIND v(dout0_59) AT=985.025n

.meas tran vdout0_60ck1960 FIND v(dout0_60) AT=985.025n

.meas tran vdout0_61ck1960 FIND v(dout0_61) AT=985.025n

.meas tran vdout0_62ck1960 FIND v(dout0_62) AT=985.025n

.meas tran vdout0_63ck1960 FIND v(dout0_63) AT=985.025n

.meas tran vdout0_64ck1960 FIND v(dout0_64) AT=985.025n

.meas tran vdout0_65ck1960 FIND v(dout0_65) AT=985.025n

.meas tran vdout0_66ck1960 FIND v(dout0_66) AT=985.025n

.meas tran vdout0_67ck1960 FIND v(dout0_67) AT=985.025n

.meas tran vdout0_68ck1960 FIND v(dout0_68) AT=985.025n

.meas tran vdout0_69ck1960 FIND v(dout0_69) AT=985.025n

.meas tran vdout0_70ck1960 FIND v(dout0_70) AT=985.025n

.meas tran vdout0_71ck1960 FIND v(dout0_71) AT=985.025n

.meas tran vdout0_72ck1960 FIND v(dout0_72) AT=985.025n

.meas tran vdout0_73ck1960 FIND v(dout0_73) AT=985.025n

.meas tran vdout0_74ck1960 FIND v(dout0_74) AT=985.025n

.meas tran vdout0_75ck1960 FIND v(dout0_75) AT=985.025n

.meas tran vdout0_76ck1960 FIND v(dout0_76) AT=985.025n

.meas tran vdout0_77ck1960 FIND v(dout0_77) AT=985.025n

.meas tran vdout0_78ck1960 FIND v(dout0_78) AT=985.025n

.meas tran vdout0_79ck1960 FIND v(dout0_79) AT=985.025n

.meas tran vdout0_80ck1960 FIND v(dout0_80) AT=985.025n

.meas tran vdout0_81ck1960 FIND v(dout0_81) AT=985.025n

.meas tran vdout0_82ck1960 FIND v(dout0_82) AT=985.025n

.meas tran vdout0_83ck1960 FIND v(dout0_83) AT=985.025n

.meas tran vdout0_84ck1960 FIND v(dout0_84) AT=985.025n

.meas tran vdout0_85ck1960 FIND v(dout0_85) AT=985.025n

.meas tran vdout0_86ck1960 FIND v(dout0_86) AT=985.025n

.meas tran vdout0_87ck1960 FIND v(dout0_87) AT=985.025n

.meas tran vdout0_88ck1960 FIND v(dout0_88) AT=985.025n

.meas tran vdout0_89ck1960 FIND v(dout0_89) AT=985.025n

.meas tran vdout0_90ck1960 FIND v(dout0_90) AT=985.025n

.meas tran vdout0_91ck1960 FIND v(dout0_91) AT=985.025n

.meas tran vdout0_92ck1960 FIND v(dout0_92) AT=985.025n

.meas tran vdout0_93ck1960 FIND v(dout0_93) AT=985.025n

.meas tran vdout0_94ck1960 FIND v(dout0_94) AT=985.025n

.meas tran vdout0_95ck1960 FIND v(dout0_95) AT=985.025n

.meas tran vdout0_96ck1960 FIND v(dout0_96) AT=985.025n

.meas tran vdout0_97ck1960 FIND v(dout0_97) AT=985.025n

.meas tran vdout0_98ck1960 FIND v(dout0_98) AT=985.025n

.meas tran vdout0_99ck1960 FIND v(dout0_99) AT=985.025n

.meas tran vdout0_100ck1960 FIND v(dout0_100) AT=985.025n

.meas tran vdout0_101ck1960 FIND v(dout0_101) AT=985.025n

.meas tran vdout0_102ck1960 FIND v(dout0_102) AT=985.025n

.meas tran vdout0_103ck1960 FIND v(dout0_103) AT=985.025n

.meas tran vdout0_104ck1960 FIND v(dout0_104) AT=985.025n

.meas tran vdout0_105ck1960 FIND v(dout0_105) AT=985.025n

.meas tran vdout0_106ck1960 FIND v(dout0_106) AT=985.025n

.meas tran vdout0_107ck1960 FIND v(dout0_107) AT=985.025n

.meas tran vdout0_108ck1960 FIND v(dout0_108) AT=985.025n

.meas tran vdout0_109ck1960 FIND v(dout0_109) AT=985.025n

.meas tran vdout0_110ck1960 FIND v(dout0_110) AT=985.025n

.meas tran vdout0_111ck1960 FIND v(dout0_111) AT=985.025n

.meas tran vdout0_112ck1960 FIND v(dout0_112) AT=985.025n

.meas tran vdout0_113ck1960 FIND v(dout0_113) AT=985.025n

.meas tran vdout0_114ck1960 FIND v(dout0_114) AT=985.025n

.meas tran vdout0_115ck1960 FIND v(dout0_115) AT=985.025n

.meas tran vdout0_116ck1960 FIND v(dout0_116) AT=985.025n

.meas tran vdout0_117ck1960 FIND v(dout0_117) AT=985.025n

.meas tran vdout0_118ck1960 FIND v(dout0_118) AT=985.025n

.meas tran vdout0_119ck1960 FIND v(dout0_119) AT=985.025n

.meas tran vdout0_120ck1960 FIND v(dout0_120) AT=985.025n

.meas tran vdout0_121ck1960 FIND v(dout0_121) AT=985.025n

.meas tran vdout0_122ck1960 FIND v(dout0_122) AT=985.025n

.meas tran vdout0_123ck1960 FIND v(dout0_123) AT=985.025n

.meas tran vdout0_124ck1960 FIND v(dout0_124) AT=985.025n

.meas tran vdout0_125ck1960 FIND v(dout0_125) AT=985.025n

.meas tran vdout0_126ck1960 FIND v(dout0_126) AT=985.025n

.meas tran vdout0_127ck1960 FIND v(dout0_127) AT=985.025n

.meas tran vdout0_0ck1970 FIND v(dout0_0) AT=990.025n

.meas tran vdout0_1ck1970 FIND v(dout0_1) AT=990.025n

.meas tran vdout0_2ck1970 FIND v(dout0_2) AT=990.025n

.meas tran vdout0_3ck1970 FIND v(dout0_3) AT=990.025n

.meas tran vdout0_4ck1970 FIND v(dout0_4) AT=990.025n

.meas tran vdout0_5ck1970 FIND v(dout0_5) AT=990.025n

.meas tran vdout0_6ck1970 FIND v(dout0_6) AT=990.025n

.meas tran vdout0_7ck1970 FIND v(dout0_7) AT=990.025n

.meas tran vdout0_8ck1970 FIND v(dout0_8) AT=990.025n

.meas tran vdout0_9ck1970 FIND v(dout0_9) AT=990.025n

.meas tran vdout0_10ck1970 FIND v(dout0_10) AT=990.025n

.meas tran vdout0_11ck1970 FIND v(dout0_11) AT=990.025n

.meas tran vdout0_12ck1970 FIND v(dout0_12) AT=990.025n

.meas tran vdout0_13ck1970 FIND v(dout0_13) AT=990.025n

.meas tran vdout0_14ck1970 FIND v(dout0_14) AT=990.025n

.meas tran vdout0_15ck1970 FIND v(dout0_15) AT=990.025n

.meas tran vdout0_16ck1970 FIND v(dout0_16) AT=990.025n

.meas tran vdout0_17ck1970 FIND v(dout0_17) AT=990.025n

.meas tran vdout0_18ck1970 FIND v(dout0_18) AT=990.025n

.meas tran vdout0_19ck1970 FIND v(dout0_19) AT=990.025n

.meas tran vdout0_20ck1970 FIND v(dout0_20) AT=990.025n

.meas tran vdout0_21ck1970 FIND v(dout0_21) AT=990.025n

.meas tran vdout0_22ck1970 FIND v(dout0_22) AT=990.025n

.meas tran vdout0_23ck1970 FIND v(dout0_23) AT=990.025n

.meas tran vdout0_24ck1970 FIND v(dout0_24) AT=990.025n

.meas tran vdout0_25ck1970 FIND v(dout0_25) AT=990.025n

.meas tran vdout0_26ck1970 FIND v(dout0_26) AT=990.025n

.meas tran vdout0_27ck1970 FIND v(dout0_27) AT=990.025n

.meas tran vdout0_28ck1970 FIND v(dout0_28) AT=990.025n

.meas tran vdout0_29ck1970 FIND v(dout0_29) AT=990.025n

.meas tran vdout0_30ck1970 FIND v(dout0_30) AT=990.025n

.meas tran vdout0_31ck1970 FIND v(dout0_31) AT=990.025n

.meas tran vdout0_32ck1970 FIND v(dout0_32) AT=990.025n

.meas tran vdout0_33ck1970 FIND v(dout0_33) AT=990.025n

.meas tran vdout0_34ck1970 FIND v(dout0_34) AT=990.025n

.meas tran vdout0_35ck1970 FIND v(dout0_35) AT=990.025n

.meas tran vdout0_36ck1970 FIND v(dout0_36) AT=990.025n

.meas tran vdout0_37ck1970 FIND v(dout0_37) AT=990.025n

.meas tran vdout0_38ck1970 FIND v(dout0_38) AT=990.025n

.meas tran vdout0_39ck1970 FIND v(dout0_39) AT=990.025n

.meas tran vdout0_40ck1970 FIND v(dout0_40) AT=990.025n

.meas tran vdout0_41ck1970 FIND v(dout0_41) AT=990.025n

.meas tran vdout0_42ck1970 FIND v(dout0_42) AT=990.025n

.meas tran vdout0_43ck1970 FIND v(dout0_43) AT=990.025n

.meas tran vdout0_44ck1970 FIND v(dout0_44) AT=990.025n

.meas tran vdout0_45ck1970 FIND v(dout0_45) AT=990.025n

.meas tran vdout0_46ck1970 FIND v(dout0_46) AT=990.025n

.meas tran vdout0_47ck1970 FIND v(dout0_47) AT=990.025n

.meas tran vdout0_48ck1970 FIND v(dout0_48) AT=990.025n

.meas tran vdout0_49ck1970 FIND v(dout0_49) AT=990.025n

.meas tran vdout0_50ck1970 FIND v(dout0_50) AT=990.025n

.meas tran vdout0_51ck1970 FIND v(dout0_51) AT=990.025n

.meas tran vdout0_52ck1970 FIND v(dout0_52) AT=990.025n

.meas tran vdout0_53ck1970 FIND v(dout0_53) AT=990.025n

.meas tran vdout0_54ck1970 FIND v(dout0_54) AT=990.025n

.meas tran vdout0_55ck1970 FIND v(dout0_55) AT=990.025n

.meas tran vdout0_56ck1970 FIND v(dout0_56) AT=990.025n

.meas tran vdout0_57ck1970 FIND v(dout0_57) AT=990.025n

.meas tran vdout0_58ck1970 FIND v(dout0_58) AT=990.025n

.meas tran vdout0_59ck1970 FIND v(dout0_59) AT=990.025n

.meas tran vdout0_60ck1970 FIND v(dout0_60) AT=990.025n

.meas tran vdout0_61ck1970 FIND v(dout0_61) AT=990.025n

.meas tran vdout0_62ck1970 FIND v(dout0_62) AT=990.025n

.meas tran vdout0_63ck1970 FIND v(dout0_63) AT=990.025n

.meas tran vdout0_64ck1970 FIND v(dout0_64) AT=990.025n

.meas tran vdout0_65ck1970 FIND v(dout0_65) AT=990.025n

.meas tran vdout0_66ck1970 FIND v(dout0_66) AT=990.025n

.meas tran vdout0_67ck1970 FIND v(dout0_67) AT=990.025n

.meas tran vdout0_68ck1970 FIND v(dout0_68) AT=990.025n

.meas tran vdout0_69ck1970 FIND v(dout0_69) AT=990.025n

.meas tran vdout0_70ck1970 FIND v(dout0_70) AT=990.025n

.meas tran vdout0_71ck1970 FIND v(dout0_71) AT=990.025n

.meas tran vdout0_72ck1970 FIND v(dout0_72) AT=990.025n

.meas tran vdout0_73ck1970 FIND v(dout0_73) AT=990.025n

.meas tran vdout0_74ck1970 FIND v(dout0_74) AT=990.025n

.meas tran vdout0_75ck1970 FIND v(dout0_75) AT=990.025n

.meas tran vdout0_76ck1970 FIND v(dout0_76) AT=990.025n

.meas tran vdout0_77ck1970 FIND v(dout0_77) AT=990.025n

.meas tran vdout0_78ck1970 FIND v(dout0_78) AT=990.025n

.meas tran vdout0_79ck1970 FIND v(dout0_79) AT=990.025n

.meas tran vdout0_80ck1970 FIND v(dout0_80) AT=990.025n

.meas tran vdout0_81ck1970 FIND v(dout0_81) AT=990.025n

.meas tran vdout0_82ck1970 FIND v(dout0_82) AT=990.025n

.meas tran vdout0_83ck1970 FIND v(dout0_83) AT=990.025n

.meas tran vdout0_84ck1970 FIND v(dout0_84) AT=990.025n

.meas tran vdout0_85ck1970 FIND v(dout0_85) AT=990.025n

.meas tran vdout0_86ck1970 FIND v(dout0_86) AT=990.025n

.meas tran vdout0_87ck1970 FIND v(dout0_87) AT=990.025n

.meas tran vdout0_88ck1970 FIND v(dout0_88) AT=990.025n

.meas tran vdout0_89ck1970 FIND v(dout0_89) AT=990.025n

.meas tran vdout0_90ck1970 FIND v(dout0_90) AT=990.025n

.meas tran vdout0_91ck1970 FIND v(dout0_91) AT=990.025n

.meas tran vdout0_92ck1970 FIND v(dout0_92) AT=990.025n

.meas tran vdout0_93ck1970 FIND v(dout0_93) AT=990.025n

.meas tran vdout0_94ck1970 FIND v(dout0_94) AT=990.025n

.meas tran vdout0_95ck1970 FIND v(dout0_95) AT=990.025n

.meas tran vdout0_96ck1970 FIND v(dout0_96) AT=990.025n

.meas tran vdout0_97ck1970 FIND v(dout0_97) AT=990.025n

.meas tran vdout0_98ck1970 FIND v(dout0_98) AT=990.025n

.meas tran vdout0_99ck1970 FIND v(dout0_99) AT=990.025n

.meas tran vdout0_100ck1970 FIND v(dout0_100) AT=990.025n

.meas tran vdout0_101ck1970 FIND v(dout0_101) AT=990.025n

.meas tran vdout0_102ck1970 FIND v(dout0_102) AT=990.025n

.meas tran vdout0_103ck1970 FIND v(dout0_103) AT=990.025n

.meas tran vdout0_104ck1970 FIND v(dout0_104) AT=990.025n

.meas tran vdout0_105ck1970 FIND v(dout0_105) AT=990.025n

.meas tran vdout0_106ck1970 FIND v(dout0_106) AT=990.025n

.meas tran vdout0_107ck1970 FIND v(dout0_107) AT=990.025n

.meas tran vdout0_108ck1970 FIND v(dout0_108) AT=990.025n

.meas tran vdout0_109ck1970 FIND v(dout0_109) AT=990.025n

.meas tran vdout0_110ck1970 FIND v(dout0_110) AT=990.025n

.meas tran vdout0_111ck1970 FIND v(dout0_111) AT=990.025n

.meas tran vdout0_112ck1970 FIND v(dout0_112) AT=990.025n

.meas tran vdout0_113ck1970 FIND v(dout0_113) AT=990.025n

.meas tran vdout0_114ck1970 FIND v(dout0_114) AT=990.025n

.meas tran vdout0_115ck1970 FIND v(dout0_115) AT=990.025n

.meas tran vdout0_116ck1970 FIND v(dout0_116) AT=990.025n

.meas tran vdout0_117ck1970 FIND v(dout0_117) AT=990.025n

.meas tran vdout0_118ck1970 FIND v(dout0_118) AT=990.025n

.meas tran vdout0_119ck1970 FIND v(dout0_119) AT=990.025n

.meas tran vdout0_120ck1970 FIND v(dout0_120) AT=990.025n

.meas tran vdout0_121ck1970 FIND v(dout0_121) AT=990.025n

.meas tran vdout0_122ck1970 FIND v(dout0_122) AT=990.025n

.meas tran vdout0_123ck1970 FIND v(dout0_123) AT=990.025n

.meas tran vdout0_124ck1970 FIND v(dout0_124) AT=990.025n

.meas tran vdout0_125ck1970 FIND v(dout0_125) AT=990.025n

.meas tran vdout0_126ck1970 FIND v(dout0_126) AT=990.025n

.meas tran vdout0_127ck1970 FIND v(dout0_127) AT=990.025n

.meas tran vdout0_0ck2000 FIND v(dout0_0) AT=1005.025n

.meas tran vdout0_1ck2000 FIND v(dout0_1) AT=1005.025n

.meas tran vdout0_2ck2000 FIND v(dout0_2) AT=1005.025n

.meas tran vdout0_3ck2000 FIND v(dout0_3) AT=1005.025n

.meas tran vdout0_4ck2000 FIND v(dout0_4) AT=1005.025n

.meas tran vdout0_5ck2000 FIND v(dout0_5) AT=1005.025n

.meas tran vdout0_6ck2000 FIND v(dout0_6) AT=1005.025n

.meas tran vdout0_7ck2000 FIND v(dout0_7) AT=1005.025n

.meas tran vdout0_8ck2000 FIND v(dout0_8) AT=1005.025n

.meas tran vdout0_9ck2000 FIND v(dout0_9) AT=1005.025n

.meas tran vdout0_10ck2000 FIND v(dout0_10) AT=1005.025n

.meas tran vdout0_11ck2000 FIND v(dout0_11) AT=1005.025n

.meas tran vdout0_12ck2000 FIND v(dout0_12) AT=1005.025n

.meas tran vdout0_13ck2000 FIND v(dout0_13) AT=1005.025n

.meas tran vdout0_14ck2000 FIND v(dout0_14) AT=1005.025n

.meas tran vdout0_15ck2000 FIND v(dout0_15) AT=1005.025n

.meas tran vdout0_16ck2000 FIND v(dout0_16) AT=1005.025n

.meas tran vdout0_17ck2000 FIND v(dout0_17) AT=1005.025n

.meas tran vdout0_18ck2000 FIND v(dout0_18) AT=1005.025n

.meas tran vdout0_19ck2000 FIND v(dout0_19) AT=1005.025n

.meas tran vdout0_20ck2000 FIND v(dout0_20) AT=1005.025n

.meas tran vdout0_21ck2000 FIND v(dout0_21) AT=1005.025n

.meas tran vdout0_22ck2000 FIND v(dout0_22) AT=1005.025n

.meas tran vdout0_23ck2000 FIND v(dout0_23) AT=1005.025n

.meas tran vdout0_24ck2000 FIND v(dout0_24) AT=1005.025n

.meas tran vdout0_25ck2000 FIND v(dout0_25) AT=1005.025n

.meas tran vdout0_26ck2000 FIND v(dout0_26) AT=1005.025n

.meas tran vdout0_27ck2000 FIND v(dout0_27) AT=1005.025n

.meas tran vdout0_28ck2000 FIND v(dout0_28) AT=1005.025n

.meas tran vdout0_29ck2000 FIND v(dout0_29) AT=1005.025n

.meas tran vdout0_30ck2000 FIND v(dout0_30) AT=1005.025n

.meas tran vdout0_31ck2000 FIND v(dout0_31) AT=1005.025n

.meas tran vdout0_32ck2000 FIND v(dout0_32) AT=1005.025n

.meas tran vdout0_33ck2000 FIND v(dout0_33) AT=1005.025n

.meas tran vdout0_34ck2000 FIND v(dout0_34) AT=1005.025n

.meas tran vdout0_35ck2000 FIND v(dout0_35) AT=1005.025n

.meas tran vdout0_36ck2000 FIND v(dout0_36) AT=1005.025n

.meas tran vdout0_37ck2000 FIND v(dout0_37) AT=1005.025n

.meas tran vdout0_38ck2000 FIND v(dout0_38) AT=1005.025n

.meas tran vdout0_39ck2000 FIND v(dout0_39) AT=1005.025n

.meas tran vdout0_40ck2000 FIND v(dout0_40) AT=1005.025n

.meas tran vdout0_41ck2000 FIND v(dout0_41) AT=1005.025n

.meas tran vdout0_42ck2000 FIND v(dout0_42) AT=1005.025n

.meas tran vdout0_43ck2000 FIND v(dout0_43) AT=1005.025n

.meas tran vdout0_44ck2000 FIND v(dout0_44) AT=1005.025n

.meas tran vdout0_45ck2000 FIND v(dout0_45) AT=1005.025n

.meas tran vdout0_46ck2000 FIND v(dout0_46) AT=1005.025n

.meas tran vdout0_47ck2000 FIND v(dout0_47) AT=1005.025n

.meas tran vdout0_48ck2000 FIND v(dout0_48) AT=1005.025n

.meas tran vdout0_49ck2000 FIND v(dout0_49) AT=1005.025n

.meas tran vdout0_50ck2000 FIND v(dout0_50) AT=1005.025n

.meas tran vdout0_51ck2000 FIND v(dout0_51) AT=1005.025n

.meas tran vdout0_52ck2000 FIND v(dout0_52) AT=1005.025n

.meas tran vdout0_53ck2000 FIND v(dout0_53) AT=1005.025n

.meas tran vdout0_54ck2000 FIND v(dout0_54) AT=1005.025n

.meas tran vdout0_55ck2000 FIND v(dout0_55) AT=1005.025n

.meas tran vdout0_56ck2000 FIND v(dout0_56) AT=1005.025n

.meas tran vdout0_57ck2000 FIND v(dout0_57) AT=1005.025n

.meas tran vdout0_58ck2000 FIND v(dout0_58) AT=1005.025n

.meas tran vdout0_59ck2000 FIND v(dout0_59) AT=1005.025n

.meas tran vdout0_60ck2000 FIND v(dout0_60) AT=1005.025n

.meas tran vdout0_61ck2000 FIND v(dout0_61) AT=1005.025n

.meas tran vdout0_62ck2000 FIND v(dout0_62) AT=1005.025n

.meas tran vdout0_63ck2000 FIND v(dout0_63) AT=1005.025n

.meas tran vdout0_64ck2000 FIND v(dout0_64) AT=1005.025n

.meas tran vdout0_65ck2000 FIND v(dout0_65) AT=1005.025n

.meas tran vdout0_66ck2000 FIND v(dout0_66) AT=1005.025n

.meas tran vdout0_67ck2000 FIND v(dout0_67) AT=1005.025n

.meas tran vdout0_68ck2000 FIND v(dout0_68) AT=1005.025n

.meas tran vdout0_69ck2000 FIND v(dout0_69) AT=1005.025n

.meas tran vdout0_70ck2000 FIND v(dout0_70) AT=1005.025n

.meas tran vdout0_71ck2000 FIND v(dout0_71) AT=1005.025n

.meas tran vdout0_72ck2000 FIND v(dout0_72) AT=1005.025n

.meas tran vdout0_73ck2000 FIND v(dout0_73) AT=1005.025n

.meas tran vdout0_74ck2000 FIND v(dout0_74) AT=1005.025n

.meas tran vdout0_75ck2000 FIND v(dout0_75) AT=1005.025n

.meas tran vdout0_76ck2000 FIND v(dout0_76) AT=1005.025n

.meas tran vdout0_77ck2000 FIND v(dout0_77) AT=1005.025n

.meas tran vdout0_78ck2000 FIND v(dout0_78) AT=1005.025n

.meas tran vdout0_79ck2000 FIND v(dout0_79) AT=1005.025n

.meas tran vdout0_80ck2000 FIND v(dout0_80) AT=1005.025n

.meas tran vdout0_81ck2000 FIND v(dout0_81) AT=1005.025n

.meas tran vdout0_82ck2000 FIND v(dout0_82) AT=1005.025n

.meas tran vdout0_83ck2000 FIND v(dout0_83) AT=1005.025n

.meas tran vdout0_84ck2000 FIND v(dout0_84) AT=1005.025n

.meas tran vdout0_85ck2000 FIND v(dout0_85) AT=1005.025n

.meas tran vdout0_86ck2000 FIND v(dout0_86) AT=1005.025n

.meas tran vdout0_87ck2000 FIND v(dout0_87) AT=1005.025n

.meas tran vdout0_88ck2000 FIND v(dout0_88) AT=1005.025n

.meas tran vdout0_89ck2000 FIND v(dout0_89) AT=1005.025n

.meas tran vdout0_90ck2000 FIND v(dout0_90) AT=1005.025n

.meas tran vdout0_91ck2000 FIND v(dout0_91) AT=1005.025n

.meas tran vdout0_92ck2000 FIND v(dout0_92) AT=1005.025n

.meas tran vdout0_93ck2000 FIND v(dout0_93) AT=1005.025n

.meas tran vdout0_94ck2000 FIND v(dout0_94) AT=1005.025n

.meas tran vdout0_95ck2000 FIND v(dout0_95) AT=1005.025n

.meas tran vdout0_96ck2000 FIND v(dout0_96) AT=1005.025n

.meas tran vdout0_97ck2000 FIND v(dout0_97) AT=1005.025n

.meas tran vdout0_98ck2000 FIND v(dout0_98) AT=1005.025n

.meas tran vdout0_99ck2000 FIND v(dout0_99) AT=1005.025n

.meas tran vdout0_100ck2000 FIND v(dout0_100) AT=1005.025n

.meas tran vdout0_101ck2000 FIND v(dout0_101) AT=1005.025n

.meas tran vdout0_102ck2000 FIND v(dout0_102) AT=1005.025n

.meas tran vdout0_103ck2000 FIND v(dout0_103) AT=1005.025n

.meas tran vdout0_104ck2000 FIND v(dout0_104) AT=1005.025n

.meas tran vdout0_105ck2000 FIND v(dout0_105) AT=1005.025n

.meas tran vdout0_106ck2000 FIND v(dout0_106) AT=1005.025n

.meas tran vdout0_107ck2000 FIND v(dout0_107) AT=1005.025n

.meas tran vdout0_108ck2000 FIND v(dout0_108) AT=1005.025n

.meas tran vdout0_109ck2000 FIND v(dout0_109) AT=1005.025n

.meas tran vdout0_110ck2000 FIND v(dout0_110) AT=1005.025n

.meas tran vdout0_111ck2000 FIND v(dout0_111) AT=1005.025n

.meas tran vdout0_112ck2000 FIND v(dout0_112) AT=1005.025n

.meas tran vdout0_113ck2000 FIND v(dout0_113) AT=1005.025n

.meas tran vdout0_114ck2000 FIND v(dout0_114) AT=1005.025n

.meas tran vdout0_115ck2000 FIND v(dout0_115) AT=1005.025n

.meas tran vdout0_116ck2000 FIND v(dout0_116) AT=1005.025n

.meas tran vdout0_117ck2000 FIND v(dout0_117) AT=1005.025n

.meas tran vdout0_118ck2000 FIND v(dout0_118) AT=1005.025n

.meas tran vdout0_119ck2000 FIND v(dout0_119) AT=1005.025n

.meas tran vdout0_120ck2000 FIND v(dout0_120) AT=1005.025n

.meas tran vdout0_121ck2000 FIND v(dout0_121) AT=1005.025n

.meas tran vdout0_122ck2000 FIND v(dout0_122) AT=1005.025n

.meas tran vdout0_123ck2000 FIND v(dout0_123) AT=1005.025n

.meas tran vdout0_124ck2000 FIND v(dout0_124) AT=1005.025n

.meas tran vdout0_125ck2000 FIND v(dout0_125) AT=1005.025n

.meas tran vdout0_126ck2000 FIND v(dout0_126) AT=1005.025n

.meas tran vdout0_127ck2000 FIND v(dout0_127) AT=1005.025n

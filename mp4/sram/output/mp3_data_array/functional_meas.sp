.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_128ck40 FIND v(dout0_128) AT=25.025n

.meas tran vdout0_129ck40 FIND v(dout0_129) AT=25.025n

.meas tran vdout0_130ck40 FIND v(dout0_130) AT=25.025n

.meas tran vdout0_131ck40 FIND v(dout0_131) AT=25.025n

.meas tran vdout0_132ck40 FIND v(dout0_132) AT=25.025n

.meas tran vdout0_133ck40 FIND v(dout0_133) AT=25.025n

.meas tran vdout0_134ck40 FIND v(dout0_134) AT=25.025n

.meas tran vdout0_135ck40 FIND v(dout0_135) AT=25.025n

.meas tran vdout0_136ck40 FIND v(dout0_136) AT=25.025n

.meas tran vdout0_137ck40 FIND v(dout0_137) AT=25.025n

.meas tran vdout0_138ck40 FIND v(dout0_138) AT=25.025n

.meas tran vdout0_139ck40 FIND v(dout0_139) AT=25.025n

.meas tran vdout0_140ck40 FIND v(dout0_140) AT=25.025n

.meas tran vdout0_141ck40 FIND v(dout0_141) AT=25.025n

.meas tran vdout0_142ck40 FIND v(dout0_142) AT=25.025n

.meas tran vdout0_143ck40 FIND v(dout0_143) AT=25.025n

.meas tran vdout0_144ck40 FIND v(dout0_144) AT=25.025n

.meas tran vdout0_145ck40 FIND v(dout0_145) AT=25.025n

.meas tran vdout0_146ck40 FIND v(dout0_146) AT=25.025n

.meas tran vdout0_147ck40 FIND v(dout0_147) AT=25.025n

.meas tran vdout0_148ck40 FIND v(dout0_148) AT=25.025n

.meas tran vdout0_149ck40 FIND v(dout0_149) AT=25.025n

.meas tran vdout0_150ck40 FIND v(dout0_150) AT=25.025n

.meas tran vdout0_151ck40 FIND v(dout0_151) AT=25.025n

.meas tran vdout0_152ck40 FIND v(dout0_152) AT=25.025n

.meas tran vdout0_153ck40 FIND v(dout0_153) AT=25.025n

.meas tran vdout0_154ck40 FIND v(dout0_154) AT=25.025n

.meas tran vdout0_155ck40 FIND v(dout0_155) AT=25.025n

.meas tran vdout0_156ck40 FIND v(dout0_156) AT=25.025n

.meas tran vdout0_157ck40 FIND v(dout0_157) AT=25.025n

.meas tran vdout0_158ck40 FIND v(dout0_158) AT=25.025n

.meas tran vdout0_159ck40 FIND v(dout0_159) AT=25.025n

.meas tran vdout0_160ck40 FIND v(dout0_160) AT=25.025n

.meas tran vdout0_161ck40 FIND v(dout0_161) AT=25.025n

.meas tran vdout0_162ck40 FIND v(dout0_162) AT=25.025n

.meas tran vdout0_163ck40 FIND v(dout0_163) AT=25.025n

.meas tran vdout0_164ck40 FIND v(dout0_164) AT=25.025n

.meas tran vdout0_165ck40 FIND v(dout0_165) AT=25.025n

.meas tran vdout0_166ck40 FIND v(dout0_166) AT=25.025n

.meas tran vdout0_167ck40 FIND v(dout0_167) AT=25.025n

.meas tran vdout0_168ck40 FIND v(dout0_168) AT=25.025n

.meas tran vdout0_169ck40 FIND v(dout0_169) AT=25.025n

.meas tran vdout0_170ck40 FIND v(dout0_170) AT=25.025n

.meas tran vdout0_171ck40 FIND v(dout0_171) AT=25.025n

.meas tran vdout0_172ck40 FIND v(dout0_172) AT=25.025n

.meas tran vdout0_173ck40 FIND v(dout0_173) AT=25.025n

.meas tran vdout0_174ck40 FIND v(dout0_174) AT=25.025n

.meas tran vdout0_175ck40 FIND v(dout0_175) AT=25.025n

.meas tran vdout0_176ck40 FIND v(dout0_176) AT=25.025n

.meas tran vdout0_177ck40 FIND v(dout0_177) AT=25.025n

.meas tran vdout0_178ck40 FIND v(dout0_178) AT=25.025n

.meas tran vdout0_179ck40 FIND v(dout0_179) AT=25.025n

.meas tran vdout0_180ck40 FIND v(dout0_180) AT=25.025n

.meas tran vdout0_181ck40 FIND v(dout0_181) AT=25.025n

.meas tran vdout0_182ck40 FIND v(dout0_182) AT=25.025n

.meas tran vdout0_183ck40 FIND v(dout0_183) AT=25.025n

.meas tran vdout0_184ck40 FIND v(dout0_184) AT=25.025n

.meas tran vdout0_185ck40 FIND v(dout0_185) AT=25.025n

.meas tran vdout0_186ck40 FIND v(dout0_186) AT=25.025n

.meas tran vdout0_187ck40 FIND v(dout0_187) AT=25.025n

.meas tran vdout0_188ck40 FIND v(dout0_188) AT=25.025n

.meas tran vdout0_189ck40 FIND v(dout0_189) AT=25.025n

.meas tran vdout0_190ck40 FIND v(dout0_190) AT=25.025n

.meas tran vdout0_191ck40 FIND v(dout0_191) AT=25.025n

.meas tran vdout0_192ck40 FIND v(dout0_192) AT=25.025n

.meas tran vdout0_193ck40 FIND v(dout0_193) AT=25.025n

.meas tran vdout0_194ck40 FIND v(dout0_194) AT=25.025n

.meas tran vdout0_195ck40 FIND v(dout0_195) AT=25.025n

.meas tran vdout0_196ck40 FIND v(dout0_196) AT=25.025n

.meas tran vdout0_197ck40 FIND v(dout0_197) AT=25.025n

.meas tran vdout0_198ck40 FIND v(dout0_198) AT=25.025n

.meas tran vdout0_199ck40 FIND v(dout0_199) AT=25.025n

.meas tran vdout0_200ck40 FIND v(dout0_200) AT=25.025n

.meas tran vdout0_201ck40 FIND v(dout0_201) AT=25.025n

.meas tran vdout0_202ck40 FIND v(dout0_202) AT=25.025n

.meas tran vdout0_203ck40 FIND v(dout0_203) AT=25.025n

.meas tran vdout0_204ck40 FIND v(dout0_204) AT=25.025n

.meas tran vdout0_205ck40 FIND v(dout0_205) AT=25.025n

.meas tran vdout0_206ck40 FIND v(dout0_206) AT=25.025n

.meas tran vdout0_207ck40 FIND v(dout0_207) AT=25.025n

.meas tran vdout0_208ck40 FIND v(dout0_208) AT=25.025n

.meas tran vdout0_209ck40 FIND v(dout0_209) AT=25.025n

.meas tran vdout0_210ck40 FIND v(dout0_210) AT=25.025n

.meas tran vdout0_211ck40 FIND v(dout0_211) AT=25.025n

.meas tran vdout0_212ck40 FIND v(dout0_212) AT=25.025n

.meas tran vdout0_213ck40 FIND v(dout0_213) AT=25.025n

.meas tran vdout0_214ck40 FIND v(dout0_214) AT=25.025n

.meas tran vdout0_215ck40 FIND v(dout0_215) AT=25.025n

.meas tran vdout0_216ck40 FIND v(dout0_216) AT=25.025n

.meas tran vdout0_217ck40 FIND v(dout0_217) AT=25.025n

.meas tran vdout0_218ck40 FIND v(dout0_218) AT=25.025n

.meas tran vdout0_219ck40 FIND v(dout0_219) AT=25.025n

.meas tran vdout0_220ck40 FIND v(dout0_220) AT=25.025n

.meas tran vdout0_221ck40 FIND v(dout0_221) AT=25.025n

.meas tran vdout0_222ck40 FIND v(dout0_222) AT=25.025n

.meas tran vdout0_223ck40 FIND v(dout0_223) AT=25.025n

.meas tran vdout0_224ck40 FIND v(dout0_224) AT=25.025n

.meas tran vdout0_225ck40 FIND v(dout0_225) AT=25.025n

.meas tran vdout0_226ck40 FIND v(dout0_226) AT=25.025n

.meas tran vdout0_227ck40 FIND v(dout0_227) AT=25.025n

.meas tran vdout0_228ck40 FIND v(dout0_228) AT=25.025n

.meas tran vdout0_229ck40 FIND v(dout0_229) AT=25.025n

.meas tran vdout0_230ck40 FIND v(dout0_230) AT=25.025n

.meas tran vdout0_231ck40 FIND v(dout0_231) AT=25.025n

.meas tran vdout0_232ck40 FIND v(dout0_232) AT=25.025n

.meas tran vdout0_233ck40 FIND v(dout0_233) AT=25.025n

.meas tran vdout0_234ck40 FIND v(dout0_234) AT=25.025n

.meas tran vdout0_235ck40 FIND v(dout0_235) AT=25.025n

.meas tran vdout0_236ck40 FIND v(dout0_236) AT=25.025n

.meas tran vdout0_237ck40 FIND v(dout0_237) AT=25.025n

.meas tran vdout0_238ck40 FIND v(dout0_238) AT=25.025n

.meas tran vdout0_239ck40 FIND v(dout0_239) AT=25.025n

.meas tran vdout0_240ck40 FIND v(dout0_240) AT=25.025n

.meas tran vdout0_241ck40 FIND v(dout0_241) AT=25.025n

.meas tran vdout0_242ck40 FIND v(dout0_242) AT=25.025n

.meas tran vdout0_243ck40 FIND v(dout0_243) AT=25.025n

.meas tran vdout0_244ck40 FIND v(dout0_244) AT=25.025n

.meas tran vdout0_245ck40 FIND v(dout0_245) AT=25.025n

.meas tran vdout0_246ck40 FIND v(dout0_246) AT=25.025n

.meas tran vdout0_247ck40 FIND v(dout0_247) AT=25.025n

.meas tran vdout0_248ck40 FIND v(dout0_248) AT=25.025n

.meas tran vdout0_249ck40 FIND v(dout0_249) AT=25.025n

.meas tran vdout0_250ck40 FIND v(dout0_250) AT=25.025n

.meas tran vdout0_251ck40 FIND v(dout0_251) AT=25.025n

.meas tran vdout0_252ck40 FIND v(dout0_252) AT=25.025n

.meas tran vdout0_253ck40 FIND v(dout0_253) AT=25.025n

.meas tran vdout0_254ck40 FIND v(dout0_254) AT=25.025n

.meas tran vdout0_255ck40 FIND v(dout0_255) AT=25.025n

.meas tran vdout0_0ck50 FIND v(dout0_0) AT=30.025n

.meas tran vdout0_1ck50 FIND v(dout0_1) AT=30.025n

.meas tran vdout0_2ck50 FIND v(dout0_2) AT=30.025n

.meas tran vdout0_3ck50 FIND v(dout0_3) AT=30.025n

.meas tran vdout0_4ck50 FIND v(dout0_4) AT=30.025n

.meas tran vdout0_5ck50 FIND v(dout0_5) AT=30.025n

.meas tran vdout0_6ck50 FIND v(dout0_6) AT=30.025n

.meas tran vdout0_7ck50 FIND v(dout0_7) AT=30.025n

.meas tran vdout0_8ck50 FIND v(dout0_8) AT=30.025n

.meas tran vdout0_9ck50 FIND v(dout0_9) AT=30.025n

.meas tran vdout0_10ck50 FIND v(dout0_10) AT=30.025n

.meas tran vdout0_11ck50 FIND v(dout0_11) AT=30.025n

.meas tran vdout0_12ck50 FIND v(dout0_12) AT=30.025n

.meas tran vdout0_13ck50 FIND v(dout0_13) AT=30.025n

.meas tran vdout0_14ck50 FIND v(dout0_14) AT=30.025n

.meas tran vdout0_15ck50 FIND v(dout0_15) AT=30.025n

.meas tran vdout0_16ck50 FIND v(dout0_16) AT=30.025n

.meas tran vdout0_17ck50 FIND v(dout0_17) AT=30.025n

.meas tran vdout0_18ck50 FIND v(dout0_18) AT=30.025n

.meas tran vdout0_19ck50 FIND v(dout0_19) AT=30.025n

.meas tran vdout0_20ck50 FIND v(dout0_20) AT=30.025n

.meas tran vdout0_21ck50 FIND v(dout0_21) AT=30.025n

.meas tran vdout0_22ck50 FIND v(dout0_22) AT=30.025n

.meas tran vdout0_23ck50 FIND v(dout0_23) AT=30.025n

.meas tran vdout0_24ck50 FIND v(dout0_24) AT=30.025n

.meas tran vdout0_25ck50 FIND v(dout0_25) AT=30.025n

.meas tran vdout0_26ck50 FIND v(dout0_26) AT=30.025n

.meas tran vdout0_27ck50 FIND v(dout0_27) AT=30.025n

.meas tran vdout0_28ck50 FIND v(dout0_28) AT=30.025n

.meas tran vdout0_29ck50 FIND v(dout0_29) AT=30.025n

.meas tran vdout0_30ck50 FIND v(dout0_30) AT=30.025n

.meas tran vdout0_31ck50 FIND v(dout0_31) AT=30.025n

.meas tran vdout0_32ck50 FIND v(dout0_32) AT=30.025n

.meas tran vdout0_33ck50 FIND v(dout0_33) AT=30.025n

.meas tran vdout0_34ck50 FIND v(dout0_34) AT=30.025n

.meas tran vdout0_35ck50 FIND v(dout0_35) AT=30.025n

.meas tran vdout0_36ck50 FIND v(dout0_36) AT=30.025n

.meas tran vdout0_37ck50 FIND v(dout0_37) AT=30.025n

.meas tran vdout0_38ck50 FIND v(dout0_38) AT=30.025n

.meas tran vdout0_39ck50 FIND v(dout0_39) AT=30.025n

.meas tran vdout0_40ck50 FIND v(dout0_40) AT=30.025n

.meas tran vdout0_41ck50 FIND v(dout0_41) AT=30.025n

.meas tran vdout0_42ck50 FIND v(dout0_42) AT=30.025n

.meas tran vdout0_43ck50 FIND v(dout0_43) AT=30.025n

.meas tran vdout0_44ck50 FIND v(dout0_44) AT=30.025n

.meas tran vdout0_45ck50 FIND v(dout0_45) AT=30.025n

.meas tran vdout0_46ck50 FIND v(dout0_46) AT=30.025n

.meas tran vdout0_47ck50 FIND v(dout0_47) AT=30.025n

.meas tran vdout0_48ck50 FIND v(dout0_48) AT=30.025n

.meas tran vdout0_49ck50 FIND v(dout0_49) AT=30.025n

.meas tran vdout0_50ck50 FIND v(dout0_50) AT=30.025n

.meas tran vdout0_51ck50 FIND v(dout0_51) AT=30.025n

.meas tran vdout0_52ck50 FIND v(dout0_52) AT=30.025n

.meas tran vdout0_53ck50 FIND v(dout0_53) AT=30.025n

.meas tran vdout0_54ck50 FIND v(dout0_54) AT=30.025n

.meas tran vdout0_55ck50 FIND v(dout0_55) AT=30.025n

.meas tran vdout0_56ck50 FIND v(dout0_56) AT=30.025n

.meas tran vdout0_57ck50 FIND v(dout0_57) AT=30.025n

.meas tran vdout0_58ck50 FIND v(dout0_58) AT=30.025n

.meas tran vdout0_59ck50 FIND v(dout0_59) AT=30.025n

.meas tran vdout0_60ck50 FIND v(dout0_60) AT=30.025n

.meas tran vdout0_61ck50 FIND v(dout0_61) AT=30.025n

.meas tran vdout0_62ck50 FIND v(dout0_62) AT=30.025n

.meas tran vdout0_63ck50 FIND v(dout0_63) AT=30.025n

.meas tran vdout0_64ck50 FIND v(dout0_64) AT=30.025n

.meas tran vdout0_65ck50 FIND v(dout0_65) AT=30.025n

.meas tran vdout0_66ck50 FIND v(dout0_66) AT=30.025n

.meas tran vdout0_67ck50 FIND v(dout0_67) AT=30.025n

.meas tran vdout0_68ck50 FIND v(dout0_68) AT=30.025n

.meas tran vdout0_69ck50 FIND v(dout0_69) AT=30.025n

.meas tran vdout0_70ck50 FIND v(dout0_70) AT=30.025n

.meas tran vdout0_71ck50 FIND v(dout0_71) AT=30.025n

.meas tran vdout0_72ck50 FIND v(dout0_72) AT=30.025n

.meas tran vdout0_73ck50 FIND v(dout0_73) AT=30.025n

.meas tran vdout0_74ck50 FIND v(dout0_74) AT=30.025n

.meas tran vdout0_75ck50 FIND v(dout0_75) AT=30.025n

.meas tran vdout0_76ck50 FIND v(dout0_76) AT=30.025n

.meas tran vdout0_77ck50 FIND v(dout0_77) AT=30.025n

.meas tran vdout0_78ck50 FIND v(dout0_78) AT=30.025n

.meas tran vdout0_79ck50 FIND v(dout0_79) AT=30.025n

.meas tran vdout0_80ck50 FIND v(dout0_80) AT=30.025n

.meas tran vdout0_81ck50 FIND v(dout0_81) AT=30.025n

.meas tran vdout0_82ck50 FIND v(dout0_82) AT=30.025n

.meas tran vdout0_83ck50 FIND v(dout0_83) AT=30.025n

.meas tran vdout0_84ck50 FIND v(dout0_84) AT=30.025n

.meas tran vdout0_85ck50 FIND v(dout0_85) AT=30.025n

.meas tran vdout0_86ck50 FIND v(dout0_86) AT=30.025n

.meas tran vdout0_87ck50 FIND v(dout0_87) AT=30.025n

.meas tran vdout0_88ck50 FIND v(dout0_88) AT=30.025n

.meas tran vdout0_89ck50 FIND v(dout0_89) AT=30.025n

.meas tran vdout0_90ck50 FIND v(dout0_90) AT=30.025n

.meas tran vdout0_91ck50 FIND v(dout0_91) AT=30.025n

.meas tran vdout0_92ck50 FIND v(dout0_92) AT=30.025n

.meas tran vdout0_93ck50 FIND v(dout0_93) AT=30.025n

.meas tran vdout0_94ck50 FIND v(dout0_94) AT=30.025n

.meas tran vdout0_95ck50 FIND v(dout0_95) AT=30.025n

.meas tran vdout0_96ck50 FIND v(dout0_96) AT=30.025n

.meas tran vdout0_97ck50 FIND v(dout0_97) AT=30.025n

.meas tran vdout0_98ck50 FIND v(dout0_98) AT=30.025n

.meas tran vdout0_99ck50 FIND v(dout0_99) AT=30.025n

.meas tran vdout0_100ck50 FIND v(dout0_100) AT=30.025n

.meas tran vdout0_101ck50 FIND v(dout0_101) AT=30.025n

.meas tran vdout0_102ck50 FIND v(dout0_102) AT=30.025n

.meas tran vdout0_103ck50 FIND v(dout0_103) AT=30.025n

.meas tran vdout0_104ck50 FIND v(dout0_104) AT=30.025n

.meas tran vdout0_105ck50 FIND v(dout0_105) AT=30.025n

.meas tran vdout0_106ck50 FIND v(dout0_106) AT=30.025n

.meas tran vdout0_107ck50 FIND v(dout0_107) AT=30.025n

.meas tran vdout0_108ck50 FIND v(dout0_108) AT=30.025n

.meas tran vdout0_109ck50 FIND v(dout0_109) AT=30.025n

.meas tran vdout0_110ck50 FIND v(dout0_110) AT=30.025n

.meas tran vdout0_111ck50 FIND v(dout0_111) AT=30.025n

.meas tran vdout0_112ck50 FIND v(dout0_112) AT=30.025n

.meas tran vdout0_113ck50 FIND v(dout0_113) AT=30.025n

.meas tran vdout0_114ck50 FIND v(dout0_114) AT=30.025n

.meas tran vdout0_115ck50 FIND v(dout0_115) AT=30.025n

.meas tran vdout0_116ck50 FIND v(dout0_116) AT=30.025n

.meas tran vdout0_117ck50 FIND v(dout0_117) AT=30.025n

.meas tran vdout0_118ck50 FIND v(dout0_118) AT=30.025n

.meas tran vdout0_119ck50 FIND v(dout0_119) AT=30.025n

.meas tran vdout0_120ck50 FIND v(dout0_120) AT=30.025n

.meas tran vdout0_121ck50 FIND v(dout0_121) AT=30.025n

.meas tran vdout0_122ck50 FIND v(dout0_122) AT=30.025n

.meas tran vdout0_123ck50 FIND v(dout0_123) AT=30.025n

.meas tran vdout0_124ck50 FIND v(dout0_124) AT=30.025n

.meas tran vdout0_125ck50 FIND v(dout0_125) AT=30.025n

.meas tran vdout0_126ck50 FIND v(dout0_126) AT=30.025n

.meas tran vdout0_127ck50 FIND v(dout0_127) AT=30.025n

.meas tran vdout0_128ck50 FIND v(dout0_128) AT=30.025n

.meas tran vdout0_129ck50 FIND v(dout0_129) AT=30.025n

.meas tran vdout0_130ck50 FIND v(dout0_130) AT=30.025n

.meas tran vdout0_131ck50 FIND v(dout0_131) AT=30.025n

.meas tran vdout0_132ck50 FIND v(dout0_132) AT=30.025n

.meas tran vdout0_133ck50 FIND v(dout0_133) AT=30.025n

.meas tran vdout0_134ck50 FIND v(dout0_134) AT=30.025n

.meas tran vdout0_135ck50 FIND v(dout0_135) AT=30.025n

.meas tran vdout0_136ck50 FIND v(dout0_136) AT=30.025n

.meas tran vdout0_137ck50 FIND v(dout0_137) AT=30.025n

.meas tran vdout0_138ck50 FIND v(dout0_138) AT=30.025n

.meas tran vdout0_139ck50 FIND v(dout0_139) AT=30.025n

.meas tran vdout0_140ck50 FIND v(dout0_140) AT=30.025n

.meas tran vdout0_141ck50 FIND v(dout0_141) AT=30.025n

.meas tran vdout0_142ck50 FIND v(dout0_142) AT=30.025n

.meas tran vdout0_143ck50 FIND v(dout0_143) AT=30.025n

.meas tran vdout0_144ck50 FIND v(dout0_144) AT=30.025n

.meas tran vdout0_145ck50 FIND v(dout0_145) AT=30.025n

.meas tran vdout0_146ck50 FIND v(dout0_146) AT=30.025n

.meas tran vdout0_147ck50 FIND v(dout0_147) AT=30.025n

.meas tran vdout0_148ck50 FIND v(dout0_148) AT=30.025n

.meas tran vdout0_149ck50 FIND v(dout0_149) AT=30.025n

.meas tran vdout0_150ck50 FIND v(dout0_150) AT=30.025n

.meas tran vdout0_151ck50 FIND v(dout0_151) AT=30.025n

.meas tran vdout0_152ck50 FIND v(dout0_152) AT=30.025n

.meas tran vdout0_153ck50 FIND v(dout0_153) AT=30.025n

.meas tran vdout0_154ck50 FIND v(dout0_154) AT=30.025n

.meas tran vdout0_155ck50 FIND v(dout0_155) AT=30.025n

.meas tran vdout0_156ck50 FIND v(dout0_156) AT=30.025n

.meas tran vdout0_157ck50 FIND v(dout0_157) AT=30.025n

.meas tran vdout0_158ck50 FIND v(dout0_158) AT=30.025n

.meas tran vdout0_159ck50 FIND v(dout0_159) AT=30.025n

.meas tran vdout0_160ck50 FIND v(dout0_160) AT=30.025n

.meas tran vdout0_161ck50 FIND v(dout0_161) AT=30.025n

.meas tran vdout0_162ck50 FIND v(dout0_162) AT=30.025n

.meas tran vdout0_163ck50 FIND v(dout0_163) AT=30.025n

.meas tran vdout0_164ck50 FIND v(dout0_164) AT=30.025n

.meas tran vdout0_165ck50 FIND v(dout0_165) AT=30.025n

.meas tran vdout0_166ck50 FIND v(dout0_166) AT=30.025n

.meas tran vdout0_167ck50 FIND v(dout0_167) AT=30.025n

.meas tran vdout0_168ck50 FIND v(dout0_168) AT=30.025n

.meas tran vdout0_169ck50 FIND v(dout0_169) AT=30.025n

.meas tran vdout0_170ck50 FIND v(dout0_170) AT=30.025n

.meas tran vdout0_171ck50 FIND v(dout0_171) AT=30.025n

.meas tran vdout0_172ck50 FIND v(dout0_172) AT=30.025n

.meas tran vdout0_173ck50 FIND v(dout0_173) AT=30.025n

.meas tran vdout0_174ck50 FIND v(dout0_174) AT=30.025n

.meas tran vdout0_175ck50 FIND v(dout0_175) AT=30.025n

.meas tran vdout0_176ck50 FIND v(dout0_176) AT=30.025n

.meas tran vdout0_177ck50 FIND v(dout0_177) AT=30.025n

.meas tran vdout0_178ck50 FIND v(dout0_178) AT=30.025n

.meas tran vdout0_179ck50 FIND v(dout0_179) AT=30.025n

.meas tran vdout0_180ck50 FIND v(dout0_180) AT=30.025n

.meas tran vdout0_181ck50 FIND v(dout0_181) AT=30.025n

.meas tran vdout0_182ck50 FIND v(dout0_182) AT=30.025n

.meas tran vdout0_183ck50 FIND v(dout0_183) AT=30.025n

.meas tran vdout0_184ck50 FIND v(dout0_184) AT=30.025n

.meas tran vdout0_185ck50 FIND v(dout0_185) AT=30.025n

.meas tran vdout0_186ck50 FIND v(dout0_186) AT=30.025n

.meas tran vdout0_187ck50 FIND v(dout0_187) AT=30.025n

.meas tran vdout0_188ck50 FIND v(dout0_188) AT=30.025n

.meas tran vdout0_189ck50 FIND v(dout0_189) AT=30.025n

.meas tran vdout0_190ck50 FIND v(dout0_190) AT=30.025n

.meas tran vdout0_191ck50 FIND v(dout0_191) AT=30.025n

.meas tran vdout0_192ck50 FIND v(dout0_192) AT=30.025n

.meas tran vdout0_193ck50 FIND v(dout0_193) AT=30.025n

.meas tran vdout0_194ck50 FIND v(dout0_194) AT=30.025n

.meas tran vdout0_195ck50 FIND v(dout0_195) AT=30.025n

.meas tran vdout0_196ck50 FIND v(dout0_196) AT=30.025n

.meas tran vdout0_197ck50 FIND v(dout0_197) AT=30.025n

.meas tran vdout0_198ck50 FIND v(dout0_198) AT=30.025n

.meas tran vdout0_199ck50 FIND v(dout0_199) AT=30.025n

.meas tran vdout0_200ck50 FIND v(dout0_200) AT=30.025n

.meas tran vdout0_201ck50 FIND v(dout0_201) AT=30.025n

.meas tran vdout0_202ck50 FIND v(dout0_202) AT=30.025n

.meas tran vdout0_203ck50 FIND v(dout0_203) AT=30.025n

.meas tran vdout0_204ck50 FIND v(dout0_204) AT=30.025n

.meas tran vdout0_205ck50 FIND v(dout0_205) AT=30.025n

.meas tran vdout0_206ck50 FIND v(dout0_206) AT=30.025n

.meas tran vdout0_207ck50 FIND v(dout0_207) AT=30.025n

.meas tran vdout0_208ck50 FIND v(dout0_208) AT=30.025n

.meas tran vdout0_209ck50 FIND v(dout0_209) AT=30.025n

.meas tran vdout0_210ck50 FIND v(dout0_210) AT=30.025n

.meas tran vdout0_211ck50 FIND v(dout0_211) AT=30.025n

.meas tran vdout0_212ck50 FIND v(dout0_212) AT=30.025n

.meas tran vdout0_213ck50 FIND v(dout0_213) AT=30.025n

.meas tran vdout0_214ck50 FIND v(dout0_214) AT=30.025n

.meas tran vdout0_215ck50 FIND v(dout0_215) AT=30.025n

.meas tran vdout0_216ck50 FIND v(dout0_216) AT=30.025n

.meas tran vdout0_217ck50 FIND v(dout0_217) AT=30.025n

.meas tran vdout0_218ck50 FIND v(dout0_218) AT=30.025n

.meas tran vdout0_219ck50 FIND v(dout0_219) AT=30.025n

.meas tran vdout0_220ck50 FIND v(dout0_220) AT=30.025n

.meas tran vdout0_221ck50 FIND v(dout0_221) AT=30.025n

.meas tran vdout0_222ck50 FIND v(dout0_222) AT=30.025n

.meas tran vdout0_223ck50 FIND v(dout0_223) AT=30.025n

.meas tran vdout0_224ck50 FIND v(dout0_224) AT=30.025n

.meas tran vdout0_225ck50 FIND v(dout0_225) AT=30.025n

.meas tran vdout0_226ck50 FIND v(dout0_226) AT=30.025n

.meas tran vdout0_227ck50 FIND v(dout0_227) AT=30.025n

.meas tran vdout0_228ck50 FIND v(dout0_228) AT=30.025n

.meas tran vdout0_229ck50 FIND v(dout0_229) AT=30.025n

.meas tran vdout0_230ck50 FIND v(dout0_230) AT=30.025n

.meas tran vdout0_231ck50 FIND v(dout0_231) AT=30.025n

.meas tran vdout0_232ck50 FIND v(dout0_232) AT=30.025n

.meas tran vdout0_233ck50 FIND v(dout0_233) AT=30.025n

.meas tran vdout0_234ck50 FIND v(dout0_234) AT=30.025n

.meas tran vdout0_235ck50 FIND v(dout0_235) AT=30.025n

.meas tran vdout0_236ck50 FIND v(dout0_236) AT=30.025n

.meas tran vdout0_237ck50 FIND v(dout0_237) AT=30.025n

.meas tran vdout0_238ck50 FIND v(dout0_238) AT=30.025n

.meas tran vdout0_239ck50 FIND v(dout0_239) AT=30.025n

.meas tran vdout0_240ck50 FIND v(dout0_240) AT=30.025n

.meas tran vdout0_241ck50 FIND v(dout0_241) AT=30.025n

.meas tran vdout0_242ck50 FIND v(dout0_242) AT=30.025n

.meas tran vdout0_243ck50 FIND v(dout0_243) AT=30.025n

.meas tran vdout0_244ck50 FIND v(dout0_244) AT=30.025n

.meas tran vdout0_245ck50 FIND v(dout0_245) AT=30.025n

.meas tran vdout0_246ck50 FIND v(dout0_246) AT=30.025n

.meas tran vdout0_247ck50 FIND v(dout0_247) AT=30.025n

.meas tran vdout0_248ck50 FIND v(dout0_248) AT=30.025n

.meas tran vdout0_249ck50 FIND v(dout0_249) AT=30.025n

.meas tran vdout0_250ck50 FIND v(dout0_250) AT=30.025n

.meas tran vdout0_251ck50 FIND v(dout0_251) AT=30.025n

.meas tran vdout0_252ck50 FIND v(dout0_252) AT=30.025n

.meas tran vdout0_253ck50 FIND v(dout0_253) AT=30.025n

.meas tran vdout0_254ck50 FIND v(dout0_254) AT=30.025n

.meas tran vdout0_255ck50 FIND v(dout0_255) AT=30.025n

.meas tran vdout0_0ck60 FIND v(dout0_0) AT=35.025n

.meas tran vdout0_1ck60 FIND v(dout0_1) AT=35.025n

.meas tran vdout0_2ck60 FIND v(dout0_2) AT=35.025n

.meas tran vdout0_3ck60 FIND v(dout0_3) AT=35.025n

.meas tran vdout0_4ck60 FIND v(dout0_4) AT=35.025n

.meas tran vdout0_5ck60 FIND v(dout0_5) AT=35.025n

.meas tran vdout0_6ck60 FIND v(dout0_6) AT=35.025n

.meas tran vdout0_7ck60 FIND v(dout0_7) AT=35.025n

.meas tran vdout0_8ck60 FIND v(dout0_8) AT=35.025n

.meas tran vdout0_9ck60 FIND v(dout0_9) AT=35.025n

.meas tran vdout0_10ck60 FIND v(dout0_10) AT=35.025n

.meas tran vdout0_11ck60 FIND v(dout0_11) AT=35.025n

.meas tran vdout0_12ck60 FIND v(dout0_12) AT=35.025n

.meas tran vdout0_13ck60 FIND v(dout0_13) AT=35.025n

.meas tran vdout0_14ck60 FIND v(dout0_14) AT=35.025n

.meas tran vdout0_15ck60 FIND v(dout0_15) AT=35.025n

.meas tran vdout0_16ck60 FIND v(dout0_16) AT=35.025n

.meas tran vdout0_17ck60 FIND v(dout0_17) AT=35.025n

.meas tran vdout0_18ck60 FIND v(dout0_18) AT=35.025n

.meas tran vdout0_19ck60 FIND v(dout0_19) AT=35.025n

.meas tran vdout0_20ck60 FIND v(dout0_20) AT=35.025n

.meas tran vdout0_21ck60 FIND v(dout0_21) AT=35.025n

.meas tran vdout0_22ck60 FIND v(dout0_22) AT=35.025n

.meas tran vdout0_23ck60 FIND v(dout0_23) AT=35.025n

.meas tran vdout0_24ck60 FIND v(dout0_24) AT=35.025n

.meas tran vdout0_25ck60 FIND v(dout0_25) AT=35.025n

.meas tran vdout0_26ck60 FIND v(dout0_26) AT=35.025n

.meas tran vdout0_27ck60 FIND v(dout0_27) AT=35.025n

.meas tran vdout0_28ck60 FIND v(dout0_28) AT=35.025n

.meas tran vdout0_29ck60 FIND v(dout0_29) AT=35.025n

.meas tran vdout0_30ck60 FIND v(dout0_30) AT=35.025n

.meas tran vdout0_31ck60 FIND v(dout0_31) AT=35.025n

.meas tran vdout0_32ck60 FIND v(dout0_32) AT=35.025n

.meas tran vdout0_33ck60 FIND v(dout0_33) AT=35.025n

.meas tran vdout0_34ck60 FIND v(dout0_34) AT=35.025n

.meas tran vdout0_35ck60 FIND v(dout0_35) AT=35.025n

.meas tran vdout0_36ck60 FIND v(dout0_36) AT=35.025n

.meas tran vdout0_37ck60 FIND v(dout0_37) AT=35.025n

.meas tran vdout0_38ck60 FIND v(dout0_38) AT=35.025n

.meas tran vdout0_39ck60 FIND v(dout0_39) AT=35.025n

.meas tran vdout0_40ck60 FIND v(dout0_40) AT=35.025n

.meas tran vdout0_41ck60 FIND v(dout0_41) AT=35.025n

.meas tran vdout0_42ck60 FIND v(dout0_42) AT=35.025n

.meas tran vdout0_43ck60 FIND v(dout0_43) AT=35.025n

.meas tran vdout0_44ck60 FIND v(dout0_44) AT=35.025n

.meas tran vdout0_45ck60 FIND v(dout0_45) AT=35.025n

.meas tran vdout0_46ck60 FIND v(dout0_46) AT=35.025n

.meas tran vdout0_47ck60 FIND v(dout0_47) AT=35.025n

.meas tran vdout0_48ck60 FIND v(dout0_48) AT=35.025n

.meas tran vdout0_49ck60 FIND v(dout0_49) AT=35.025n

.meas tran vdout0_50ck60 FIND v(dout0_50) AT=35.025n

.meas tran vdout0_51ck60 FIND v(dout0_51) AT=35.025n

.meas tran vdout0_52ck60 FIND v(dout0_52) AT=35.025n

.meas tran vdout0_53ck60 FIND v(dout0_53) AT=35.025n

.meas tran vdout0_54ck60 FIND v(dout0_54) AT=35.025n

.meas tran vdout0_55ck60 FIND v(dout0_55) AT=35.025n

.meas tran vdout0_56ck60 FIND v(dout0_56) AT=35.025n

.meas tran vdout0_57ck60 FIND v(dout0_57) AT=35.025n

.meas tran vdout0_58ck60 FIND v(dout0_58) AT=35.025n

.meas tran vdout0_59ck60 FIND v(dout0_59) AT=35.025n

.meas tran vdout0_60ck60 FIND v(dout0_60) AT=35.025n

.meas tran vdout0_61ck60 FIND v(dout0_61) AT=35.025n

.meas tran vdout0_62ck60 FIND v(dout0_62) AT=35.025n

.meas tran vdout0_63ck60 FIND v(dout0_63) AT=35.025n

.meas tran vdout0_64ck60 FIND v(dout0_64) AT=35.025n

.meas tran vdout0_65ck60 FIND v(dout0_65) AT=35.025n

.meas tran vdout0_66ck60 FIND v(dout0_66) AT=35.025n

.meas tran vdout0_67ck60 FIND v(dout0_67) AT=35.025n

.meas tran vdout0_68ck60 FIND v(dout0_68) AT=35.025n

.meas tran vdout0_69ck60 FIND v(dout0_69) AT=35.025n

.meas tran vdout0_70ck60 FIND v(dout0_70) AT=35.025n

.meas tran vdout0_71ck60 FIND v(dout0_71) AT=35.025n

.meas tran vdout0_72ck60 FIND v(dout0_72) AT=35.025n

.meas tran vdout0_73ck60 FIND v(dout0_73) AT=35.025n

.meas tran vdout0_74ck60 FIND v(dout0_74) AT=35.025n

.meas tran vdout0_75ck60 FIND v(dout0_75) AT=35.025n

.meas tran vdout0_76ck60 FIND v(dout0_76) AT=35.025n

.meas tran vdout0_77ck60 FIND v(dout0_77) AT=35.025n

.meas tran vdout0_78ck60 FIND v(dout0_78) AT=35.025n

.meas tran vdout0_79ck60 FIND v(dout0_79) AT=35.025n

.meas tran vdout0_80ck60 FIND v(dout0_80) AT=35.025n

.meas tran vdout0_81ck60 FIND v(dout0_81) AT=35.025n

.meas tran vdout0_82ck60 FIND v(dout0_82) AT=35.025n

.meas tran vdout0_83ck60 FIND v(dout0_83) AT=35.025n

.meas tran vdout0_84ck60 FIND v(dout0_84) AT=35.025n

.meas tran vdout0_85ck60 FIND v(dout0_85) AT=35.025n

.meas tran vdout0_86ck60 FIND v(dout0_86) AT=35.025n

.meas tran vdout0_87ck60 FIND v(dout0_87) AT=35.025n

.meas tran vdout0_88ck60 FIND v(dout0_88) AT=35.025n

.meas tran vdout0_89ck60 FIND v(dout0_89) AT=35.025n

.meas tran vdout0_90ck60 FIND v(dout0_90) AT=35.025n

.meas tran vdout0_91ck60 FIND v(dout0_91) AT=35.025n

.meas tran vdout0_92ck60 FIND v(dout0_92) AT=35.025n

.meas tran vdout0_93ck60 FIND v(dout0_93) AT=35.025n

.meas tran vdout0_94ck60 FIND v(dout0_94) AT=35.025n

.meas tran vdout0_95ck60 FIND v(dout0_95) AT=35.025n

.meas tran vdout0_96ck60 FIND v(dout0_96) AT=35.025n

.meas tran vdout0_97ck60 FIND v(dout0_97) AT=35.025n

.meas tran vdout0_98ck60 FIND v(dout0_98) AT=35.025n

.meas tran vdout0_99ck60 FIND v(dout0_99) AT=35.025n

.meas tran vdout0_100ck60 FIND v(dout0_100) AT=35.025n

.meas tran vdout0_101ck60 FIND v(dout0_101) AT=35.025n

.meas tran vdout0_102ck60 FIND v(dout0_102) AT=35.025n

.meas tran vdout0_103ck60 FIND v(dout0_103) AT=35.025n

.meas tran vdout0_104ck60 FIND v(dout0_104) AT=35.025n

.meas tran vdout0_105ck60 FIND v(dout0_105) AT=35.025n

.meas tran vdout0_106ck60 FIND v(dout0_106) AT=35.025n

.meas tran vdout0_107ck60 FIND v(dout0_107) AT=35.025n

.meas tran vdout0_108ck60 FIND v(dout0_108) AT=35.025n

.meas tran vdout0_109ck60 FIND v(dout0_109) AT=35.025n

.meas tran vdout0_110ck60 FIND v(dout0_110) AT=35.025n

.meas tran vdout0_111ck60 FIND v(dout0_111) AT=35.025n

.meas tran vdout0_112ck60 FIND v(dout0_112) AT=35.025n

.meas tran vdout0_113ck60 FIND v(dout0_113) AT=35.025n

.meas tran vdout0_114ck60 FIND v(dout0_114) AT=35.025n

.meas tran vdout0_115ck60 FIND v(dout0_115) AT=35.025n

.meas tran vdout0_116ck60 FIND v(dout0_116) AT=35.025n

.meas tran vdout0_117ck60 FIND v(dout0_117) AT=35.025n

.meas tran vdout0_118ck60 FIND v(dout0_118) AT=35.025n

.meas tran vdout0_119ck60 FIND v(dout0_119) AT=35.025n

.meas tran vdout0_120ck60 FIND v(dout0_120) AT=35.025n

.meas tran vdout0_121ck60 FIND v(dout0_121) AT=35.025n

.meas tran vdout0_122ck60 FIND v(dout0_122) AT=35.025n

.meas tran vdout0_123ck60 FIND v(dout0_123) AT=35.025n

.meas tran vdout0_124ck60 FIND v(dout0_124) AT=35.025n

.meas tran vdout0_125ck60 FIND v(dout0_125) AT=35.025n

.meas tran vdout0_126ck60 FIND v(dout0_126) AT=35.025n

.meas tran vdout0_127ck60 FIND v(dout0_127) AT=35.025n

.meas tran vdout0_128ck60 FIND v(dout0_128) AT=35.025n

.meas tran vdout0_129ck60 FIND v(dout0_129) AT=35.025n

.meas tran vdout0_130ck60 FIND v(dout0_130) AT=35.025n

.meas tran vdout0_131ck60 FIND v(dout0_131) AT=35.025n

.meas tran vdout0_132ck60 FIND v(dout0_132) AT=35.025n

.meas tran vdout0_133ck60 FIND v(dout0_133) AT=35.025n

.meas tran vdout0_134ck60 FIND v(dout0_134) AT=35.025n

.meas tran vdout0_135ck60 FIND v(dout0_135) AT=35.025n

.meas tran vdout0_136ck60 FIND v(dout0_136) AT=35.025n

.meas tran vdout0_137ck60 FIND v(dout0_137) AT=35.025n

.meas tran vdout0_138ck60 FIND v(dout0_138) AT=35.025n

.meas tran vdout0_139ck60 FIND v(dout0_139) AT=35.025n

.meas tran vdout0_140ck60 FIND v(dout0_140) AT=35.025n

.meas tran vdout0_141ck60 FIND v(dout0_141) AT=35.025n

.meas tran vdout0_142ck60 FIND v(dout0_142) AT=35.025n

.meas tran vdout0_143ck60 FIND v(dout0_143) AT=35.025n

.meas tran vdout0_144ck60 FIND v(dout0_144) AT=35.025n

.meas tran vdout0_145ck60 FIND v(dout0_145) AT=35.025n

.meas tran vdout0_146ck60 FIND v(dout0_146) AT=35.025n

.meas tran vdout0_147ck60 FIND v(dout0_147) AT=35.025n

.meas tran vdout0_148ck60 FIND v(dout0_148) AT=35.025n

.meas tran vdout0_149ck60 FIND v(dout0_149) AT=35.025n

.meas tran vdout0_150ck60 FIND v(dout0_150) AT=35.025n

.meas tran vdout0_151ck60 FIND v(dout0_151) AT=35.025n

.meas tran vdout0_152ck60 FIND v(dout0_152) AT=35.025n

.meas tran vdout0_153ck60 FIND v(dout0_153) AT=35.025n

.meas tran vdout0_154ck60 FIND v(dout0_154) AT=35.025n

.meas tran vdout0_155ck60 FIND v(dout0_155) AT=35.025n

.meas tran vdout0_156ck60 FIND v(dout0_156) AT=35.025n

.meas tran vdout0_157ck60 FIND v(dout0_157) AT=35.025n

.meas tran vdout0_158ck60 FIND v(dout0_158) AT=35.025n

.meas tran vdout0_159ck60 FIND v(dout0_159) AT=35.025n

.meas tran vdout0_160ck60 FIND v(dout0_160) AT=35.025n

.meas tran vdout0_161ck60 FIND v(dout0_161) AT=35.025n

.meas tran vdout0_162ck60 FIND v(dout0_162) AT=35.025n

.meas tran vdout0_163ck60 FIND v(dout0_163) AT=35.025n

.meas tran vdout0_164ck60 FIND v(dout0_164) AT=35.025n

.meas tran vdout0_165ck60 FIND v(dout0_165) AT=35.025n

.meas tran vdout0_166ck60 FIND v(dout0_166) AT=35.025n

.meas tran vdout0_167ck60 FIND v(dout0_167) AT=35.025n

.meas tran vdout0_168ck60 FIND v(dout0_168) AT=35.025n

.meas tran vdout0_169ck60 FIND v(dout0_169) AT=35.025n

.meas tran vdout0_170ck60 FIND v(dout0_170) AT=35.025n

.meas tran vdout0_171ck60 FIND v(dout0_171) AT=35.025n

.meas tran vdout0_172ck60 FIND v(dout0_172) AT=35.025n

.meas tran vdout0_173ck60 FIND v(dout0_173) AT=35.025n

.meas tran vdout0_174ck60 FIND v(dout0_174) AT=35.025n

.meas tran vdout0_175ck60 FIND v(dout0_175) AT=35.025n

.meas tran vdout0_176ck60 FIND v(dout0_176) AT=35.025n

.meas tran vdout0_177ck60 FIND v(dout0_177) AT=35.025n

.meas tran vdout0_178ck60 FIND v(dout0_178) AT=35.025n

.meas tran vdout0_179ck60 FIND v(dout0_179) AT=35.025n

.meas tran vdout0_180ck60 FIND v(dout0_180) AT=35.025n

.meas tran vdout0_181ck60 FIND v(dout0_181) AT=35.025n

.meas tran vdout0_182ck60 FIND v(dout0_182) AT=35.025n

.meas tran vdout0_183ck60 FIND v(dout0_183) AT=35.025n

.meas tran vdout0_184ck60 FIND v(dout0_184) AT=35.025n

.meas tran vdout0_185ck60 FIND v(dout0_185) AT=35.025n

.meas tran vdout0_186ck60 FIND v(dout0_186) AT=35.025n

.meas tran vdout0_187ck60 FIND v(dout0_187) AT=35.025n

.meas tran vdout0_188ck60 FIND v(dout0_188) AT=35.025n

.meas tran vdout0_189ck60 FIND v(dout0_189) AT=35.025n

.meas tran vdout0_190ck60 FIND v(dout0_190) AT=35.025n

.meas tran vdout0_191ck60 FIND v(dout0_191) AT=35.025n

.meas tran vdout0_192ck60 FIND v(dout0_192) AT=35.025n

.meas tran vdout0_193ck60 FIND v(dout0_193) AT=35.025n

.meas tran vdout0_194ck60 FIND v(dout0_194) AT=35.025n

.meas tran vdout0_195ck60 FIND v(dout0_195) AT=35.025n

.meas tran vdout0_196ck60 FIND v(dout0_196) AT=35.025n

.meas tran vdout0_197ck60 FIND v(dout0_197) AT=35.025n

.meas tran vdout0_198ck60 FIND v(dout0_198) AT=35.025n

.meas tran vdout0_199ck60 FIND v(dout0_199) AT=35.025n

.meas tran vdout0_200ck60 FIND v(dout0_200) AT=35.025n

.meas tran vdout0_201ck60 FIND v(dout0_201) AT=35.025n

.meas tran vdout0_202ck60 FIND v(dout0_202) AT=35.025n

.meas tran vdout0_203ck60 FIND v(dout0_203) AT=35.025n

.meas tran vdout0_204ck60 FIND v(dout0_204) AT=35.025n

.meas tran vdout0_205ck60 FIND v(dout0_205) AT=35.025n

.meas tran vdout0_206ck60 FIND v(dout0_206) AT=35.025n

.meas tran vdout0_207ck60 FIND v(dout0_207) AT=35.025n

.meas tran vdout0_208ck60 FIND v(dout0_208) AT=35.025n

.meas tran vdout0_209ck60 FIND v(dout0_209) AT=35.025n

.meas tran vdout0_210ck60 FIND v(dout0_210) AT=35.025n

.meas tran vdout0_211ck60 FIND v(dout0_211) AT=35.025n

.meas tran vdout0_212ck60 FIND v(dout0_212) AT=35.025n

.meas tran vdout0_213ck60 FIND v(dout0_213) AT=35.025n

.meas tran vdout0_214ck60 FIND v(dout0_214) AT=35.025n

.meas tran vdout0_215ck60 FIND v(dout0_215) AT=35.025n

.meas tran vdout0_216ck60 FIND v(dout0_216) AT=35.025n

.meas tran vdout0_217ck60 FIND v(dout0_217) AT=35.025n

.meas tran vdout0_218ck60 FIND v(dout0_218) AT=35.025n

.meas tran vdout0_219ck60 FIND v(dout0_219) AT=35.025n

.meas tran vdout0_220ck60 FIND v(dout0_220) AT=35.025n

.meas tran vdout0_221ck60 FIND v(dout0_221) AT=35.025n

.meas tran vdout0_222ck60 FIND v(dout0_222) AT=35.025n

.meas tran vdout0_223ck60 FIND v(dout0_223) AT=35.025n

.meas tran vdout0_224ck60 FIND v(dout0_224) AT=35.025n

.meas tran vdout0_225ck60 FIND v(dout0_225) AT=35.025n

.meas tran vdout0_226ck60 FIND v(dout0_226) AT=35.025n

.meas tran vdout0_227ck60 FIND v(dout0_227) AT=35.025n

.meas tran vdout0_228ck60 FIND v(dout0_228) AT=35.025n

.meas tran vdout0_229ck60 FIND v(dout0_229) AT=35.025n

.meas tran vdout0_230ck60 FIND v(dout0_230) AT=35.025n

.meas tran vdout0_231ck60 FIND v(dout0_231) AT=35.025n

.meas tran vdout0_232ck60 FIND v(dout0_232) AT=35.025n

.meas tran vdout0_233ck60 FIND v(dout0_233) AT=35.025n

.meas tran vdout0_234ck60 FIND v(dout0_234) AT=35.025n

.meas tran vdout0_235ck60 FIND v(dout0_235) AT=35.025n

.meas tran vdout0_236ck60 FIND v(dout0_236) AT=35.025n

.meas tran vdout0_237ck60 FIND v(dout0_237) AT=35.025n

.meas tran vdout0_238ck60 FIND v(dout0_238) AT=35.025n

.meas tran vdout0_239ck60 FIND v(dout0_239) AT=35.025n

.meas tran vdout0_240ck60 FIND v(dout0_240) AT=35.025n

.meas tran vdout0_241ck60 FIND v(dout0_241) AT=35.025n

.meas tran vdout0_242ck60 FIND v(dout0_242) AT=35.025n

.meas tran vdout0_243ck60 FIND v(dout0_243) AT=35.025n

.meas tran vdout0_244ck60 FIND v(dout0_244) AT=35.025n

.meas tran vdout0_245ck60 FIND v(dout0_245) AT=35.025n

.meas tran vdout0_246ck60 FIND v(dout0_246) AT=35.025n

.meas tran vdout0_247ck60 FIND v(dout0_247) AT=35.025n

.meas tran vdout0_248ck60 FIND v(dout0_248) AT=35.025n

.meas tran vdout0_249ck60 FIND v(dout0_249) AT=35.025n

.meas tran vdout0_250ck60 FIND v(dout0_250) AT=35.025n

.meas tran vdout0_251ck60 FIND v(dout0_251) AT=35.025n

.meas tran vdout0_252ck60 FIND v(dout0_252) AT=35.025n

.meas tran vdout0_253ck60 FIND v(dout0_253) AT=35.025n

.meas tran vdout0_254ck60 FIND v(dout0_254) AT=35.025n

.meas tran vdout0_255ck60 FIND v(dout0_255) AT=35.025n

.meas tran vdout0_0ck80 FIND v(dout0_0) AT=45.025n

.meas tran vdout0_1ck80 FIND v(dout0_1) AT=45.025n

.meas tran vdout0_2ck80 FIND v(dout0_2) AT=45.025n

.meas tran vdout0_3ck80 FIND v(dout0_3) AT=45.025n

.meas tran vdout0_4ck80 FIND v(dout0_4) AT=45.025n

.meas tran vdout0_5ck80 FIND v(dout0_5) AT=45.025n

.meas tran vdout0_6ck80 FIND v(dout0_6) AT=45.025n

.meas tran vdout0_7ck80 FIND v(dout0_7) AT=45.025n

.meas tran vdout0_8ck80 FIND v(dout0_8) AT=45.025n

.meas tran vdout0_9ck80 FIND v(dout0_9) AT=45.025n

.meas tran vdout0_10ck80 FIND v(dout0_10) AT=45.025n

.meas tran vdout0_11ck80 FIND v(dout0_11) AT=45.025n

.meas tran vdout0_12ck80 FIND v(dout0_12) AT=45.025n

.meas tran vdout0_13ck80 FIND v(dout0_13) AT=45.025n

.meas tran vdout0_14ck80 FIND v(dout0_14) AT=45.025n

.meas tran vdout0_15ck80 FIND v(dout0_15) AT=45.025n

.meas tran vdout0_16ck80 FIND v(dout0_16) AT=45.025n

.meas tran vdout0_17ck80 FIND v(dout0_17) AT=45.025n

.meas tran vdout0_18ck80 FIND v(dout0_18) AT=45.025n

.meas tran vdout0_19ck80 FIND v(dout0_19) AT=45.025n

.meas tran vdout0_20ck80 FIND v(dout0_20) AT=45.025n

.meas tran vdout0_21ck80 FIND v(dout0_21) AT=45.025n

.meas tran vdout0_22ck80 FIND v(dout0_22) AT=45.025n

.meas tran vdout0_23ck80 FIND v(dout0_23) AT=45.025n

.meas tran vdout0_24ck80 FIND v(dout0_24) AT=45.025n

.meas tran vdout0_25ck80 FIND v(dout0_25) AT=45.025n

.meas tran vdout0_26ck80 FIND v(dout0_26) AT=45.025n

.meas tran vdout0_27ck80 FIND v(dout0_27) AT=45.025n

.meas tran vdout0_28ck80 FIND v(dout0_28) AT=45.025n

.meas tran vdout0_29ck80 FIND v(dout0_29) AT=45.025n

.meas tran vdout0_30ck80 FIND v(dout0_30) AT=45.025n

.meas tran vdout0_31ck80 FIND v(dout0_31) AT=45.025n

.meas tran vdout0_32ck80 FIND v(dout0_32) AT=45.025n

.meas tran vdout0_33ck80 FIND v(dout0_33) AT=45.025n

.meas tran vdout0_34ck80 FIND v(dout0_34) AT=45.025n

.meas tran vdout0_35ck80 FIND v(dout0_35) AT=45.025n

.meas tran vdout0_36ck80 FIND v(dout0_36) AT=45.025n

.meas tran vdout0_37ck80 FIND v(dout0_37) AT=45.025n

.meas tran vdout0_38ck80 FIND v(dout0_38) AT=45.025n

.meas tran vdout0_39ck80 FIND v(dout0_39) AT=45.025n

.meas tran vdout0_40ck80 FIND v(dout0_40) AT=45.025n

.meas tran vdout0_41ck80 FIND v(dout0_41) AT=45.025n

.meas tran vdout0_42ck80 FIND v(dout0_42) AT=45.025n

.meas tran vdout0_43ck80 FIND v(dout0_43) AT=45.025n

.meas tran vdout0_44ck80 FIND v(dout0_44) AT=45.025n

.meas tran vdout0_45ck80 FIND v(dout0_45) AT=45.025n

.meas tran vdout0_46ck80 FIND v(dout0_46) AT=45.025n

.meas tran vdout0_47ck80 FIND v(dout0_47) AT=45.025n

.meas tran vdout0_48ck80 FIND v(dout0_48) AT=45.025n

.meas tran vdout0_49ck80 FIND v(dout0_49) AT=45.025n

.meas tran vdout0_50ck80 FIND v(dout0_50) AT=45.025n

.meas tran vdout0_51ck80 FIND v(dout0_51) AT=45.025n

.meas tran vdout0_52ck80 FIND v(dout0_52) AT=45.025n

.meas tran vdout0_53ck80 FIND v(dout0_53) AT=45.025n

.meas tran vdout0_54ck80 FIND v(dout0_54) AT=45.025n

.meas tran vdout0_55ck80 FIND v(dout0_55) AT=45.025n

.meas tran vdout0_56ck80 FIND v(dout0_56) AT=45.025n

.meas tran vdout0_57ck80 FIND v(dout0_57) AT=45.025n

.meas tran vdout0_58ck80 FIND v(dout0_58) AT=45.025n

.meas tran vdout0_59ck80 FIND v(dout0_59) AT=45.025n

.meas tran vdout0_60ck80 FIND v(dout0_60) AT=45.025n

.meas tran vdout0_61ck80 FIND v(dout0_61) AT=45.025n

.meas tran vdout0_62ck80 FIND v(dout0_62) AT=45.025n

.meas tran vdout0_63ck80 FIND v(dout0_63) AT=45.025n

.meas tran vdout0_64ck80 FIND v(dout0_64) AT=45.025n

.meas tran vdout0_65ck80 FIND v(dout0_65) AT=45.025n

.meas tran vdout0_66ck80 FIND v(dout0_66) AT=45.025n

.meas tran vdout0_67ck80 FIND v(dout0_67) AT=45.025n

.meas tran vdout0_68ck80 FIND v(dout0_68) AT=45.025n

.meas tran vdout0_69ck80 FIND v(dout0_69) AT=45.025n

.meas tran vdout0_70ck80 FIND v(dout0_70) AT=45.025n

.meas tran vdout0_71ck80 FIND v(dout0_71) AT=45.025n

.meas tran vdout0_72ck80 FIND v(dout0_72) AT=45.025n

.meas tran vdout0_73ck80 FIND v(dout0_73) AT=45.025n

.meas tran vdout0_74ck80 FIND v(dout0_74) AT=45.025n

.meas tran vdout0_75ck80 FIND v(dout0_75) AT=45.025n

.meas tran vdout0_76ck80 FIND v(dout0_76) AT=45.025n

.meas tran vdout0_77ck80 FIND v(dout0_77) AT=45.025n

.meas tran vdout0_78ck80 FIND v(dout0_78) AT=45.025n

.meas tran vdout0_79ck80 FIND v(dout0_79) AT=45.025n

.meas tran vdout0_80ck80 FIND v(dout0_80) AT=45.025n

.meas tran vdout0_81ck80 FIND v(dout0_81) AT=45.025n

.meas tran vdout0_82ck80 FIND v(dout0_82) AT=45.025n

.meas tran vdout0_83ck80 FIND v(dout0_83) AT=45.025n

.meas tran vdout0_84ck80 FIND v(dout0_84) AT=45.025n

.meas tran vdout0_85ck80 FIND v(dout0_85) AT=45.025n

.meas tran vdout0_86ck80 FIND v(dout0_86) AT=45.025n

.meas tran vdout0_87ck80 FIND v(dout0_87) AT=45.025n

.meas tran vdout0_88ck80 FIND v(dout0_88) AT=45.025n

.meas tran vdout0_89ck80 FIND v(dout0_89) AT=45.025n

.meas tran vdout0_90ck80 FIND v(dout0_90) AT=45.025n

.meas tran vdout0_91ck80 FIND v(dout0_91) AT=45.025n

.meas tran vdout0_92ck80 FIND v(dout0_92) AT=45.025n

.meas tran vdout0_93ck80 FIND v(dout0_93) AT=45.025n

.meas tran vdout0_94ck80 FIND v(dout0_94) AT=45.025n

.meas tran vdout0_95ck80 FIND v(dout0_95) AT=45.025n

.meas tran vdout0_96ck80 FIND v(dout0_96) AT=45.025n

.meas tran vdout0_97ck80 FIND v(dout0_97) AT=45.025n

.meas tran vdout0_98ck80 FIND v(dout0_98) AT=45.025n

.meas tran vdout0_99ck80 FIND v(dout0_99) AT=45.025n

.meas tran vdout0_100ck80 FIND v(dout0_100) AT=45.025n

.meas tran vdout0_101ck80 FIND v(dout0_101) AT=45.025n

.meas tran vdout0_102ck80 FIND v(dout0_102) AT=45.025n

.meas tran vdout0_103ck80 FIND v(dout0_103) AT=45.025n

.meas tran vdout0_104ck80 FIND v(dout0_104) AT=45.025n

.meas tran vdout0_105ck80 FIND v(dout0_105) AT=45.025n

.meas tran vdout0_106ck80 FIND v(dout0_106) AT=45.025n

.meas tran vdout0_107ck80 FIND v(dout0_107) AT=45.025n

.meas tran vdout0_108ck80 FIND v(dout0_108) AT=45.025n

.meas tran vdout0_109ck80 FIND v(dout0_109) AT=45.025n

.meas tran vdout0_110ck80 FIND v(dout0_110) AT=45.025n

.meas tran vdout0_111ck80 FIND v(dout0_111) AT=45.025n

.meas tran vdout0_112ck80 FIND v(dout0_112) AT=45.025n

.meas tran vdout0_113ck80 FIND v(dout0_113) AT=45.025n

.meas tran vdout0_114ck80 FIND v(dout0_114) AT=45.025n

.meas tran vdout0_115ck80 FIND v(dout0_115) AT=45.025n

.meas tran vdout0_116ck80 FIND v(dout0_116) AT=45.025n

.meas tran vdout0_117ck80 FIND v(dout0_117) AT=45.025n

.meas tran vdout0_118ck80 FIND v(dout0_118) AT=45.025n

.meas tran vdout0_119ck80 FIND v(dout0_119) AT=45.025n

.meas tran vdout0_120ck80 FIND v(dout0_120) AT=45.025n

.meas tran vdout0_121ck80 FIND v(dout0_121) AT=45.025n

.meas tran vdout0_122ck80 FIND v(dout0_122) AT=45.025n

.meas tran vdout0_123ck80 FIND v(dout0_123) AT=45.025n

.meas tran vdout0_124ck80 FIND v(dout0_124) AT=45.025n

.meas tran vdout0_125ck80 FIND v(dout0_125) AT=45.025n

.meas tran vdout0_126ck80 FIND v(dout0_126) AT=45.025n

.meas tran vdout0_127ck80 FIND v(dout0_127) AT=45.025n

.meas tran vdout0_128ck80 FIND v(dout0_128) AT=45.025n

.meas tran vdout0_129ck80 FIND v(dout0_129) AT=45.025n

.meas tran vdout0_130ck80 FIND v(dout0_130) AT=45.025n

.meas tran vdout0_131ck80 FIND v(dout0_131) AT=45.025n

.meas tran vdout0_132ck80 FIND v(dout0_132) AT=45.025n

.meas tran vdout0_133ck80 FIND v(dout0_133) AT=45.025n

.meas tran vdout0_134ck80 FIND v(dout0_134) AT=45.025n

.meas tran vdout0_135ck80 FIND v(dout0_135) AT=45.025n

.meas tran vdout0_136ck80 FIND v(dout0_136) AT=45.025n

.meas tran vdout0_137ck80 FIND v(dout0_137) AT=45.025n

.meas tran vdout0_138ck80 FIND v(dout0_138) AT=45.025n

.meas tran vdout0_139ck80 FIND v(dout0_139) AT=45.025n

.meas tran vdout0_140ck80 FIND v(dout0_140) AT=45.025n

.meas tran vdout0_141ck80 FIND v(dout0_141) AT=45.025n

.meas tran vdout0_142ck80 FIND v(dout0_142) AT=45.025n

.meas tran vdout0_143ck80 FIND v(dout0_143) AT=45.025n

.meas tran vdout0_144ck80 FIND v(dout0_144) AT=45.025n

.meas tran vdout0_145ck80 FIND v(dout0_145) AT=45.025n

.meas tran vdout0_146ck80 FIND v(dout0_146) AT=45.025n

.meas tran vdout0_147ck80 FIND v(dout0_147) AT=45.025n

.meas tran vdout0_148ck80 FIND v(dout0_148) AT=45.025n

.meas tran vdout0_149ck80 FIND v(dout0_149) AT=45.025n

.meas tran vdout0_150ck80 FIND v(dout0_150) AT=45.025n

.meas tran vdout0_151ck80 FIND v(dout0_151) AT=45.025n

.meas tran vdout0_152ck80 FIND v(dout0_152) AT=45.025n

.meas tran vdout0_153ck80 FIND v(dout0_153) AT=45.025n

.meas tran vdout0_154ck80 FIND v(dout0_154) AT=45.025n

.meas tran vdout0_155ck80 FIND v(dout0_155) AT=45.025n

.meas tran vdout0_156ck80 FIND v(dout0_156) AT=45.025n

.meas tran vdout0_157ck80 FIND v(dout0_157) AT=45.025n

.meas tran vdout0_158ck80 FIND v(dout0_158) AT=45.025n

.meas tran vdout0_159ck80 FIND v(dout0_159) AT=45.025n

.meas tran vdout0_160ck80 FIND v(dout0_160) AT=45.025n

.meas tran vdout0_161ck80 FIND v(dout0_161) AT=45.025n

.meas tran vdout0_162ck80 FIND v(dout0_162) AT=45.025n

.meas tran vdout0_163ck80 FIND v(dout0_163) AT=45.025n

.meas tran vdout0_164ck80 FIND v(dout0_164) AT=45.025n

.meas tran vdout0_165ck80 FIND v(dout0_165) AT=45.025n

.meas tran vdout0_166ck80 FIND v(dout0_166) AT=45.025n

.meas tran vdout0_167ck80 FIND v(dout0_167) AT=45.025n

.meas tran vdout0_168ck80 FIND v(dout0_168) AT=45.025n

.meas tran vdout0_169ck80 FIND v(dout0_169) AT=45.025n

.meas tran vdout0_170ck80 FIND v(dout0_170) AT=45.025n

.meas tran vdout0_171ck80 FIND v(dout0_171) AT=45.025n

.meas tran vdout0_172ck80 FIND v(dout0_172) AT=45.025n

.meas tran vdout0_173ck80 FIND v(dout0_173) AT=45.025n

.meas tran vdout0_174ck80 FIND v(dout0_174) AT=45.025n

.meas tran vdout0_175ck80 FIND v(dout0_175) AT=45.025n

.meas tran vdout0_176ck80 FIND v(dout0_176) AT=45.025n

.meas tran vdout0_177ck80 FIND v(dout0_177) AT=45.025n

.meas tran vdout0_178ck80 FIND v(dout0_178) AT=45.025n

.meas tran vdout0_179ck80 FIND v(dout0_179) AT=45.025n

.meas tran vdout0_180ck80 FIND v(dout0_180) AT=45.025n

.meas tran vdout0_181ck80 FIND v(dout0_181) AT=45.025n

.meas tran vdout0_182ck80 FIND v(dout0_182) AT=45.025n

.meas tran vdout0_183ck80 FIND v(dout0_183) AT=45.025n

.meas tran vdout0_184ck80 FIND v(dout0_184) AT=45.025n

.meas tran vdout0_185ck80 FIND v(dout0_185) AT=45.025n

.meas tran vdout0_186ck80 FIND v(dout0_186) AT=45.025n

.meas tran vdout0_187ck80 FIND v(dout0_187) AT=45.025n

.meas tran vdout0_188ck80 FIND v(dout0_188) AT=45.025n

.meas tran vdout0_189ck80 FIND v(dout0_189) AT=45.025n

.meas tran vdout0_190ck80 FIND v(dout0_190) AT=45.025n

.meas tran vdout0_191ck80 FIND v(dout0_191) AT=45.025n

.meas tran vdout0_192ck80 FIND v(dout0_192) AT=45.025n

.meas tran vdout0_193ck80 FIND v(dout0_193) AT=45.025n

.meas tran vdout0_194ck80 FIND v(dout0_194) AT=45.025n

.meas tran vdout0_195ck80 FIND v(dout0_195) AT=45.025n

.meas tran vdout0_196ck80 FIND v(dout0_196) AT=45.025n

.meas tran vdout0_197ck80 FIND v(dout0_197) AT=45.025n

.meas tran vdout0_198ck80 FIND v(dout0_198) AT=45.025n

.meas tran vdout0_199ck80 FIND v(dout0_199) AT=45.025n

.meas tran vdout0_200ck80 FIND v(dout0_200) AT=45.025n

.meas tran vdout0_201ck80 FIND v(dout0_201) AT=45.025n

.meas tran vdout0_202ck80 FIND v(dout0_202) AT=45.025n

.meas tran vdout0_203ck80 FIND v(dout0_203) AT=45.025n

.meas tran vdout0_204ck80 FIND v(dout0_204) AT=45.025n

.meas tran vdout0_205ck80 FIND v(dout0_205) AT=45.025n

.meas tran vdout0_206ck80 FIND v(dout0_206) AT=45.025n

.meas tran vdout0_207ck80 FIND v(dout0_207) AT=45.025n

.meas tran vdout0_208ck80 FIND v(dout0_208) AT=45.025n

.meas tran vdout0_209ck80 FIND v(dout0_209) AT=45.025n

.meas tran vdout0_210ck80 FIND v(dout0_210) AT=45.025n

.meas tran vdout0_211ck80 FIND v(dout0_211) AT=45.025n

.meas tran vdout0_212ck80 FIND v(dout0_212) AT=45.025n

.meas tran vdout0_213ck80 FIND v(dout0_213) AT=45.025n

.meas tran vdout0_214ck80 FIND v(dout0_214) AT=45.025n

.meas tran vdout0_215ck80 FIND v(dout0_215) AT=45.025n

.meas tran vdout0_216ck80 FIND v(dout0_216) AT=45.025n

.meas tran vdout0_217ck80 FIND v(dout0_217) AT=45.025n

.meas tran vdout0_218ck80 FIND v(dout0_218) AT=45.025n

.meas tran vdout0_219ck80 FIND v(dout0_219) AT=45.025n

.meas tran vdout0_220ck80 FIND v(dout0_220) AT=45.025n

.meas tran vdout0_221ck80 FIND v(dout0_221) AT=45.025n

.meas tran vdout0_222ck80 FIND v(dout0_222) AT=45.025n

.meas tran vdout0_223ck80 FIND v(dout0_223) AT=45.025n

.meas tran vdout0_224ck80 FIND v(dout0_224) AT=45.025n

.meas tran vdout0_225ck80 FIND v(dout0_225) AT=45.025n

.meas tran vdout0_226ck80 FIND v(dout0_226) AT=45.025n

.meas tran vdout0_227ck80 FIND v(dout0_227) AT=45.025n

.meas tran vdout0_228ck80 FIND v(dout0_228) AT=45.025n

.meas tran vdout0_229ck80 FIND v(dout0_229) AT=45.025n

.meas tran vdout0_230ck80 FIND v(dout0_230) AT=45.025n

.meas tran vdout0_231ck80 FIND v(dout0_231) AT=45.025n

.meas tran vdout0_232ck80 FIND v(dout0_232) AT=45.025n

.meas tran vdout0_233ck80 FIND v(dout0_233) AT=45.025n

.meas tran vdout0_234ck80 FIND v(dout0_234) AT=45.025n

.meas tran vdout0_235ck80 FIND v(dout0_235) AT=45.025n

.meas tran vdout0_236ck80 FIND v(dout0_236) AT=45.025n

.meas tran vdout0_237ck80 FIND v(dout0_237) AT=45.025n

.meas tran vdout0_238ck80 FIND v(dout0_238) AT=45.025n

.meas tran vdout0_239ck80 FIND v(dout0_239) AT=45.025n

.meas tran vdout0_240ck80 FIND v(dout0_240) AT=45.025n

.meas tran vdout0_241ck80 FIND v(dout0_241) AT=45.025n

.meas tran vdout0_242ck80 FIND v(dout0_242) AT=45.025n

.meas tran vdout0_243ck80 FIND v(dout0_243) AT=45.025n

.meas tran vdout0_244ck80 FIND v(dout0_244) AT=45.025n

.meas tran vdout0_245ck80 FIND v(dout0_245) AT=45.025n

.meas tran vdout0_246ck80 FIND v(dout0_246) AT=45.025n

.meas tran vdout0_247ck80 FIND v(dout0_247) AT=45.025n

.meas tran vdout0_248ck80 FIND v(dout0_248) AT=45.025n

.meas tran vdout0_249ck80 FIND v(dout0_249) AT=45.025n

.meas tran vdout0_250ck80 FIND v(dout0_250) AT=45.025n

.meas tran vdout0_251ck80 FIND v(dout0_251) AT=45.025n

.meas tran vdout0_252ck80 FIND v(dout0_252) AT=45.025n

.meas tran vdout0_253ck80 FIND v(dout0_253) AT=45.025n

.meas tran vdout0_254ck80 FIND v(dout0_254) AT=45.025n

.meas tran vdout0_255ck80 FIND v(dout0_255) AT=45.025n

.meas tran vdout0_0ck90 FIND v(dout0_0) AT=50.025n

.meas tran vdout0_1ck90 FIND v(dout0_1) AT=50.025n

.meas tran vdout0_2ck90 FIND v(dout0_2) AT=50.025n

.meas tran vdout0_3ck90 FIND v(dout0_3) AT=50.025n

.meas tran vdout0_4ck90 FIND v(dout0_4) AT=50.025n

.meas tran vdout0_5ck90 FIND v(dout0_5) AT=50.025n

.meas tran vdout0_6ck90 FIND v(dout0_6) AT=50.025n

.meas tran vdout0_7ck90 FIND v(dout0_7) AT=50.025n

.meas tran vdout0_8ck90 FIND v(dout0_8) AT=50.025n

.meas tran vdout0_9ck90 FIND v(dout0_9) AT=50.025n

.meas tran vdout0_10ck90 FIND v(dout0_10) AT=50.025n

.meas tran vdout0_11ck90 FIND v(dout0_11) AT=50.025n

.meas tran vdout0_12ck90 FIND v(dout0_12) AT=50.025n

.meas tran vdout0_13ck90 FIND v(dout0_13) AT=50.025n

.meas tran vdout0_14ck90 FIND v(dout0_14) AT=50.025n

.meas tran vdout0_15ck90 FIND v(dout0_15) AT=50.025n

.meas tran vdout0_16ck90 FIND v(dout0_16) AT=50.025n

.meas tran vdout0_17ck90 FIND v(dout0_17) AT=50.025n

.meas tran vdout0_18ck90 FIND v(dout0_18) AT=50.025n

.meas tran vdout0_19ck90 FIND v(dout0_19) AT=50.025n

.meas tran vdout0_20ck90 FIND v(dout0_20) AT=50.025n

.meas tran vdout0_21ck90 FIND v(dout0_21) AT=50.025n

.meas tran vdout0_22ck90 FIND v(dout0_22) AT=50.025n

.meas tran vdout0_23ck90 FIND v(dout0_23) AT=50.025n

.meas tran vdout0_24ck90 FIND v(dout0_24) AT=50.025n

.meas tran vdout0_25ck90 FIND v(dout0_25) AT=50.025n

.meas tran vdout0_26ck90 FIND v(dout0_26) AT=50.025n

.meas tran vdout0_27ck90 FIND v(dout0_27) AT=50.025n

.meas tran vdout0_28ck90 FIND v(dout0_28) AT=50.025n

.meas tran vdout0_29ck90 FIND v(dout0_29) AT=50.025n

.meas tran vdout0_30ck90 FIND v(dout0_30) AT=50.025n

.meas tran vdout0_31ck90 FIND v(dout0_31) AT=50.025n

.meas tran vdout0_32ck90 FIND v(dout0_32) AT=50.025n

.meas tran vdout0_33ck90 FIND v(dout0_33) AT=50.025n

.meas tran vdout0_34ck90 FIND v(dout0_34) AT=50.025n

.meas tran vdout0_35ck90 FIND v(dout0_35) AT=50.025n

.meas tran vdout0_36ck90 FIND v(dout0_36) AT=50.025n

.meas tran vdout0_37ck90 FIND v(dout0_37) AT=50.025n

.meas tran vdout0_38ck90 FIND v(dout0_38) AT=50.025n

.meas tran vdout0_39ck90 FIND v(dout0_39) AT=50.025n

.meas tran vdout0_40ck90 FIND v(dout0_40) AT=50.025n

.meas tran vdout0_41ck90 FIND v(dout0_41) AT=50.025n

.meas tran vdout0_42ck90 FIND v(dout0_42) AT=50.025n

.meas tran vdout0_43ck90 FIND v(dout0_43) AT=50.025n

.meas tran vdout0_44ck90 FIND v(dout0_44) AT=50.025n

.meas tran vdout0_45ck90 FIND v(dout0_45) AT=50.025n

.meas tran vdout0_46ck90 FIND v(dout0_46) AT=50.025n

.meas tran vdout0_47ck90 FIND v(dout0_47) AT=50.025n

.meas tran vdout0_48ck90 FIND v(dout0_48) AT=50.025n

.meas tran vdout0_49ck90 FIND v(dout0_49) AT=50.025n

.meas tran vdout0_50ck90 FIND v(dout0_50) AT=50.025n

.meas tran vdout0_51ck90 FIND v(dout0_51) AT=50.025n

.meas tran vdout0_52ck90 FIND v(dout0_52) AT=50.025n

.meas tran vdout0_53ck90 FIND v(dout0_53) AT=50.025n

.meas tran vdout0_54ck90 FIND v(dout0_54) AT=50.025n

.meas tran vdout0_55ck90 FIND v(dout0_55) AT=50.025n

.meas tran vdout0_56ck90 FIND v(dout0_56) AT=50.025n

.meas tran vdout0_57ck90 FIND v(dout0_57) AT=50.025n

.meas tran vdout0_58ck90 FIND v(dout0_58) AT=50.025n

.meas tran vdout0_59ck90 FIND v(dout0_59) AT=50.025n

.meas tran vdout0_60ck90 FIND v(dout0_60) AT=50.025n

.meas tran vdout0_61ck90 FIND v(dout0_61) AT=50.025n

.meas tran vdout0_62ck90 FIND v(dout0_62) AT=50.025n

.meas tran vdout0_63ck90 FIND v(dout0_63) AT=50.025n

.meas tran vdout0_64ck90 FIND v(dout0_64) AT=50.025n

.meas tran vdout0_65ck90 FIND v(dout0_65) AT=50.025n

.meas tran vdout0_66ck90 FIND v(dout0_66) AT=50.025n

.meas tran vdout0_67ck90 FIND v(dout0_67) AT=50.025n

.meas tran vdout0_68ck90 FIND v(dout0_68) AT=50.025n

.meas tran vdout0_69ck90 FIND v(dout0_69) AT=50.025n

.meas tran vdout0_70ck90 FIND v(dout0_70) AT=50.025n

.meas tran vdout0_71ck90 FIND v(dout0_71) AT=50.025n

.meas tran vdout0_72ck90 FIND v(dout0_72) AT=50.025n

.meas tran vdout0_73ck90 FIND v(dout0_73) AT=50.025n

.meas tran vdout0_74ck90 FIND v(dout0_74) AT=50.025n

.meas tran vdout0_75ck90 FIND v(dout0_75) AT=50.025n

.meas tran vdout0_76ck90 FIND v(dout0_76) AT=50.025n

.meas tran vdout0_77ck90 FIND v(dout0_77) AT=50.025n

.meas tran vdout0_78ck90 FIND v(dout0_78) AT=50.025n

.meas tran vdout0_79ck90 FIND v(dout0_79) AT=50.025n

.meas tran vdout0_80ck90 FIND v(dout0_80) AT=50.025n

.meas tran vdout0_81ck90 FIND v(dout0_81) AT=50.025n

.meas tran vdout0_82ck90 FIND v(dout0_82) AT=50.025n

.meas tran vdout0_83ck90 FIND v(dout0_83) AT=50.025n

.meas tran vdout0_84ck90 FIND v(dout0_84) AT=50.025n

.meas tran vdout0_85ck90 FIND v(dout0_85) AT=50.025n

.meas tran vdout0_86ck90 FIND v(dout0_86) AT=50.025n

.meas tran vdout0_87ck90 FIND v(dout0_87) AT=50.025n

.meas tran vdout0_88ck90 FIND v(dout0_88) AT=50.025n

.meas tran vdout0_89ck90 FIND v(dout0_89) AT=50.025n

.meas tran vdout0_90ck90 FIND v(dout0_90) AT=50.025n

.meas tran vdout0_91ck90 FIND v(dout0_91) AT=50.025n

.meas tran vdout0_92ck90 FIND v(dout0_92) AT=50.025n

.meas tran vdout0_93ck90 FIND v(dout0_93) AT=50.025n

.meas tran vdout0_94ck90 FIND v(dout0_94) AT=50.025n

.meas tran vdout0_95ck90 FIND v(dout0_95) AT=50.025n

.meas tran vdout0_96ck90 FIND v(dout0_96) AT=50.025n

.meas tran vdout0_97ck90 FIND v(dout0_97) AT=50.025n

.meas tran vdout0_98ck90 FIND v(dout0_98) AT=50.025n

.meas tran vdout0_99ck90 FIND v(dout0_99) AT=50.025n

.meas tran vdout0_100ck90 FIND v(dout0_100) AT=50.025n

.meas tran vdout0_101ck90 FIND v(dout0_101) AT=50.025n

.meas tran vdout0_102ck90 FIND v(dout0_102) AT=50.025n

.meas tran vdout0_103ck90 FIND v(dout0_103) AT=50.025n

.meas tran vdout0_104ck90 FIND v(dout0_104) AT=50.025n

.meas tran vdout0_105ck90 FIND v(dout0_105) AT=50.025n

.meas tran vdout0_106ck90 FIND v(dout0_106) AT=50.025n

.meas tran vdout0_107ck90 FIND v(dout0_107) AT=50.025n

.meas tran vdout0_108ck90 FIND v(dout0_108) AT=50.025n

.meas tran vdout0_109ck90 FIND v(dout0_109) AT=50.025n

.meas tran vdout0_110ck90 FIND v(dout0_110) AT=50.025n

.meas tran vdout0_111ck90 FIND v(dout0_111) AT=50.025n

.meas tran vdout0_112ck90 FIND v(dout0_112) AT=50.025n

.meas tran vdout0_113ck90 FIND v(dout0_113) AT=50.025n

.meas tran vdout0_114ck90 FIND v(dout0_114) AT=50.025n

.meas tran vdout0_115ck90 FIND v(dout0_115) AT=50.025n

.meas tran vdout0_116ck90 FIND v(dout0_116) AT=50.025n

.meas tran vdout0_117ck90 FIND v(dout0_117) AT=50.025n

.meas tran vdout0_118ck90 FIND v(dout0_118) AT=50.025n

.meas tran vdout0_119ck90 FIND v(dout0_119) AT=50.025n

.meas tran vdout0_120ck90 FIND v(dout0_120) AT=50.025n

.meas tran vdout0_121ck90 FIND v(dout0_121) AT=50.025n

.meas tran vdout0_122ck90 FIND v(dout0_122) AT=50.025n

.meas tran vdout0_123ck90 FIND v(dout0_123) AT=50.025n

.meas tran vdout0_124ck90 FIND v(dout0_124) AT=50.025n

.meas tran vdout0_125ck90 FIND v(dout0_125) AT=50.025n

.meas tran vdout0_126ck90 FIND v(dout0_126) AT=50.025n

.meas tran vdout0_127ck90 FIND v(dout0_127) AT=50.025n

.meas tran vdout0_128ck90 FIND v(dout0_128) AT=50.025n

.meas tran vdout0_129ck90 FIND v(dout0_129) AT=50.025n

.meas tran vdout0_130ck90 FIND v(dout0_130) AT=50.025n

.meas tran vdout0_131ck90 FIND v(dout0_131) AT=50.025n

.meas tran vdout0_132ck90 FIND v(dout0_132) AT=50.025n

.meas tran vdout0_133ck90 FIND v(dout0_133) AT=50.025n

.meas tran vdout0_134ck90 FIND v(dout0_134) AT=50.025n

.meas tran vdout0_135ck90 FIND v(dout0_135) AT=50.025n

.meas tran vdout0_136ck90 FIND v(dout0_136) AT=50.025n

.meas tran vdout0_137ck90 FIND v(dout0_137) AT=50.025n

.meas tran vdout0_138ck90 FIND v(dout0_138) AT=50.025n

.meas tran vdout0_139ck90 FIND v(dout0_139) AT=50.025n

.meas tran vdout0_140ck90 FIND v(dout0_140) AT=50.025n

.meas tran vdout0_141ck90 FIND v(dout0_141) AT=50.025n

.meas tran vdout0_142ck90 FIND v(dout0_142) AT=50.025n

.meas tran vdout0_143ck90 FIND v(dout0_143) AT=50.025n

.meas tran vdout0_144ck90 FIND v(dout0_144) AT=50.025n

.meas tran vdout0_145ck90 FIND v(dout0_145) AT=50.025n

.meas tran vdout0_146ck90 FIND v(dout0_146) AT=50.025n

.meas tran vdout0_147ck90 FIND v(dout0_147) AT=50.025n

.meas tran vdout0_148ck90 FIND v(dout0_148) AT=50.025n

.meas tran vdout0_149ck90 FIND v(dout0_149) AT=50.025n

.meas tran vdout0_150ck90 FIND v(dout0_150) AT=50.025n

.meas tran vdout0_151ck90 FIND v(dout0_151) AT=50.025n

.meas tran vdout0_152ck90 FIND v(dout0_152) AT=50.025n

.meas tran vdout0_153ck90 FIND v(dout0_153) AT=50.025n

.meas tran vdout0_154ck90 FIND v(dout0_154) AT=50.025n

.meas tran vdout0_155ck90 FIND v(dout0_155) AT=50.025n

.meas tran vdout0_156ck90 FIND v(dout0_156) AT=50.025n

.meas tran vdout0_157ck90 FIND v(dout0_157) AT=50.025n

.meas tran vdout0_158ck90 FIND v(dout0_158) AT=50.025n

.meas tran vdout0_159ck90 FIND v(dout0_159) AT=50.025n

.meas tran vdout0_160ck90 FIND v(dout0_160) AT=50.025n

.meas tran vdout0_161ck90 FIND v(dout0_161) AT=50.025n

.meas tran vdout0_162ck90 FIND v(dout0_162) AT=50.025n

.meas tran vdout0_163ck90 FIND v(dout0_163) AT=50.025n

.meas tran vdout0_164ck90 FIND v(dout0_164) AT=50.025n

.meas tran vdout0_165ck90 FIND v(dout0_165) AT=50.025n

.meas tran vdout0_166ck90 FIND v(dout0_166) AT=50.025n

.meas tran vdout0_167ck90 FIND v(dout0_167) AT=50.025n

.meas tran vdout0_168ck90 FIND v(dout0_168) AT=50.025n

.meas tran vdout0_169ck90 FIND v(dout0_169) AT=50.025n

.meas tran vdout0_170ck90 FIND v(dout0_170) AT=50.025n

.meas tran vdout0_171ck90 FIND v(dout0_171) AT=50.025n

.meas tran vdout0_172ck90 FIND v(dout0_172) AT=50.025n

.meas tran vdout0_173ck90 FIND v(dout0_173) AT=50.025n

.meas tran vdout0_174ck90 FIND v(dout0_174) AT=50.025n

.meas tran vdout0_175ck90 FIND v(dout0_175) AT=50.025n

.meas tran vdout0_176ck90 FIND v(dout0_176) AT=50.025n

.meas tran vdout0_177ck90 FIND v(dout0_177) AT=50.025n

.meas tran vdout0_178ck90 FIND v(dout0_178) AT=50.025n

.meas tran vdout0_179ck90 FIND v(dout0_179) AT=50.025n

.meas tran vdout0_180ck90 FIND v(dout0_180) AT=50.025n

.meas tran vdout0_181ck90 FIND v(dout0_181) AT=50.025n

.meas tran vdout0_182ck90 FIND v(dout0_182) AT=50.025n

.meas tran vdout0_183ck90 FIND v(dout0_183) AT=50.025n

.meas tran vdout0_184ck90 FIND v(dout0_184) AT=50.025n

.meas tran vdout0_185ck90 FIND v(dout0_185) AT=50.025n

.meas tran vdout0_186ck90 FIND v(dout0_186) AT=50.025n

.meas tran vdout0_187ck90 FIND v(dout0_187) AT=50.025n

.meas tran vdout0_188ck90 FIND v(dout0_188) AT=50.025n

.meas tran vdout0_189ck90 FIND v(dout0_189) AT=50.025n

.meas tran vdout0_190ck90 FIND v(dout0_190) AT=50.025n

.meas tran vdout0_191ck90 FIND v(dout0_191) AT=50.025n

.meas tran vdout0_192ck90 FIND v(dout0_192) AT=50.025n

.meas tran vdout0_193ck90 FIND v(dout0_193) AT=50.025n

.meas tran vdout0_194ck90 FIND v(dout0_194) AT=50.025n

.meas tran vdout0_195ck90 FIND v(dout0_195) AT=50.025n

.meas tran vdout0_196ck90 FIND v(dout0_196) AT=50.025n

.meas tran vdout0_197ck90 FIND v(dout0_197) AT=50.025n

.meas tran vdout0_198ck90 FIND v(dout0_198) AT=50.025n

.meas tran vdout0_199ck90 FIND v(dout0_199) AT=50.025n

.meas tran vdout0_200ck90 FIND v(dout0_200) AT=50.025n

.meas tran vdout0_201ck90 FIND v(dout0_201) AT=50.025n

.meas tran vdout0_202ck90 FIND v(dout0_202) AT=50.025n

.meas tran vdout0_203ck90 FIND v(dout0_203) AT=50.025n

.meas tran vdout0_204ck90 FIND v(dout0_204) AT=50.025n

.meas tran vdout0_205ck90 FIND v(dout0_205) AT=50.025n

.meas tran vdout0_206ck90 FIND v(dout0_206) AT=50.025n

.meas tran vdout0_207ck90 FIND v(dout0_207) AT=50.025n

.meas tran vdout0_208ck90 FIND v(dout0_208) AT=50.025n

.meas tran vdout0_209ck90 FIND v(dout0_209) AT=50.025n

.meas tran vdout0_210ck90 FIND v(dout0_210) AT=50.025n

.meas tran vdout0_211ck90 FIND v(dout0_211) AT=50.025n

.meas tran vdout0_212ck90 FIND v(dout0_212) AT=50.025n

.meas tran vdout0_213ck90 FIND v(dout0_213) AT=50.025n

.meas tran vdout0_214ck90 FIND v(dout0_214) AT=50.025n

.meas tran vdout0_215ck90 FIND v(dout0_215) AT=50.025n

.meas tran vdout0_216ck90 FIND v(dout0_216) AT=50.025n

.meas tran vdout0_217ck90 FIND v(dout0_217) AT=50.025n

.meas tran vdout0_218ck90 FIND v(dout0_218) AT=50.025n

.meas tran vdout0_219ck90 FIND v(dout0_219) AT=50.025n

.meas tran vdout0_220ck90 FIND v(dout0_220) AT=50.025n

.meas tran vdout0_221ck90 FIND v(dout0_221) AT=50.025n

.meas tran vdout0_222ck90 FIND v(dout0_222) AT=50.025n

.meas tran vdout0_223ck90 FIND v(dout0_223) AT=50.025n

.meas tran vdout0_224ck90 FIND v(dout0_224) AT=50.025n

.meas tran vdout0_225ck90 FIND v(dout0_225) AT=50.025n

.meas tran vdout0_226ck90 FIND v(dout0_226) AT=50.025n

.meas tran vdout0_227ck90 FIND v(dout0_227) AT=50.025n

.meas tran vdout0_228ck90 FIND v(dout0_228) AT=50.025n

.meas tran vdout0_229ck90 FIND v(dout0_229) AT=50.025n

.meas tran vdout0_230ck90 FIND v(dout0_230) AT=50.025n

.meas tran vdout0_231ck90 FIND v(dout0_231) AT=50.025n

.meas tran vdout0_232ck90 FIND v(dout0_232) AT=50.025n

.meas tran vdout0_233ck90 FIND v(dout0_233) AT=50.025n

.meas tran vdout0_234ck90 FIND v(dout0_234) AT=50.025n

.meas tran vdout0_235ck90 FIND v(dout0_235) AT=50.025n

.meas tran vdout0_236ck90 FIND v(dout0_236) AT=50.025n

.meas tran vdout0_237ck90 FIND v(dout0_237) AT=50.025n

.meas tran vdout0_238ck90 FIND v(dout0_238) AT=50.025n

.meas tran vdout0_239ck90 FIND v(dout0_239) AT=50.025n

.meas tran vdout0_240ck90 FIND v(dout0_240) AT=50.025n

.meas tran vdout0_241ck90 FIND v(dout0_241) AT=50.025n

.meas tran vdout0_242ck90 FIND v(dout0_242) AT=50.025n

.meas tran vdout0_243ck90 FIND v(dout0_243) AT=50.025n

.meas tran vdout0_244ck90 FIND v(dout0_244) AT=50.025n

.meas tran vdout0_245ck90 FIND v(dout0_245) AT=50.025n

.meas tran vdout0_246ck90 FIND v(dout0_246) AT=50.025n

.meas tran vdout0_247ck90 FIND v(dout0_247) AT=50.025n

.meas tran vdout0_248ck90 FIND v(dout0_248) AT=50.025n

.meas tran vdout0_249ck90 FIND v(dout0_249) AT=50.025n

.meas tran vdout0_250ck90 FIND v(dout0_250) AT=50.025n

.meas tran vdout0_251ck90 FIND v(dout0_251) AT=50.025n

.meas tran vdout0_252ck90 FIND v(dout0_252) AT=50.025n

.meas tran vdout0_253ck90 FIND v(dout0_253) AT=50.025n

.meas tran vdout0_254ck90 FIND v(dout0_254) AT=50.025n

.meas tran vdout0_255ck90 FIND v(dout0_255) AT=50.025n

.meas tran vdout0_0ck110 FIND v(dout0_0) AT=60.025n

.meas tran vdout0_1ck110 FIND v(dout0_1) AT=60.025n

.meas tran vdout0_2ck110 FIND v(dout0_2) AT=60.025n

.meas tran vdout0_3ck110 FIND v(dout0_3) AT=60.025n

.meas tran vdout0_4ck110 FIND v(dout0_4) AT=60.025n

.meas tran vdout0_5ck110 FIND v(dout0_5) AT=60.025n

.meas tran vdout0_6ck110 FIND v(dout0_6) AT=60.025n

.meas tran vdout0_7ck110 FIND v(dout0_7) AT=60.025n

.meas tran vdout0_8ck110 FIND v(dout0_8) AT=60.025n

.meas tran vdout0_9ck110 FIND v(dout0_9) AT=60.025n

.meas tran vdout0_10ck110 FIND v(dout0_10) AT=60.025n

.meas tran vdout0_11ck110 FIND v(dout0_11) AT=60.025n

.meas tran vdout0_12ck110 FIND v(dout0_12) AT=60.025n

.meas tran vdout0_13ck110 FIND v(dout0_13) AT=60.025n

.meas tran vdout0_14ck110 FIND v(dout0_14) AT=60.025n

.meas tran vdout0_15ck110 FIND v(dout0_15) AT=60.025n

.meas tran vdout0_16ck110 FIND v(dout0_16) AT=60.025n

.meas tran vdout0_17ck110 FIND v(dout0_17) AT=60.025n

.meas tran vdout0_18ck110 FIND v(dout0_18) AT=60.025n

.meas tran vdout0_19ck110 FIND v(dout0_19) AT=60.025n

.meas tran vdout0_20ck110 FIND v(dout0_20) AT=60.025n

.meas tran vdout0_21ck110 FIND v(dout0_21) AT=60.025n

.meas tran vdout0_22ck110 FIND v(dout0_22) AT=60.025n

.meas tran vdout0_23ck110 FIND v(dout0_23) AT=60.025n

.meas tran vdout0_24ck110 FIND v(dout0_24) AT=60.025n

.meas tran vdout0_25ck110 FIND v(dout0_25) AT=60.025n

.meas tran vdout0_26ck110 FIND v(dout0_26) AT=60.025n

.meas tran vdout0_27ck110 FIND v(dout0_27) AT=60.025n

.meas tran vdout0_28ck110 FIND v(dout0_28) AT=60.025n

.meas tran vdout0_29ck110 FIND v(dout0_29) AT=60.025n

.meas tran vdout0_30ck110 FIND v(dout0_30) AT=60.025n

.meas tran vdout0_31ck110 FIND v(dout0_31) AT=60.025n

.meas tran vdout0_32ck110 FIND v(dout0_32) AT=60.025n

.meas tran vdout0_33ck110 FIND v(dout0_33) AT=60.025n

.meas tran vdout0_34ck110 FIND v(dout0_34) AT=60.025n

.meas tran vdout0_35ck110 FIND v(dout0_35) AT=60.025n

.meas tran vdout0_36ck110 FIND v(dout0_36) AT=60.025n

.meas tran vdout0_37ck110 FIND v(dout0_37) AT=60.025n

.meas tran vdout0_38ck110 FIND v(dout0_38) AT=60.025n

.meas tran vdout0_39ck110 FIND v(dout0_39) AT=60.025n

.meas tran vdout0_40ck110 FIND v(dout0_40) AT=60.025n

.meas tran vdout0_41ck110 FIND v(dout0_41) AT=60.025n

.meas tran vdout0_42ck110 FIND v(dout0_42) AT=60.025n

.meas tran vdout0_43ck110 FIND v(dout0_43) AT=60.025n

.meas tran vdout0_44ck110 FIND v(dout0_44) AT=60.025n

.meas tran vdout0_45ck110 FIND v(dout0_45) AT=60.025n

.meas tran vdout0_46ck110 FIND v(dout0_46) AT=60.025n

.meas tran vdout0_47ck110 FIND v(dout0_47) AT=60.025n

.meas tran vdout0_48ck110 FIND v(dout0_48) AT=60.025n

.meas tran vdout0_49ck110 FIND v(dout0_49) AT=60.025n

.meas tran vdout0_50ck110 FIND v(dout0_50) AT=60.025n

.meas tran vdout0_51ck110 FIND v(dout0_51) AT=60.025n

.meas tran vdout0_52ck110 FIND v(dout0_52) AT=60.025n

.meas tran vdout0_53ck110 FIND v(dout0_53) AT=60.025n

.meas tran vdout0_54ck110 FIND v(dout0_54) AT=60.025n

.meas tran vdout0_55ck110 FIND v(dout0_55) AT=60.025n

.meas tran vdout0_56ck110 FIND v(dout0_56) AT=60.025n

.meas tran vdout0_57ck110 FIND v(dout0_57) AT=60.025n

.meas tran vdout0_58ck110 FIND v(dout0_58) AT=60.025n

.meas tran vdout0_59ck110 FIND v(dout0_59) AT=60.025n

.meas tran vdout0_60ck110 FIND v(dout0_60) AT=60.025n

.meas tran vdout0_61ck110 FIND v(dout0_61) AT=60.025n

.meas tran vdout0_62ck110 FIND v(dout0_62) AT=60.025n

.meas tran vdout0_63ck110 FIND v(dout0_63) AT=60.025n

.meas tran vdout0_64ck110 FIND v(dout0_64) AT=60.025n

.meas tran vdout0_65ck110 FIND v(dout0_65) AT=60.025n

.meas tran vdout0_66ck110 FIND v(dout0_66) AT=60.025n

.meas tran vdout0_67ck110 FIND v(dout0_67) AT=60.025n

.meas tran vdout0_68ck110 FIND v(dout0_68) AT=60.025n

.meas tran vdout0_69ck110 FIND v(dout0_69) AT=60.025n

.meas tran vdout0_70ck110 FIND v(dout0_70) AT=60.025n

.meas tran vdout0_71ck110 FIND v(dout0_71) AT=60.025n

.meas tran vdout0_72ck110 FIND v(dout0_72) AT=60.025n

.meas tran vdout0_73ck110 FIND v(dout0_73) AT=60.025n

.meas tran vdout0_74ck110 FIND v(dout0_74) AT=60.025n

.meas tran vdout0_75ck110 FIND v(dout0_75) AT=60.025n

.meas tran vdout0_76ck110 FIND v(dout0_76) AT=60.025n

.meas tran vdout0_77ck110 FIND v(dout0_77) AT=60.025n

.meas tran vdout0_78ck110 FIND v(dout0_78) AT=60.025n

.meas tran vdout0_79ck110 FIND v(dout0_79) AT=60.025n

.meas tran vdout0_80ck110 FIND v(dout0_80) AT=60.025n

.meas tran vdout0_81ck110 FIND v(dout0_81) AT=60.025n

.meas tran vdout0_82ck110 FIND v(dout0_82) AT=60.025n

.meas tran vdout0_83ck110 FIND v(dout0_83) AT=60.025n

.meas tran vdout0_84ck110 FIND v(dout0_84) AT=60.025n

.meas tran vdout0_85ck110 FIND v(dout0_85) AT=60.025n

.meas tran vdout0_86ck110 FIND v(dout0_86) AT=60.025n

.meas tran vdout0_87ck110 FIND v(dout0_87) AT=60.025n

.meas tran vdout0_88ck110 FIND v(dout0_88) AT=60.025n

.meas tran vdout0_89ck110 FIND v(dout0_89) AT=60.025n

.meas tran vdout0_90ck110 FIND v(dout0_90) AT=60.025n

.meas tran vdout0_91ck110 FIND v(dout0_91) AT=60.025n

.meas tran vdout0_92ck110 FIND v(dout0_92) AT=60.025n

.meas tran vdout0_93ck110 FIND v(dout0_93) AT=60.025n

.meas tran vdout0_94ck110 FIND v(dout0_94) AT=60.025n

.meas tran vdout0_95ck110 FIND v(dout0_95) AT=60.025n

.meas tran vdout0_96ck110 FIND v(dout0_96) AT=60.025n

.meas tran vdout0_97ck110 FIND v(dout0_97) AT=60.025n

.meas tran vdout0_98ck110 FIND v(dout0_98) AT=60.025n

.meas tran vdout0_99ck110 FIND v(dout0_99) AT=60.025n

.meas tran vdout0_100ck110 FIND v(dout0_100) AT=60.025n

.meas tran vdout0_101ck110 FIND v(dout0_101) AT=60.025n

.meas tran vdout0_102ck110 FIND v(dout0_102) AT=60.025n

.meas tran vdout0_103ck110 FIND v(dout0_103) AT=60.025n

.meas tran vdout0_104ck110 FIND v(dout0_104) AT=60.025n

.meas tran vdout0_105ck110 FIND v(dout0_105) AT=60.025n

.meas tran vdout0_106ck110 FIND v(dout0_106) AT=60.025n

.meas tran vdout0_107ck110 FIND v(dout0_107) AT=60.025n

.meas tran vdout0_108ck110 FIND v(dout0_108) AT=60.025n

.meas tran vdout0_109ck110 FIND v(dout0_109) AT=60.025n

.meas tran vdout0_110ck110 FIND v(dout0_110) AT=60.025n

.meas tran vdout0_111ck110 FIND v(dout0_111) AT=60.025n

.meas tran vdout0_112ck110 FIND v(dout0_112) AT=60.025n

.meas tran vdout0_113ck110 FIND v(dout0_113) AT=60.025n

.meas tran vdout0_114ck110 FIND v(dout0_114) AT=60.025n

.meas tran vdout0_115ck110 FIND v(dout0_115) AT=60.025n

.meas tran vdout0_116ck110 FIND v(dout0_116) AT=60.025n

.meas tran vdout0_117ck110 FIND v(dout0_117) AT=60.025n

.meas tran vdout0_118ck110 FIND v(dout0_118) AT=60.025n

.meas tran vdout0_119ck110 FIND v(dout0_119) AT=60.025n

.meas tran vdout0_120ck110 FIND v(dout0_120) AT=60.025n

.meas tran vdout0_121ck110 FIND v(dout0_121) AT=60.025n

.meas tran vdout0_122ck110 FIND v(dout0_122) AT=60.025n

.meas tran vdout0_123ck110 FIND v(dout0_123) AT=60.025n

.meas tran vdout0_124ck110 FIND v(dout0_124) AT=60.025n

.meas tran vdout0_125ck110 FIND v(dout0_125) AT=60.025n

.meas tran vdout0_126ck110 FIND v(dout0_126) AT=60.025n

.meas tran vdout0_127ck110 FIND v(dout0_127) AT=60.025n

.meas tran vdout0_128ck110 FIND v(dout0_128) AT=60.025n

.meas tran vdout0_129ck110 FIND v(dout0_129) AT=60.025n

.meas tran vdout0_130ck110 FIND v(dout0_130) AT=60.025n

.meas tran vdout0_131ck110 FIND v(dout0_131) AT=60.025n

.meas tran vdout0_132ck110 FIND v(dout0_132) AT=60.025n

.meas tran vdout0_133ck110 FIND v(dout0_133) AT=60.025n

.meas tran vdout0_134ck110 FIND v(dout0_134) AT=60.025n

.meas tran vdout0_135ck110 FIND v(dout0_135) AT=60.025n

.meas tran vdout0_136ck110 FIND v(dout0_136) AT=60.025n

.meas tran vdout0_137ck110 FIND v(dout0_137) AT=60.025n

.meas tran vdout0_138ck110 FIND v(dout0_138) AT=60.025n

.meas tran vdout0_139ck110 FIND v(dout0_139) AT=60.025n

.meas tran vdout0_140ck110 FIND v(dout0_140) AT=60.025n

.meas tran vdout0_141ck110 FIND v(dout0_141) AT=60.025n

.meas tran vdout0_142ck110 FIND v(dout0_142) AT=60.025n

.meas tran vdout0_143ck110 FIND v(dout0_143) AT=60.025n

.meas tran vdout0_144ck110 FIND v(dout0_144) AT=60.025n

.meas tran vdout0_145ck110 FIND v(dout0_145) AT=60.025n

.meas tran vdout0_146ck110 FIND v(dout0_146) AT=60.025n

.meas tran vdout0_147ck110 FIND v(dout0_147) AT=60.025n

.meas tran vdout0_148ck110 FIND v(dout0_148) AT=60.025n

.meas tran vdout0_149ck110 FIND v(dout0_149) AT=60.025n

.meas tran vdout0_150ck110 FIND v(dout0_150) AT=60.025n

.meas tran vdout0_151ck110 FIND v(dout0_151) AT=60.025n

.meas tran vdout0_152ck110 FIND v(dout0_152) AT=60.025n

.meas tran vdout0_153ck110 FIND v(dout0_153) AT=60.025n

.meas tran vdout0_154ck110 FIND v(dout0_154) AT=60.025n

.meas tran vdout0_155ck110 FIND v(dout0_155) AT=60.025n

.meas tran vdout0_156ck110 FIND v(dout0_156) AT=60.025n

.meas tran vdout0_157ck110 FIND v(dout0_157) AT=60.025n

.meas tran vdout0_158ck110 FIND v(dout0_158) AT=60.025n

.meas tran vdout0_159ck110 FIND v(dout0_159) AT=60.025n

.meas tran vdout0_160ck110 FIND v(dout0_160) AT=60.025n

.meas tran vdout0_161ck110 FIND v(dout0_161) AT=60.025n

.meas tran vdout0_162ck110 FIND v(dout0_162) AT=60.025n

.meas tran vdout0_163ck110 FIND v(dout0_163) AT=60.025n

.meas tran vdout0_164ck110 FIND v(dout0_164) AT=60.025n

.meas tran vdout0_165ck110 FIND v(dout0_165) AT=60.025n

.meas tran vdout0_166ck110 FIND v(dout0_166) AT=60.025n

.meas tran vdout0_167ck110 FIND v(dout0_167) AT=60.025n

.meas tran vdout0_168ck110 FIND v(dout0_168) AT=60.025n

.meas tran vdout0_169ck110 FIND v(dout0_169) AT=60.025n

.meas tran vdout0_170ck110 FIND v(dout0_170) AT=60.025n

.meas tran vdout0_171ck110 FIND v(dout0_171) AT=60.025n

.meas tran vdout0_172ck110 FIND v(dout0_172) AT=60.025n

.meas tran vdout0_173ck110 FIND v(dout0_173) AT=60.025n

.meas tran vdout0_174ck110 FIND v(dout0_174) AT=60.025n

.meas tran vdout0_175ck110 FIND v(dout0_175) AT=60.025n

.meas tran vdout0_176ck110 FIND v(dout0_176) AT=60.025n

.meas tran vdout0_177ck110 FIND v(dout0_177) AT=60.025n

.meas tran vdout0_178ck110 FIND v(dout0_178) AT=60.025n

.meas tran vdout0_179ck110 FIND v(dout0_179) AT=60.025n

.meas tran vdout0_180ck110 FIND v(dout0_180) AT=60.025n

.meas tran vdout0_181ck110 FIND v(dout0_181) AT=60.025n

.meas tran vdout0_182ck110 FIND v(dout0_182) AT=60.025n

.meas tran vdout0_183ck110 FIND v(dout0_183) AT=60.025n

.meas tran vdout0_184ck110 FIND v(dout0_184) AT=60.025n

.meas tran vdout0_185ck110 FIND v(dout0_185) AT=60.025n

.meas tran vdout0_186ck110 FIND v(dout0_186) AT=60.025n

.meas tran vdout0_187ck110 FIND v(dout0_187) AT=60.025n

.meas tran vdout0_188ck110 FIND v(dout0_188) AT=60.025n

.meas tran vdout0_189ck110 FIND v(dout0_189) AT=60.025n

.meas tran vdout0_190ck110 FIND v(dout0_190) AT=60.025n

.meas tran vdout0_191ck110 FIND v(dout0_191) AT=60.025n

.meas tran vdout0_192ck110 FIND v(dout0_192) AT=60.025n

.meas tran vdout0_193ck110 FIND v(dout0_193) AT=60.025n

.meas tran vdout0_194ck110 FIND v(dout0_194) AT=60.025n

.meas tran vdout0_195ck110 FIND v(dout0_195) AT=60.025n

.meas tran vdout0_196ck110 FIND v(dout0_196) AT=60.025n

.meas tran vdout0_197ck110 FIND v(dout0_197) AT=60.025n

.meas tran vdout0_198ck110 FIND v(dout0_198) AT=60.025n

.meas tran vdout0_199ck110 FIND v(dout0_199) AT=60.025n

.meas tran vdout0_200ck110 FIND v(dout0_200) AT=60.025n

.meas tran vdout0_201ck110 FIND v(dout0_201) AT=60.025n

.meas tran vdout0_202ck110 FIND v(dout0_202) AT=60.025n

.meas tran vdout0_203ck110 FIND v(dout0_203) AT=60.025n

.meas tran vdout0_204ck110 FIND v(dout0_204) AT=60.025n

.meas tran vdout0_205ck110 FIND v(dout0_205) AT=60.025n

.meas tran vdout0_206ck110 FIND v(dout0_206) AT=60.025n

.meas tran vdout0_207ck110 FIND v(dout0_207) AT=60.025n

.meas tran vdout0_208ck110 FIND v(dout0_208) AT=60.025n

.meas tran vdout0_209ck110 FIND v(dout0_209) AT=60.025n

.meas tran vdout0_210ck110 FIND v(dout0_210) AT=60.025n

.meas tran vdout0_211ck110 FIND v(dout0_211) AT=60.025n

.meas tran vdout0_212ck110 FIND v(dout0_212) AT=60.025n

.meas tran vdout0_213ck110 FIND v(dout0_213) AT=60.025n

.meas tran vdout0_214ck110 FIND v(dout0_214) AT=60.025n

.meas tran vdout0_215ck110 FIND v(dout0_215) AT=60.025n

.meas tran vdout0_216ck110 FIND v(dout0_216) AT=60.025n

.meas tran vdout0_217ck110 FIND v(dout0_217) AT=60.025n

.meas tran vdout0_218ck110 FIND v(dout0_218) AT=60.025n

.meas tran vdout0_219ck110 FIND v(dout0_219) AT=60.025n

.meas tran vdout0_220ck110 FIND v(dout0_220) AT=60.025n

.meas tran vdout0_221ck110 FIND v(dout0_221) AT=60.025n

.meas tran vdout0_222ck110 FIND v(dout0_222) AT=60.025n

.meas tran vdout0_223ck110 FIND v(dout0_223) AT=60.025n

.meas tran vdout0_224ck110 FIND v(dout0_224) AT=60.025n

.meas tran vdout0_225ck110 FIND v(dout0_225) AT=60.025n

.meas tran vdout0_226ck110 FIND v(dout0_226) AT=60.025n

.meas tran vdout0_227ck110 FIND v(dout0_227) AT=60.025n

.meas tran vdout0_228ck110 FIND v(dout0_228) AT=60.025n

.meas tran vdout0_229ck110 FIND v(dout0_229) AT=60.025n

.meas tran vdout0_230ck110 FIND v(dout0_230) AT=60.025n

.meas tran vdout0_231ck110 FIND v(dout0_231) AT=60.025n

.meas tran vdout0_232ck110 FIND v(dout0_232) AT=60.025n

.meas tran vdout0_233ck110 FIND v(dout0_233) AT=60.025n

.meas tran vdout0_234ck110 FIND v(dout0_234) AT=60.025n

.meas tran vdout0_235ck110 FIND v(dout0_235) AT=60.025n

.meas tran vdout0_236ck110 FIND v(dout0_236) AT=60.025n

.meas tran vdout0_237ck110 FIND v(dout0_237) AT=60.025n

.meas tran vdout0_238ck110 FIND v(dout0_238) AT=60.025n

.meas tran vdout0_239ck110 FIND v(dout0_239) AT=60.025n

.meas tran vdout0_240ck110 FIND v(dout0_240) AT=60.025n

.meas tran vdout0_241ck110 FIND v(dout0_241) AT=60.025n

.meas tran vdout0_242ck110 FIND v(dout0_242) AT=60.025n

.meas tran vdout0_243ck110 FIND v(dout0_243) AT=60.025n

.meas tran vdout0_244ck110 FIND v(dout0_244) AT=60.025n

.meas tran vdout0_245ck110 FIND v(dout0_245) AT=60.025n

.meas tran vdout0_246ck110 FIND v(dout0_246) AT=60.025n

.meas tran vdout0_247ck110 FIND v(dout0_247) AT=60.025n

.meas tran vdout0_248ck110 FIND v(dout0_248) AT=60.025n

.meas tran vdout0_249ck110 FIND v(dout0_249) AT=60.025n

.meas tran vdout0_250ck110 FIND v(dout0_250) AT=60.025n

.meas tran vdout0_251ck110 FIND v(dout0_251) AT=60.025n

.meas tran vdout0_252ck110 FIND v(dout0_252) AT=60.025n

.meas tran vdout0_253ck110 FIND v(dout0_253) AT=60.025n

.meas tran vdout0_254ck110 FIND v(dout0_254) AT=60.025n

.meas tran vdout0_255ck110 FIND v(dout0_255) AT=60.025n

.meas tran vdout0_0ck120 FIND v(dout0_0) AT=65.025n

.meas tran vdout0_1ck120 FIND v(dout0_1) AT=65.025n

.meas tran vdout0_2ck120 FIND v(dout0_2) AT=65.025n

.meas tran vdout0_3ck120 FIND v(dout0_3) AT=65.025n

.meas tran vdout0_4ck120 FIND v(dout0_4) AT=65.025n

.meas tran vdout0_5ck120 FIND v(dout0_5) AT=65.025n

.meas tran vdout0_6ck120 FIND v(dout0_6) AT=65.025n

.meas tran vdout0_7ck120 FIND v(dout0_7) AT=65.025n

.meas tran vdout0_8ck120 FIND v(dout0_8) AT=65.025n

.meas tran vdout0_9ck120 FIND v(dout0_9) AT=65.025n

.meas tran vdout0_10ck120 FIND v(dout0_10) AT=65.025n

.meas tran vdout0_11ck120 FIND v(dout0_11) AT=65.025n

.meas tran vdout0_12ck120 FIND v(dout0_12) AT=65.025n

.meas tran vdout0_13ck120 FIND v(dout0_13) AT=65.025n

.meas tran vdout0_14ck120 FIND v(dout0_14) AT=65.025n

.meas tran vdout0_15ck120 FIND v(dout0_15) AT=65.025n

.meas tran vdout0_16ck120 FIND v(dout0_16) AT=65.025n

.meas tran vdout0_17ck120 FIND v(dout0_17) AT=65.025n

.meas tran vdout0_18ck120 FIND v(dout0_18) AT=65.025n

.meas tran vdout0_19ck120 FIND v(dout0_19) AT=65.025n

.meas tran vdout0_20ck120 FIND v(dout0_20) AT=65.025n

.meas tran vdout0_21ck120 FIND v(dout0_21) AT=65.025n

.meas tran vdout0_22ck120 FIND v(dout0_22) AT=65.025n

.meas tran vdout0_23ck120 FIND v(dout0_23) AT=65.025n

.meas tran vdout0_24ck120 FIND v(dout0_24) AT=65.025n

.meas tran vdout0_25ck120 FIND v(dout0_25) AT=65.025n

.meas tran vdout0_26ck120 FIND v(dout0_26) AT=65.025n

.meas tran vdout0_27ck120 FIND v(dout0_27) AT=65.025n

.meas tran vdout0_28ck120 FIND v(dout0_28) AT=65.025n

.meas tran vdout0_29ck120 FIND v(dout0_29) AT=65.025n

.meas tran vdout0_30ck120 FIND v(dout0_30) AT=65.025n

.meas tran vdout0_31ck120 FIND v(dout0_31) AT=65.025n

.meas tran vdout0_32ck120 FIND v(dout0_32) AT=65.025n

.meas tran vdout0_33ck120 FIND v(dout0_33) AT=65.025n

.meas tran vdout0_34ck120 FIND v(dout0_34) AT=65.025n

.meas tran vdout0_35ck120 FIND v(dout0_35) AT=65.025n

.meas tran vdout0_36ck120 FIND v(dout0_36) AT=65.025n

.meas tran vdout0_37ck120 FIND v(dout0_37) AT=65.025n

.meas tran vdout0_38ck120 FIND v(dout0_38) AT=65.025n

.meas tran vdout0_39ck120 FIND v(dout0_39) AT=65.025n

.meas tran vdout0_40ck120 FIND v(dout0_40) AT=65.025n

.meas tran vdout0_41ck120 FIND v(dout0_41) AT=65.025n

.meas tran vdout0_42ck120 FIND v(dout0_42) AT=65.025n

.meas tran vdout0_43ck120 FIND v(dout0_43) AT=65.025n

.meas tran vdout0_44ck120 FIND v(dout0_44) AT=65.025n

.meas tran vdout0_45ck120 FIND v(dout0_45) AT=65.025n

.meas tran vdout0_46ck120 FIND v(dout0_46) AT=65.025n

.meas tran vdout0_47ck120 FIND v(dout0_47) AT=65.025n

.meas tran vdout0_48ck120 FIND v(dout0_48) AT=65.025n

.meas tran vdout0_49ck120 FIND v(dout0_49) AT=65.025n

.meas tran vdout0_50ck120 FIND v(dout0_50) AT=65.025n

.meas tran vdout0_51ck120 FIND v(dout0_51) AT=65.025n

.meas tran vdout0_52ck120 FIND v(dout0_52) AT=65.025n

.meas tran vdout0_53ck120 FIND v(dout0_53) AT=65.025n

.meas tran vdout0_54ck120 FIND v(dout0_54) AT=65.025n

.meas tran vdout0_55ck120 FIND v(dout0_55) AT=65.025n

.meas tran vdout0_56ck120 FIND v(dout0_56) AT=65.025n

.meas tran vdout0_57ck120 FIND v(dout0_57) AT=65.025n

.meas tran vdout0_58ck120 FIND v(dout0_58) AT=65.025n

.meas tran vdout0_59ck120 FIND v(dout0_59) AT=65.025n

.meas tran vdout0_60ck120 FIND v(dout0_60) AT=65.025n

.meas tran vdout0_61ck120 FIND v(dout0_61) AT=65.025n

.meas tran vdout0_62ck120 FIND v(dout0_62) AT=65.025n

.meas tran vdout0_63ck120 FIND v(dout0_63) AT=65.025n

.meas tran vdout0_64ck120 FIND v(dout0_64) AT=65.025n

.meas tran vdout0_65ck120 FIND v(dout0_65) AT=65.025n

.meas tran vdout0_66ck120 FIND v(dout0_66) AT=65.025n

.meas tran vdout0_67ck120 FIND v(dout0_67) AT=65.025n

.meas tran vdout0_68ck120 FIND v(dout0_68) AT=65.025n

.meas tran vdout0_69ck120 FIND v(dout0_69) AT=65.025n

.meas tran vdout0_70ck120 FIND v(dout0_70) AT=65.025n

.meas tran vdout0_71ck120 FIND v(dout0_71) AT=65.025n

.meas tran vdout0_72ck120 FIND v(dout0_72) AT=65.025n

.meas tran vdout0_73ck120 FIND v(dout0_73) AT=65.025n

.meas tran vdout0_74ck120 FIND v(dout0_74) AT=65.025n

.meas tran vdout0_75ck120 FIND v(dout0_75) AT=65.025n

.meas tran vdout0_76ck120 FIND v(dout0_76) AT=65.025n

.meas tran vdout0_77ck120 FIND v(dout0_77) AT=65.025n

.meas tran vdout0_78ck120 FIND v(dout0_78) AT=65.025n

.meas tran vdout0_79ck120 FIND v(dout0_79) AT=65.025n

.meas tran vdout0_80ck120 FIND v(dout0_80) AT=65.025n

.meas tran vdout0_81ck120 FIND v(dout0_81) AT=65.025n

.meas tran vdout0_82ck120 FIND v(dout0_82) AT=65.025n

.meas tran vdout0_83ck120 FIND v(dout0_83) AT=65.025n

.meas tran vdout0_84ck120 FIND v(dout0_84) AT=65.025n

.meas tran vdout0_85ck120 FIND v(dout0_85) AT=65.025n

.meas tran vdout0_86ck120 FIND v(dout0_86) AT=65.025n

.meas tran vdout0_87ck120 FIND v(dout0_87) AT=65.025n

.meas tran vdout0_88ck120 FIND v(dout0_88) AT=65.025n

.meas tran vdout0_89ck120 FIND v(dout0_89) AT=65.025n

.meas tran vdout0_90ck120 FIND v(dout0_90) AT=65.025n

.meas tran vdout0_91ck120 FIND v(dout0_91) AT=65.025n

.meas tran vdout0_92ck120 FIND v(dout0_92) AT=65.025n

.meas tran vdout0_93ck120 FIND v(dout0_93) AT=65.025n

.meas tran vdout0_94ck120 FIND v(dout0_94) AT=65.025n

.meas tran vdout0_95ck120 FIND v(dout0_95) AT=65.025n

.meas tran vdout0_96ck120 FIND v(dout0_96) AT=65.025n

.meas tran vdout0_97ck120 FIND v(dout0_97) AT=65.025n

.meas tran vdout0_98ck120 FIND v(dout0_98) AT=65.025n

.meas tran vdout0_99ck120 FIND v(dout0_99) AT=65.025n

.meas tran vdout0_100ck120 FIND v(dout0_100) AT=65.025n

.meas tran vdout0_101ck120 FIND v(dout0_101) AT=65.025n

.meas tran vdout0_102ck120 FIND v(dout0_102) AT=65.025n

.meas tran vdout0_103ck120 FIND v(dout0_103) AT=65.025n

.meas tran vdout0_104ck120 FIND v(dout0_104) AT=65.025n

.meas tran vdout0_105ck120 FIND v(dout0_105) AT=65.025n

.meas tran vdout0_106ck120 FIND v(dout0_106) AT=65.025n

.meas tran vdout0_107ck120 FIND v(dout0_107) AT=65.025n

.meas tran vdout0_108ck120 FIND v(dout0_108) AT=65.025n

.meas tran vdout0_109ck120 FIND v(dout0_109) AT=65.025n

.meas tran vdout0_110ck120 FIND v(dout0_110) AT=65.025n

.meas tran vdout0_111ck120 FIND v(dout0_111) AT=65.025n

.meas tran vdout0_112ck120 FIND v(dout0_112) AT=65.025n

.meas tran vdout0_113ck120 FIND v(dout0_113) AT=65.025n

.meas tran vdout0_114ck120 FIND v(dout0_114) AT=65.025n

.meas tran vdout0_115ck120 FIND v(dout0_115) AT=65.025n

.meas tran vdout0_116ck120 FIND v(dout0_116) AT=65.025n

.meas tran vdout0_117ck120 FIND v(dout0_117) AT=65.025n

.meas tran vdout0_118ck120 FIND v(dout0_118) AT=65.025n

.meas tran vdout0_119ck120 FIND v(dout0_119) AT=65.025n

.meas tran vdout0_120ck120 FIND v(dout0_120) AT=65.025n

.meas tran vdout0_121ck120 FIND v(dout0_121) AT=65.025n

.meas tran vdout0_122ck120 FIND v(dout0_122) AT=65.025n

.meas tran vdout0_123ck120 FIND v(dout0_123) AT=65.025n

.meas tran vdout0_124ck120 FIND v(dout0_124) AT=65.025n

.meas tran vdout0_125ck120 FIND v(dout0_125) AT=65.025n

.meas tran vdout0_126ck120 FIND v(dout0_126) AT=65.025n

.meas tran vdout0_127ck120 FIND v(dout0_127) AT=65.025n

.meas tran vdout0_128ck120 FIND v(dout0_128) AT=65.025n

.meas tran vdout0_129ck120 FIND v(dout0_129) AT=65.025n

.meas tran vdout0_130ck120 FIND v(dout0_130) AT=65.025n

.meas tran vdout0_131ck120 FIND v(dout0_131) AT=65.025n

.meas tran vdout0_132ck120 FIND v(dout0_132) AT=65.025n

.meas tran vdout0_133ck120 FIND v(dout0_133) AT=65.025n

.meas tran vdout0_134ck120 FIND v(dout0_134) AT=65.025n

.meas tran vdout0_135ck120 FIND v(dout0_135) AT=65.025n

.meas tran vdout0_136ck120 FIND v(dout0_136) AT=65.025n

.meas tran vdout0_137ck120 FIND v(dout0_137) AT=65.025n

.meas tran vdout0_138ck120 FIND v(dout0_138) AT=65.025n

.meas tran vdout0_139ck120 FIND v(dout0_139) AT=65.025n

.meas tran vdout0_140ck120 FIND v(dout0_140) AT=65.025n

.meas tran vdout0_141ck120 FIND v(dout0_141) AT=65.025n

.meas tran vdout0_142ck120 FIND v(dout0_142) AT=65.025n

.meas tran vdout0_143ck120 FIND v(dout0_143) AT=65.025n

.meas tran vdout0_144ck120 FIND v(dout0_144) AT=65.025n

.meas tran vdout0_145ck120 FIND v(dout0_145) AT=65.025n

.meas tran vdout0_146ck120 FIND v(dout0_146) AT=65.025n

.meas tran vdout0_147ck120 FIND v(dout0_147) AT=65.025n

.meas tran vdout0_148ck120 FIND v(dout0_148) AT=65.025n

.meas tran vdout0_149ck120 FIND v(dout0_149) AT=65.025n

.meas tran vdout0_150ck120 FIND v(dout0_150) AT=65.025n

.meas tran vdout0_151ck120 FIND v(dout0_151) AT=65.025n

.meas tran vdout0_152ck120 FIND v(dout0_152) AT=65.025n

.meas tran vdout0_153ck120 FIND v(dout0_153) AT=65.025n

.meas tran vdout0_154ck120 FIND v(dout0_154) AT=65.025n

.meas tran vdout0_155ck120 FIND v(dout0_155) AT=65.025n

.meas tran vdout0_156ck120 FIND v(dout0_156) AT=65.025n

.meas tran vdout0_157ck120 FIND v(dout0_157) AT=65.025n

.meas tran vdout0_158ck120 FIND v(dout0_158) AT=65.025n

.meas tran vdout0_159ck120 FIND v(dout0_159) AT=65.025n

.meas tran vdout0_160ck120 FIND v(dout0_160) AT=65.025n

.meas tran vdout0_161ck120 FIND v(dout0_161) AT=65.025n

.meas tran vdout0_162ck120 FIND v(dout0_162) AT=65.025n

.meas tran vdout0_163ck120 FIND v(dout0_163) AT=65.025n

.meas tran vdout0_164ck120 FIND v(dout0_164) AT=65.025n

.meas tran vdout0_165ck120 FIND v(dout0_165) AT=65.025n

.meas tran vdout0_166ck120 FIND v(dout0_166) AT=65.025n

.meas tran vdout0_167ck120 FIND v(dout0_167) AT=65.025n

.meas tran vdout0_168ck120 FIND v(dout0_168) AT=65.025n

.meas tran vdout0_169ck120 FIND v(dout0_169) AT=65.025n

.meas tran vdout0_170ck120 FIND v(dout0_170) AT=65.025n

.meas tran vdout0_171ck120 FIND v(dout0_171) AT=65.025n

.meas tran vdout0_172ck120 FIND v(dout0_172) AT=65.025n

.meas tran vdout0_173ck120 FIND v(dout0_173) AT=65.025n

.meas tran vdout0_174ck120 FIND v(dout0_174) AT=65.025n

.meas tran vdout0_175ck120 FIND v(dout0_175) AT=65.025n

.meas tran vdout0_176ck120 FIND v(dout0_176) AT=65.025n

.meas tran vdout0_177ck120 FIND v(dout0_177) AT=65.025n

.meas tran vdout0_178ck120 FIND v(dout0_178) AT=65.025n

.meas tran vdout0_179ck120 FIND v(dout0_179) AT=65.025n

.meas tran vdout0_180ck120 FIND v(dout0_180) AT=65.025n

.meas tran vdout0_181ck120 FIND v(dout0_181) AT=65.025n

.meas tran vdout0_182ck120 FIND v(dout0_182) AT=65.025n

.meas tran vdout0_183ck120 FIND v(dout0_183) AT=65.025n

.meas tran vdout0_184ck120 FIND v(dout0_184) AT=65.025n

.meas tran vdout0_185ck120 FIND v(dout0_185) AT=65.025n

.meas tran vdout0_186ck120 FIND v(dout0_186) AT=65.025n

.meas tran vdout0_187ck120 FIND v(dout0_187) AT=65.025n

.meas tran vdout0_188ck120 FIND v(dout0_188) AT=65.025n

.meas tran vdout0_189ck120 FIND v(dout0_189) AT=65.025n

.meas tran vdout0_190ck120 FIND v(dout0_190) AT=65.025n

.meas tran vdout0_191ck120 FIND v(dout0_191) AT=65.025n

.meas tran vdout0_192ck120 FIND v(dout0_192) AT=65.025n

.meas tran vdout0_193ck120 FIND v(dout0_193) AT=65.025n

.meas tran vdout0_194ck120 FIND v(dout0_194) AT=65.025n

.meas tran vdout0_195ck120 FIND v(dout0_195) AT=65.025n

.meas tran vdout0_196ck120 FIND v(dout0_196) AT=65.025n

.meas tran vdout0_197ck120 FIND v(dout0_197) AT=65.025n

.meas tran vdout0_198ck120 FIND v(dout0_198) AT=65.025n

.meas tran vdout0_199ck120 FIND v(dout0_199) AT=65.025n

.meas tran vdout0_200ck120 FIND v(dout0_200) AT=65.025n

.meas tran vdout0_201ck120 FIND v(dout0_201) AT=65.025n

.meas tran vdout0_202ck120 FIND v(dout0_202) AT=65.025n

.meas tran vdout0_203ck120 FIND v(dout0_203) AT=65.025n

.meas tran vdout0_204ck120 FIND v(dout0_204) AT=65.025n

.meas tran vdout0_205ck120 FIND v(dout0_205) AT=65.025n

.meas tran vdout0_206ck120 FIND v(dout0_206) AT=65.025n

.meas tran vdout0_207ck120 FIND v(dout0_207) AT=65.025n

.meas tran vdout0_208ck120 FIND v(dout0_208) AT=65.025n

.meas tran vdout0_209ck120 FIND v(dout0_209) AT=65.025n

.meas tran vdout0_210ck120 FIND v(dout0_210) AT=65.025n

.meas tran vdout0_211ck120 FIND v(dout0_211) AT=65.025n

.meas tran vdout0_212ck120 FIND v(dout0_212) AT=65.025n

.meas tran vdout0_213ck120 FIND v(dout0_213) AT=65.025n

.meas tran vdout0_214ck120 FIND v(dout0_214) AT=65.025n

.meas tran vdout0_215ck120 FIND v(dout0_215) AT=65.025n

.meas tran vdout0_216ck120 FIND v(dout0_216) AT=65.025n

.meas tran vdout0_217ck120 FIND v(dout0_217) AT=65.025n

.meas tran vdout0_218ck120 FIND v(dout0_218) AT=65.025n

.meas tran vdout0_219ck120 FIND v(dout0_219) AT=65.025n

.meas tran vdout0_220ck120 FIND v(dout0_220) AT=65.025n

.meas tran vdout0_221ck120 FIND v(dout0_221) AT=65.025n

.meas tran vdout0_222ck120 FIND v(dout0_222) AT=65.025n

.meas tran vdout0_223ck120 FIND v(dout0_223) AT=65.025n

.meas tran vdout0_224ck120 FIND v(dout0_224) AT=65.025n

.meas tran vdout0_225ck120 FIND v(dout0_225) AT=65.025n

.meas tran vdout0_226ck120 FIND v(dout0_226) AT=65.025n

.meas tran vdout0_227ck120 FIND v(dout0_227) AT=65.025n

.meas tran vdout0_228ck120 FIND v(dout0_228) AT=65.025n

.meas tran vdout0_229ck120 FIND v(dout0_229) AT=65.025n

.meas tran vdout0_230ck120 FIND v(dout0_230) AT=65.025n

.meas tran vdout0_231ck120 FIND v(dout0_231) AT=65.025n

.meas tran vdout0_232ck120 FIND v(dout0_232) AT=65.025n

.meas tran vdout0_233ck120 FIND v(dout0_233) AT=65.025n

.meas tran vdout0_234ck120 FIND v(dout0_234) AT=65.025n

.meas tran vdout0_235ck120 FIND v(dout0_235) AT=65.025n

.meas tran vdout0_236ck120 FIND v(dout0_236) AT=65.025n

.meas tran vdout0_237ck120 FIND v(dout0_237) AT=65.025n

.meas tran vdout0_238ck120 FIND v(dout0_238) AT=65.025n

.meas tran vdout0_239ck120 FIND v(dout0_239) AT=65.025n

.meas tran vdout0_240ck120 FIND v(dout0_240) AT=65.025n

.meas tran vdout0_241ck120 FIND v(dout0_241) AT=65.025n

.meas tran vdout0_242ck120 FIND v(dout0_242) AT=65.025n

.meas tran vdout0_243ck120 FIND v(dout0_243) AT=65.025n

.meas tran vdout0_244ck120 FIND v(dout0_244) AT=65.025n

.meas tran vdout0_245ck120 FIND v(dout0_245) AT=65.025n

.meas tran vdout0_246ck120 FIND v(dout0_246) AT=65.025n

.meas tran vdout0_247ck120 FIND v(dout0_247) AT=65.025n

.meas tran vdout0_248ck120 FIND v(dout0_248) AT=65.025n

.meas tran vdout0_249ck120 FIND v(dout0_249) AT=65.025n

.meas tran vdout0_250ck120 FIND v(dout0_250) AT=65.025n

.meas tran vdout0_251ck120 FIND v(dout0_251) AT=65.025n

.meas tran vdout0_252ck120 FIND v(dout0_252) AT=65.025n

.meas tran vdout0_253ck120 FIND v(dout0_253) AT=65.025n

.meas tran vdout0_254ck120 FIND v(dout0_254) AT=65.025n

.meas tran vdout0_255ck120 FIND v(dout0_255) AT=65.025n

.meas tran vdout0_0ck130 FIND v(dout0_0) AT=70.025n

.meas tran vdout0_1ck130 FIND v(dout0_1) AT=70.025n

.meas tran vdout0_2ck130 FIND v(dout0_2) AT=70.025n

.meas tran vdout0_3ck130 FIND v(dout0_3) AT=70.025n

.meas tran vdout0_4ck130 FIND v(dout0_4) AT=70.025n

.meas tran vdout0_5ck130 FIND v(dout0_5) AT=70.025n

.meas tran vdout0_6ck130 FIND v(dout0_6) AT=70.025n

.meas tran vdout0_7ck130 FIND v(dout0_7) AT=70.025n

.meas tran vdout0_8ck130 FIND v(dout0_8) AT=70.025n

.meas tran vdout0_9ck130 FIND v(dout0_9) AT=70.025n

.meas tran vdout0_10ck130 FIND v(dout0_10) AT=70.025n

.meas tran vdout0_11ck130 FIND v(dout0_11) AT=70.025n

.meas tran vdout0_12ck130 FIND v(dout0_12) AT=70.025n

.meas tran vdout0_13ck130 FIND v(dout0_13) AT=70.025n

.meas tran vdout0_14ck130 FIND v(dout0_14) AT=70.025n

.meas tran vdout0_15ck130 FIND v(dout0_15) AT=70.025n

.meas tran vdout0_16ck130 FIND v(dout0_16) AT=70.025n

.meas tran vdout0_17ck130 FIND v(dout0_17) AT=70.025n

.meas tran vdout0_18ck130 FIND v(dout0_18) AT=70.025n

.meas tran vdout0_19ck130 FIND v(dout0_19) AT=70.025n

.meas tran vdout0_20ck130 FIND v(dout0_20) AT=70.025n

.meas tran vdout0_21ck130 FIND v(dout0_21) AT=70.025n

.meas tran vdout0_22ck130 FIND v(dout0_22) AT=70.025n

.meas tran vdout0_23ck130 FIND v(dout0_23) AT=70.025n

.meas tran vdout0_24ck130 FIND v(dout0_24) AT=70.025n

.meas tran vdout0_25ck130 FIND v(dout0_25) AT=70.025n

.meas tran vdout0_26ck130 FIND v(dout0_26) AT=70.025n

.meas tran vdout0_27ck130 FIND v(dout0_27) AT=70.025n

.meas tran vdout0_28ck130 FIND v(dout0_28) AT=70.025n

.meas tran vdout0_29ck130 FIND v(dout0_29) AT=70.025n

.meas tran vdout0_30ck130 FIND v(dout0_30) AT=70.025n

.meas tran vdout0_31ck130 FIND v(dout0_31) AT=70.025n

.meas tran vdout0_32ck130 FIND v(dout0_32) AT=70.025n

.meas tran vdout0_33ck130 FIND v(dout0_33) AT=70.025n

.meas tran vdout0_34ck130 FIND v(dout0_34) AT=70.025n

.meas tran vdout0_35ck130 FIND v(dout0_35) AT=70.025n

.meas tran vdout0_36ck130 FIND v(dout0_36) AT=70.025n

.meas tran vdout0_37ck130 FIND v(dout0_37) AT=70.025n

.meas tran vdout0_38ck130 FIND v(dout0_38) AT=70.025n

.meas tran vdout0_39ck130 FIND v(dout0_39) AT=70.025n

.meas tran vdout0_40ck130 FIND v(dout0_40) AT=70.025n

.meas tran vdout0_41ck130 FIND v(dout0_41) AT=70.025n

.meas tran vdout0_42ck130 FIND v(dout0_42) AT=70.025n

.meas tran vdout0_43ck130 FIND v(dout0_43) AT=70.025n

.meas tran vdout0_44ck130 FIND v(dout0_44) AT=70.025n

.meas tran vdout0_45ck130 FIND v(dout0_45) AT=70.025n

.meas tran vdout0_46ck130 FIND v(dout0_46) AT=70.025n

.meas tran vdout0_47ck130 FIND v(dout0_47) AT=70.025n

.meas tran vdout0_48ck130 FIND v(dout0_48) AT=70.025n

.meas tran vdout0_49ck130 FIND v(dout0_49) AT=70.025n

.meas tran vdout0_50ck130 FIND v(dout0_50) AT=70.025n

.meas tran vdout0_51ck130 FIND v(dout0_51) AT=70.025n

.meas tran vdout0_52ck130 FIND v(dout0_52) AT=70.025n

.meas tran vdout0_53ck130 FIND v(dout0_53) AT=70.025n

.meas tran vdout0_54ck130 FIND v(dout0_54) AT=70.025n

.meas tran vdout0_55ck130 FIND v(dout0_55) AT=70.025n

.meas tran vdout0_56ck130 FIND v(dout0_56) AT=70.025n

.meas tran vdout0_57ck130 FIND v(dout0_57) AT=70.025n

.meas tran vdout0_58ck130 FIND v(dout0_58) AT=70.025n

.meas tran vdout0_59ck130 FIND v(dout0_59) AT=70.025n

.meas tran vdout0_60ck130 FIND v(dout0_60) AT=70.025n

.meas tran vdout0_61ck130 FIND v(dout0_61) AT=70.025n

.meas tran vdout0_62ck130 FIND v(dout0_62) AT=70.025n

.meas tran vdout0_63ck130 FIND v(dout0_63) AT=70.025n

.meas tran vdout0_64ck130 FIND v(dout0_64) AT=70.025n

.meas tran vdout0_65ck130 FIND v(dout0_65) AT=70.025n

.meas tran vdout0_66ck130 FIND v(dout0_66) AT=70.025n

.meas tran vdout0_67ck130 FIND v(dout0_67) AT=70.025n

.meas tran vdout0_68ck130 FIND v(dout0_68) AT=70.025n

.meas tran vdout0_69ck130 FIND v(dout0_69) AT=70.025n

.meas tran vdout0_70ck130 FIND v(dout0_70) AT=70.025n

.meas tran vdout0_71ck130 FIND v(dout0_71) AT=70.025n

.meas tran vdout0_72ck130 FIND v(dout0_72) AT=70.025n

.meas tran vdout0_73ck130 FIND v(dout0_73) AT=70.025n

.meas tran vdout0_74ck130 FIND v(dout0_74) AT=70.025n

.meas tran vdout0_75ck130 FIND v(dout0_75) AT=70.025n

.meas tran vdout0_76ck130 FIND v(dout0_76) AT=70.025n

.meas tran vdout0_77ck130 FIND v(dout0_77) AT=70.025n

.meas tran vdout0_78ck130 FIND v(dout0_78) AT=70.025n

.meas tran vdout0_79ck130 FIND v(dout0_79) AT=70.025n

.meas tran vdout0_80ck130 FIND v(dout0_80) AT=70.025n

.meas tran vdout0_81ck130 FIND v(dout0_81) AT=70.025n

.meas tran vdout0_82ck130 FIND v(dout0_82) AT=70.025n

.meas tran vdout0_83ck130 FIND v(dout0_83) AT=70.025n

.meas tran vdout0_84ck130 FIND v(dout0_84) AT=70.025n

.meas tran vdout0_85ck130 FIND v(dout0_85) AT=70.025n

.meas tran vdout0_86ck130 FIND v(dout0_86) AT=70.025n

.meas tran vdout0_87ck130 FIND v(dout0_87) AT=70.025n

.meas tran vdout0_88ck130 FIND v(dout0_88) AT=70.025n

.meas tran vdout0_89ck130 FIND v(dout0_89) AT=70.025n

.meas tran vdout0_90ck130 FIND v(dout0_90) AT=70.025n

.meas tran vdout0_91ck130 FIND v(dout0_91) AT=70.025n

.meas tran vdout0_92ck130 FIND v(dout0_92) AT=70.025n

.meas tran vdout0_93ck130 FIND v(dout0_93) AT=70.025n

.meas tran vdout0_94ck130 FIND v(dout0_94) AT=70.025n

.meas tran vdout0_95ck130 FIND v(dout0_95) AT=70.025n

.meas tran vdout0_96ck130 FIND v(dout0_96) AT=70.025n

.meas tran vdout0_97ck130 FIND v(dout0_97) AT=70.025n

.meas tran vdout0_98ck130 FIND v(dout0_98) AT=70.025n

.meas tran vdout0_99ck130 FIND v(dout0_99) AT=70.025n

.meas tran vdout0_100ck130 FIND v(dout0_100) AT=70.025n

.meas tran vdout0_101ck130 FIND v(dout0_101) AT=70.025n

.meas tran vdout0_102ck130 FIND v(dout0_102) AT=70.025n

.meas tran vdout0_103ck130 FIND v(dout0_103) AT=70.025n

.meas tran vdout0_104ck130 FIND v(dout0_104) AT=70.025n

.meas tran vdout0_105ck130 FIND v(dout0_105) AT=70.025n

.meas tran vdout0_106ck130 FIND v(dout0_106) AT=70.025n

.meas tran vdout0_107ck130 FIND v(dout0_107) AT=70.025n

.meas tran vdout0_108ck130 FIND v(dout0_108) AT=70.025n

.meas tran vdout0_109ck130 FIND v(dout0_109) AT=70.025n

.meas tran vdout0_110ck130 FIND v(dout0_110) AT=70.025n

.meas tran vdout0_111ck130 FIND v(dout0_111) AT=70.025n

.meas tran vdout0_112ck130 FIND v(dout0_112) AT=70.025n

.meas tran vdout0_113ck130 FIND v(dout0_113) AT=70.025n

.meas tran vdout0_114ck130 FIND v(dout0_114) AT=70.025n

.meas tran vdout0_115ck130 FIND v(dout0_115) AT=70.025n

.meas tran vdout0_116ck130 FIND v(dout0_116) AT=70.025n

.meas tran vdout0_117ck130 FIND v(dout0_117) AT=70.025n

.meas tran vdout0_118ck130 FIND v(dout0_118) AT=70.025n

.meas tran vdout0_119ck130 FIND v(dout0_119) AT=70.025n

.meas tran vdout0_120ck130 FIND v(dout0_120) AT=70.025n

.meas tran vdout0_121ck130 FIND v(dout0_121) AT=70.025n

.meas tran vdout0_122ck130 FIND v(dout0_122) AT=70.025n

.meas tran vdout0_123ck130 FIND v(dout0_123) AT=70.025n

.meas tran vdout0_124ck130 FIND v(dout0_124) AT=70.025n

.meas tran vdout0_125ck130 FIND v(dout0_125) AT=70.025n

.meas tran vdout0_126ck130 FIND v(dout0_126) AT=70.025n

.meas tran vdout0_127ck130 FIND v(dout0_127) AT=70.025n

.meas tran vdout0_128ck130 FIND v(dout0_128) AT=70.025n

.meas tran vdout0_129ck130 FIND v(dout0_129) AT=70.025n

.meas tran vdout0_130ck130 FIND v(dout0_130) AT=70.025n

.meas tran vdout0_131ck130 FIND v(dout0_131) AT=70.025n

.meas tran vdout0_132ck130 FIND v(dout0_132) AT=70.025n

.meas tran vdout0_133ck130 FIND v(dout0_133) AT=70.025n

.meas tran vdout0_134ck130 FIND v(dout0_134) AT=70.025n

.meas tran vdout0_135ck130 FIND v(dout0_135) AT=70.025n

.meas tran vdout0_136ck130 FIND v(dout0_136) AT=70.025n

.meas tran vdout0_137ck130 FIND v(dout0_137) AT=70.025n

.meas tran vdout0_138ck130 FIND v(dout0_138) AT=70.025n

.meas tran vdout0_139ck130 FIND v(dout0_139) AT=70.025n

.meas tran vdout0_140ck130 FIND v(dout0_140) AT=70.025n

.meas tran vdout0_141ck130 FIND v(dout0_141) AT=70.025n

.meas tran vdout0_142ck130 FIND v(dout0_142) AT=70.025n

.meas tran vdout0_143ck130 FIND v(dout0_143) AT=70.025n

.meas tran vdout0_144ck130 FIND v(dout0_144) AT=70.025n

.meas tran vdout0_145ck130 FIND v(dout0_145) AT=70.025n

.meas tran vdout0_146ck130 FIND v(dout0_146) AT=70.025n

.meas tran vdout0_147ck130 FIND v(dout0_147) AT=70.025n

.meas tran vdout0_148ck130 FIND v(dout0_148) AT=70.025n

.meas tran vdout0_149ck130 FIND v(dout0_149) AT=70.025n

.meas tran vdout0_150ck130 FIND v(dout0_150) AT=70.025n

.meas tran vdout0_151ck130 FIND v(dout0_151) AT=70.025n

.meas tran vdout0_152ck130 FIND v(dout0_152) AT=70.025n

.meas tran vdout0_153ck130 FIND v(dout0_153) AT=70.025n

.meas tran vdout0_154ck130 FIND v(dout0_154) AT=70.025n

.meas tran vdout0_155ck130 FIND v(dout0_155) AT=70.025n

.meas tran vdout0_156ck130 FIND v(dout0_156) AT=70.025n

.meas tran vdout0_157ck130 FIND v(dout0_157) AT=70.025n

.meas tran vdout0_158ck130 FIND v(dout0_158) AT=70.025n

.meas tran vdout0_159ck130 FIND v(dout0_159) AT=70.025n

.meas tran vdout0_160ck130 FIND v(dout0_160) AT=70.025n

.meas tran vdout0_161ck130 FIND v(dout0_161) AT=70.025n

.meas tran vdout0_162ck130 FIND v(dout0_162) AT=70.025n

.meas tran vdout0_163ck130 FIND v(dout0_163) AT=70.025n

.meas tran vdout0_164ck130 FIND v(dout0_164) AT=70.025n

.meas tran vdout0_165ck130 FIND v(dout0_165) AT=70.025n

.meas tran vdout0_166ck130 FIND v(dout0_166) AT=70.025n

.meas tran vdout0_167ck130 FIND v(dout0_167) AT=70.025n

.meas tran vdout0_168ck130 FIND v(dout0_168) AT=70.025n

.meas tran vdout0_169ck130 FIND v(dout0_169) AT=70.025n

.meas tran vdout0_170ck130 FIND v(dout0_170) AT=70.025n

.meas tran vdout0_171ck130 FIND v(dout0_171) AT=70.025n

.meas tran vdout0_172ck130 FIND v(dout0_172) AT=70.025n

.meas tran vdout0_173ck130 FIND v(dout0_173) AT=70.025n

.meas tran vdout0_174ck130 FIND v(dout0_174) AT=70.025n

.meas tran vdout0_175ck130 FIND v(dout0_175) AT=70.025n

.meas tran vdout0_176ck130 FIND v(dout0_176) AT=70.025n

.meas tran vdout0_177ck130 FIND v(dout0_177) AT=70.025n

.meas tran vdout0_178ck130 FIND v(dout0_178) AT=70.025n

.meas tran vdout0_179ck130 FIND v(dout0_179) AT=70.025n

.meas tran vdout0_180ck130 FIND v(dout0_180) AT=70.025n

.meas tran vdout0_181ck130 FIND v(dout0_181) AT=70.025n

.meas tran vdout0_182ck130 FIND v(dout0_182) AT=70.025n

.meas tran vdout0_183ck130 FIND v(dout0_183) AT=70.025n

.meas tran vdout0_184ck130 FIND v(dout0_184) AT=70.025n

.meas tran vdout0_185ck130 FIND v(dout0_185) AT=70.025n

.meas tran vdout0_186ck130 FIND v(dout0_186) AT=70.025n

.meas tran vdout0_187ck130 FIND v(dout0_187) AT=70.025n

.meas tran vdout0_188ck130 FIND v(dout0_188) AT=70.025n

.meas tran vdout0_189ck130 FIND v(dout0_189) AT=70.025n

.meas tran vdout0_190ck130 FIND v(dout0_190) AT=70.025n

.meas tran vdout0_191ck130 FIND v(dout0_191) AT=70.025n

.meas tran vdout0_192ck130 FIND v(dout0_192) AT=70.025n

.meas tran vdout0_193ck130 FIND v(dout0_193) AT=70.025n

.meas tran vdout0_194ck130 FIND v(dout0_194) AT=70.025n

.meas tran vdout0_195ck130 FIND v(dout0_195) AT=70.025n

.meas tran vdout0_196ck130 FIND v(dout0_196) AT=70.025n

.meas tran vdout0_197ck130 FIND v(dout0_197) AT=70.025n

.meas tran vdout0_198ck130 FIND v(dout0_198) AT=70.025n

.meas tran vdout0_199ck130 FIND v(dout0_199) AT=70.025n

.meas tran vdout0_200ck130 FIND v(dout0_200) AT=70.025n

.meas tran vdout0_201ck130 FIND v(dout0_201) AT=70.025n

.meas tran vdout0_202ck130 FIND v(dout0_202) AT=70.025n

.meas tran vdout0_203ck130 FIND v(dout0_203) AT=70.025n

.meas tran vdout0_204ck130 FIND v(dout0_204) AT=70.025n

.meas tran vdout0_205ck130 FIND v(dout0_205) AT=70.025n

.meas tran vdout0_206ck130 FIND v(dout0_206) AT=70.025n

.meas tran vdout0_207ck130 FIND v(dout0_207) AT=70.025n

.meas tran vdout0_208ck130 FIND v(dout0_208) AT=70.025n

.meas tran vdout0_209ck130 FIND v(dout0_209) AT=70.025n

.meas tran vdout0_210ck130 FIND v(dout0_210) AT=70.025n

.meas tran vdout0_211ck130 FIND v(dout0_211) AT=70.025n

.meas tran vdout0_212ck130 FIND v(dout0_212) AT=70.025n

.meas tran vdout0_213ck130 FIND v(dout0_213) AT=70.025n

.meas tran vdout0_214ck130 FIND v(dout0_214) AT=70.025n

.meas tran vdout0_215ck130 FIND v(dout0_215) AT=70.025n

.meas tran vdout0_216ck130 FIND v(dout0_216) AT=70.025n

.meas tran vdout0_217ck130 FIND v(dout0_217) AT=70.025n

.meas tran vdout0_218ck130 FIND v(dout0_218) AT=70.025n

.meas tran vdout0_219ck130 FIND v(dout0_219) AT=70.025n

.meas tran vdout0_220ck130 FIND v(dout0_220) AT=70.025n

.meas tran vdout0_221ck130 FIND v(dout0_221) AT=70.025n

.meas tran vdout0_222ck130 FIND v(dout0_222) AT=70.025n

.meas tran vdout0_223ck130 FIND v(dout0_223) AT=70.025n

.meas tran vdout0_224ck130 FIND v(dout0_224) AT=70.025n

.meas tran vdout0_225ck130 FIND v(dout0_225) AT=70.025n

.meas tran vdout0_226ck130 FIND v(dout0_226) AT=70.025n

.meas tran vdout0_227ck130 FIND v(dout0_227) AT=70.025n

.meas tran vdout0_228ck130 FIND v(dout0_228) AT=70.025n

.meas tran vdout0_229ck130 FIND v(dout0_229) AT=70.025n

.meas tran vdout0_230ck130 FIND v(dout0_230) AT=70.025n

.meas tran vdout0_231ck130 FIND v(dout0_231) AT=70.025n

.meas tran vdout0_232ck130 FIND v(dout0_232) AT=70.025n

.meas tran vdout0_233ck130 FIND v(dout0_233) AT=70.025n

.meas tran vdout0_234ck130 FIND v(dout0_234) AT=70.025n

.meas tran vdout0_235ck130 FIND v(dout0_235) AT=70.025n

.meas tran vdout0_236ck130 FIND v(dout0_236) AT=70.025n

.meas tran vdout0_237ck130 FIND v(dout0_237) AT=70.025n

.meas tran vdout0_238ck130 FIND v(dout0_238) AT=70.025n

.meas tran vdout0_239ck130 FIND v(dout0_239) AT=70.025n

.meas tran vdout0_240ck130 FIND v(dout0_240) AT=70.025n

.meas tran vdout0_241ck130 FIND v(dout0_241) AT=70.025n

.meas tran vdout0_242ck130 FIND v(dout0_242) AT=70.025n

.meas tran vdout0_243ck130 FIND v(dout0_243) AT=70.025n

.meas tran vdout0_244ck130 FIND v(dout0_244) AT=70.025n

.meas tran vdout0_245ck130 FIND v(dout0_245) AT=70.025n

.meas tran vdout0_246ck130 FIND v(dout0_246) AT=70.025n

.meas tran vdout0_247ck130 FIND v(dout0_247) AT=70.025n

.meas tran vdout0_248ck130 FIND v(dout0_248) AT=70.025n

.meas tran vdout0_249ck130 FIND v(dout0_249) AT=70.025n

.meas tran vdout0_250ck130 FIND v(dout0_250) AT=70.025n

.meas tran vdout0_251ck130 FIND v(dout0_251) AT=70.025n

.meas tran vdout0_252ck130 FIND v(dout0_252) AT=70.025n

.meas tran vdout0_253ck130 FIND v(dout0_253) AT=70.025n

.meas tran vdout0_254ck130 FIND v(dout0_254) AT=70.025n

.meas tran vdout0_255ck130 FIND v(dout0_255) AT=70.025n

.meas tran vdout0_0ck140 FIND v(dout0_0) AT=75.025n

.meas tran vdout0_1ck140 FIND v(dout0_1) AT=75.025n

.meas tran vdout0_2ck140 FIND v(dout0_2) AT=75.025n

.meas tran vdout0_3ck140 FIND v(dout0_3) AT=75.025n

.meas tran vdout0_4ck140 FIND v(dout0_4) AT=75.025n

.meas tran vdout0_5ck140 FIND v(dout0_5) AT=75.025n

.meas tran vdout0_6ck140 FIND v(dout0_6) AT=75.025n

.meas tran vdout0_7ck140 FIND v(dout0_7) AT=75.025n

.meas tran vdout0_8ck140 FIND v(dout0_8) AT=75.025n

.meas tran vdout0_9ck140 FIND v(dout0_9) AT=75.025n

.meas tran vdout0_10ck140 FIND v(dout0_10) AT=75.025n

.meas tran vdout0_11ck140 FIND v(dout0_11) AT=75.025n

.meas tran vdout0_12ck140 FIND v(dout0_12) AT=75.025n

.meas tran vdout0_13ck140 FIND v(dout0_13) AT=75.025n

.meas tran vdout0_14ck140 FIND v(dout0_14) AT=75.025n

.meas tran vdout0_15ck140 FIND v(dout0_15) AT=75.025n

.meas tran vdout0_16ck140 FIND v(dout0_16) AT=75.025n

.meas tran vdout0_17ck140 FIND v(dout0_17) AT=75.025n

.meas tran vdout0_18ck140 FIND v(dout0_18) AT=75.025n

.meas tran vdout0_19ck140 FIND v(dout0_19) AT=75.025n

.meas tran vdout0_20ck140 FIND v(dout0_20) AT=75.025n

.meas tran vdout0_21ck140 FIND v(dout0_21) AT=75.025n

.meas tran vdout0_22ck140 FIND v(dout0_22) AT=75.025n

.meas tran vdout0_23ck140 FIND v(dout0_23) AT=75.025n

.meas tran vdout0_24ck140 FIND v(dout0_24) AT=75.025n

.meas tran vdout0_25ck140 FIND v(dout0_25) AT=75.025n

.meas tran vdout0_26ck140 FIND v(dout0_26) AT=75.025n

.meas tran vdout0_27ck140 FIND v(dout0_27) AT=75.025n

.meas tran vdout0_28ck140 FIND v(dout0_28) AT=75.025n

.meas tran vdout0_29ck140 FIND v(dout0_29) AT=75.025n

.meas tran vdout0_30ck140 FIND v(dout0_30) AT=75.025n

.meas tran vdout0_31ck140 FIND v(dout0_31) AT=75.025n

.meas tran vdout0_32ck140 FIND v(dout0_32) AT=75.025n

.meas tran vdout0_33ck140 FIND v(dout0_33) AT=75.025n

.meas tran vdout0_34ck140 FIND v(dout0_34) AT=75.025n

.meas tran vdout0_35ck140 FIND v(dout0_35) AT=75.025n

.meas tran vdout0_36ck140 FIND v(dout0_36) AT=75.025n

.meas tran vdout0_37ck140 FIND v(dout0_37) AT=75.025n

.meas tran vdout0_38ck140 FIND v(dout0_38) AT=75.025n

.meas tran vdout0_39ck140 FIND v(dout0_39) AT=75.025n

.meas tran vdout0_40ck140 FIND v(dout0_40) AT=75.025n

.meas tran vdout0_41ck140 FIND v(dout0_41) AT=75.025n

.meas tran vdout0_42ck140 FIND v(dout0_42) AT=75.025n

.meas tran vdout0_43ck140 FIND v(dout0_43) AT=75.025n

.meas tran vdout0_44ck140 FIND v(dout0_44) AT=75.025n

.meas tran vdout0_45ck140 FIND v(dout0_45) AT=75.025n

.meas tran vdout0_46ck140 FIND v(dout0_46) AT=75.025n

.meas tran vdout0_47ck140 FIND v(dout0_47) AT=75.025n

.meas tran vdout0_48ck140 FIND v(dout0_48) AT=75.025n

.meas tran vdout0_49ck140 FIND v(dout0_49) AT=75.025n

.meas tran vdout0_50ck140 FIND v(dout0_50) AT=75.025n

.meas tran vdout0_51ck140 FIND v(dout0_51) AT=75.025n

.meas tran vdout0_52ck140 FIND v(dout0_52) AT=75.025n

.meas tran vdout0_53ck140 FIND v(dout0_53) AT=75.025n

.meas tran vdout0_54ck140 FIND v(dout0_54) AT=75.025n

.meas tran vdout0_55ck140 FIND v(dout0_55) AT=75.025n

.meas tran vdout0_56ck140 FIND v(dout0_56) AT=75.025n

.meas tran vdout0_57ck140 FIND v(dout0_57) AT=75.025n

.meas tran vdout0_58ck140 FIND v(dout0_58) AT=75.025n

.meas tran vdout0_59ck140 FIND v(dout0_59) AT=75.025n

.meas tran vdout0_60ck140 FIND v(dout0_60) AT=75.025n

.meas tran vdout0_61ck140 FIND v(dout0_61) AT=75.025n

.meas tran vdout0_62ck140 FIND v(dout0_62) AT=75.025n

.meas tran vdout0_63ck140 FIND v(dout0_63) AT=75.025n

.meas tran vdout0_64ck140 FIND v(dout0_64) AT=75.025n

.meas tran vdout0_65ck140 FIND v(dout0_65) AT=75.025n

.meas tran vdout0_66ck140 FIND v(dout0_66) AT=75.025n

.meas tran vdout0_67ck140 FIND v(dout0_67) AT=75.025n

.meas tran vdout0_68ck140 FIND v(dout0_68) AT=75.025n

.meas tran vdout0_69ck140 FIND v(dout0_69) AT=75.025n

.meas tran vdout0_70ck140 FIND v(dout0_70) AT=75.025n

.meas tran vdout0_71ck140 FIND v(dout0_71) AT=75.025n

.meas tran vdout0_72ck140 FIND v(dout0_72) AT=75.025n

.meas tran vdout0_73ck140 FIND v(dout0_73) AT=75.025n

.meas tran vdout0_74ck140 FIND v(dout0_74) AT=75.025n

.meas tran vdout0_75ck140 FIND v(dout0_75) AT=75.025n

.meas tran vdout0_76ck140 FIND v(dout0_76) AT=75.025n

.meas tran vdout0_77ck140 FIND v(dout0_77) AT=75.025n

.meas tran vdout0_78ck140 FIND v(dout0_78) AT=75.025n

.meas tran vdout0_79ck140 FIND v(dout0_79) AT=75.025n

.meas tran vdout0_80ck140 FIND v(dout0_80) AT=75.025n

.meas tran vdout0_81ck140 FIND v(dout0_81) AT=75.025n

.meas tran vdout0_82ck140 FIND v(dout0_82) AT=75.025n

.meas tran vdout0_83ck140 FIND v(dout0_83) AT=75.025n

.meas tran vdout0_84ck140 FIND v(dout0_84) AT=75.025n

.meas tran vdout0_85ck140 FIND v(dout0_85) AT=75.025n

.meas tran vdout0_86ck140 FIND v(dout0_86) AT=75.025n

.meas tran vdout0_87ck140 FIND v(dout0_87) AT=75.025n

.meas tran vdout0_88ck140 FIND v(dout0_88) AT=75.025n

.meas tran vdout0_89ck140 FIND v(dout0_89) AT=75.025n

.meas tran vdout0_90ck140 FIND v(dout0_90) AT=75.025n

.meas tran vdout0_91ck140 FIND v(dout0_91) AT=75.025n

.meas tran vdout0_92ck140 FIND v(dout0_92) AT=75.025n

.meas tran vdout0_93ck140 FIND v(dout0_93) AT=75.025n

.meas tran vdout0_94ck140 FIND v(dout0_94) AT=75.025n

.meas tran vdout0_95ck140 FIND v(dout0_95) AT=75.025n

.meas tran vdout0_96ck140 FIND v(dout0_96) AT=75.025n

.meas tran vdout0_97ck140 FIND v(dout0_97) AT=75.025n

.meas tran vdout0_98ck140 FIND v(dout0_98) AT=75.025n

.meas tran vdout0_99ck140 FIND v(dout0_99) AT=75.025n

.meas tran vdout0_100ck140 FIND v(dout0_100) AT=75.025n

.meas tran vdout0_101ck140 FIND v(dout0_101) AT=75.025n

.meas tran vdout0_102ck140 FIND v(dout0_102) AT=75.025n

.meas tran vdout0_103ck140 FIND v(dout0_103) AT=75.025n

.meas tran vdout0_104ck140 FIND v(dout0_104) AT=75.025n

.meas tran vdout0_105ck140 FIND v(dout0_105) AT=75.025n

.meas tran vdout0_106ck140 FIND v(dout0_106) AT=75.025n

.meas tran vdout0_107ck140 FIND v(dout0_107) AT=75.025n

.meas tran vdout0_108ck140 FIND v(dout0_108) AT=75.025n

.meas tran vdout0_109ck140 FIND v(dout0_109) AT=75.025n

.meas tran vdout0_110ck140 FIND v(dout0_110) AT=75.025n

.meas tran vdout0_111ck140 FIND v(dout0_111) AT=75.025n

.meas tran vdout0_112ck140 FIND v(dout0_112) AT=75.025n

.meas tran vdout0_113ck140 FIND v(dout0_113) AT=75.025n

.meas tran vdout0_114ck140 FIND v(dout0_114) AT=75.025n

.meas tran vdout0_115ck140 FIND v(dout0_115) AT=75.025n

.meas tran vdout0_116ck140 FIND v(dout0_116) AT=75.025n

.meas tran vdout0_117ck140 FIND v(dout0_117) AT=75.025n

.meas tran vdout0_118ck140 FIND v(dout0_118) AT=75.025n

.meas tran vdout0_119ck140 FIND v(dout0_119) AT=75.025n

.meas tran vdout0_120ck140 FIND v(dout0_120) AT=75.025n

.meas tran vdout0_121ck140 FIND v(dout0_121) AT=75.025n

.meas tran vdout0_122ck140 FIND v(dout0_122) AT=75.025n

.meas tran vdout0_123ck140 FIND v(dout0_123) AT=75.025n

.meas tran vdout0_124ck140 FIND v(dout0_124) AT=75.025n

.meas tran vdout0_125ck140 FIND v(dout0_125) AT=75.025n

.meas tran vdout0_126ck140 FIND v(dout0_126) AT=75.025n

.meas tran vdout0_127ck140 FIND v(dout0_127) AT=75.025n

.meas tran vdout0_128ck140 FIND v(dout0_128) AT=75.025n

.meas tran vdout0_129ck140 FIND v(dout0_129) AT=75.025n

.meas tran vdout0_130ck140 FIND v(dout0_130) AT=75.025n

.meas tran vdout0_131ck140 FIND v(dout0_131) AT=75.025n

.meas tran vdout0_132ck140 FIND v(dout0_132) AT=75.025n

.meas tran vdout0_133ck140 FIND v(dout0_133) AT=75.025n

.meas tran vdout0_134ck140 FIND v(dout0_134) AT=75.025n

.meas tran vdout0_135ck140 FIND v(dout0_135) AT=75.025n

.meas tran vdout0_136ck140 FIND v(dout0_136) AT=75.025n

.meas tran vdout0_137ck140 FIND v(dout0_137) AT=75.025n

.meas tran vdout0_138ck140 FIND v(dout0_138) AT=75.025n

.meas tran vdout0_139ck140 FIND v(dout0_139) AT=75.025n

.meas tran vdout0_140ck140 FIND v(dout0_140) AT=75.025n

.meas tran vdout0_141ck140 FIND v(dout0_141) AT=75.025n

.meas tran vdout0_142ck140 FIND v(dout0_142) AT=75.025n

.meas tran vdout0_143ck140 FIND v(dout0_143) AT=75.025n

.meas tran vdout0_144ck140 FIND v(dout0_144) AT=75.025n

.meas tran vdout0_145ck140 FIND v(dout0_145) AT=75.025n

.meas tran vdout0_146ck140 FIND v(dout0_146) AT=75.025n

.meas tran vdout0_147ck140 FIND v(dout0_147) AT=75.025n

.meas tran vdout0_148ck140 FIND v(dout0_148) AT=75.025n

.meas tran vdout0_149ck140 FIND v(dout0_149) AT=75.025n

.meas tran vdout0_150ck140 FIND v(dout0_150) AT=75.025n

.meas tran vdout0_151ck140 FIND v(dout0_151) AT=75.025n

.meas tran vdout0_152ck140 FIND v(dout0_152) AT=75.025n

.meas tran vdout0_153ck140 FIND v(dout0_153) AT=75.025n

.meas tran vdout0_154ck140 FIND v(dout0_154) AT=75.025n

.meas tran vdout0_155ck140 FIND v(dout0_155) AT=75.025n

.meas tran vdout0_156ck140 FIND v(dout0_156) AT=75.025n

.meas tran vdout0_157ck140 FIND v(dout0_157) AT=75.025n

.meas tran vdout0_158ck140 FIND v(dout0_158) AT=75.025n

.meas tran vdout0_159ck140 FIND v(dout0_159) AT=75.025n

.meas tran vdout0_160ck140 FIND v(dout0_160) AT=75.025n

.meas tran vdout0_161ck140 FIND v(dout0_161) AT=75.025n

.meas tran vdout0_162ck140 FIND v(dout0_162) AT=75.025n

.meas tran vdout0_163ck140 FIND v(dout0_163) AT=75.025n

.meas tran vdout0_164ck140 FIND v(dout0_164) AT=75.025n

.meas tran vdout0_165ck140 FIND v(dout0_165) AT=75.025n

.meas tran vdout0_166ck140 FIND v(dout0_166) AT=75.025n

.meas tran vdout0_167ck140 FIND v(dout0_167) AT=75.025n

.meas tran vdout0_168ck140 FIND v(dout0_168) AT=75.025n

.meas tran vdout0_169ck140 FIND v(dout0_169) AT=75.025n

.meas tran vdout0_170ck140 FIND v(dout0_170) AT=75.025n

.meas tran vdout0_171ck140 FIND v(dout0_171) AT=75.025n

.meas tran vdout0_172ck140 FIND v(dout0_172) AT=75.025n

.meas tran vdout0_173ck140 FIND v(dout0_173) AT=75.025n

.meas tran vdout0_174ck140 FIND v(dout0_174) AT=75.025n

.meas tran vdout0_175ck140 FIND v(dout0_175) AT=75.025n

.meas tran vdout0_176ck140 FIND v(dout0_176) AT=75.025n

.meas tran vdout0_177ck140 FIND v(dout0_177) AT=75.025n

.meas tran vdout0_178ck140 FIND v(dout0_178) AT=75.025n

.meas tran vdout0_179ck140 FIND v(dout0_179) AT=75.025n

.meas tran vdout0_180ck140 FIND v(dout0_180) AT=75.025n

.meas tran vdout0_181ck140 FIND v(dout0_181) AT=75.025n

.meas tran vdout0_182ck140 FIND v(dout0_182) AT=75.025n

.meas tran vdout0_183ck140 FIND v(dout0_183) AT=75.025n

.meas tran vdout0_184ck140 FIND v(dout0_184) AT=75.025n

.meas tran vdout0_185ck140 FIND v(dout0_185) AT=75.025n

.meas tran vdout0_186ck140 FIND v(dout0_186) AT=75.025n

.meas tran vdout0_187ck140 FIND v(dout0_187) AT=75.025n

.meas tran vdout0_188ck140 FIND v(dout0_188) AT=75.025n

.meas tran vdout0_189ck140 FIND v(dout0_189) AT=75.025n

.meas tran vdout0_190ck140 FIND v(dout0_190) AT=75.025n

.meas tran vdout0_191ck140 FIND v(dout0_191) AT=75.025n

.meas tran vdout0_192ck140 FIND v(dout0_192) AT=75.025n

.meas tran vdout0_193ck140 FIND v(dout0_193) AT=75.025n

.meas tran vdout0_194ck140 FIND v(dout0_194) AT=75.025n

.meas tran vdout0_195ck140 FIND v(dout0_195) AT=75.025n

.meas tran vdout0_196ck140 FIND v(dout0_196) AT=75.025n

.meas tran vdout0_197ck140 FIND v(dout0_197) AT=75.025n

.meas tran vdout0_198ck140 FIND v(dout0_198) AT=75.025n

.meas tran vdout0_199ck140 FIND v(dout0_199) AT=75.025n

.meas tran vdout0_200ck140 FIND v(dout0_200) AT=75.025n

.meas tran vdout0_201ck140 FIND v(dout0_201) AT=75.025n

.meas tran vdout0_202ck140 FIND v(dout0_202) AT=75.025n

.meas tran vdout0_203ck140 FIND v(dout0_203) AT=75.025n

.meas tran vdout0_204ck140 FIND v(dout0_204) AT=75.025n

.meas tran vdout0_205ck140 FIND v(dout0_205) AT=75.025n

.meas tran vdout0_206ck140 FIND v(dout0_206) AT=75.025n

.meas tran vdout0_207ck140 FIND v(dout0_207) AT=75.025n

.meas tran vdout0_208ck140 FIND v(dout0_208) AT=75.025n

.meas tran vdout0_209ck140 FIND v(dout0_209) AT=75.025n

.meas tran vdout0_210ck140 FIND v(dout0_210) AT=75.025n

.meas tran vdout0_211ck140 FIND v(dout0_211) AT=75.025n

.meas tran vdout0_212ck140 FIND v(dout0_212) AT=75.025n

.meas tran vdout0_213ck140 FIND v(dout0_213) AT=75.025n

.meas tran vdout0_214ck140 FIND v(dout0_214) AT=75.025n

.meas tran vdout0_215ck140 FIND v(dout0_215) AT=75.025n

.meas tran vdout0_216ck140 FIND v(dout0_216) AT=75.025n

.meas tran vdout0_217ck140 FIND v(dout0_217) AT=75.025n

.meas tran vdout0_218ck140 FIND v(dout0_218) AT=75.025n

.meas tran vdout0_219ck140 FIND v(dout0_219) AT=75.025n

.meas tran vdout0_220ck140 FIND v(dout0_220) AT=75.025n

.meas tran vdout0_221ck140 FIND v(dout0_221) AT=75.025n

.meas tran vdout0_222ck140 FIND v(dout0_222) AT=75.025n

.meas tran vdout0_223ck140 FIND v(dout0_223) AT=75.025n

.meas tran vdout0_224ck140 FIND v(dout0_224) AT=75.025n

.meas tran vdout0_225ck140 FIND v(dout0_225) AT=75.025n

.meas tran vdout0_226ck140 FIND v(dout0_226) AT=75.025n

.meas tran vdout0_227ck140 FIND v(dout0_227) AT=75.025n

.meas tran vdout0_228ck140 FIND v(dout0_228) AT=75.025n

.meas tran vdout0_229ck140 FIND v(dout0_229) AT=75.025n

.meas tran vdout0_230ck140 FIND v(dout0_230) AT=75.025n

.meas tran vdout0_231ck140 FIND v(dout0_231) AT=75.025n

.meas tran vdout0_232ck140 FIND v(dout0_232) AT=75.025n

.meas tran vdout0_233ck140 FIND v(dout0_233) AT=75.025n

.meas tran vdout0_234ck140 FIND v(dout0_234) AT=75.025n

.meas tran vdout0_235ck140 FIND v(dout0_235) AT=75.025n

.meas tran vdout0_236ck140 FIND v(dout0_236) AT=75.025n

.meas tran vdout0_237ck140 FIND v(dout0_237) AT=75.025n

.meas tran vdout0_238ck140 FIND v(dout0_238) AT=75.025n

.meas tran vdout0_239ck140 FIND v(dout0_239) AT=75.025n

.meas tran vdout0_240ck140 FIND v(dout0_240) AT=75.025n

.meas tran vdout0_241ck140 FIND v(dout0_241) AT=75.025n

.meas tran vdout0_242ck140 FIND v(dout0_242) AT=75.025n

.meas tran vdout0_243ck140 FIND v(dout0_243) AT=75.025n

.meas tran vdout0_244ck140 FIND v(dout0_244) AT=75.025n

.meas tran vdout0_245ck140 FIND v(dout0_245) AT=75.025n

.meas tran vdout0_246ck140 FIND v(dout0_246) AT=75.025n

.meas tran vdout0_247ck140 FIND v(dout0_247) AT=75.025n

.meas tran vdout0_248ck140 FIND v(dout0_248) AT=75.025n

.meas tran vdout0_249ck140 FIND v(dout0_249) AT=75.025n

.meas tran vdout0_250ck140 FIND v(dout0_250) AT=75.025n

.meas tran vdout0_251ck140 FIND v(dout0_251) AT=75.025n

.meas tran vdout0_252ck140 FIND v(dout0_252) AT=75.025n

.meas tran vdout0_253ck140 FIND v(dout0_253) AT=75.025n

.meas tran vdout0_254ck140 FIND v(dout0_254) AT=75.025n

.meas tran vdout0_255ck140 FIND v(dout0_255) AT=75.025n

.meas tran vdout0_0ck160 FIND v(dout0_0) AT=85.025n

.meas tran vdout0_1ck160 FIND v(dout0_1) AT=85.025n

.meas tran vdout0_2ck160 FIND v(dout0_2) AT=85.025n

.meas tran vdout0_3ck160 FIND v(dout0_3) AT=85.025n

.meas tran vdout0_4ck160 FIND v(dout0_4) AT=85.025n

.meas tran vdout0_5ck160 FIND v(dout0_5) AT=85.025n

.meas tran vdout0_6ck160 FIND v(dout0_6) AT=85.025n

.meas tran vdout0_7ck160 FIND v(dout0_7) AT=85.025n

.meas tran vdout0_8ck160 FIND v(dout0_8) AT=85.025n

.meas tran vdout0_9ck160 FIND v(dout0_9) AT=85.025n

.meas tran vdout0_10ck160 FIND v(dout0_10) AT=85.025n

.meas tran vdout0_11ck160 FIND v(dout0_11) AT=85.025n

.meas tran vdout0_12ck160 FIND v(dout0_12) AT=85.025n

.meas tran vdout0_13ck160 FIND v(dout0_13) AT=85.025n

.meas tran vdout0_14ck160 FIND v(dout0_14) AT=85.025n

.meas tran vdout0_15ck160 FIND v(dout0_15) AT=85.025n

.meas tran vdout0_16ck160 FIND v(dout0_16) AT=85.025n

.meas tran vdout0_17ck160 FIND v(dout0_17) AT=85.025n

.meas tran vdout0_18ck160 FIND v(dout0_18) AT=85.025n

.meas tran vdout0_19ck160 FIND v(dout0_19) AT=85.025n

.meas tran vdout0_20ck160 FIND v(dout0_20) AT=85.025n

.meas tran vdout0_21ck160 FIND v(dout0_21) AT=85.025n

.meas tran vdout0_22ck160 FIND v(dout0_22) AT=85.025n

.meas tran vdout0_23ck160 FIND v(dout0_23) AT=85.025n

.meas tran vdout0_24ck160 FIND v(dout0_24) AT=85.025n

.meas tran vdout0_25ck160 FIND v(dout0_25) AT=85.025n

.meas tran vdout0_26ck160 FIND v(dout0_26) AT=85.025n

.meas tran vdout0_27ck160 FIND v(dout0_27) AT=85.025n

.meas tran vdout0_28ck160 FIND v(dout0_28) AT=85.025n

.meas tran vdout0_29ck160 FIND v(dout0_29) AT=85.025n

.meas tran vdout0_30ck160 FIND v(dout0_30) AT=85.025n

.meas tran vdout0_31ck160 FIND v(dout0_31) AT=85.025n

.meas tran vdout0_32ck160 FIND v(dout0_32) AT=85.025n

.meas tran vdout0_33ck160 FIND v(dout0_33) AT=85.025n

.meas tran vdout0_34ck160 FIND v(dout0_34) AT=85.025n

.meas tran vdout0_35ck160 FIND v(dout0_35) AT=85.025n

.meas tran vdout0_36ck160 FIND v(dout0_36) AT=85.025n

.meas tran vdout0_37ck160 FIND v(dout0_37) AT=85.025n

.meas tran vdout0_38ck160 FIND v(dout0_38) AT=85.025n

.meas tran vdout0_39ck160 FIND v(dout0_39) AT=85.025n

.meas tran vdout0_40ck160 FIND v(dout0_40) AT=85.025n

.meas tran vdout0_41ck160 FIND v(dout0_41) AT=85.025n

.meas tran vdout0_42ck160 FIND v(dout0_42) AT=85.025n

.meas tran vdout0_43ck160 FIND v(dout0_43) AT=85.025n

.meas tran vdout0_44ck160 FIND v(dout0_44) AT=85.025n

.meas tran vdout0_45ck160 FIND v(dout0_45) AT=85.025n

.meas tran vdout0_46ck160 FIND v(dout0_46) AT=85.025n

.meas tran vdout0_47ck160 FIND v(dout0_47) AT=85.025n

.meas tran vdout0_48ck160 FIND v(dout0_48) AT=85.025n

.meas tran vdout0_49ck160 FIND v(dout0_49) AT=85.025n

.meas tran vdout0_50ck160 FIND v(dout0_50) AT=85.025n

.meas tran vdout0_51ck160 FIND v(dout0_51) AT=85.025n

.meas tran vdout0_52ck160 FIND v(dout0_52) AT=85.025n

.meas tran vdout0_53ck160 FIND v(dout0_53) AT=85.025n

.meas tran vdout0_54ck160 FIND v(dout0_54) AT=85.025n

.meas tran vdout0_55ck160 FIND v(dout0_55) AT=85.025n

.meas tran vdout0_56ck160 FIND v(dout0_56) AT=85.025n

.meas tran vdout0_57ck160 FIND v(dout0_57) AT=85.025n

.meas tran vdout0_58ck160 FIND v(dout0_58) AT=85.025n

.meas tran vdout0_59ck160 FIND v(dout0_59) AT=85.025n

.meas tran vdout0_60ck160 FIND v(dout0_60) AT=85.025n

.meas tran vdout0_61ck160 FIND v(dout0_61) AT=85.025n

.meas tran vdout0_62ck160 FIND v(dout0_62) AT=85.025n

.meas tran vdout0_63ck160 FIND v(dout0_63) AT=85.025n

.meas tran vdout0_64ck160 FIND v(dout0_64) AT=85.025n

.meas tran vdout0_65ck160 FIND v(dout0_65) AT=85.025n

.meas tran vdout0_66ck160 FIND v(dout0_66) AT=85.025n

.meas tran vdout0_67ck160 FIND v(dout0_67) AT=85.025n

.meas tran vdout0_68ck160 FIND v(dout0_68) AT=85.025n

.meas tran vdout0_69ck160 FIND v(dout0_69) AT=85.025n

.meas tran vdout0_70ck160 FIND v(dout0_70) AT=85.025n

.meas tran vdout0_71ck160 FIND v(dout0_71) AT=85.025n

.meas tran vdout0_72ck160 FIND v(dout0_72) AT=85.025n

.meas tran vdout0_73ck160 FIND v(dout0_73) AT=85.025n

.meas tran vdout0_74ck160 FIND v(dout0_74) AT=85.025n

.meas tran vdout0_75ck160 FIND v(dout0_75) AT=85.025n

.meas tran vdout0_76ck160 FIND v(dout0_76) AT=85.025n

.meas tran vdout0_77ck160 FIND v(dout0_77) AT=85.025n

.meas tran vdout0_78ck160 FIND v(dout0_78) AT=85.025n

.meas tran vdout0_79ck160 FIND v(dout0_79) AT=85.025n

.meas tran vdout0_80ck160 FIND v(dout0_80) AT=85.025n

.meas tran vdout0_81ck160 FIND v(dout0_81) AT=85.025n

.meas tran vdout0_82ck160 FIND v(dout0_82) AT=85.025n

.meas tran vdout0_83ck160 FIND v(dout0_83) AT=85.025n

.meas tran vdout0_84ck160 FIND v(dout0_84) AT=85.025n

.meas tran vdout0_85ck160 FIND v(dout0_85) AT=85.025n

.meas tran vdout0_86ck160 FIND v(dout0_86) AT=85.025n

.meas tran vdout0_87ck160 FIND v(dout0_87) AT=85.025n

.meas tran vdout0_88ck160 FIND v(dout0_88) AT=85.025n

.meas tran vdout0_89ck160 FIND v(dout0_89) AT=85.025n

.meas tran vdout0_90ck160 FIND v(dout0_90) AT=85.025n

.meas tran vdout0_91ck160 FIND v(dout0_91) AT=85.025n

.meas tran vdout0_92ck160 FIND v(dout0_92) AT=85.025n

.meas tran vdout0_93ck160 FIND v(dout0_93) AT=85.025n

.meas tran vdout0_94ck160 FIND v(dout0_94) AT=85.025n

.meas tran vdout0_95ck160 FIND v(dout0_95) AT=85.025n

.meas tran vdout0_96ck160 FIND v(dout0_96) AT=85.025n

.meas tran vdout0_97ck160 FIND v(dout0_97) AT=85.025n

.meas tran vdout0_98ck160 FIND v(dout0_98) AT=85.025n

.meas tran vdout0_99ck160 FIND v(dout0_99) AT=85.025n

.meas tran vdout0_100ck160 FIND v(dout0_100) AT=85.025n

.meas tran vdout0_101ck160 FIND v(dout0_101) AT=85.025n

.meas tran vdout0_102ck160 FIND v(dout0_102) AT=85.025n

.meas tran vdout0_103ck160 FIND v(dout0_103) AT=85.025n

.meas tran vdout0_104ck160 FIND v(dout0_104) AT=85.025n

.meas tran vdout0_105ck160 FIND v(dout0_105) AT=85.025n

.meas tran vdout0_106ck160 FIND v(dout0_106) AT=85.025n

.meas tran vdout0_107ck160 FIND v(dout0_107) AT=85.025n

.meas tran vdout0_108ck160 FIND v(dout0_108) AT=85.025n

.meas tran vdout0_109ck160 FIND v(dout0_109) AT=85.025n

.meas tran vdout0_110ck160 FIND v(dout0_110) AT=85.025n

.meas tran vdout0_111ck160 FIND v(dout0_111) AT=85.025n

.meas tran vdout0_112ck160 FIND v(dout0_112) AT=85.025n

.meas tran vdout0_113ck160 FIND v(dout0_113) AT=85.025n

.meas tran vdout0_114ck160 FIND v(dout0_114) AT=85.025n

.meas tran vdout0_115ck160 FIND v(dout0_115) AT=85.025n

.meas tran vdout0_116ck160 FIND v(dout0_116) AT=85.025n

.meas tran vdout0_117ck160 FIND v(dout0_117) AT=85.025n

.meas tran vdout0_118ck160 FIND v(dout0_118) AT=85.025n

.meas tran vdout0_119ck160 FIND v(dout0_119) AT=85.025n

.meas tran vdout0_120ck160 FIND v(dout0_120) AT=85.025n

.meas tran vdout0_121ck160 FIND v(dout0_121) AT=85.025n

.meas tran vdout0_122ck160 FIND v(dout0_122) AT=85.025n

.meas tran vdout0_123ck160 FIND v(dout0_123) AT=85.025n

.meas tran vdout0_124ck160 FIND v(dout0_124) AT=85.025n

.meas tran vdout0_125ck160 FIND v(dout0_125) AT=85.025n

.meas tran vdout0_126ck160 FIND v(dout0_126) AT=85.025n

.meas tran vdout0_127ck160 FIND v(dout0_127) AT=85.025n

.meas tran vdout0_128ck160 FIND v(dout0_128) AT=85.025n

.meas tran vdout0_129ck160 FIND v(dout0_129) AT=85.025n

.meas tran vdout0_130ck160 FIND v(dout0_130) AT=85.025n

.meas tran vdout0_131ck160 FIND v(dout0_131) AT=85.025n

.meas tran vdout0_132ck160 FIND v(dout0_132) AT=85.025n

.meas tran vdout0_133ck160 FIND v(dout0_133) AT=85.025n

.meas tran vdout0_134ck160 FIND v(dout0_134) AT=85.025n

.meas tran vdout0_135ck160 FIND v(dout0_135) AT=85.025n

.meas tran vdout0_136ck160 FIND v(dout0_136) AT=85.025n

.meas tran vdout0_137ck160 FIND v(dout0_137) AT=85.025n

.meas tran vdout0_138ck160 FIND v(dout0_138) AT=85.025n

.meas tran vdout0_139ck160 FIND v(dout0_139) AT=85.025n

.meas tran vdout0_140ck160 FIND v(dout0_140) AT=85.025n

.meas tran vdout0_141ck160 FIND v(dout0_141) AT=85.025n

.meas tran vdout0_142ck160 FIND v(dout0_142) AT=85.025n

.meas tran vdout0_143ck160 FIND v(dout0_143) AT=85.025n

.meas tran vdout0_144ck160 FIND v(dout0_144) AT=85.025n

.meas tran vdout0_145ck160 FIND v(dout0_145) AT=85.025n

.meas tran vdout0_146ck160 FIND v(dout0_146) AT=85.025n

.meas tran vdout0_147ck160 FIND v(dout0_147) AT=85.025n

.meas tran vdout0_148ck160 FIND v(dout0_148) AT=85.025n

.meas tran vdout0_149ck160 FIND v(dout0_149) AT=85.025n

.meas tran vdout0_150ck160 FIND v(dout0_150) AT=85.025n

.meas tran vdout0_151ck160 FIND v(dout0_151) AT=85.025n

.meas tran vdout0_152ck160 FIND v(dout0_152) AT=85.025n

.meas tran vdout0_153ck160 FIND v(dout0_153) AT=85.025n

.meas tran vdout0_154ck160 FIND v(dout0_154) AT=85.025n

.meas tran vdout0_155ck160 FIND v(dout0_155) AT=85.025n

.meas tran vdout0_156ck160 FIND v(dout0_156) AT=85.025n

.meas tran vdout0_157ck160 FIND v(dout0_157) AT=85.025n

.meas tran vdout0_158ck160 FIND v(dout0_158) AT=85.025n

.meas tran vdout0_159ck160 FIND v(dout0_159) AT=85.025n

.meas tran vdout0_160ck160 FIND v(dout0_160) AT=85.025n

.meas tran vdout0_161ck160 FIND v(dout0_161) AT=85.025n

.meas tran vdout0_162ck160 FIND v(dout0_162) AT=85.025n

.meas tran vdout0_163ck160 FIND v(dout0_163) AT=85.025n

.meas tran vdout0_164ck160 FIND v(dout0_164) AT=85.025n

.meas tran vdout0_165ck160 FIND v(dout0_165) AT=85.025n

.meas tran vdout0_166ck160 FIND v(dout0_166) AT=85.025n

.meas tran vdout0_167ck160 FIND v(dout0_167) AT=85.025n

.meas tran vdout0_168ck160 FIND v(dout0_168) AT=85.025n

.meas tran vdout0_169ck160 FIND v(dout0_169) AT=85.025n

.meas tran vdout0_170ck160 FIND v(dout0_170) AT=85.025n

.meas tran vdout0_171ck160 FIND v(dout0_171) AT=85.025n

.meas tran vdout0_172ck160 FIND v(dout0_172) AT=85.025n

.meas tran vdout0_173ck160 FIND v(dout0_173) AT=85.025n

.meas tran vdout0_174ck160 FIND v(dout0_174) AT=85.025n

.meas tran vdout0_175ck160 FIND v(dout0_175) AT=85.025n

.meas tran vdout0_176ck160 FIND v(dout0_176) AT=85.025n

.meas tran vdout0_177ck160 FIND v(dout0_177) AT=85.025n

.meas tran vdout0_178ck160 FIND v(dout0_178) AT=85.025n

.meas tran vdout0_179ck160 FIND v(dout0_179) AT=85.025n

.meas tran vdout0_180ck160 FIND v(dout0_180) AT=85.025n

.meas tran vdout0_181ck160 FIND v(dout0_181) AT=85.025n

.meas tran vdout0_182ck160 FIND v(dout0_182) AT=85.025n

.meas tran vdout0_183ck160 FIND v(dout0_183) AT=85.025n

.meas tran vdout0_184ck160 FIND v(dout0_184) AT=85.025n

.meas tran vdout0_185ck160 FIND v(dout0_185) AT=85.025n

.meas tran vdout0_186ck160 FIND v(dout0_186) AT=85.025n

.meas tran vdout0_187ck160 FIND v(dout0_187) AT=85.025n

.meas tran vdout0_188ck160 FIND v(dout0_188) AT=85.025n

.meas tran vdout0_189ck160 FIND v(dout0_189) AT=85.025n

.meas tran vdout0_190ck160 FIND v(dout0_190) AT=85.025n

.meas tran vdout0_191ck160 FIND v(dout0_191) AT=85.025n

.meas tran vdout0_192ck160 FIND v(dout0_192) AT=85.025n

.meas tran vdout0_193ck160 FIND v(dout0_193) AT=85.025n

.meas tran vdout0_194ck160 FIND v(dout0_194) AT=85.025n

.meas tran vdout0_195ck160 FIND v(dout0_195) AT=85.025n

.meas tran vdout0_196ck160 FIND v(dout0_196) AT=85.025n

.meas tran vdout0_197ck160 FIND v(dout0_197) AT=85.025n

.meas tran vdout0_198ck160 FIND v(dout0_198) AT=85.025n

.meas tran vdout0_199ck160 FIND v(dout0_199) AT=85.025n

.meas tran vdout0_200ck160 FIND v(dout0_200) AT=85.025n

.meas tran vdout0_201ck160 FIND v(dout0_201) AT=85.025n

.meas tran vdout0_202ck160 FIND v(dout0_202) AT=85.025n

.meas tran vdout0_203ck160 FIND v(dout0_203) AT=85.025n

.meas tran vdout0_204ck160 FIND v(dout0_204) AT=85.025n

.meas tran vdout0_205ck160 FIND v(dout0_205) AT=85.025n

.meas tran vdout0_206ck160 FIND v(dout0_206) AT=85.025n

.meas tran vdout0_207ck160 FIND v(dout0_207) AT=85.025n

.meas tran vdout0_208ck160 FIND v(dout0_208) AT=85.025n

.meas tran vdout0_209ck160 FIND v(dout0_209) AT=85.025n

.meas tran vdout0_210ck160 FIND v(dout0_210) AT=85.025n

.meas tran vdout0_211ck160 FIND v(dout0_211) AT=85.025n

.meas tran vdout0_212ck160 FIND v(dout0_212) AT=85.025n

.meas tran vdout0_213ck160 FIND v(dout0_213) AT=85.025n

.meas tran vdout0_214ck160 FIND v(dout0_214) AT=85.025n

.meas tran vdout0_215ck160 FIND v(dout0_215) AT=85.025n

.meas tran vdout0_216ck160 FIND v(dout0_216) AT=85.025n

.meas tran vdout0_217ck160 FIND v(dout0_217) AT=85.025n

.meas tran vdout0_218ck160 FIND v(dout0_218) AT=85.025n

.meas tran vdout0_219ck160 FIND v(dout0_219) AT=85.025n

.meas tran vdout0_220ck160 FIND v(dout0_220) AT=85.025n

.meas tran vdout0_221ck160 FIND v(dout0_221) AT=85.025n

.meas tran vdout0_222ck160 FIND v(dout0_222) AT=85.025n

.meas tran vdout0_223ck160 FIND v(dout0_223) AT=85.025n

.meas tran vdout0_224ck160 FIND v(dout0_224) AT=85.025n

.meas tran vdout0_225ck160 FIND v(dout0_225) AT=85.025n

.meas tran vdout0_226ck160 FIND v(dout0_226) AT=85.025n

.meas tran vdout0_227ck160 FIND v(dout0_227) AT=85.025n

.meas tran vdout0_228ck160 FIND v(dout0_228) AT=85.025n

.meas tran vdout0_229ck160 FIND v(dout0_229) AT=85.025n

.meas tran vdout0_230ck160 FIND v(dout0_230) AT=85.025n

.meas tran vdout0_231ck160 FIND v(dout0_231) AT=85.025n

.meas tran vdout0_232ck160 FIND v(dout0_232) AT=85.025n

.meas tran vdout0_233ck160 FIND v(dout0_233) AT=85.025n

.meas tran vdout0_234ck160 FIND v(dout0_234) AT=85.025n

.meas tran vdout0_235ck160 FIND v(dout0_235) AT=85.025n

.meas tran vdout0_236ck160 FIND v(dout0_236) AT=85.025n

.meas tran vdout0_237ck160 FIND v(dout0_237) AT=85.025n

.meas tran vdout0_238ck160 FIND v(dout0_238) AT=85.025n

.meas tran vdout0_239ck160 FIND v(dout0_239) AT=85.025n

.meas tran vdout0_240ck160 FIND v(dout0_240) AT=85.025n

.meas tran vdout0_241ck160 FIND v(dout0_241) AT=85.025n

.meas tran vdout0_242ck160 FIND v(dout0_242) AT=85.025n

.meas tran vdout0_243ck160 FIND v(dout0_243) AT=85.025n

.meas tran vdout0_244ck160 FIND v(dout0_244) AT=85.025n

.meas tran vdout0_245ck160 FIND v(dout0_245) AT=85.025n

.meas tran vdout0_246ck160 FIND v(dout0_246) AT=85.025n

.meas tran vdout0_247ck160 FIND v(dout0_247) AT=85.025n

.meas tran vdout0_248ck160 FIND v(dout0_248) AT=85.025n

.meas tran vdout0_249ck160 FIND v(dout0_249) AT=85.025n

.meas tran vdout0_250ck160 FIND v(dout0_250) AT=85.025n

.meas tran vdout0_251ck160 FIND v(dout0_251) AT=85.025n

.meas tran vdout0_252ck160 FIND v(dout0_252) AT=85.025n

.meas tran vdout0_253ck160 FIND v(dout0_253) AT=85.025n

.meas tran vdout0_254ck160 FIND v(dout0_254) AT=85.025n

.meas tran vdout0_255ck160 FIND v(dout0_255) AT=85.025n

.meas tran vdout0_0ck170 FIND v(dout0_0) AT=90.025n

.meas tran vdout0_1ck170 FIND v(dout0_1) AT=90.025n

.meas tran vdout0_2ck170 FIND v(dout0_2) AT=90.025n

.meas tran vdout0_3ck170 FIND v(dout0_3) AT=90.025n

.meas tran vdout0_4ck170 FIND v(dout0_4) AT=90.025n

.meas tran vdout0_5ck170 FIND v(dout0_5) AT=90.025n

.meas tran vdout0_6ck170 FIND v(dout0_6) AT=90.025n

.meas tran vdout0_7ck170 FIND v(dout0_7) AT=90.025n

.meas tran vdout0_8ck170 FIND v(dout0_8) AT=90.025n

.meas tran vdout0_9ck170 FIND v(dout0_9) AT=90.025n

.meas tran vdout0_10ck170 FIND v(dout0_10) AT=90.025n

.meas tran vdout0_11ck170 FIND v(dout0_11) AT=90.025n

.meas tran vdout0_12ck170 FIND v(dout0_12) AT=90.025n

.meas tran vdout0_13ck170 FIND v(dout0_13) AT=90.025n

.meas tran vdout0_14ck170 FIND v(dout0_14) AT=90.025n

.meas tran vdout0_15ck170 FIND v(dout0_15) AT=90.025n

.meas tran vdout0_16ck170 FIND v(dout0_16) AT=90.025n

.meas tran vdout0_17ck170 FIND v(dout0_17) AT=90.025n

.meas tran vdout0_18ck170 FIND v(dout0_18) AT=90.025n

.meas tran vdout0_19ck170 FIND v(dout0_19) AT=90.025n

.meas tran vdout0_20ck170 FIND v(dout0_20) AT=90.025n

.meas tran vdout0_21ck170 FIND v(dout0_21) AT=90.025n

.meas tran vdout0_22ck170 FIND v(dout0_22) AT=90.025n

.meas tran vdout0_23ck170 FIND v(dout0_23) AT=90.025n

.meas tran vdout0_24ck170 FIND v(dout0_24) AT=90.025n

.meas tran vdout0_25ck170 FIND v(dout0_25) AT=90.025n

.meas tran vdout0_26ck170 FIND v(dout0_26) AT=90.025n

.meas tran vdout0_27ck170 FIND v(dout0_27) AT=90.025n

.meas tran vdout0_28ck170 FIND v(dout0_28) AT=90.025n

.meas tran vdout0_29ck170 FIND v(dout0_29) AT=90.025n

.meas tran vdout0_30ck170 FIND v(dout0_30) AT=90.025n

.meas tran vdout0_31ck170 FIND v(dout0_31) AT=90.025n

.meas tran vdout0_32ck170 FIND v(dout0_32) AT=90.025n

.meas tran vdout0_33ck170 FIND v(dout0_33) AT=90.025n

.meas tran vdout0_34ck170 FIND v(dout0_34) AT=90.025n

.meas tran vdout0_35ck170 FIND v(dout0_35) AT=90.025n

.meas tran vdout0_36ck170 FIND v(dout0_36) AT=90.025n

.meas tran vdout0_37ck170 FIND v(dout0_37) AT=90.025n

.meas tran vdout0_38ck170 FIND v(dout0_38) AT=90.025n

.meas tran vdout0_39ck170 FIND v(dout0_39) AT=90.025n

.meas tran vdout0_40ck170 FIND v(dout0_40) AT=90.025n

.meas tran vdout0_41ck170 FIND v(dout0_41) AT=90.025n

.meas tran vdout0_42ck170 FIND v(dout0_42) AT=90.025n

.meas tran vdout0_43ck170 FIND v(dout0_43) AT=90.025n

.meas tran vdout0_44ck170 FIND v(dout0_44) AT=90.025n

.meas tran vdout0_45ck170 FIND v(dout0_45) AT=90.025n

.meas tran vdout0_46ck170 FIND v(dout0_46) AT=90.025n

.meas tran vdout0_47ck170 FIND v(dout0_47) AT=90.025n

.meas tran vdout0_48ck170 FIND v(dout0_48) AT=90.025n

.meas tran vdout0_49ck170 FIND v(dout0_49) AT=90.025n

.meas tran vdout0_50ck170 FIND v(dout0_50) AT=90.025n

.meas tran vdout0_51ck170 FIND v(dout0_51) AT=90.025n

.meas tran vdout0_52ck170 FIND v(dout0_52) AT=90.025n

.meas tran vdout0_53ck170 FIND v(dout0_53) AT=90.025n

.meas tran vdout0_54ck170 FIND v(dout0_54) AT=90.025n

.meas tran vdout0_55ck170 FIND v(dout0_55) AT=90.025n

.meas tran vdout0_56ck170 FIND v(dout0_56) AT=90.025n

.meas tran vdout0_57ck170 FIND v(dout0_57) AT=90.025n

.meas tran vdout0_58ck170 FIND v(dout0_58) AT=90.025n

.meas tran vdout0_59ck170 FIND v(dout0_59) AT=90.025n

.meas tran vdout0_60ck170 FIND v(dout0_60) AT=90.025n

.meas tran vdout0_61ck170 FIND v(dout0_61) AT=90.025n

.meas tran vdout0_62ck170 FIND v(dout0_62) AT=90.025n

.meas tran vdout0_63ck170 FIND v(dout0_63) AT=90.025n

.meas tran vdout0_64ck170 FIND v(dout0_64) AT=90.025n

.meas tran vdout0_65ck170 FIND v(dout0_65) AT=90.025n

.meas tran vdout0_66ck170 FIND v(dout0_66) AT=90.025n

.meas tran vdout0_67ck170 FIND v(dout0_67) AT=90.025n

.meas tran vdout0_68ck170 FIND v(dout0_68) AT=90.025n

.meas tran vdout0_69ck170 FIND v(dout0_69) AT=90.025n

.meas tran vdout0_70ck170 FIND v(dout0_70) AT=90.025n

.meas tran vdout0_71ck170 FIND v(dout0_71) AT=90.025n

.meas tran vdout0_72ck170 FIND v(dout0_72) AT=90.025n

.meas tran vdout0_73ck170 FIND v(dout0_73) AT=90.025n

.meas tran vdout0_74ck170 FIND v(dout0_74) AT=90.025n

.meas tran vdout0_75ck170 FIND v(dout0_75) AT=90.025n

.meas tran vdout0_76ck170 FIND v(dout0_76) AT=90.025n

.meas tran vdout0_77ck170 FIND v(dout0_77) AT=90.025n

.meas tran vdout0_78ck170 FIND v(dout0_78) AT=90.025n

.meas tran vdout0_79ck170 FIND v(dout0_79) AT=90.025n

.meas tran vdout0_80ck170 FIND v(dout0_80) AT=90.025n

.meas tran vdout0_81ck170 FIND v(dout0_81) AT=90.025n

.meas tran vdout0_82ck170 FIND v(dout0_82) AT=90.025n

.meas tran vdout0_83ck170 FIND v(dout0_83) AT=90.025n

.meas tran vdout0_84ck170 FIND v(dout0_84) AT=90.025n

.meas tran vdout0_85ck170 FIND v(dout0_85) AT=90.025n

.meas tran vdout0_86ck170 FIND v(dout0_86) AT=90.025n

.meas tran vdout0_87ck170 FIND v(dout0_87) AT=90.025n

.meas tran vdout0_88ck170 FIND v(dout0_88) AT=90.025n

.meas tran vdout0_89ck170 FIND v(dout0_89) AT=90.025n

.meas tran vdout0_90ck170 FIND v(dout0_90) AT=90.025n

.meas tran vdout0_91ck170 FIND v(dout0_91) AT=90.025n

.meas tran vdout0_92ck170 FIND v(dout0_92) AT=90.025n

.meas tran vdout0_93ck170 FIND v(dout0_93) AT=90.025n

.meas tran vdout0_94ck170 FIND v(dout0_94) AT=90.025n

.meas tran vdout0_95ck170 FIND v(dout0_95) AT=90.025n

.meas tran vdout0_96ck170 FIND v(dout0_96) AT=90.025n

.meas tran vdout0_97ck170 FIND v(dout0_97) AT=90.025n

.meas tran vdout0_98ck170 FIND v(dout0_98) AT=90.025n

.meas tran vdout0_99ck170 FIND v(dout0_99) AT=90.025n

.meas tran vdout0_100ck170 FIND v(dout0_100) AT=90.025n

.meas tran vdout0_101ck170 FIND v(dout0_101) AT=90.025n

.meas tran vdout0_102ck170 FIND v(dout0_102) AT=90.025n

.meas tran vdout0_103ck170 FIND v(dout0_103) AT=90.025n

.meas tran vdout0_104ck170 FIND v(dout0_104) AT=90.025n

.meas tran vdout0_105ck170 FIND v(dout0_105) AT=90.025n

.meas tran vdout0_106ck170 FIND v(dout0_106) AT=90.025n

.meas tran vdout0_107ck170 FIND v(dout0_107) AT=90.025n

.meas tran vdout0_108ck170 FIND v(dout0_108) AT=90.025n

.meas tran vdout0_109ck170 FIND v(dout0_109) AT=90.025n

.meas tran vdout0_110ck170 FIND v(dout0_110) AT=90.025n

.meas tran vdout0_111ck170 FIND v(dout0_111) AT=90.025n

.meas tran vdout0_112ck170 FIND v(dout0_112) AT=90.025n

.meas tran vdout0_113ck170 FIND v(dout0_113) AT=90.025n

.meas tran vdout0_114ck170 FIND v(dout0_114) AT=90.025n

.meas tran vdout0_115ck170 FIND v(dout0_115) AT=90.025n

.meas tran vdout0_116ck170 FIND v(dout0_116) AT=90.025n

.meas tran vdout0_117ck170 FIND v(dout0_117) AT=90.025n

.meas tran vdout0_118ck170 FIND v(dout0_118) AT=90.025n

.meas tran vdout0_119ck170 FIND v(dout0_119) AT=90.025n

.meas tran vdout0_120ck170 FIND v(dout0_120) AT=90.025n

.meas tran vdout0_121ck170 FIND v(dout0_121) AT=90.025n

.meas tran vdout0_122ck170 FIND v(dout0_122) AT=90.025n

.meas tran vdout0_123ck170 FIND v(dout0_123) AT=90.025n

.meas tran vdout0_124ck170 FIND v(dout0_124) AT=90.025n

.meas tran vdout0_125ck170 FIND v(dout0_125) AT=90.025n

.meas tran vdout0_126ck170 FIND v(dout0_126) AT=90.025n

.meas tran vdout0_127ck170 FIND v(dout0_127) AT=90.025n

.meas tran vdout0_128ck170 FIND v(dout0_128) AT=90.025n

.meas tran vdout0_129ck170 FIND v(dout0_129) AT=90.025n

.meas tran vdout0_130ck170 FIND v(dout0_130) AT=90.025n

.meas tran vdout0_131ck170 FIND v(dout0_131) AT=90.025n

.meas tran vdout0_132ck170 FIND v(dout0_132) AT=90.025n

.meas tran vdout0_133ck170 FIND v(dout0_133) AT=90.025n

.meas tran vdout0_134ck170 FIND v(dout0_134) AT=90.025n

.meas tran vdout0_135ck170 FIND v(dout0_135) AT=90.025n

.meas tran vdout0_136ck170 FIND v(dout0_136) AT=90.025n

.meas tran vdout0_137ck170 FIND v(dout0_137) AT=90.025n

.meas tran vdout0_138ck170 FIND v(dout0_138) AT=90.025n

.meas tran vdout0_139ck170 FIND v(dout0_139) AT=90.025n

.meas tran vdout0_140ck170 FIND v(dout0_140) AT=90.025n

.meas tran vdout0_141ck170 FIND v(dout0_141) AT=90.025n

.meas tran vdout0_142ck170 FIND v(dout0_142) AT=90.025n

.meas tran vdout0_143ck170 FIND v(dout0_143) AT=90.025n

.meas tran vdout0_144ck170 FIND v(dout0_144) AT=90.025n

.meas tran vdout0_145ck170 FIND v(dout0_145) AT=90.025n

.meas tran vdout0_146ck170 FIND v(dout0_146) AT=90.025n

.meas tran vdout0_147ck170 FIND v(dout0_147) AT=90.025n

.meas tran vdout0_148ck170 FIND v(dout0_148) AT=90.025n

.meas tran vdout0_149ck170 FIND v(dout0_149) AT=90.025n

.meas tran vdout0_150ck170 FIND v(dout0_150) AT=90.025n

.meas tran vdout0_151ck170 FIND v(dout0_151) AT=90.025n

.meas tran vdout0_152ck170 FIND v(dout0_152) AT=90.025n

.meas tran vdout0_153ck170 FIND v(dout0_153) AT=90.025n

.meas tran vdout0_154ck170 FIND v(dout0_154) AT=90.025n

.meas tran vdout0_155ck170 FIND v(dout0_155) AT=90.025n

.meas tran vdout0_156ck170 FIND v(dout0_156) AT=90.025n

.meas tran vdout0_157ck170 FIND v(dout0_157) AT=90.025n

.meas tran vdout0_158ck170 FIND v(dout0_158) AT=90.025n

.meas tran vdout0_159ck170 FIND v(dout0_159) AT=90.025n

.meas tran vdout0_160ck170 FIND v(dout0_160) AT=90.025n

.meas tran vdout0_161ck170 FIND v(dout0_161) AT=90.025n

.meas tran vdout0_162ck170 FIND v(dout0_162) AT=90.025n

.meas tran vdout0_163ck170 FIND v(dout0_163) AT=90.025n

.meas tran vdout0_164ck170 FIND v(dout0_164) AT=90.025n

.meas tran vdout0_165ck170 FIND v(dout0_165) AT=90.025n

.meas tran vdout0_166ck170 FIND v(dout0_166) AT=90.025n

.meas tran vdout0_167ck170 FIND v(dout0_167) AT=90.025n

.meas tran vdout0_168ck170 FIND v(dout0_168) AT=90.025n

.meas tran vdout0_169ck170 FIND v(dout0_169) AT=90.025n

.meas tran vdout0_170ck170 FIND v(dout0_170) AT=90.025n

.meas tran vdout0_171ck170 FIND v(dout0_171) AT=90.025n

.meas tran vdout0_172ck170 FIND v(dout0_172) AT=90.025n

.meas tran vdout0_173ck170 FIND v(dout0_173) AT=90.025n

.meas tran vdout0_174ck170 FIND v(dout0_174) AT=90.025n

.meas tran vdout0_175ck170 FIND v(dout0_175) AT=90.025n

.meas tran vdout0_176ck170 FIND v(dout0_176) AT=90.025n

.meas tran vdout0_177ck170 FIND v(dout0_177) AT=90.025n

.meas tran vdout0_178ck170 FIND v(dout0_178) AT=90.025n

.meas tran vdout0_179ck170 FIND v(dout0_179) AT=90.025n

.meas tran vdout0_180ck170 FIND v(dout0_180) AT=90.025n

.meas tran vdout0_181ck170 FIND v(dout0_181) AT=90.025n

.meas tran vdout0_182ck170 FIND v(dout0_182) AT=90.025n

.meas tran vdout0_183ck170 FIND v(dout0_183) AT=90.025n

.meas tran vdout0_184ck170 FIND v(dout0_184) AT=90.025n

.meas tran vdout0_185ck170 FIND v(dout0_185) AT=90.025n

.meas tran vdout0_186ck170 FIND v(dout0_186) AT=90.025n

.meas tran vdout0_187ck170 FIND v(dout0_187) AT=90.025n

.meas tran vdout0_188ck170 FIND v(dout0_188) AT=90.025n

.meas tran vdout0_189ck170 FIND v(dout0_189) AT=90.025n

.meas tran vdout0_190ck170 FIND v(dout0_190) AT=90.025n

.meas tran vdout0_191ck170 FIND v(dout0_191) AT=90.025n

.meas tran vdout0_192ck170 FIND v(dout0_192) AT=90.025n

.meas tran vdout0_193ck170 FIND v(dout0_193) AT=90.025n

.meas tran vdout0_194ck170 FIND v(dout0_194) AT=90.025n

.meas tran vdout0_195ck170 FIND v(dout0_195) AT=90.025n

.meas tran vdout0_196ck170 FIND v(dout0_196) AT=90.025n

.meas tran vdout0_197ck170 FIND v(dout0_197) AT=90.025n

.meas tran vdout0_198ck170 FIND v(dout0_198) AT=90.025n

.meas tran vdout0_199ck170 FIND v(dout0_199) AT=90.025n

.meas tran vdout0_200ck170 FIND v(dout0_200) AT=90.025n

.meas tran vdout0_201ck170 FIND v(dout0_201) AT=90.025n

.meas tran vdout0_202ck170 FIND v(dout0_202) AT=90.025n

.meas tran vdout0_203ck170 FIND v(dout0_203) AT=90.025n

.meas tran vdout0_204ck170 FIND v(dout0_204) AT=90.025n

.meas tran vdout0_205ck170 FIND v(dout0_205) AT=90.025n

.meas tran vdout0_206ck170 FIND v(dout0_206) AT=90.025n

.meas tran vdout0_207ck170 FIND v(dout0_207) AT=90.025n

.meas tran vdout0_208ck170 FIND v(dout0_208) AT=90.025n

.meas tran vdout0_209ck170 FIND v(dout0_209) AT=90.025n

.meas tran vdout0_210ck170 FIND v(dout0_210) AT=90.025n

.meas tran vdout0_211ck170 FIND v(dout0_211) AT=90.025n

.meas tran vdout0_212ck170 FIND v(dout0_212) AT=90.025n

.meas tran vdout0_213ck170 FIND v(dout0_213) AT=90.025n

.meas tran vdout0_214ck170 FIND v(dout0_214) AT=90.025n

.meas tran vdout0_215ck170 FIND v(dout0_215) AT=90.025n

.meas tran vdout0_216ck170 FIND v(dout0_216) AT=90.025n

.meas tran vdout0_217ck170 FIND v(dout0_217) AT=90.025n

.meas tran vdout0_218ck170 FIND v(dout0_218) AT=90.025n

.meas tran vdout0_219ck170 FIND v(dout0_219) AT=90.025n

.meas tran vdout0_220ck170 FIND v(dout0_220) AT=90.025n

.meas tran vdout0_221ck170 FIND v(dout0_221) AT=90.025n

.meas tran vdout0_222ck170 FIND v(dout0_222) AT=90.025n

.meas tran vdout0_223ck170 FIND v(dout0_223) AT=90.025n

.meas tran vdout0_224ck170 FIND v(dout0_224) AT=90.025n

.meas tran vdout0_225ck170 FIND v(dout0_225) AT=90.025n

.meas tran vdout0_226ck170 FIND v(dout0_226) AT=90.025n

.meas tran vdout0_227ck170 FIND v(dout0_227) AT=90.025n

.meas tran vdout0_228ck170 FIND v(dout0_228) AT=90.025n

.meas tran vdout0_229ck170 FIND v(dout0_229) AT=90.025n

.meas tran vdout0_230ck170 FIND v(dout0_230) AT=90.025n

.meas tran vdout0_231ck170 FIND v(dout0_231) AT=90.025n

.meas tran vdout0_232ck170 FIND v(dout0_232) AT=90.025n

.meas tran vdout0_233ck170 FIND v(dout0_233) AT=90.025n

.meas tran vdout0_234ck170 FIND v(dout0_234) AT=90.025n

.meas tran vdout0_235ck170 FIND v(dout0_235) AT=90.025n

.meas tran vdout0_236ck170 FIND v(dout0_236) AT=90.025n

.meas tran vdout0_237ck170 FIND v(dout0_237) AT=90.025n

.meas tran vdout0_238ck170 FIND v(dout0_238) AT=90.025n

.meas tran vdout0_239ck170 FIND v(dout0_239) AT=90.025n

.meas tran vdout0_240ck170 FIND v(dout0_240) AT=90.025n

.meas tran vdout0_241ck170 FIND v(dout0_241) AT=90.025n

.meas tran vdout0_242ck170 FIND v(dout0_242) AT=90.025n

.meas tran vdout0_243ck170 FIND v(dout0_243) AT=90.025n

.meas tran vdout0_244ck170 FIND v(dout0_244) AT=90.025n

.meas tran vdout0_245ck170 FIND v(dout0_245) AT=90.025n

.meas tran vdout0_246ck170 FIND v(dout0_246) AT=90.025n

.meas tran vdout0_247ck170 FIND v(dout0_247) AT=90.025n

.meas tran vdout0_248ck170 FIND v(dout0_248) AT=90.025n

.meas tran vdout0_249ck170 FIND v(dout0_249) AT=90.025n

.meas tran vdout0_250ck170 FIND v(dout0_250) AT=90.025n

.meas tran vdout0_251ck170 FIND v(dout0_251) AT=90.025n

.meas tran vdout0_252ck170 FIND v(dout0_252) AT=90.025n

.meas tran vdout0_253ck170 FIND v(dout0_253) AT=90.025n

.meas tran vdout0_254ck170 FIND v(dout0_254) AT=90.025n

.meas tran vdout0_255ck170 FIND v(dout0_255) AT=90.025n

.meas tran vdout0_0ck200 FIND v(dout0_0) AT=105.025n

.meas tran vdout0_1ck200 FIND v(dout0_1) AT=105.025n

.meas tran vdout0_2ck200 FIND v(dout0_2) AT=105.025n

.meas tran vdout0_3ck200 FIND v(dout0_3) AT=105.025n

.meas tran vdout0_4ck200 FIND v(dout0_4) AT=105.025n

.meas tran vdout0_5ck200 FIND v(dout0_5) AT=105.025n

.meas tran vdout0_6ck200 FIND v(dout0_6) AT=105.025n

.meas tran vdout0_7ck200 FIND v(dout0_7) AT=105.025n

.meas tran vdout0_8ck200 FIND v(dout0_8) AT=105.025n

.meas tran vdout0_9ck200 FIND v(dout0_9) AT=105.025n

.meas tran vdout0_10ck200 FIND v(dout0_10) AT=105.025n

.meas tran vdout0_11ck200 FIND v(dout0_11) AT=105.025n

.meas tran vdout0_12ck200 FIND v(dout0_12) AT=105.025n

.meas tran vdout0_13ck200 FIND v(dout0_13) AT=105.025n

.meas tran vdout0_14ck200 FIND v(dout0_14) AT=105.025n

.meas tran vdout0_15ck200 FIND v(dout0_15) AT=105.025n

.meas tran vdout0_16ck200 FIND v(dout0_16) AT=105.025n

.meas tran vdout0_17ck200 FIND v(dout0_17) AT=105.025n

.meas tran vdout0_18ck200 FIND v(dout0_18) AT=105.025n

.meas tran vdout0_19ck200 FIND v(dout0_19) AT=105.025n

.meas tran vdout0_20ck200 FIND v(dout0_20) AT=105.025n

.meas tran vdout0_21ck200 FIND v(dout0_21) AT=105.025n

.meas tran vdout0_22ck200 FIND v(dout0_22) AT=105.025n

.meas tran vdout0_23ck200 FIND v(dout0_23) AT=105.025n

.meas tran vdout0_24ck200 FIND v(dout0_24) AT=105.025n

.meas tran vdout0_25ck200 FIND v(dout0_25) AT=105.025n

.meas tran vdout0_26ck200 FIND v(dout0_26) AT=105.025n

.meas tran vdout0_27ck200 FIND v(dout0_27) AT=105.025n

.meas tran vdout0_28ck200 FIND v(dout0_28) AT=105.025n

.meas tran vdout0_29ck200 FIND v(dout0_29) AT=105.025n

.meas tran vdout0_30ck200 FIND v(dout0_30) AT=105.025n

.meas tran vdout0_31ck200 FIND v(dout0_31) AT=105.025n

.meas tran vdout0_32ck200 FIND v(dout0_32) AT=105.025n

.meas tran vdout0_33ck200 FIND v(dout0_33) AT=105.025n

.meas tran vdout0_34ck200 FIND v(dout0_34) AT=105.025n

.meas tran vdout0_35ck200 FIND v(dout0_35) AT=105.025n

.meas tran vdout0_36ck200 FIND v(dout0_36) AT=105.025n

.meas tran vdout0_37ck200 FIND v(dout0_37) AT=105.025n

.meas tran vdout0_38ck200 FIND v(dout0_38) AT=105.025n

.meas tran vdout0_39ck200 FIND v(dout0_39) AT=105.025n

.meas tran vdout0_40ck200 FIND v(dout0_40) AT=105.025n

.meas tran vdout0_41ck200 FIND v(dout0_41) AT=105.025n

.meas tran vdout0_42ck200 FIND v(dout0_42) AT=105.025n

.meas tran vdout0_43ck200 FIND v(dout0_43) AT=105.025n

.meas tran vdout0_44ck200 FIND v(dout0_44) AT=105.025n

.meas tran vdout0_45ck200 FIND v(dout0_45) AT=105.025n

.meas tran vdout0_46ck200 FIND v(dout0_46) AT=105.025n

.meas tran vdout0_47ck200 FIND v(dout0_47) AT=105.025n

.meas tran vdout0_48ck200 FIND v(dout0_48) AT=105.025n

.meas tran vdout0_49ck200 FIND v(dout0_49) AT=105.025n

.meas tran vdout0_50ck200 FIND v(dout0_50) AT=105.025n

.meas tran vdout0_51ck200 FIND v(dout0_51) AT=105.025n

.meas tran vdout0_52ck200 FIND v(dout0_52) AT=105.025n

.meas tran vdout0_53ck200 FIND v(dout0_53) AT=105.025n

.meas tran vdout0_54ck200 FIND v(dout0_54) AT=105.025n

.meas tran vdout0_55ck200 FIND v(dout0_55) AT=105.025n

.meas tran vdout0_56ck200 FIND v(dout0_56) AT=105.025n

.meas tran vdout0_57ck200 FIND v(dout0_57) AT=105.025n

.meas tran vdout0_58ck200 FIND v(dout0_58) AT=105.025n

.meas tran vdout0_59ck200 FIND v(dout0_59) AT=105.025n

.meas tran vdout0_60ck200 FIND v(dout0_60) AT=105.025n

.meas tran vdout0_61ck200 FIND v(dout0_61) AT=105.025n

.meas tran vdout0_62ck200 FIND v(dout0_62) AT=105.025n

.meas tran vdout0_63ck200 FIND v(dout0_63) AT=105.025n

.meas tran vdout0_64ck200 FIND v(dout0_64) AT=105.025n

.meas tran vdout0_65ck200 FIND v(dout0_65) AT=105.025n

.meas tran vdout0_66ck200 FIND v(dout0_66) AT=105.025n

.meas tran vdout0_67ck200 FIND v(dout0_67) AT=105.025n

.meas tran vdout0_68ck200 FIND v(dout0_68) AT=105.025n

.meas tran vdout0_69ck200 FIND v(dout0_69) AT=105.025n

.meas tran vdout0_70ck200 FIND v(dout0_70) AT=105.025n

.meas tran vdout0_71ck200 FIND v(dout0_71) AT=105.025n

.meas tran vdout0_72ck200 FIND v(dout0_72) AT=105.025n

.meas tran vdout0_73ck200 FIND v(dout0_73) AT=105.025n

.meas tran vdout0_74ck200 FIND v(dout0_74) AT=105.025n

.meas tran vdout0_75ck200 FIND v(dout0_75) AT=105.025n

.meas tran vdout0_76ck200 FIND v(dout0_76) AT=105.025n

.meas tran vdout0_77ck200 FIND v(dout0_77) AT=105.025n

.meas tran vdout0_78ck200 FIND v(dout0_78) AT=105.025n

.meas tran vdout0_79ck200 FIND v(dout0_79) AT=105.025n

.meas tran vdout0_80ck200 FIND v(dout0_80) AT=105.025n

.meas tran vdout0_81ck200 FIND v(dout0_81) AT=105.025n

.meas tran vdout0_82ck200 FIND v(dout0_82) AT=105.025n

.meas tran vdout0_83ck200 FIND v(dout0_83) AT=105.025n

.meas tran vdout0_84ck200 FIND v(dout0_84) AT=105.025n

.meas tran vdout0_85ck200 FIND v(dout0_85) AT=105.025n

.meas tran vdout0_86ck200 FIND v(dout0_86) AT=105.025n

.meas tran vdout0_87ck200 FIND v(dout0_87) AT=105.025n

.meas tran vdout0_88ck200 FIND v(dout0_88) AT=105.025n

.meas tran vdout0_89ck200 FIND v(dout0_89) AT=105.025n

.meas tran vdout0_90ck200 FIND v(dout0_90) AT=105.025n

.meas tran vdout0_91ck200 FIND v(dout0_91) AT=105.025n

.meas tran vdout0_92ck200 FIND v(dout0_92) AT=105.025n

.meas tran vdout0_93ck200 FIND v(dout0_93) AT=105.025n

.meas tran vdout0_94ck200 FIND v(dout0_94) AT=105.025n

.meas tran vdout0_95ck200 FIND v(dout0_95) AT=105.025n

.meas tran vdout0_96ck200 FIND v(dout0_96) AT=105.025n

.meas tran vdout0_97ck200 FIND v(dout0_97) AT=105.025n

.meas tran vdout0_98ck200 FIND v(dout0_98) AT=105.025n

.meas tran vdout0_99ck200 FIND v(dout0_99) AT=105.025n

.meas tran vdout0_100ck200 FIND v(dout0_100) AT=105.025n

.meas tran vdout0_101ck200 FIND v(dout0_101) AT=105.025n

.meas tran vdout0_102ck200 FIND v(dout0_102) AT=105.025n

.meas tran vdout0_103ck200 FIND v(dout0_103) AT=105.025n

.meas tran vdout0_104ck200 FIND v(dout0_104) AT=105.025n

.meas tran vdout0_105ck200 FIND v(dout0_105) AT=105.025n

.meas tran vdout0_106ck200 FIND v(dout0_106) AT=105.025n

.meas tran vdout0_107ck200 FIND v(dout0_107) AT=105.025n

.meas tran vdout0_108ck200 FIND v(dout0_108) AT=105.025n

.meas tran vdout0_109ck200 FIND v(dout0_109) AT=105.025n

.meas tran vdout0_110ck200 FIND v(dout0_110) AT=105.025n

.meas tran vdout0_111ck200 FIND v(dout0_111) AT=105.025n

.meas tran vdout0_112ck200 FIND v(dout0_112) AT=105.025n

.meas tran vdout0_113ck200 FIND v(dout0_113) AT=105.025n

.meas tran vdout0_114ck200 FIND v(dout0_114) AT=105.025n

.meas tran vdout0_115ck200 FIND v(dout0_115) AT=105.025n

.meas tran vdout0_116ck200 FIND v(dout0_116) AT=105.025n

.meas tran vdout0_117ck200 FIND v(dout0_117) AT=105.025n

.meas tran vdout0_118ck200 FIND v(dout0_118) AT=105.025n

.meas tran vdout0_119ck200 FIND v(dout0_119) AT=105.025n

.meas tran vdout0_120ck200 FIND v(dout0_120) AT=105.025n

.meas tran vdout0_121ck200 FIND v(dout0_121) AT=105.025n

.meas tran vdout0_122ck200 FIND v(dout0_122) AT=105.025n

.meas tran vdout0_123ck200 FIND v(dout0_123) AT=105.025n

.meas tran vdout0_124ck200 FIND v(dout0_124) AT=105.025n

.meas tran vdout0_125ck200 FIND v(dout0_125) AT=105.025n

.meas tran vdout0_126ck200 FIND v(dout0_126) AT=105.025n

.meas tran vdout0_127ck200 FIND v(dout0_127) AT=105.025n

.meas tran vdout0_128ck200 FIND v(dout0_128) AT=105.025n

.meas tran vdout0_129ck200 FIND v(dout0_129) AT=105.025n

.meas tran vdout0_130ck200 FIND v(dout0_130) AT=105.025n

.meas tran vdout0_131ck200 FIND v(dout0_131) AT=105.025n

.meas tran vdout0_132ck200 FIND v(dout0_132) AT=105.025n

.meas tran vdout0_133ck200 FIND v(dout0_133) AT=105.025n

.meas tran vdout0_134ck200 FIND v(dout0_134) AT=105.025n

.meas tran vdout0_135ck200 FIND v(dout0_135) AT=105.025n

.meas tran vdout0_136ck200 FIND v(dout0_136) AT=105.025n

.meas tran vdout0_137ck200 FIND v(dout0_137) AT=105.025n

.meas tran vdout0_138ck200 FIND v(dout0_138) AT=105.025n

.meas tran vdout0_139ck200 FIND v(dout0_139) AT=105.025n

.meas tran vdout0_140ck200 FIND v(dout0_140) AT=105.025n

.meas tran vdout0_141ck200 FIND v(dout0_141) AT=105.025n

.meas tran vdout0_142ck200 FIND v(dout0_142) AT=105.025n

.meas tran vdout0_143ck200 FIND v(dout0_143) AT=105.025n

.meas tran vdout0_144ck200 FIND v(dout0_144) AT=105.025n

.meas tran vdout0_145ck200 FIND v(dout0_145) AT=105.025n

.meas tran vdout0_146ck200 FIND v(dout0_146) AT=105.025n

.meas tran vdout0_147ck200 FIND v(dout0_147) AT=105.025n

.meas tran vdout0_148ck200 FIND v(dout0_148) AT=105.025n

.meas tran vdout0_149ck200 FIND v(dout0_149) AT=105.025n

.meas tran vdout0_150ck200 FIND v(dout0_150) AT=105.025n

.meas tran vdout0_151ck200 FIND v(dout0_151) AT=105.025n

.meas tran vdout0_152ck200 FIND v(dout0_152) AT=105.025n

.meas tran vdout0_153ck200 FIND v(dout0_153) AT=105.025n

.meas tran vdout0_154ck200 FIND v(dout0_154) AT=105.025n

.meas tran vdout0_155ck200 FIND v(dout0_155) AT=105.025n

.meas tran vdout0_156ck200 FIND v(dout0_156) AT=105.025n

.meas tran vdout0_157ck200 FIND v(dout0_157) AT=105.025n

.meas tran vdout0_158ck200 FIND v(dout0_158) AT=105.025n

.meas tran vdout0_159ck200 FIND v(dout0_159) AT=105.025n

.meas tran vdout0_160ck200 FIND v(dout0_160) AT=105.025n

.meas tran vdout0_161ck200 FIND v(dout0_161) AT=105.025n

.meas tran vdout0_162ck200 FIND v(dout0_162) AT=105.025n

.meas tran vdout0_163ck200 FIND v(dout0_163) AT=105.025n

.meas tran vdout0_164ck200 FIND v(dout0_164) AT=105.025n

.meas tran vdout0_165ck200 FIND v(dout0_165) AT=105.025n

.meas tran vdout0_166ck200 FIND v(dout0_166) AT=105.025n

.meas tran vdout0_167ck200 FIND v(dout0_167) AT=105.025n

.meas tran vdout0_168ck200 FIND v(dout0_168) AT=105.025n

.meas tran vdout0_169ck200 FIND v(dout0_169) AT=105.025n

.meas tran vdout0_170ck200 FIND v(dout0_170) AT=105.025n

.meas tran vdout0_171ck200 FIND v(dout0_171) AT=105.025n

.meas tran vdout0_172ck200 FIND v(dout0_172) AT=105.025n

.meas tran vdout0_173ck200 FIND v(dout0_173) AT=105.025n

.meas tran vdout0_174ck200 FIND v(dout0_174) AT=105.025n

.meas tran vdout0_175ck200 FIND v(dout0_175) AT=105.025n

.meas tran vdout0_176ck200 FIND v(dout0_176) AT=105.025n

.meas tran vdout0_177ck200 FIND v(dout0_177) AT=105.025n

.meas tran vdout0_178ck200 FIND v(dout0_178) AT=105.025n

.meas tran vdout0_179ck200 FIND v(dout0_179) AT=105.025n

.meas tran vdout0_180ck200 FIND v(dout0_180) AT=105.025n

.meas tran vdout0_181ck200 FIND v(dout0_181) AT=105.025n

.meas tran vdout0_182ck200 FIND v(dout0_182) AT=105.025n

.meas tran vdout0_183ck200 FIND v(dout0_183) AT=105.025n

.meas tran vdout0_184ck200 FIND v(dout0_184) AT=105.025n

.meas tran vdout0_185ck200 FIND v(dout0_185) AT=105.025n

.meas tran vdout0_186ck200 FIND v(dout0_186) AT=105.025n

.meas tran vdout0_187ck200 FIND v(dout0_187) AT=105.025n

.meas tran vdout0_188ck200 FIND v(dout0_188) AT=105.025n

.meas tran vdout0_189ck200 FIND v(dout0_189) AT=105.025n

.meas tran vdout0_190ck200 FIND v(dout0_190) AT=105.025n

.meas tran vdout0_191ck200 FIND v(dout0_191) AT=105.025n

.meas tran vdout0_192ck200 FIND v(dout0_192) AT=105.025n

.meas tran vdout0_193ck200 FIND v(dout0_193) AT=105.025n

.meas tran vdout0_194ck200 FIND v(dout0_194) AT=105.025n

.meas tran vdout0_195ck200 FIND v(dout0_195) AT=105.025n

.meas tran vdout0_196ck200 FIND v(dout0_196) AT=105.025n

.meas tran vdout0_197ck200 FIND v(dout0_197) AT=105.025n

.meas tran vdout0_198ck200 FIND v(dout0_198) AT=105.025n

.meas tran vdout0_199ck200 FIND v(dout0_199) AT=105.025n

.meas tran vdout0_200ck200 FIND v(dout0_200) AT=105.025n

.meas tran vdout0_201ck200 FIND v(dout0_201) AT=105.025n

.meas tran vdout0_202ck200 FIND v(dout0_202) AT=105.025n

.meas tran vdout0_203ck200 FIND v(dout0_203) AT=105.025n

.meas tran vdout0_204ck200 FIND v(dout0_204) AT=105.025n

.meas tran vdout0_205ck200 FIND v(dout0_205) AT=105.025n

.meas tran vdout0_206ck200 FIND v(dout0_206) AT=105.025n

.meas tran vdout0_207ck200 FIND v(dout0_207) AT=105.025n

.meas tran vdout0_208ck200 FIND v(dout0_208) AT=105.025n

.meas tran vdout0_209ck200 FIND v(dout0_209) AT=105.025n

.meas tran vdout0_210ck200 FIND v(dout0_210) AT=105.025n

.meas tran vdout0_211ck200 FIND v(dout0_211) AT=105.025n

.meas tran vdout0_212ck200 FIND v(dout0_212) AT=105.025n

.meas tran vdout0_213ck200 FIND v(dout0_213) AT=105.025n

.meas tran vdout0_214ck200 FIND v(dout0_214) AT=105.025n

.meas tran vdout0_215ck200 FIND v(dout0_215) AT=105.025n

.meas tran vdout0_216ck200 FIND v(dout0_216) AT=105.025n

.meas tran vdout0_217ck200 FIND v(dout0_217) AT=105.025n

.meas tran vdout0_218ck200 FIND v(dout0_218) AT=105.025n

.meas tran vdout0_219ck200 FIND v(dout0_219) AT=105.025n

.meas tran vdout0_220ck200 FIND v(dout0_220) AT=105.025n

.meas tran vdout0_221ck200 FIND v(dout0_221) AT=105.025n

.meas tran vdout0_222ck200 FIND v(dout0_222) AT=105.025n

.meas tran vdout0_223ck200 FIND v(dout0_223) AT=105.025n

.meas tran vdout0_224ck200 FIND v(dout0_224) AT=105.025n

.meas tran vdout0_225ck200 FIND v(dout0_225) AT=105.025n

.meas tran vdout0_226ck200 FIND v(dout0_226) AT=105.025n

.meas tran vdout0_227ck200 FIND v(dout0_227) AT=105.025n

.meas tran vdout0_228ck200 FIND v(dout0_228) AT=105.025n

.meas tran vdout0_229ck200 FIND v(dout0_229) AT=105.025n

.meas tran vdout0_230ck200 FIND v(dout0_230) AT=105.025n

.meas tran vdout0_231ck200 FIND v(dout0_231) AT=105.025n

.meas tran vdout0_232ck200 FIND v(dout0_232) AT=105.025n

.meas tran vdout0_233ck200 FIND v(dout0_233) AT=105.025n

.meas tran vdout0_234ck200 FIND v(dout0_234) AT=105.025n

.meas tran vdout0_235ck200 FIND v(dout0_235) AT=105.025n

.meas tran vdout0_236ck200 FIND v(dout0_236) AT=105.025n

.meas tran vdout0_237ck200 FIND v(dout0_237) AT=105.025n

.meas tran vdout0_238ck200 FIND v(dout0_238) AT=105.025n

.meas tran vdout0_239ck200 FIND v(dout0_239) AT=105.025n

.meas tran vdout0_240ck200 FIND v(dout0_240) AT=105.025n

.meas tran vdout0_241ck200 FIND v(dout0_241) AT=105.025n

.meas tran vdout0_242ck200 FIND v(dout0_242) AT=105.025n

.meas tran vdout0_243ck200 FIND v(dout0_243) AT=105.025n

.meas tran vdout0_244ck200 FIND v(dout0_244) AT=105.025n

.meas tran vdout0_245ck200 FIND v(dout0_245) AT=105.025n

.meas tran vdout0_246ck200 FIND v(dout0_246) AT=105.025n

.meas tran vdout0_247ck200 FIND v(dout0_247) AT=105.025n

.meas tran vdout0_248ck200 FIND v(dout0_248) AT=105.025n

.meas tran vdout0_249ck200 FIND v(dout0_249) AT=105.025n

.meas tran vdout0_250ck200 FIND v(dout0_250) AT=105.025n

.meas tran vdout0_251ck200 FIND v(dout0_251) AT=105.025n

.meas tran vdout0_252ck200 FIND v(dout0_252) AT=105.025n

.meas tran vdout0_253ck200 FIND v(dout0_253) AT=105.025n

.meas tran vdout0_254ck200 FIND v(dout0_254) AT=105.025n

.meas tran vdout0_255ck200 FIND v(dout0_255) AT=105.025n

.meas tran vdout0_0ck240 FIND v(dout0_0) AT=125.025n

.meas tran vdout0_1ck240 FIND v(dout0_1) AT=125.025n

.meas tran vdout0_2ck240 FIND v(dout0_2) AT=125.025n

.meas tran vdout0_3ck240 FIND v(dout0_3) AT=125.025n

.meas tran vdout0_4ck240 FIND v(dout0_4) AT=125.025n

.meas tran vdout0_5ck240 FIND v(dout0_5) AT=125.025n

.meas tran vdout0_6ck240 FIND v(dout0_6) AT=125.025n

.meas tran vdout0_7ck240 FIND v(dout0_7) AT=125.025n

.meas tran vdout0_8ck240 FIND v(dout0_8) AT=125.025n

.meas tran vdout0_9ck240 FIND v(dout0_9) AT=125.025n

.meas tran vdout0_10ck240 FIND v(dout0_10) AT=125.025n

.meas tran vdout0_11ck240 FIND v(dout0_11) AT=125.025n

.meas tran vdout0_12ck240 FIND v(dout0_12) AT=125.025n

.meas tran vdout0_13ck240 FIND v(dout0_13) AT=125.025n

.meas tran vdout0_14ck240 FIND v(dout0_14) AT=125.025n

.meas tran vdout0_15ck240 FIND v(dout0_15) AT=125.025n

.meas tran vdout0_16ck240 FIND v(dout0_16) AT=125.025n

.meas tran vdout0_17ck240 FIND v(dout0_17) AT=125.025n

.meas tran vdout0_18ck240 FIND v(dout0_18) AT=125.025n

.meas tran vdout0_19ck240 FIND v(dout0_19) AT=125.025n

.meas tran vdout0_20ck240 FIND v(dout0_20) AT=125.025n

.meas tran vdout0_21ck240 FIND v(dout0_21) AT=125.025n

.meas tran vdout0_22ck240 FIND v(dout0_22) AT=125.025n

.meas tran vdout0_23ck240 FIND v(dout0_23) AT=125.025n

.meas tran vdout0_24ck240 FIND v(dout0_24) AT=125.025n

.meas tran vdout0_25ck240 FIND v(dout0_25) AT=125.025n

.meas tran vdout0_26ck240 FIND v(dout0_26) AT=125.025n

.meas tran vdout0_27ck240 FIND v(dout0_27) AT=125.025n

.meas tran vdout0_28ck240 FIND v(dout0_28) AT=125.025n

.meas tran vdout0_29ck240 FIND v(dout0_29) AT=125.025n

.meas tran vdout0_30ck240 FIND v(dout0_30) AT=125.025n

.meas tran vdout0_31ck240 FIND v(dout0_31) AT=125.025n

.meas tran vdout0_32ck240 FIND v(dout0_32) AT=125.025n

.meas tran vdout0_33ck240 FIND v(dout0_33) AT=125.025n

.meas tran vdout0_34ck240 FIND v(dout0_34) AT=125.025n

.meas tran vdout0_35ck240 FIND v(dout0_35) AT=125.025n

.meas tran vdout0_36ck240 FIND v(dout0_36) AT=125.025n

.meas tran vdout0_37ck240 FIND v(dout0_37) AT=125.025n

.meas tran vdout0_38ck240 FIND v(dout0_38) AT=125.025n

.meas tran vdout0_39ck240 FIND v(dout0_39) AT=125.025n

.meas tran vdout0_40ck240 FIND v(dout0_40) AT=125.025n

.meas tran vdout0_41ck240 FIND v(dout0_41) AT=125.025n

.meas tran vdout0_42ck240 FIND v(dout0_42) AT=125.025n

.meas tran vdout0_43ck240 FIND v(dout0_43) AT=125.025n

.meas tran vdout0_44ck240 FIND v(dout0_44) AT=125.025n

.meas tran vdout0_45ck240 FIND v(dout0_45) AT=125.025n

.meas tran vdout0_46ck240 FIND v(dout0_46) AT=125.025n

.meas tran vdout0_47ck240 FIND v(dout0_47) AT=125.025n

.meas tran vdout0_48ck240 FIND v(dout0_48) AT=125.025n

.meas tran vdout0_49ck240 FIND v(dout0_49) AT=125.025n

.meas tran vdout0_50ck240 FIND v(dout0_50) AT=125.025n

.meas tran vdout0_51ck240 FIND v(dout0_51) AT=125.025n

.meas tran vdout0_52ck240 FIND v(dout0_52) AT=125.025n

.meas tran vdout0_53ck240 FIND v(dout0_53) AT=125.025n

.meas tran vdout0_54ck240 FIND v(dout0_54) AT=125.025n

.meas tran vdout0_55ck240 FIND v(dout0_55) AT=125.025n

.meas tran vdout0_56ck240 FIND v(dout0_56) AT=125.025n

.meas tran vdout0_57ck240 FIND v(dout0_57) AT=125.025n

.meas tran vdout0_58ck240 FIND v(dout0_58) AT=125.025n

.meas tran vdout0_59ck240 FIND v(dout0_59) AT=125.025n

.meas tran vdout0_60ck240 FIND v(dout0_60) AT=125.025n

.meas tran vdout0_61ck240 FIND v(dout0_61) AT=125.025n

.meas tran vdout0_62ck240 FIND v(dout0_62) AT=125.025n

.meas tran vdout0_63ck240 FIND v(dout0_63) AT=125.025n

.meas tran vdout0_64ck240 FIND v(dout0_64) AT=125.025n

.meas tran vdout0_65ck240 FIND v(dout0_65) AT=125.025n

.meas tran vdout0_66ck240 FIND v(dout0_66) AT=125.025n

.meas tran vdout0_67ck240 FIND v(dout0_67) AT=125.025n

.meas tran vdout0_68ck240 FIND v(dout0_68) AT=125.025n

.meas tran vdout0_69ck240 FIND v(dout0_69) AT=125.025n

.meas tran vdout0_70ck240 FIND v(dout0_70) AT=125.025n

.meas tran vdout0_71ck240 FIND v(dout0_71) AT=125.025n

.meas tran vdout0_72ck240 FIND v(dout0_72) AT=125.025n

.meas tran vdout0_73ck240 FIND v(dout0_73) AT=125.025n

.meas tran vdout0_74ck240 FIND v(dout0_74) AT=125.025n

.meas tran vdout0_75ck240 FIND v(dout0_75) AT=125.025n

.meas tran vdout0_76ck240 FIND v(dout0_76) AT=125.025n

.meas tran vdout0_77ck240 FIND v(dout0_77) AT=125.025n

.meas tran vdout0_78ck240 FIND v(dout0_78) AT=125.025n

.meas tran vdout0_79ck240 FIND v(dout0_79) AT=125.025n

.meas tran vdout0_80ck240 FIND v(dout0_80) AT=125.025n

.meas tran vdout0_81ck240 FIND v(dout0_81) AT=125.025n

.meas tran vdout0_82ck240 FIND v(dout0_82) AT=125.025n

.meas tran vdout0_83ck240 FIND v(dout0_83) AT=125.025n

.meas tran vdout0_84ck240 FIND v(dout0_84) AT=125.025n

.meas tran vdout0_85ck240 FIND v(dout0_85) AT=125.025n

.meas tran vdout0_86ck240 FIND v(dout0_86) AT=125.025n

.meas tran vdout0_87ck240 FIND v(dout0_87) AT=125.025n

.meas tran vdout0_88ck240 FIND v(dout0_88) AT=125.025n

.meas tran vdout0_89ck240 FIND v(dout0_89) AT=125.025n

.meas tran vdout0_90ck240 FIND v(dout0_90) AT=125.025n

.meas tran vdout0_91ck240 FIND v(dout0_91) AT=125.025n

.meas tran vdout0_92ck240 FIND v(dout0_92) AT=125.025n

.meas tran vdout0_93ck240 FIND v(dout0_93) AT=125.025n

.meas tran vdout0_94ck240 FIND v(dout0_94) AT=125.025n

.meas tran vdout0_95ck240 FIND v(dout0_95) AT=125.025n

.meas tran vdout0_96ck240 FIND v(dout0_96) AT=125.025n

.meas tran vdout0_97ck240 FIND v(dout0_97) AT=125.025n

.meas tran vdout0_98ck240 FIND v(dout0_98) AT=125.025n

.meas tran vdout0_99ck240 FIND v(dout0_99) AT=125.025n

.meas tran vdout0_100ck240 FIND v(dout0_100) AT=125.025n

.meas tran vdout0_101ck240 FIND v(dout0_101) AT=125.025n

.meas tran vdout0_102ck240 FIND v(dout0_102) AT=125.025n

.meas tran vdout0_103ck240 FIND v(dout0_103) AT=125.025n

.meas tran vdout0_104ck240 FIND v(dout0_104) AT=125.025n

.meas tran vdout0_105ck240 FIND v(dout0_105) AT=125.025n

.meas tran vdout0_106ck240 FIND v(dout0_106) AT=125.025n

.meas tran vdout0_107ck240 FIND v(dout0_107) AT=125.025n

.meas tran vdout0_108ck240 FIND v(dout0_108) AT=125.025n

.meas tran vdout0_109ck240 FIND v(dout0_109) AT=125.025n

.meas tran vdout0_110ck240 FIND v(dout0_110) AT=125.025n

.meas tran vdout0_111ck240 FIND v(dout0_111) AT=125.025n

.meas tran vdout0_112ck240 FIND v(dout0_112) AT=125.025n

.meas tran vdout0_113ck240 FIND v(dout0_113) AT=125.025n

.meas tran vdout0_114ck240 FIND v(dout0_114) AT=125.025n

.meas tran vdout0_115ck240 FIND v(dout0_115) AT=125.025n

.meas tran vdout0_116ck240 FIND v(dout0_116) AT=125.025n

.meas tran vdout0_117ck240 FIND v(dout0_117) AT=125.025n

.meas tran vdout0_118ck240 FIND v(dout0_118) AT=125.025n

.meas tran vdout0_119ck240 FIND v(dout0_119) AT=125.025n

.meas tran vdout0_120ck240 FIND v(dout0_120) AT=125.025n

.meas tran vdout0_121ck240 FIND v(dout0_121) AT=125.025n

.meas tran vdout0_122ck240 FIND v(dout0_122) AT=125.025n

.meas tran vdout0_123ck240 FIND v(dout0_123) AT=125.025n

.meas tran vdout0_124ck240 FIND v(dout0_124) AT=125.025n

.meas tran vdout0_125ck240 FIND v(dout0_125) AT=125.025n

.meas tran vdout0_126ck240 FIND v(dout0_126) AT=125.025n

.meas tran vdout0_127ck240 FIND v(dout0_127) AT=125.025n

.meas tran vdout0_128ck240 FIND v(dout0_128) AT=125.025n

.meas tran vdout0_129ck240 FIND v(dout0_129) AT=125.025n

.meas tran vdout0_130ck240 FIND v(dout0_130) AT=125.025n

.meas tran vdout0_131ck240 FIND v(dout0_131) AT=125.025n

.meas tran vdout0_132ck240 FIND v(dout0_132) AT=125.025n

.meas tran vdout0_133ck240 FIND v(dout0_133) AT=125.025n

.meas tran vdout0_134ck240 FIND v(dout0_134) AT=125.025n

.meas tran vdout0_135ck240 FIND v(dout0_135) AT=125.025n

.meas tran vdout0_136ck240 FIND v(dout0_136) AT=125.025n

.meas tran vdout0_137ck240 FIND v(dout0_137) AT=125.025n

.meas tran vdout0_138ck240 FIND v(dout0_138) AT=125.025n

.meas tran vdout0_139ck240 FIND v(dout0_139) AT=125.025n

.meas tran vdout0_140ck240 FIND v(dout0_140) AT=125.025n

.meas tran vdout0_141ck240 FIND v(dout0_141) AT=125.025n

.meas tran vdout0_142ck240 FIND v(dout0_142) AT=125.025n

.meas tran vdout0_143ck240 FIND v(dout0_143) AT=125.025n

.meas tran vdout0_144ck240 FIND v(dout0_144) AT=125.025n

.meas tran vdout0_145ck240 FIND v(dout0_145) AT=125.025n

.meas tran vdout0_146ck240 FIND v(dout0_146) AT=125.025n

.meas tran vdout0_147ck240 FIND v(dout0_147) AT=125.025n

.meas tran vdout0_148ck240 FIND v(dout0_148) AT=125.025n

.meas tran vdout0_149ck240 FIND v(dout0_149) AT=125.025n

.meas tran vdout0_150ck240 FIND v(dout0_150) AT=125.025n

.meas tran vdout0_151ck240 FIND v(dout0_151) AT=125.025n

.meas tran vdout0_152ck240 FIND v(dout0_152) AT=125.025n

.meas tran vdout0_153ck240 FIND v(dout0_153) AT=125.025n

.meas tran vdout0_154ck240 FIND v(dout0_154) AT=125.025n

.meas tran vdout0_155ck240 FIND v(dout0_155) AT=125.025n

.meas tran vdout0_156ck240 FIND v(dout0_156) AT=125.025n

.meas tran vdout0_157ck240 FIND v(dout0_157) AT=125.025n

.meas tran vdout0_158ck240 FIND v(dout0_158) AT=125.025n

.meas tran vdout0_159ck240 FIND v(dout0_159) AT=125.025n

.meas tran vdout0_160ck240 FIND v(dout0_160) AT=125.025n

.meas tran vdout0_161ck240 FIND v(dout0_161) AT=125.025n

.meas tran vdout0_162ck240 FIND v(dout0_162) AT=125.025n

.meas tran vdout0_163ck240 FIND v(dout0_163) AT=125.025n

.meas tran vdout0_164ck240 FIND v(dout0_164) AT=125.025n

.meas tran vdout0_165ck240 FIND v(dout0_165) AT=125.025n

.meas tran vdout0_166ck240 FIND v(dout0_166) AT=125.025n

.meas tran vdout0_167ck240 FIND v(dout0_167) AT=125.025n

.meas tran vdout0_168ck240 FIND v(dout0_168) AT=125.025n

.meas tran vdout0_169ck240 FIND v(dout0_169) AT=125.025n

.meas tran vdout0_170ck240 FIND v(dout0_170) AT=125.025n

.meas tran vdout0_171ck240 FIND v(dout0_171) AT=125.025n

.meas tran vdout0_172ck240 FIND v(dout0_172) AT=125.025n

.meas tran vdout0_173ck240 FIND v(dout0_173) AT=125.025n

.meas tran vdout0_174ck240 FIND v(dout0_174) AT=125.025n

.meas tran vdout0_175ck240 FIND v(dout0_175) AT=125.025n

.meas tran vdout0_176ck240 FIND v(dout0_176) AT=125.025n

.meas tran vdout0_177ck240 FIND v(dout0_177) AT=125.025n

.meas tran vdout0_178ck240 FIND v(dout0_178) AT=125.025n

.meas tran vdout0_179ck240 FIND v(dout0_179) AT=125.025n

.meas tran vdout0_180ck240 FIND v(dout0_180) AT=125.025n

.meas tran vdout0_181ck240 FIND v(dout0_181) AT=125.025n

.meas tran vdout0_182ck240 FIND v(dout0_182) AT=125.025n

.meas tran vdout0_183ck240 FIND v(dout0_183) AT=125.025n

.meas tran vdout0_184ck240 FIND v(dout0_184) AT=125.025n

.meas tran vdout0_185ck240 FIND v(dout0_185) AT=125.025n

.meas tran vdout0_186ck240 FIND v(dout0_186) AT=125.025n

.meas tran vdout0_187ck240 FIND v(dout0_187) AT=125.025n

.meas tran vdout0_188ck240 FIND v(dout0_188) AT=125.025n

.meas tran vdout0_189ck240 FIND v(dout0_189) AT=125.025n

.meas tran vdout0_190ck240 FIND v(dout0_190) AT=125.025n

.meas tran vdout0_191ck240 FIND v(dout0_191) AT=125.025n

.meas tran vdout0_192ck240 FIND v(dout0_192) AT=125.025n

.meas tran vdout0_193ck240 FIND v(dout0_193) AT=125.025n

.meas tran vdout0_194ck240 FIND v(dout0_194) AT=125.025n

.meas tran vdout0_195ck240 FIND v(dout0_195) AT=125.025n

.meas tran vdout0_196ck240 FIND v(dout0_196) AT=125.025n

.meas tran vdout0_197ck240 FIND v(dout0_197) AT=125.025n

.meas tran vdout0_198ck240 FIND v(dout0_198) AT=125.025n

.meas tran vdout0_199ck240 FIND v(dout0_199) AT=125.025n

.meas tran vdout0_200ck240 FIND v(dout0_200) AT=125.025n

.meas tran vdout0_201ck240 FIND v(dout0_201) AT=125.025n

.meas tran vdout0_202ck240 FIND v(dout0_202) AT=125.025n

.meas tran vdout0_203ck240 FIND v(dout0_203) AT=125.025n

.meas tran vdout0_204ck240 FIND v(dout0_204) AT=125.025n

.meas tran vdout0_205ck240 FIND v(dout0_205) AT=125.025n

.meas tran vdout0_206ck240 FIND v(dout0_206) AT=125.025n

.meas tran vdout0_207ck240 FIND v(dout0_207) AT=125.025n

.meas tran vdout0_208ck240 FIND v(dout0_208) AT=125.025n

.meas tran vdout0_209ck240 FIND v(dout0_209) AT=125.025n

.meas tran vdout0_210ck240 FIND v(dout0_210) AT=125.025n

.meas tran vdout0_211ck240 FIND v(dout0_211) AT=125.025n

.meas tran vdout0_212ck240 FIND v(dout0_212) AT=125.025n

.meas tran vdout0_213ck240 FIND v(dout0_213) AT=125.025n

.meas tran vdout0_214ck240 FIND v(dout0_214) AT=125.025n

.meas tran vdout0_215ck240 FIND v(dout0_215) AT=125.025n

.meas tran vdout0_216ck240 FIND v(dout0_216) AT=125.025n

.meas tran vdout0_217ck240 FIND v(dout0_217) AT=125.025n

.meas tran vdout0_218ck240 FIND v(dout0_218) AT=125.025n

.meas tran vdout0_219ck240 FIND v(dout0_219) AT=125.025n

.meas tran vdout0_220ck240 FIND v(dout0_220) AT=125.025n

.meas tran vdout0_221ck240 FIND v(dout0_221) AT=125.025n

.meas tran vdout0_222ck240 FIND v(dout0_222) AT=125.025n

.meas tran vdout0_223ck240 FIND v(dout0_223) AT=125.025n

.meas tran vdout0_224ck240 FIND v(dout0_224) AT=125.025n

.meas tran vdout0_225ck240 FIND v(dout0_225) AT=125.025n

.meas tran vdout0_226ck240 FIND v(dout0_226) AT=125.025n

.meas tran vdout0_227ck240 FIND v(dout0_227) AT=125.025n

.meas tran vdout0_228ck240 FIND v(dout0_228) AT=125.025n

.meas tran vdout0_229ck240 FIND v(dout0_229) AT=125.025n

.meas tran vdout0_230ck240 FIND v(dout0_230) AT=125.025n

.meas tran vdout0_231ck240 FIND v(dout0_231) AT=125.025n

.meas tran vdout0_232ck240 FIND v(dout0_232) AT=125.025n

.meas tran vdout0_233ck240 FIND v(dout0_233) AT=125.025n

.meas tran vdout0_234ck240 FIND v(dout0_234) AT=125.025n

.meas tran vdout0_235ck240 FIND v(dout0_235) AT=125.025n

.meas tran vdout0_236ck240 FIND v(dout0_236) AT=125.025n

.meas tran vdout0_237ck240 FIND v(dout0_237) AT=125.025n

.meas tran vdout0_238ck240 FIND v(dout0_238) AT=125.025n

.meas tran vdout0_239ck240 FIND v(dout0_239) AT=125.025n

.meas tran vdout0_240ck240 FIND v(dout0_240) AT=125.025n

.meas tran vdout0_241ck240 FIND v(dout0_241) AT=125.025n

.meas tran vdout0_242ck240 FIND v(dout0_242) AT=125.025n

.meas tran vdout0_243ck240 FIND v(dout0_243) AT=125.025n

.meas tran vdout0_244ck240 FIND v(dout0_244) AT=125.025n

.meas tran vdout0_245ck240 FIND v(dout0_245) AT=125.025n

.meas tran vdout0_246ck240 FIND v(dout0_246) AT=125.025n

.meas tran vdout0_247ck240 FIND v(dout0_247) AT=125.025n

.meas tran vdout0_248ck240 FIND v(dout0_248) AT=125.025n

.meas tran vdout0_249ck240 FIND v(dout0_249) AT=125.025n

.meas tran vdout0_250ck240 FIND v(dout0_250) AT=125.025n

.meas tran vdout0_251ck240 FIND v(dout0_251) AT=125.025n

.meas tran vdout0_252ck240 FIND v(dout0_252) AT=125.025n

.meas tran vdout0_253ck240 FIND v(dout0_253) AT=125.025n

.meas tran vdout0_254ck240 FIND v(dout0_254) AT=125.025n

.meas tran vdout0_255ck240 FIND v(dout0_255) AT=125.025n

.meas tran vdout0_0ck280 FIND v(dout0_0) AT=145.025n

.meas tran vdout0_1ck280 FIND v(dout0_1) AT=145.025n

.meas tran vdout0_2ck280 FIND v(dout0_2) AT=145.025n

.meas tran vdout0_3ck280 FIND v(dout0_3) AT=145.025n

.meas tran vdout0_4ck280 FIND v(dout0_4) AT=145.025n

.meas tran vdout0_5ck280 FIND v(dout0_5) AT=145.025n

.meas tran vdout0_6ck280 FIND v(dout0_6) AT=145.025n

.meas tran vdout0_7ck280 FIND v(dout0_7) AT=145.025n

.meas tran vdout0_8ck280 FIND v(dout0_8) AT=145.025n

.meas tran vdout0_9ck280 FIND v(dout0_9) AT=145.025n

.meas tran vdout0_10ck280 FIND v(dout0_10) AT=145.025n

.meas tran vdout0_11ck280 FIND v(dout0_11) AT=145.025n

.meas tran vdout0_12ck280 FIND v(dout0_12) AT=145.025n

.meas tran vdout0_13ck280 FIND v(dout0_13) AT=145.025n

.meas tran vdout0_14ck280 FIND v(dout0_14) AT=145.025n

.meas tran vdout0_15ck280 FIND v(dout0_15) AT=145.025n

.meas tran vdout0_16ck280 FIND v(dout0_16) AT=145.025n

.meas tran vdout0_17ck280 FIND v(dout0_17) AT=145.025n

.meas tran vdout0_18ck280 FIND v(dout0_18) AT=145.025n

.meas tran vdout0_19ck280 FIND v(dout0_19) AT=145.025n

.meas tran vdout0_20ck280 FIND v(dout0_20) AT=145.025n

.meas tran vdout0_21ck280 FIND v(dout0_21) AT=145.025n

.meas tran vdout0_22ck280 FIND v(dout0_22) AT=145.025n

.meas tran vdout0_23ck280 FIND v(dout0_23) AT=145.025n

.meas tran vdout0_24ck280 FIND v(dout0_24) AT=145.025n

.meas tran vdout0_25ck280 FIND v(dout0_25) AT=145.025n

.meas tran vdout0_26ck280 FIND v(dout0_26) AT=145.025n

.meas tran vdout0_27ck280 FIND v(dout0_27) AT=145.025n

.meas tran vdout0_28ck280 FIND v(dout0_28) AT=145.025n

.meas tran vdout0_29ck280 FIND v(dout0_29) AT=145.025n

.meas tran vdout0_30ck280 FIND v(dout0_30) AT=145.025n

.meas tran vdout0_31ck280 FIND v(dout0_31) AT=145.025n

.meas tran vdout0_32ck280 FIND v(dout0_32) AT=145.025n

.meas tran vdout0_33ck280 FIND v(dout0_33) AT=145.025n

.meas tran vdout0_34ck280 FIND v(dout0_34) AT=145.025n

.meas tran vdout0_35ck280 FIND v(dout0_35) AT=145.025n

.meas tran vdout0_36ck280 FIND v(dout0_36) AT=145.025n

.meas tran vdout0_37ck280 FIND v(dout0_37) AT=145.025n

.meas tran vdout0_38ck280 FIND v(dout0_38) AT=145.025n

.meas tran vdout0_39ck280 FIND v(dout0_39) AT=145.025n

.meas tran vdout0_40ck280 FIND v(dout0_40) AT=145.025n

.meas tran vdout0_41ck280 FIND v(dout0_41) AT=145.025n

.meas tran vdout0_42ck280 FIND v(dout0_42) AT=145.025n

.meas tran vdout0_43ck280 FIND v(dout0_43) AT=145.025n

.meas tran vdout0_44ck280 FIND v(dout0_44) AT=145.025n

.meas tran vdout0_45ck280 FIND v(dout0_45) AT=145.025n

.meas tran vdout0_46ck280 FIND v(dout0_46) AT=145.025n

.meas tran vdout0_47ck280 FIND v(dout0_47) AT=145.025n

.meas tran vdout0_48ck280 FIND v(dout0_48) AT=145.025n

.meas tran vdout0_49ck280 FIND v(dout0_49) AT=145.025n

.meas tran vdout0_50ck280 FIND v(dout0_50) AT=145.025n

.meas tran vdout0_51ck280 FIND v(dout0_51) AT=145.025n

.meas tran vdout0_52ck280 FIND v(dout0_52) AT=145.025n

.meas tran vdout0_53ck280 FIND v(dout0_53) AT=145.025n

.meas tran vdout0_54ck280 FIND v(dout0_54) AT=145.025n

.meas tran vdout0_55ck280 FIND v(dout0_55) AT=145.025n

.meas tran vdout0_56ck280 FIND v(dout0_56) AT=145.025n

.meas tran vdout0_57ck280 FIND v(dout0_57) AT=145.025n

.meas tran vdout0_58ck280 FIND v(dout0_58) AT=145.025n

.meas tran vdout0_59ck280 FIND v(dout0_59) AT=145.025n

.meas tran vdout0_60ck280 FIND v(dout0_60) AT=145.025n

.meas tran vdout0_61ck280 FIND v(dout0_61) AT=145.025n

.meas tran vdout0_62ck280 FIND v(dout0_62) AT=145.025n

.meas tran vdout0_63ck280 FIND v(dout0_63) AT=145.025n

.meas tran vdout0_64ck280 FIND v(dout0_64) AT=145.025n

.meas tran vdout0_65ck280 FIND v(dout0_65) AT=145.025n

.meas tran vdout0_66ck280 FIND v(dout0_66) AT=145.025n

.meas tran vdout0_67ck280 FIND v(dout0_67) AT=145.025n

.meas tran vdout0_68ck280 FIND v(dout0_68) AT=145.025n

.meas tran vdout0_69ck280 FIND v(dout0_69) AT=145.025n

.meas tran vdout0_70ck280 FIND v(dout0_70) AT=145.025n

.meas tran vdout0_71ck280 FIND v(dout0_71) AT=145.025n

.meas tran vdout0_72ck280 FIND v(dout0_72) AT=145.025n

.meas tran vdout0_73ck280 FIND v(dout0_73) AT=145.025n

.meas tran vdout0_74ck280 FIND v(dout0_74) AT=145.025n

.meas tran vdout0_75ck280 FIND v(dout0_75) AT=145.025n

.meas tran vdout0_76ck280 FIND v(dout0_76) AT=145.025n

.meas tran vdout0_77ck280 FIND v(dout0_77) AT=145.025n

.meas tran vdout0_78ck280 FIND v(dout0_78) AT=145.025n

.meas tran vdout0_79ck280 FIND v(dout0_79) AT=145.025n

.meas tran vdout0_80ck280 FIND v(dout0_80) AT=145.025n

.meas tran vdout0_81ck280 FIND v(dout0_81) AT=145.025n

.meas tran vdout0_82ck280 FIND v(dout0_82) AT=145.025n

.meas tran vdout0_83ck280 FIND v(dout0_83) AT=145.025n

.meas tran vdout0_84ck280 FIND v(dout0_84) AT=145.025n

.meas tran vdout0_85ck280 FIND v(dout0_85) AT=145.025n

.meas tran vdout0_86ck280 FIND v(dout0_86) AT=145.025n

.meas tran vdout0_87ck280 FIND v(dout0_87) AT=145.025n

.meas tran vdout0_88ck280 FIND v(dout0_88) AT=145.025n

.meas tran vdout0_89ck280 FIND v(dout0_89) AT=145.025n

.meas tran vdout0_90ck280 FIND v(dout0_90) AT=145.025n

.meas tran vdout0_91ck280 FIND v(dout0_91) AT=145.025n

.meas tran vdout0_92ck280 FIND v(dout0_92) AT=145.025n

.meas tran vdout0_93ck280 FIND v(dout0_93) AT=145.025n

.meas tran vdout0_94ck280 FIND v(dout0_94) AT=145.025n

.meas tran vdout0_95ck280 FIND v(dout0_95) AT=145.025n

.meas tran vdout0_96ck280 FIND v(dout0_96) AT=145.025n

.meas tran vdout0_97ck280 FIND v(dout0_97) AT=145.025n

.meas tran vdout0_98ck280 FIND v(dout0_98) AT=145.025n

.meas tran vdout0_99ck280 FIND v(dout0_99) AT=145.025n

.meas tran vdout0_100ck280 FIND v(dout0_100) AT=145.025n

.meas tran vdout0_101ck280 FIND v(dout0_101) AT=145.025n

.meas tran vdout0_102ck280 FIND v(dout0_102) AT=145.025n

.meas tran vdout0_103ck280 FIND v(dout0_103) AT=145.025n

.meas tran vdout0_104ck280 FIND v(dout0_104) AT=145.025n

.meas tran vdout0_105ck280 FIND v(dout0_105) AT=145.025n

.meas tran vdout0_106ck280 FIND v(dout0_106) AT=145.025n

.meas tran vdout0_107ck280 FIND v(dout0_107) AT=145.025n

.meas tran vdout0_108ck280 FIND v(dout0_108) AT=145.025n

.meas tran vdout0_109ck280 FIND v(dout0_109) AT=145.025n

.meas tran vdout0_110ck280 FIND v(dout0_110) AT=145.025n

.meas tran vdout0_111ck280 FIND v(dout0_111) AT=145.025n

.meas tran vdout0_112ck280 FIND v(dout0_112) AT=145.025n

.meas tran vdout0_113ck280 FIND v(dout0_113) AT=145.025n

.meas tran vdout0_114ck280 FIND v(dout0_114) AT=145.025n

.meas tran vdout0_115ck280 FIND v(dout0_115) AT=145.025n

.meas tran vdout0_116ck280 FIND v(dout0_116) AT=145.025n

.meas tran vdout0_117ck280 FIND v(dout0_117) AT=145.025n

.meas tran vdout0_118ck280 FIND v(dout0_118) AT=145.025n

.meas tran vdout0_119ck280 FIND v(dout0_119) AT=145.025n

.meas tran vdout0_120ck280 FIND v(dout0_120) AT=145.025n

.meas tran vdout0_121ck280 FIND v(dout0_121) AT=145.025n

.meas tran vdout0_122ck280 FIND v(dout0_122) AT=145.025n

.meas tran vdout0_123ck280 FIND v(dout0_123) AT=145.025n

.meas tran vdout0_124ck280 FIND v(dout0_124) AT=145.025n

.meas tran vdout0_125ck280 FIND v(dout0_125) AT=145.025n

.meas tran vdout0_126ck280 FIND v(dout0_126) AT=145.025n

.meas tran vdout0_127ck280 FIND v(dout0_127) AT=145.025n

.meas tran vdout0_128ck280 FIND v(dout0_128) AT=145.025n

.meas tran vdout0_129ck280 FIND v(dout0_129) AT=145.025n

.meas tran vdout0_130ck280 FIND v(dout0_130) AT=145.025n

.meas tran vdout0_131ck280 FIND v(dout0_131) AT=145.025n

.meas tran vdout0_132ck280 FIND v(dout0_132) AT=145.025n

.meas tran vdout0_133ck280 FIND v(dout0_133) AT=145.025n

.meas tran vdout0_134ck280 FIND v(dout0_134) AT=145.025n

.meas tran vdout0_135ck280 FIND v(dout0_135) AT=145.025n

.meas tran vdout0_136ck280 FIND v(dout0_136) AT=145.025n

.meas tran vdout0_137ck280 FIND v(dout0_137) AT=145.025n

.meas tran vdout0_138ck280 FIND v(dout0_138) AT=145.025n

.meas tran vdout0_139ck280 FIND v(dout0_139) AT=145.025n

.meas tran vdout0_140ck280 FIND v(dout0_140) AT=145.025n

.meas tran vdout0_141ck280 FIND v(dout0_141) AT=145.025n

.meas tran vdout0_142ck280 FIND v(dout0_142) AT=145.025n

.meas tran vdout0_143ck280 FIND v(dout0_143) AT=145.025n

.meas tran vdout0_144ck280 FIND v(dout0_144) AT=145.025n

.meas tran vdout0_145ck280 FIND v(dout0_145) AT=145.025n

.meas tran vdout0_146ck280 FIND v(dout0_146) AT=145.025n

.meas tran vdout0_147ck280 FIND v(dout0_147) AT=145.025n

.meas tran vdout0_148ck280 FIND v(dout0_148) AT=145.025n

.meas tran vdout0_149ck280 FIND v(dout0_149) AT=145.025n

.meas tran vdout0_150ck280 FIND v(dout0_150) AT=145.025n

.meas tran vdout0_151ck280 FIND v(dout0_151) AT=145.025n

.meas tran vdout0_152ck280 FIND v(dout0_152) AT=145.025n

.meas tran vdout0_153ck280 FIND v(dout0_153) AT=145.025n

.meas tran vdout0_154ck280 FIND v(dout0_154) AT=145.025n

.meas tran vdout0_155ck280 FIND v(dout0_155) AT=145.025n

.meas tran vdout0_156ck280 FIND v(dout0_156) AT=145.025n

.meas tran vdout0_157ck280 FIND v(dout0_157) AT=145.025n

.meas tran vdout0_158ck280 FIND v(dout0_158) AT=145.025n

.meas tran vdout0_159ck280 FIND v(dout0_159) AT=145.025n

.meas tran vdout0_160ck280 FIND v(dout0_160) AT=145.025n

.meas tran vdout0_161ck280 FIND v(dout0_161) AT=145.025n

.meas tran vdout0_162ck280 FIND v(dout0_162) AT=145.025n

.meas tran vdout0_163ck280 FIND v(dout0_163) AT=145.025n

.meas tran vdout0_164ck280 FIND v(dout0_164) AT=145.025n

.meas tran vdout0_165ck280 FIND v(dout0_165) AT=145.025n

.meas tran vdout0_166ck280 FIND v(dout0_166) AT=145.025n

.meas tran vdout0_167ck280 FIND v(dout0_167) AT=145.025n

.meas tran vdout0_168ck280 FIND v(dout0_168) AT=145.025n

.meas tran vdout0_169ck280 FIND v(dout0_169) AT=145.025n

.meas tran vdout0_170ck280 FIND v(dout0_170) AT=145.025n

.meas tran vdout0_171ck280 FIND v(dout0_171) AT=145.025n

.meas tran vdout0_172ck280 FIND v(dout0_172) AT=145.025n

.meas tran vdout0_173ck280 FIND v(dout0_173) AT=145.025n

.meas tran vdout0_174ck280 FIND v(dout0_174) AT=145.025n

.meas tran vdout0_175ck280 FIND v(dout0_175) AT=145.025n

.meas tran vdout0_176ck280 FIND v(dout0_176) AT=145.025n

.meas tran vdout0_177ck280 FIND v(dout0_177) AT=145.025n

.meas tran vdout0_178ck280 FIND v(dout0_178) AT=145.025n

.meas tran vdout0_179ck280 FIND v(dout0_179) AT=145.025n

.meas tran vdout0_180ck280 FIND v(dout0_180) AT=145.025n

.meas tran vdout0_181ck280 FIND v(dout0_181) AT=145.025n

.meas tran vdout0_182ck280 FIND v(dout0_182) AT=145.025n

.meas tran vdout0_183ck280 FIND v(dout0_183) AT=145.025n

.meas tran vdout0_184ck280 FIND v(dout0_184) AT=145.025n

.meas tran vdout0_185ck280 FIND v(dout0_185) AT=145.025n

.meas tran vdout0_186ck280 FIND v(dout0_186) AT=145.025n

.meas tran vdout0_187ck280 FIND v(dout0_187) AT=145.025n

.meas tran vdout0_188ck280 FIND v(dout0_188) AT=145.025n

.meas tran vdout0_189ck280 FIND v(dout0_189) AT=145.025n

.meas tran vdout0_190ck280 FIND v(dout0_190) AT=145.025n

.meas tran vdout0_191ck280 FIND v(dout0_191) AT=145.025n

.meas tran vdout0_192ck280 FIND v(dout0_192) AT=145.025n

.meas tran vdout0_193ck280 FIND v(dout0_193) AT=145.025n

.meas tran vdout0_194ck280 FIND v(dout0_194) AT=145.025n

.meas tran vdout0_195ck280 FIND v(dout0_195) AT=145.025n

.meas tran vdout0_196ck280 FIND v(dout0_196) AT=145.025n

.meas tran vdout0_197ck280 FIND v(dout0_197) AT=145.025n

.meas tran vdout0_198ck280 FIND v(dout0_198) AT=145.025n

.meas tran vdout0_199ck280 FIND v(dout0_199) AT=145.025n

.meas tran vdout0_200ck280 FIND v(dout0_200) AT=145.025n

.meas tran vdout0_201ck280 FIND v(dout0_201) AT=145.025n

.meas tran vdout0_202ck280 FIND v(dout0_202) AT=145.025n

.meas tran vdout0_203ck280 FIND v(dout0_203) AT=145.025n

.meas tran vdout0_204ck280 FIND v(dout0_204) AT=145.025n

.meas tran vdout0_205ck280 FIND v(dout0_205) AT=145.025n

.meas tran vdout0_206ck280 FIND v(dout0_206) AT=145.025n

.meas tran vdout0_207ck280 FIND v(dout0_207) AT=145.025n

.meas tran vdout0_208ck280 FIND v(dout0_208) AT=145.025n

.meas tran vdout0_209ck280 FIND v(dout0_209) AT=145.025n

.meas tran vdout0_210ck280 FIND v(dout0_210) AT=145.025n

.meas tran vdout0_211ck280 FIND v(dout0_211) AT=145.025n

.meas tran vdout0_212ck280 FIND v(dout0_212) AT=145.025n

.meas tran vdout0_213ck280 FIND v(dout0_213) AT=145.025n

.meas tran vdout0_214ck280 FIND v(dout0_214) AT=145.025n

.meas tran vdout0_215ck280 FIND v(dout0_215) AT=145.025n

.meas tran vdout0_216ck280 FIND v(dout0_216) AT=145.025n

.meas tran vdout0_217ck280 FIND v(dout0_217) AT=145.025n

.meas tran vdout0_218ck280 FIND v(dout0_218) AT=145.025n

.meas tran vdout0_219ck280 FIND v(dout0_219) AT=145.025n

.meas tran vdout0_220ck280 FIND v(dout0_220) AT=145.025n

.meas tran vdout0_221ck280 FIND v(dout0_221) AT=145.025n

.meas tran vdout0_222ck280 FIND v(dout0_222) AT=145.025n

.meas tran vdout0_223ck280 FIND v(dout0_223) AT=145.025n

.meas tran vdout0_224ck280 FIND v(dout0_224) AT=145.025n

.meas tran vdout0_225ck280 FIND v(dout0_225) AT=145.025n

.meas tran vdout0_226ck280 FIND v(dout0_226) AT=145.025n

.meas tran vdout0_227ck280 FIND v(dout0_227) AT=145.025n

.meas tran vdout0_228ck280 FIND v(dout0_228) AT=145.025n

.meas tran vdout0_229ck280 FIND v(dout0_229) AT=145.025n

.meas tran vdout0_230ck280 FIND v(dout0_230) AT=145.025n

.meas tran vdout0_231ck280 FIND v(dout0_231) AT=145.025n

.meas tran vdout0_232ck280 FIND v(dout0_232) AT=145.025n

.meas tran vdout0_233ck280 FIND v(dout0_233) AT=145.025n

.meas tran vdout0_234ck280 FIND v(dout0_234) AT=145.025n

.meas tran vdout0_235ck280 FIND v(dout0_235) AT=145.025n

.meas tran vdout0_236ck280 FIND v(dout0_236) AT=145.025n

.meas tran vdout0_237ck280 FIND v(dout0_237) AT=145.025n

.meas tran vdout0_238ck280 FIND v(dout0_238) AT=145.025n

.meas tran vdout0_239ck280 FIND v(dout0_239) AT=145.025n

.meas tran vdout0_240ck280 FIND v(dout0_240) AT=145.025n

.meas tran vdout0_241ck280 FIND v(dout0_241) AT=145.025n

.meas tran vdout0_242ck280 FIND v(dout0_242) AT=145.025n

.meas tran vdout0_243ck280 FIND v(dout0_243) AT=145.025n

.meas tran vdout0_244ck280 FIND v(dout0_244) AT=145.025n

.meas tran vdout0_245ck280 FIND v(dout0_245) AT=145.025n

.meas tran vdout0_246ck280 FIND v(dout0_246) AT=145.025n

.meas tran vdout0_247ck280 FIND v(dout0_247) AT=145.025n

.meas tran vdout0_248ck280 FIND v(dout0_248) AT=145.025n

.meas tran vdout0_249ck280 FIND v(dout0_249) AT=145.025n

.meas tran vdout0_250ck280 FIND v(dout0_250) AT=145.025n

.meas tran vdout0_251ck280 FIND v(dout0_251) AT=145.025n

.meas tran vdout0_252ck280 FIND v(dout0_252) AT=145.025n

.meas tran vdout0_253ck280 FIND v(dout0_253) AT=145.025n

.meas tran vdout0_254ck280 FIND v(dout0_254) AT=145.025n

.meas tran vdout0_255ck280 FIND v(dout0_255) AT=145.025n

.meas tran vdout0_0ck340 FIND v(dout0_0) AT=175.025n

.meas tran vdout0_1ck340 FIND v(dout0_1) AT=175.025n

.meas tran vdout0_2ck340 FIND v(dout0_2) AT=175.025n

.meas tran vdout0_3ck340 FIND v(dout0_3) AT=175.025n

.meas tran vdout0_4ck340 FIND v(dout0_4) AT=175.025n

.meas tran vdout0_5ck340 FIND v(dout0_5) AT=175.025n

.meas tran vdout0_6ck340 FIND v(dout0_6) AT=175.025n

.meas tran vdout0_7ck340 FIND v(dout0_7) AT=175.025n

.meas tran vdout0_8ck340 FIND v(dout0_8) AT=175.025n

.meas tran vdout0_9ck340 FIND v(dout0_9) AT=175.025n

.meas tran vdout0_10ck340 FIND v(dout0_10) AT=175.025n

.meas tran vdout0_11ck340 FIND v(dout0_11) AT=175.025n

.meas tran vdout0_12ck340 FIND v(dout0_12) AT=175.025n

.meas tran vdout0_13ck340 FIND v(dout0_13) AT=175.025n

.meas tran vdout0_14ck340 FIND v(dout0_14) AT=175.025n

.meas tran vdout0_15ck340 FIND v(dout0_15) AT=175.025n

.meas tran vdout0_16ck340 FIND v(dout0_16) AT=175.025n

.meas tran vdout0_17ck340 FIND v(dout0_17) AT=175.025n

.meas tran vdout0_18ck340 FIND v(dout0_18) AT=175.025n

.meas tran vdout0_19ck340 FIND v(dout0_19) AT=175.025n

.meas tran vdout0_20ck340 FIND v(dout0_20) AT=175.025n

.meas tran vdout0_21ck340 FIND v(dout0_21) AT=175.025n

.meas tran vdout0_22ck340 FIND v(dout0_22) AT=175.025n

.meas tran vdout0_23ck340 FIND v(dout0_23) AT=175.025n

.meas tran vdout0_24ck340 FIND v(dout0_24) AT=175.025n

.meas tran vdout0_25ck340 FIND v(dout0_25) AT=175.025n

.meas tran vdout0_26ck340 FIND v(dout0_26) AT=175.025n

.meas tran vdout0_27ck340 FIND v(dout0_27) AT=175.025n

.meas tran vdout0_28ck340 FIND v(dout0_28) AT=175.025n

.meas tran vdout0_29ck340 FIND v(dout0_29) AT=175.025n

.meas tran vdout0_30ck340 FIND v(dout0_30) AT=175.025n

.meas tran vdout0_31ck340 FIND v(dout0_31) AT=175.025n

.meas tran vdout0_32ck340 FIND v(dout0_32) AT=175.025n

.meas tran vdout0_33ck340 FIND v(dout0_33) AT=175.025n

.meas tran vdout0_34ck340 FIND v(dout0_34) AT=175.025n

.meas tran vdout0_35ck340 FIND v(dout0_35) AT=175.025n

.meas tran vdout0_36ck340 FIND v(dout0_36) AT=175.025n

.meas tran vdout0_37ck340 FIND v(dout0_37) AT=175.025n

.meas tran vdout0_38ck340 FIND v(dout0_38) AT=175.025n

.meas tran vdout0_39ck340 FIND v(dout0_39) AT=175.025n

.meas tran vdout0_40ck340 FIND v(dout0_40) AT=175.025n

.meas tran vdout0_41ck340 FIND v(dout0_41) AT=175.025n

.meas tran vdout0_42ck340 FIND v(dout0_42) AT=175.025n

.meas tran vdout0_43ck340 FIND v(dout0_43) AT=175.025n

.meas tran vdout0_44ck340 FIND v(dout0_44) AT=175.025n

.meas tran vdout0_45ck340 FIND v(dout0_45) AT=175.025n

.meas tran vdout0_46ck340 FIND v(dout0_46) AT=175.025n

.meas tran vdout0_47ck340 FIND v(dout0_47) AT=175.025n

.meas tran vdout0_48ck340 FIND v(dout0_48) AT=175.025n

.meas tran vdout0_49ck340 FIND v(dout0_49) AT=175.025n

.meas tran vdout0_50ck340 FIND v(dout0_50) AT=175.025n

.meas tran vdout0_51ck340 FIND v(dout0_51) AT=175.025n

.meas tran vdout0_52ck340 FIND v(dout0_52) AT=175.025n

.meas tran vdout0_53ck340 FIND v(dout0_53) AT=175.025n

.meas tran vdout0_54ck340 FIND v(dout0_54) AT=175.025n

.meas tran vdout0_55ck340 FIND v(dout0_55) AT=175.025n

.meas tran vdout0_56ck340 FIND v(dout0_56) AT=175.025n

.meas tran vdout0_57ck340 FIND v(dout0_57) AT=175.025n

.meas tran vdout0_58ck340 FIND v(dout0_58) AT=175.025n

.meas tran vdout0_59ck340 FIND v(dout0_59) AT=175.025n

.meas tran vdout0_60ck340 FIND v(dout0_60) AT=175.025n

.meas tran vdout0_61ck340 FIND v(dout0_61) AT=175.025n

.meas tran vdout0_62ck340 FIND v(dout0_62) AT=175.025n

.meas tran vdout0_63ck340 FIND v(dout0_63) AT=175.025n

.meas tran vdout0_64ck340 FIND v(dout0_64) AT=175.025n

.meas tran vdout0_65ck340 FIND v(dout0_65) AT=175.025n

.meas tran vdout0_66ck340 FIND v(dout0_66) AT=175.025n

.meas tran vdout0_67ck340 FIND v(dout0_67) AT=175.025n

.meas tran vdout0_68ck340 FIND v(dout0_68) AT=175.025n

.meas tran vdout0_69ck340 FIND v(dout0_69) AT=175.025n

.meas tran vdout0_70ck340 FIND v(dout0_70) AT=175.025n

.meas tran vdout0_71ck340 FIND v(dout0_71) AT=175.025n

.meas tran vdout0_72ck340 FIND v(dout0_72) AT=175.025n

.meas tran vdout0_73ck340 FIND v(dout0_73) AT=175.025n

.meas tran vdout0_74ck340 FIND v(dout0_74) AT=175.025n

.meas tran vdout0_75ck340 FIND v(dout0_75) AT=175.025n

.meas tran vdout0_76ck340 FIND v(dout0_76) AT=175.025n

.meas tran vdout0_77ck340 FIND v(dout0_77) AT=175.025n

.meas tran vdout0_78ck340 FIND v(dout0_78) AT=175.025n

.meas tran vdout0_79ck340 FIND v(dout0_79) AT=175.025n

.meas tran vdout0_80ck340 FIND v(dout0_80) AT=175.025n

.meas tran vdout0_81ck340 FIND v(dout0_81) AT=175.025n

.meas tran vdout0_82ck340 FIND v(dout0_82) AT=175.025n

.meas tran vdout0_83ck340 FIND v(dout0_83) AT=175.025n

.meas tran vdout0_84ck340 FIND v(dout0_84) AT=175.025n

.meas tran vdout0_85ck340 FIND v(dout0_85) AT=175.025n

.meas tran vdout0_86ck340 FIND v(dout0_86) AT=175.025n

.meas tran vdout0_87ck340 FIND v(dout0_87) AT=175.025n

.meas tran vdout0_88ck340 FIND v(dout0_88) AT=175.025n

.meas tran vdout0_89ck340 FIND v(dout0_89) AT=175.025n

.meas tran vdout0_90ck340 FIND v(dout0_90) AT=175.025n

.meas tran vdout0_91ck340 FIND v(dout0_91) AT=175.025n

.meas tran vdout0_92ck340 FIND v(dout0_92) AT=175.025n

.meas tran vdout0_93ck340 FIND v(dout0_93) AT=175.025n

.meas tran vdout0_94ck340 FIND v(dout0_94) AT=175.025n

.meas tran vdout0_95ck340 FIND v(dout0_95) AT=175.025n

.meas tran vdout0_96ck340 FIND v(dout0_96) AT=175.025n

.meas tran vdout0_97ck340 FIND v(dout0_97) AT=175.025n

.meas tran vdout0_98ck340 FIND v(dout0_98) AT=175.025n

.meas tran vdout0_99ck340 FIND v(dout0_99) AT=175.025n

.meas tran vdout0_100ck340 FIND v(dout0_100) AT=175.025n

.meas tran vdout0_101ck340 FIND v(dout0_101) AT=175.025n

.meas tran vdout0_102ck340 FIND v(dout0_102) AT=175.025n

.meas tran vdout0_103ck340 FIND v(dout0_103) AT=175.025n

.meas tran vdout0_104ck340 FIND v(dout0_104) AT=175.025n

.meas tran vdout0_105ck340 FIND v(dout0_105) AT=175.025n

.meas tran vdout0_106ck340 FIND v(dout0_106) AT=175.025n

.meas tran vdout0_107ck340 FIND v(dout0_107) AT=175.025n

.meas tran vdout0_108ck340 FIND v(dout0_108) AT=175.025n

.meas tran vdout0_109ck340 FIND v(dout0_109) AT=175.025n

.meas tran vdout0_110ck340 FIND v(dout0_110) AT=175.025n

.meas tran vdout0_111ck340 FIND v(dout0_111) AT=175.025n

.meas tran vdout0_112ck340 FIND v(dout0_112) AT=175.025n

.meas tran vdout0_113ck340 FIND v(dout0_113) AT=175.025n

.meas tran vdout0_114ck340 FIND v(dout0_114) AT=175.025n

.meas tran vdout0_115ck340 FIND v(dout0_115) AT=175.025n

.meas tran vdout0_116ck340 FIND v(dout0_116) AT=175.025n

.meas tran vdout0_117ck340 FIND v(dout0_117) AT=175.025n

.meas tran vdout0_118ck340 FIND v(dout0_118) AT=175.025n

.meas tran vdout0_119ck340 FIND v(dout0_119) AT=175.025n

.meas tran vdout0_120ck340 FIND v(dout0_120) AT=175.025n

.meas tran vdout0_121ck340 FIND v(dout0_121) AT=175.025n

.meas tran vdout0_122ck340 FIND v(dout0_122) AT=175.025n

.meas tran vdout0_123ck340 FIND v(dout0_123) AT=175.025n

.meas tran vdout0_124ck340 FIND v(dout0_124) AT=175.025n

.meas tran vdout0_125ck340 FIND v(dout0_125) AT=175.025n

.meas tran vdout0_126ck340 FIND v(dout0_126) AT=175.025n

.meas tran vdout0_127ck340 FIND v(dout0_127) AT=175.025n

.meas tran vdout0_128ck340 FIND v(dout0_128) AT=175.025n

.meas tran vdout0_129ck340 FIND v(dout0_129) AT=175.025n

.meas tran vdout0_130ck340 FIND v(dout0_130) AT=175.025n

.meas tran vdout0_131ck340 FIND v(dout0_131) AT=175.025n

.meas tran vdout0_132ck340 FIND v(dout0_132) AT=175.025n

.meas tran vdout0_133ck340 FIND v(dout0_133) AT=175.025n

.meas tran vdout0_134ck340 FIND v(dout0_134) AT=175.025n

.meas tran vdout0_135ck340 FIND v(dout0_135) AT=175.025n

.meas tran vdout0_136ck340 FIND v(dout0_136) AT=175.025n

.meas tran vdout0_137ck340 FIND v(dout0_137) AT=175.025n

.meas tran vdout0_138ck340 FIND v(dout0_138) AT=175.025n

.meas tran vdout0_139ck340 FIND v(dout0_139) AT=175.025n

.meas tran vdout0_140ck340 FIND v(dout0_140) AT=175.025n

.meas tran vdout0_141ck340 FIND v(dout0_141) AT=175.025n

.meas tran vdout0_142ck340 FIND v(dout0_142) AT=175.025n

.meas tran vdout0_143ck340 FIND v(dout0_143) AT=175.025n

.meas tran vdout0_144ck340 FIND v(dout0_144) AT=175.025n

.meas tran vdout0_145ck340 FIND v(dout0_145) AT=175.025n

.meas tran vdout0_146ck340 FIND v(dout0_146) AT=175.025n

.meas tran vdout0_147ck340 FIND v(dout0_147) AT=175.025n

.meas tran vdout0_148ck340 FIND v(dout0_148) AT=175.025n

.meas tran vdout0_149ck340 FIND v(dout0_149) AT=175.025n

.meas tran vdout0_150ck340 FIND v(dout0_150) AT=175.025n

.meas tran vdout0_151ck340 FIND v(dout0_151) AT=175.025n

.meas tran vdout0_152ck340 FIND v(dout0_152) AT=175.025n

.meas tran vdout0_153ck340 FIND v(dout0_153) AT=175.025n

.meas tran vdout0_154ck340 FIND v(dout0_154) AT=175.025n

.meas tran vdout0_155ck340 FIND v(dout0_155) AT=175.025n

.meas tran vdout0_156ck340 FIND v(dout0_156) AT=175.025n

.meas tran vdout0_157ck340 FIND v(dout0_157) AT=175.025n

.meas tran vdout0_158ck340 FIND v(dout0_158) AT=175.025n

.meas tran vdout0_159ck340 FIND v(dout0_159) AT=175.025n

.meas tran vdout0_160ck340 FIND v(dout0_160) AT=175.025n

.meas tran vdout0_161ck340 FIND v(dout0_161) AT=175.025n

.meas tran vdout0_162ck340 FIND v(dout0_162) AT=175.025n

.meas tran vdout0_163ck340 FIND v(dout0_163) AT=175.025n

.meas tran vdout0_164ck340 FIND v(dout0_164) AT=175.025n

.meas tran vdout0_165ck340 FIND v(dout0_165) AT=175.025n

.meas tran vdout0_166ck340 FIND v(dout0_166) AT=175.025n

.meas tran vdout0_167ck340 FIND v(dout0_167) AT=175.025n

.meas tran vdout0_168ck340 FIND v(dout0_168) AT=175.025n

.meas tran vdout0_169ck340 FIND v(dout0_169) AT=175.025n

.meas tran vdout0_170ck340 FIND v(dout0_170) AT=175.025n

.meas tran vdout0_171ck340 FIND v(dout0_171) AT=175.025n

.meas tran vdout0_172ck340 FIND v(dout0_172) AT=175.025n

.meas tran vdout0_173ck340 FIND v(dout0_173) AT=175.025n

.meas tran vdout0_174ck340 FIND v(dout0_174) AT=175.025n

.meas tran vdout0_175ck340 FIND v(dout0_175) AT=175.025n

.meas tran vdout0_176ck340 FIND v(dout0_176) AT=175.025n

.meas tran vdout0_177ck340 FIND v(dout0_177) AT=175.025n

.meas tran vdout0_178ck340 FIND v(dout0_178) AT=175.025n

.meas tran vdout0_179ck340 FIND v(dout0_179) AT=175.025n

.meas tran vdout0_180ck340 FIND v(dout0_180) AT=175.025n

.meas tran vdout0_181ck340 FIND v(dout0_181) AT=175.025n

.meas tran vdout0_182ck340 FIND v(dout0_182) AT=175.025n

.meas tran vdout0_183ck340 FIND v(dout0_183) AT=175.025n

.meas tran vdout0_184ck340 FIND v(dout0_184) AT=175.025n

.meas tran vdout0_185ck340 FIND v(dout0_185) AT=175.025n

.meas tran vdout0_186ck340 FIND v(dout0_186) AT=175.025n

.meas tran vdout0_187ck340 FIND v(dout0_187) AT=175.025n

.meas tran vdout0_188ck340 FIND v(dout0_188) AT=175.025n

.meas tran vdout0_189ck340 FIND v(dout0_189) AT=175.025n

.meas tran vdout0_190ck340 FIND v(dout0_190) AT=175.025n

.meas tran vdout0_191ck340 FIND v(dout0_191) AT=175.025n

.meas tran vdout0_192ck340 FIND v(dout0_192) AT=175.025n

.meas tran vdout0_193ck340 FIND v(dout0_193) AT=175.025n

.meas tran vdout0_194ck340 FIND v(dout0_194) AT=175.025n

.meas tran vdout0_195ck340 FIND v(dout0_195) AT=175.025n

.meas tran vdout0_196ck340 FIND v(dout0_196) AT=175.025n

.meas tran vdout0_197ck340 FIND v(dout0_197) AT=175.025n

.meas tran vdout0_198ck340 FIND v(dout0_198) AT=175.025n

.meas tran vdout0_199ck340 FIND v(dout0_199) AT=175.025n

.meas tran vdout0_200ck340 FIND v(dout0_200) AT=175.025n

.meas tran vdout0_201ck340 FIND v(dout0_201) AT=175.025n

.meas tran vdout0_202ck340 FIND v(dout0_202) AT=175.025n

.meas tran vdout0_203ck340 FIND v(dout0_203) AT=175.025n

.meas tran vdout0_204ck340 FIND v(dout0_204) AT=175.025n

.meas tran vdout0_205ck340 FIND v(dout0_205) AT=175.025n

.meas tran vdout0_206ck340 FIND v(dout0_206) AT=175.025n

.meas tran vdout0_207ck340 FIND v(dout0_207) AT=175.025n

.meas tran vdout0_208ck340 FIND v(dout0_208) AT=175.025n

.meas tran vdout0_209ck340 FIND v(dout0_209) AT=175.025n

.meas tran vdout0_210ck340 FIND v(dout0_210) AT=175.025n

.meas tran vdout0_211ck340 FIND v(dout0_211) AT=175.025n

.meas tran vdout0_212ck340 FIND v(dout0_212) AT=175.025n

.meas tran vdout0_213ck340 FIND v(dout0_213) AT=175.025n

.meas tran vdout0_214ck340 FIND v(dout0_214) AT=175.025n

.meas tran vdout0_215ck340 FIND v(dout0_215) AT=175.025n

.meas tran vdout0_216ck340 FIND v(dout0_216) AT=175.025n

.meas tran vdout0_217ck340 FIND v(dout0_217) AT=175.025n

.meas tran vdout0_218ck340 FIND v(dout0_218) AT=175.025n

.meas tran vdout0_219ck340 FIND v(dout0_219) AT=175.025n

.meas tran vdout0_220ck340 FIND v(dout0_220) AT=175.025n

.meas tran vdout0_221ck340 FIND v(dout0_221) AT=175.025n

.meas tran vdout0_222ck340 FIND v(dout0_222) AT=175.025n

.meas tran vdout0_223ck340 FIND v(dout0_223) AT=175.025n

.meas tran vdout0_224ck340 FIND v(dout0_224) AT=175.025n

.meas tran vdout0_225ck340 FIND v(dout0_225) AT=175.025n

.meas tran vdout0_226ck340 FIND v(dout0_226) AT=175.025n

.meas tran vdout0_227ck340 FIND v(dout0_227) AT=175.025n

.meas tran vdout0_228ck340 FIND v(dout0_228) AT=175.025n

.meas tran vdout0_229ck340 FIND v(dout0_229) AT=175.025n

.meas tran vdout0_230ck340 FIND v(dout0_230) AT=175.025n

.meas tran vdout0_231ck340 FIND v(dout0_231) AT=175.025n

.meas tran vdout0_232ck340 FIND v(dout0_232) AT=175.025n

.meas tran vdout0_233ck340 FIND v(dout0_233) AT=175.025n

.meas tran vdout0_234ck340 FIND v(dout0_234) AT=175.025n

.meas tran vdout0_235ck340 FIND v(dout0_235) AT=175.025n

.meas tran vdout0_236ck340 FIND v(dout0_236) AT=175.025n

.meas tran vdout0_237ck340 FIND v(dout0_237) AT=175.025n

.meas tran vdout0_238ck340 FIND v(dout0_238) AT=175.025n

.meas tran vdout0_239ck340 FIND v(dout0_239) AT=175.025n

.meas tran vdout0_240ck340 FIND v(dout0_240) AT=175.025n

.meas tran vdout0_241ck340 FIND v(dout0_241) AT=175.025n

.meas tran vdout0_242ck340 FIND v(dout0_242) AT=175.025n

.meas tran vdout0_243ck340 FIND v(dout0_243) AT=175.025n

.meas tran vdout0_244ck340 FIND v(dout0_244) AT=175.025n

.meas tran vdout0_245ck340 FIND v(dout0_245) AT=175.025n

.meas tran vdout0_246ck340 FIND v(dout0_246) AT=175.025n

.meas tran vdout0_247ck340 FIND v(dout0_247) AT=175.025n

.meas tran vdout0_248ck340 FIND v(dout0_248) AT=175.025n

.meas tran vdout0_249ck340 FIND v(dout0_249) AT=175.025n

.meas tran vdout0_250ck340 FIND v(dout0_250) AT=175.025n

.meas tran vdout0_251ck340 FIND v(dout0_251) AT=175.025n

.meas tran vdout0_252ck340 FIND v(dout0_252) AT=175.025n

.meas tran vdout0_253ck340 FIND v(dout0_253) AT=175.025n

.meas tran vdout0_254ck340 FIND v(dout0_254) AT=175.025n

.meas tran vdout0_255ck340 FIND v(dout0_255) AT=175.025n

.meas tran vdout0_0ck350 FIND v(dout0_0) AT=180.025n

.meas tran vdout0_1ck350 FIND v(dout0_1) AT=180.025n

.meas tran vdout0_2ck350 FIND v(dout0_2) AT=180.025n

.meas tran vdout0_3ck350 FIND v(dout0_3) AT=180.025n

.meas tran vdout0_4ck350 FIND v(dout0_4) AT=180.025n

.meas tran vdout0_5ck350 FIND v(dout0_5) AT=180.025n

.meas tran vdout0_6ck350 FIND v(dout0_6) AT=180.025n

.meas tran vdout0_7ck350 FIND v(dout0_7) AT=180.025n

.meas tran vdout0_8ck350 FIND v(dout0_8) AT=180.025n

.meas tran vdout0_9ck350 FIND v(dout0_9) AT=180.025n

.meas tran vdout0_10ck350 FIND v(dout0_10) AT=180.025n

.meas tran vdout0_11ck350 FIND v(dout0_11) AT=180.025n

.meas tran vdout0_12ck350 FIND v(dout0_12) AT=180.025n

.meas tran vdout0_13ck350 FIND v(dout0_13) AT=180.025n

.meas tran vdout0_14ck350 FIND v(dout0_14) AT=180.025n

.meas tran vdout0_15ck350 FIND v(dout0_15) AT=180.025n

.meas tran vdout0_16ck350 FIND v(dout0_16) AT=180.025n

.meas tran vdout0_17ck350 FIND v(dout0_17) AT=180.025n

.meas tran vdout0_18ck350 FIND v(dout0_18) AT=180.025n

.meas tran vdout0_19ck350 FIND v(dout0_19) AT=180.025n

.meas tran vdout0_20ck350 FIND v(dout0_20) AT=180.025n

.meas tran vdout0_21ck350 FIND v(dout0_21) AT=180.025n

.meas tran vdout0_22ck350 FIND v(dout0_22) AT=180.025n

.meas tran vdout0_23ck350 FIND v(dout0_23) AT=180.025n

.meas tran vdout0_24ck350 FIND v(dout0_24) AT=180.025n

.meas tran vdout0_25ck350 FIND v(dout0_25) AT=180.025n

.meas tran vdout0_26ck350 FIND v(dout0_26) AT=180.025n

.meas tran vdout0_27ck350 FIND v(dout0_27) AT=180.025n

.meas tran vdout0_28ck350 FIND v(dout0_28) AT=180.025n

.meas tran vdout0_29ck350 FIND v(dout0_29) AT=180.025n

.meas tran vdout0_30ck350 FIND v(dout0_30) AT=180.025n

.meas tran vdout0_31ck350 FIND v(dout0_31) AT=180.025n

.meas tran vdout0_32ck350 FIND v(dout0_32) AT=180.025n

.meas tran vdout0_33ck350 FIND v(dout0_33) AT=180.025n

.meas tran vdout0_34ck350 FIND v(dout0_34) AT=180.025n

.meas tran vdout0_35ck350 FIND v(dout0_35) AT=180.025n

.meas tran vdout0_36ck350 FIND v(dout0_36) AT=180.025n

.meas tran vdout0_37ck350 FIND v(dout0_37) AT=180.025n

.meas tran vdout0_38ck350 FIND v(dout0_38) AT=180.025n

.meas tran vdout0_39ck350 FIND v(dout0_39) AT=180.025n

.meas tran vdout0_40ck350 FIND v(dout0_40) AT=180.025n

.meas tran vdout0_41ck350 FIND v(dout0_41) AT=180.025n

.meas tran vdout0_42ck350 FIND v(dout0_42) AT=180.025n

.meas tran vdout0_43ck350 FIND v(dout0_43) AT=180.025n

.meas tran vdout0_44ck350 FIND v(dout0_44) AT=180.025n

.meas tran vdout0_45ck350 FIND v(dout0_45) AT=180.025n

.meas tran vdout0_46ck350 FIND v(dout0_46) AT=180.025n

.meas tran vdout0_47ck350 FIND v(dout0_47) AT=180.025n

.meas tran vdout0_48ck350 FIND v(dout0_48) AT=180.025n

.meas tran vdout0_49ck350 FIND v(dout0_49) AT=180.025n

.meas tran vdout0_50ck350 FIND v(dout0_50) AT=180.025n

.meas tran vdout0_51ck350 FIND v(dout0_51) AT=180.025n

.meas tran vdout0_52ck350 FIND v(dout0_52) AT=180.025n

.meas tran vdout0_53ck350 FIND v(dout0_53) AT=180.025n

.meas tran vdout0_54ck350 FIND v(dout0_54) AT=180.025n

.meas tran vdout0_55ck350 FIND v(dout0_55) AT=180.025n

.meas tran vdout0_56ck350 FIND v(dout0_56) AT=180.025n

.meas tran vdout0_57ck350 FIND v(dout0_57) AT=180.025n

.meas tran vdout0_58ck350 FIND v(dout0_58) AT=180.025n

.meas tran vdout0_59ck350 FIND v(dout0_59) AT=180.025n

.meas tran vdout0_60ck350 FIND v(dout0_60) AT=180.025n

.meas tran vdout0_61ck350 FIND v(dout0_61) AT=180.025n

.meas tran vdout0_62ck350 FIND v(dout0_62) AT=180.025n

.meas tran vdout0_63ck350 FIND v(dout0_63) AT=180.025n

.meas tran vdout0_64ck350 FIND v(dout0_64) AT=180.025n

.meas tran vdout0_65ck350 FIND v(dout0_65) AT=180.025n

.meas tran vdout0_66ck350 FIND v(dout0_66) AT=180.025n

.meas tran vdout0_67ck350 FIND v(dout0_67) AT=180.025n

.meas tran vdout0_68ck350 FIND v(dout0_68) AT=180.025n

.meas tran vdout0_69ck350 FIND v(dout0_69) AT=180.025n

.meas tran vdout0_70ck350 FIND v(dout0_70) AT=180.025n

.meas tran vdout0_71ck350 FIND v(dout0_71) AT=180.025n

.meas tran vdout0_72ck350 FIND v(dout0_72) AT=180.025n

.meas tran vdout0_73ck350 FIND v(dout0_73) AT=180.025n

.meas tran vdout0_74ck350 FIND v(dout0_74) AT=180.025n

.meas tran vdout0_75ck350 FIND v(dout0_75) AT=180.025n

.meas tran vdout0_76ck350 FIND v(dout0_76) AT=180.025n

.meas tran vdout0_77ck350 FIND v(dout0_77) AT=180.025n

.meas tran vdout0_78ck350 FIND v(dout0_78) AT=180.025n

.meas tran vdout0_79ck350 FIND v(dout0_79) AT=180.025n

.meas tran vdout0_80ck350 FIND v(dout0_80) AT=180.025n

.meas tran vdout0_81ck350 FIND v(dout0_81) AT=180.025n

.meas tran vdout0_82ck350 FIND v(dout0_82) AT=180.025n

.meas tran vdout0_83ck350 FIND v(dout0_83) AT=180.025n

.meas tran vdout0_84ck350 FIND v(dout0_84) AT=180.025n

.meas tran vdout0_85ck350 FIND v(dout0_85) AT=180.025n

.meas tran vdout0_86ck350 FIND v(dout0_86) AT=180.025n

.meas tran vdout0_87ck350 FIND v(dout0_87) AT=180.025n

.meas tran vdout0_88ck350 FIND v(dout0_88) AT=180.025n

.meas tran vdout0_89ck350 FIND v(dout0_89) AT=180.025n

.meas tran vdout0_90ck350 FIND v(dout0_90) AT=180.025n

.meas tran vdout0_91ck350 FIND v(dout0_91) AT=180.025n

.meas tran vdout0_92ck350 FIND v(dout0_92) AT=180.025n

.meas tran vdout0_93ck350 FIND v(dout0_93) AT=180.025n

.meas tran vdout0_94ck350 FIND v(dout0_94) AT=180.025n

.meas tran vdout0_95ck350 FIND v(dout0_95) AT=180.025n

.meas tran vdout0_96ck350 FIND v(dout0_96) AT=180.025n

.meas tran vdout0_97ck350 FIND v(dout0_97) AT=180.025n

.meas tran vdout0_98ck350 FIND v(dout0_98) AT=180.025n

.meas tran vdout0_99ck350 FIND v(dout0_99) AT=180.025n

.meas tran vdout0_100ck350 FIND v(dout0_100) AT=180.025n

.meas tran vdout0_101ck350 FIND v(dout0_101) AT=180.025n

.meas tran vdout0_102ck350 FIND v(dout0_102) AT=180.025n

.meas tran vdout0_103ck350 FIND v(dout0_103) AT=180.025n

.meas tran vdout0_104ck350 FIND v(dout0_104) AT=180.025n

.meas tran vdout0_105ck350 FIND v(dout0_105) AT=180.025n

.meas tran vdout0_106ck350 FIND v(dout0_106) AT=180.025n

.meas tran vdout0_107ck350 FIND v(dout0_107) AT=180.025n

.meas tran vdout0_108ck350 FIND v(dout0_108) AT=180.025n

.meas tran vdout0_109ck350 FIND v(dout0_109) AT=180.025n

.meas tran vdout0_110ck350 FIND v(dout0_110) AT=180.025n

.meas tran vdout0_111ck350 FIND v(dout0_111) AT=180.025n

.meas tran vdout0_112ck350 FIND v(dout0_112) AT=180.025n

.meas tran vdout0_113ck350 FIND v(dout0_113) AT=180.025n

.meas tran vdout0_114ck350 FIND v(dout0_114) AT=180.025n

.meas tran vdout0_115ck350 FIND v(dout0_115) AT=180.025n

.meas tran vdout0_116ck350 FIND v(dout0_116) AT=180.025n

.meas tran vdout0_117ck350 FIND v(dout0_117) AT=180.025n

.meas tran vdout0_118ck350 FIND v(dout0_118) AT=180.025n

.meas tran vdout0_119ck350 FIND v(dout0_119) AT=180.025n

.meas tran vdout0_120ck350 FIND v(dout0_120) AT=180.025n

.meas tran vdout0_121ck350 FIND v(dout0_121) AT=180.025n

.meas tran vdout0_122ck350 FIND v(dout0_122) AT=180.025n

.meas tran vdout0_123ck350 FIND v(dout0_123) AT=180.025n

.meas tran vdout0_124ck350 FIND v(dout0_124) AT=180.025n

.meas tran vdout0_125ck350 FIND v(dout0_125) AT=180.025n

.meas tran vdout0_126ck350 FIND v(dout0_126) AT=180.025n

.meas tran vdout0_127ck350 FIND v(dout0_127) AT=180.025n

.meas tran vdout0_128ck350 FIND v(dout0_128) AT=180.025n

.meas tran vdout0_129ck350 FIND v(dout0_129) AT=180.025n

.meas tran vdout0_130ck350 FIND v(dout0_130) AT=180.025n

.meas tran vdout0_131ck350 FIND v(dout0_131) AT=180.025n

.meas tran vdout0_132ck350 FIND v(dout0_132) AT=180.025n

.meas tran vdout0_133ck350 FIND v(dout0_133) AT=180.025n

.meas tran vdout0_134ck350 FIND v(dout0_134) AT=180.025n

.meas tran vdout0_135ck350 FIND v(dout0_135) AT=180.025n

.meas tran vdout0_136ck350 FIND v(dout0_136) AT=180.025n

.meas tran vdout0_137ck350 FIND v(dout0_137) AT=180.025n

.meas tran vdout0_138ck350 FIND v(dout0_138) AT=180.025n

.meas tran vdout0_139ck350 FIND v(dout0_139) AT=180.025n

.meas tran vdout0_140ck350 FIND v(dout0_140) AT=180.025n

.meas tran vdout0_141ck350 FIND v(dout0_141) AT=180.025n

.meas tran vdout0_142ck350 FIND v(dout0_142) AT=180.025n

.meas tran vdout0_143ck350 FIND v(dout0_143) AT=180.025n

.meas tran vdout0_144ck350 FIND v(dout0_144) AT=180.025n

.meas tran vdout0_145ck350 FIND v(dout0_145) AT=180.025n

.meas tran vdout0_146ck350 FIND v(dout0_146) AT=180.025n

.meas tran vdout0_147ck350 FIND v(dout0_147) AT=180.025n

.meas tran vdout0_148ck350 FIND v(dout0_148) AT=180.025n

.meas tran vdout0_149ck350 FIND v(dout0_149) AT=180.025n

.meas tran vdout0_150ck350 FIND v(dout0_150) AT=180.025n

.meas tran vdout0_151ck350 FIND v(dout0_151) AT=180.025n

.meas tran vdout0_152ck350 FIND v(dout0_152) AT=180.025n

.meas tran vdout0_153ck350 FIND v(dout0_153) AT=180.025n

.meas tran vdout0_154ck350 FIND v(dout0_154) AT=180.025n

.meas tran vdout0_155ck350 FIND v(dout0_155) AT=180.025n

.meas tran vdout0_156ck350 FIND v(dout0_156) AT=180.025n

.meas tran vdout0_157ck350 FIND v(dout0_157) AT=180.025n

.meas tran vdout0_158ck350 FIND v(dout0_158) AT=180.025n

.meas tran vdout0_159ck350 FIND v(dout0_159) AT=180.025n

.meas tran vdout0_160ck350 FIND v(dout0_160) AT=180.025n

.meas tran vdout0_161ck350 FIND v(dout0_161) AT=180.025n

.meas tran vdout0_162ck350 FIND v(dout0_162) AT=180.025n

.meas tran vdout0_163ck350 FIND v(dout0_163) AT=180.025n

.meas tran vdout0_164ck350 FIND v(dout0_164) AT=180.025n

.meas tran vdout0_165ck350 FIND v(dout0_165) AT=180.025n

.meas tran vdout0_166ck350 FIND v(dout0_166) AT=180.025n

.meas tran vdout0_167ck350 FIND v(dout0_167) AT=180.025n

.meas tran vdout0_168ck350 FIND v(dout0_168) AT=180.025n

.meas tran vdout0_169ck350 FIND v(dout0_169) AT=180.025n

.meas tran vdout0_170ck350 FIND v(dout0_170) AT=180.025n

.meas tran vdout0_171ck350 FIND v(dout0_171) AT=180.025n

.meas tran vdout0_172ck350 FIND v(dout0_172) AT=180.025n

.meas tran vdout0_173ck350 FIND v(dout0_173) AT=180.025n

.meas tran vdout0_174ck350 FIND v(dout0_174) AT=180.025n

.meas tran vdout0_175ck350 FIND v(dout0_175) AT=180.025n

.meas tran vdout0_176ck350 FIND v(dout0_176) AT=180.025n

.meas tran vdout0_177ck350 FIND v(dout0_177) AT=180.025n

.meas tran vdout0_178ck350 FIND v(dout0_178) AT=180.025n

.meas tran vdout0_179ck350 FIND v(dout0_179) AT=180.025n

.meas tran vdout0_180ck350 FIND v(dout0_180) AT=180.025n

.meas tran vdout0_181ck350 FIND v(dout0_181) AT=180.025n

.meas tran vdout0_182ck350 FIND v(dout0_182) AT=180.025n

.meas tran vdout0_183ck350 FIND v(dout0_183) AT=180.025n

.meas tran vdout0_184ck350 FIND v(dout0_184) AT=180.025n

.meas tran vdout0_185ck350 FIND v(dout0_185) AT=180.025n

.meas tran vdout0_186ck350 FIND v(dout0_186) AT=180.025n

.meas tran vdout0_187ck350 FIND v(dout0_187) AT=180.025n

.meas tran vdout0_188ck350 FIND v(dout0_188) AT=180.025n

.meas tran vdout0_189ck350 FIND v(dout0_189) AT=180.025n

.meas tran vdout0_190ck350 FIND v(dout0_190) AT=180.025n

.meas tran vdout0_191ck350 FIND v(dout0_191) AT=180.025n

.meas tran vdout0_192ck350 FIND v(dout0_192) AT=180.025n

.meas tran vdout0_193ck350 FIND v(dout0_193) AT=180.025n

.meas tran vdout0_194ck350 FIND v(dout0_194) AT=180.025n

.meas tran vdout0_195ck350 FIND v(dout0_195) AT=180.025n

.meas tran vdout0_196ck350 FIND v(dout0_196) AT=180.025n

.meas tran vdout0_197ck350 FIND v(dout0_197) AT=180.025n

.meas tran vdout0_198ck350 FIND v(dout0_198) AT=180.025n

.meas tran vdout0_199ck350 FIND v(dout0_199) AT=180.025n

.meas tran vdout0_200ck350 FIND v(dout0_200) AT=180.025n

.meas tran vdout0_201ck350 FIND v(dout0_201) AT=180.025n

.meas tran vdout0_202ck350 FIND v(dout0_202) AT=180.025n

.meas tran vdout0_203ck350 FIND v(dout0_203) AT=180.025n

.meas tran vdout0_204ck350 FIND v(dout0_204) AT=180.025n

.meas tran vdout0_205ck350 FIND v(dout0_205) AT=180.025n

.meas tran vdout0_206ck350 FIND v(dout0_206) AT=180.025n

.meas tran vdout0_207ck350 FIND v(dout0_207) AT=180.025n

.meas tran vdout0_208ck350 FIND v(dout0_208) AT=180.025n

.meas tran vdout0_209ck350 FIND v(dout0_209) AT=180.025n

.meas tran vdout0_210ck350 FIND v(dout0_210) AT=180.025n

.meas tran vdout0_211ck350 FIND v(dout0_211) AT=180.025n

.meas tran vdout0_212ck350 FIND v(dout0_212) AT=180.025n

.meas tran vdout0_213ck350 FIND v(dout0_213) AT=180.025n

.meas tran vdout0_214ck350 FIND v(dout0_214) AT=180.025n

.meas tran vdout0_215ck350 FIND v(dout0_215) AT=180.025n

.meas tran vdout0_216ck350 FIND v(dout0_216) AT=180.025n

.meas tran vdout0_217ck350 FIND v(dout0_217) AT=180.025n

.meas tran vdout0_218ck350 FIND v(dout0_218) AT=180.025n

.meas tran vdout0_219ck350 FIND v(dout0_219) AT=180.025n

.meas tran vdout0_220ck350 FIND v(dout0_220) AT=180.025n

.meas tran vdout0_221ck350 FIND v(dout0_221) AT=180.025n

.meas tran vdout0_222ck350 FIND v(dout0_222) AT=180.025n

.meas tran vdout0_223ck350 FIND v(dout0_223) AT=180.025n

.meas tran vdout0_224ck350 FIND v(dout0_224) AT=180.025n

.meas tran vdout0_225ck350 FIND v(dout0_225) AT=180.025n

.meas tran vdout0_226ck350 FIND v(dout0_226) AT=180.025n

.meas tran vdout0_227ck350 FIND v(dout0_227) AT=180.025n

.meas tran vdout0_228ck350 FIND v(dout0_228) AT=180.025n

.meas tran vdout0_229ck350 FIND v(dout0_229) AT=180.025n

.meas tran vdout0_230ck350 FIND v(dout0_230) AT=180.025n

.meas tran vdout0_231ck350 FIND v(dout0_231) AT=180.025n

.meas tran vdout0_232ck350 FIND v(dout0_232) AT=180.025n

.meas tran vdout0_233ck350 FIND v(dout0_233) AT=180.025n

.meas tran vdout0_234ck350 FIND v(dout0_234) AT=180.025n

.meas tran vdout0_235ck350 FIND v(dout0_235) AT=180.025n

.meas tran vdout0_236ck350 FIND v(dout0_236) AT=180.025n

.meas tran vdout0_237ck350 FIND v(dout0_237) AT=180.025n

.meas tran vdout0_238ck350 FIND v(dout0_238) AT=180.025n

.meas tran vdout0_239ck350 FIND v(dout0_239) AT=180.025n

.meas tran vdout0_240ck350 FIND v(dout0_240) AT=180.025n

.meas tran vdout0_241ck350 FIND v(dout0_241) AT=180.025n

.meas tran vdout0_242ck350 FIND v(dout0_242) AT=180.025n

.meas tran vdout0_243ck350 FIND v(dout0_243) AT=180.025n

.meas tran vdout0_244ck350 FIND v(dout0_244) AT=180.025n

.meas tran vdout0_245ck350 FIND v(dout0_245) AT=180.025n

.meas tran vdout0_246ck350 FIND v(dout0_246) AT=180.025n

.meas tran vdout0_247ck350 FIND v(dout0_247) AT=180.025n

.meas tran vdout0_248ck350 FIND v(dout0_248) AT=180.025n

.meas tran vdout0_249ck350 FIND v(dout0_249) AT=180.025n

.meas tran vdout0_250ck350 FIND v(dout0_250) AT=180.025n

.meas tran vdout0_251ck350 FIND v(dout0_251) AT=180.025n

.meas tran vdout0_252ck350 FIND v(dout0_252) AT=180.025n

.meas tran vdout0_253ck350 FIND v(dout0_253) AT=180.025n

.meas tran vdout0_254ck350 FIND v(dout0_254) AT=180.025n

.meas tran vdout0_255ck350 FIND v(dout0_255) AT=180.025n

.meas tran vdout0_0ck360 FIND v(dout0_0) AT=185.025n

.meas tran vdout0_1ck360 FIND v(dout0_1) AT=185.025n

.meas tran vdout0_2ck360 FIND v(dout0_2) AT=185.025n

.meas tran vdout0_3ck360 FIND v(dout0_3) AT=185.025n

.meas tran vdout0_4ck360 FIND v(dout0_4) AT=185.025n

.meas tran vdout0_5ck360 FIND v(dout0_5) AT=185.025n

.meas tran vdout0_6ck360 FIND v(dout0_6) AT=185.025n

.meas tran vdout0_7ck360 FIND v(dout0_7) AT=185.025n

.meas tran vdout0_8ck360 FIND v(dout0_8) AT=185.025n

.meas tran vdout0_9ck360 FIND v(dout0_9) AT=185.025n

.meas tran vdout0_10ck360 FIND v(dout0_10) AT=185.025n

.meas tran vdout0_11ck360 FIND v(dout0_11) AT=185.025n

.meas tran vdout0_12ck360 FIND v(dout0_12) AT=185.025n

.meas tran vdout0_13ck360 FIND v(dout0_13) AT=185.025n

.meas tran vdout0_14ck360 FIND v(dout0_14) AT=185.025n

.meas tran vdout0_15ck360 FIND v(dout0_15) AT=185.025n

.meas tran vdout0_16ck360 FIND v(dout0_16) AT=185.025n

.meas tran vdout0_17ck360 FIND v(dout0_17) AT=185.025n

.meas tran vdout0_18ck360 FIND v(dout0_18) AT=185.025n

.meas tran vdout0_19ck360 FIND v(dout0_19) AT=185.025n

.meas tran vdout0_20ck360 FIND v(dout0_20) AT=185.025n

.meas tran vdout0_21ck360 FIND v(dout0_21) AT=185.025n

.meas tran vdout0_22ck360 FIND v(dout0_22) AT=185.025n

.meas tran vdout0_23ck360 FIND v(dout0_23) AT=185.025n

.meas tran vdout0_24ck360 FIND v(dout0_24) AT=185.025n

.meas tran vdout0_25ck360 FIND v(dout0_25) AT=185.025n

.meas tran vdout0_26ck360 FIND v(dout0_26) AT=185.025n

.meas tran vdout0_27ck360 FIND v(dout0_27) AT=185.025n

.meas tran vdout0_28ck360 FIND v(dout0_28) AT=185.025n

.meas tran vdout0_29ck360 FIND v(dout0_29) AT=185.025n

.meas tran vdout0_30ck360 FIND v(dout0_30) AT=185.025n

.meas tran vdout0_31ck360 FIND v(dout0_31) AT=185.025n

.meas tran vdout0_32ck360 FIND v(dout0_32) AT=185.025n

.meas tran vdout0_33ck360 FIND v(dout0_33) AT=185.025n

.meas tran vdout0_34ck360 FIND v(dout0_34) AT=185.025n

.meas tran vdout0_35ck360 FIND v(dout0_35) AT=185.025n

.meas tran vdout0_36ck360 FIND v(dout0_36) AT=185.025n

.meas tran vdout0_37ck360 FIND v(dout0_37) AT=185.025n

.meas tran vdout0_38ck360 FIND v(dout0_38) AT=185.025n

.meas tran vdout0_39ck360 FIND v(dout0_39) AT=185.025n

.meas tran vdout0_40ck360 FIND v(dout0_40) AT=185.025n

.meas tran vdout0_41ck360 FIND v(dout0_41) AT=185.025n

.meas tran vdout0_42ck360 FIND v(dout0_42) AT=185.025n

.meas tran vdout0_43ck360 FIND v(dout0_43) AT=185.025n

.meas tran vdout0_44ck360 FIND v(dout0_44) AT=185.025n

.meas tran vdout0_45ck360 FIND v(dout0_45) AT=185.025n

.meas tran vdout0_46ck360 FIND v(dout0_46) AT=185.025n

.meas tran vdout0_47ck360 FIND v(dout0_47) AT=185.025n

.meas tran vdout0_48ck360 FIND v(dout0_48) AT=185.025n

.meas tran vdout0_49ck360 FIND v(dout0_49) AT=185.025n

.meas tran vdout0_50ck360 FIND v(dout0_50) AT=185.025n

.meas tran vdout0_51ck360 FIND v(dout0_51) AT=185.025n

.meas tran vdout0_52ck360 FIND v(dout0_52) AT=185.025n

.meas tran vdout0_53ck360 FIND v(dout0_53) AT=185.025n

.meas tran vdout0_54ck360 FIND v(dout0_54) AT=185.025n

.meas tran vdout0_55ck360 FIND v(dout0_55) AT=185.025n

.meas tran vdout0_56ck360 FIND v(dout0_56) AT=185.025n

.meas tran vdout0_57ck360 FIND v(dout0_57) AT=185.025n

.meas tran vdout0_58ck360 FIND v(dout0_58) AT=185.025n

.meas tran vdout0_59ck360 FIND v(dout0_59) AT=185.025n

.meas tran vdout0_60ck360 FIND v(dout0_60) AT=185.025n

.meas tran vdout0_61ck360 FIND v(dout0_61) AT=185.025n

.meas tran vdout0_62ck360 FIND v(dout0_62) AT=185.025n

.meas tran vdout0_63ck360 FIND v(dout0_63) AT=185.025n

.meas tran vdout0_64ck360 FIND v(dout0_64) AT=185.025n

.meas tran vdout0_65ck360 FIND v(dout0_65) AT=185.025n

.meas tran vdout0_66ck360 FIND v(dout0_66) AT=185.025n

.meas tran vdout0_67ck360 FIND v(dout0_67) AT=185.025n

.meas tran vdout0_68ck360 FIND v(dout0_68) AT=185.025n

.meas tran vdout0_69ck360 FIND v(dout0_69) AT=185.025n

.meas tran vdout0_70ck360 FIND v(dout0_70) AT=185.025n

.meas tran vdout0_71ck360 FIND v(dout0_71) AT=185.025n

.meas tran vdout0_72ck360 FIND v(dout0_72) AT=185.025n

.meas tran vdout0_73ck360 FIND v(dout0_73) AT=185.025n

.meas tran vdout0_74ck360 FIND v(dout0_74) AT=185.025n

.meas tran vdout0_75ck360 FIND v(dout0_75) AT=185.025n

.meas tran vdout0_76ck360 FIND v(dout0_76) AT=185.025n

.meas tran vdout0_77ck360 FIND v(dout0_77) AT=185.025n

.meas tran vdout0_78ck360 FIND v(dout0_78) AT=185.025n

.meas tran vdout0_79ck360 FIND v(dout0_79) AT=185.025n

.meas tran vdout0_80ck360 FIND v(dout0_80) AT=185.025n

.meas tran vdout0_81ck360 FIND v(dout0_81) AT=185.025n

.meas tran vdout0_82ck360 FIND v(dout0_82) AT=185.025n

.meas tran vdout0_83ck360 FIND v(dout0_83) AT=185.025n

.meas tran vdout0_84ck360 FIND v(dout0_84) AT=185.025n

.meas tran vdout0_85ck360 FIND v(dout0_85) AT=185.025n

.meas tran vdout0_86ck360 FIND v(dout0_86) AT=185.025n

.meas tran vdout0_87ck360 FIND v(dout0_87) AT=185.025n

.meas tran vdout0_88ck360 FIND v(dout0_88) AT=185.025n

.meas tran vdout0_89ck360 FIND v(dout0_89) AT=185.025n

.meas tran vdout0_90ck360 FIND v(dout0_90) AT=185.025n

.meas tran vdout0_91ck360 FIND v(dout0_91) AT=185.025n

.meas tran vdout0_92ck360 FIND v(dout0_92) AT=185.025n

.meas tran vdout0_93ck360 FIND v(dout0_93) AT=185.025n

.meas tran vdout0_94ck360 FIND v(dout0_94) AT=185.025n

.meas tran vdout0_95ck360 FIND v(dout0_95) AT=185.025n

.meas tran vdout0_96ck360 FIND v(dout0_96) AT=185.025n

.meas tran vdout0_97ck360 FIND v(dout0_97) AT=185.025n

.meas tran vdout0_98ck360 FIND v(dout0_98) AT=185.025n

.meas tran vdout0_99ck360 FIND v(dout0_99) AT=185.025n

.meas tran vdout0_100ck360 FIND v(dout0_100) AT=185.025n

.meas tran vdout0_101ck360 FIND v(dout0_101) AT=185.025n

.meas tran vdout0_102ck360 FIND v(dout0_102) AT=185.025n

.meas tran vdout0_103ck360 FIND v(dout0_103) AT=185.025n

.meas tran vdout0_104ck360 FIND v(dout0_104) AT=185.025n

.meas tran vdout0_105ck360 FIND v(dout0_105) AT=185.025n

.meas tran vdout0_106ck360 FIND v(dout0_106) AT=185.025n

.meas tran vdout0_107ck360 FIND v(dout0_107) AT=185.025n

.meas tran vdout0_108ck360 FIND v(dout0_108) AT=185.025n

.meas tran vdout0_109ck360 FIND v(dout0_109) AT=185.025n

.meas tran vdout0_110ck360 FIND v(dout0_110) AT=185.025n

.meas tran vdout0_111ck360 FIND v(dout0_111) AT=185.025n

.meas tran vdout0_112ck360 FIND v(dout0_112) AT=185.025n

.meas tran vdout0_113ck360 FIND v(dout0_113) AT=185.025n

.meas tran vdout0_114ck360 FIND v(dout0_114) AT=185.025n

.meas tran vdout0_115ck360 FIND v(dout0_115) AT=185.025n

.meas tran vdout0_116ck360 FIND v(dout0_116) AT=185.025n

.meas tran vdout0_117ck360 FIND v(dout0_117) AT=185.025n

.meas tran vdout0_118ck360 FIND v(dout0_118) AT=185.025n

.meas tran vdout0_119ck360 FIND v(dout0_119) AT=185.025n

.meas tran vdout0_120ck360 FIND v(dout0_120) AT=185.025n

.meas tran vdout0_121ck360 FIND v(dout0_121) AT=185.025n

.meas tran vdout0_122ck360 FIND v(dout0_122) AT=185.025n

.meas tran vdout0_123ck360 FIND v(dout0_123) AT=185.025n

.meas tran vdout0_124ck360 FIND v(dout0_124) AT=185.025n

.meas tran vdout0_125ck360 FIND v(dout0_125) AT=185.025n

.meas tran vdout0_126ck360 FIND v(dout0_126) AT=185.025n

.meas tran vdout0_127ck360 FIND v(dout0_127) AT=185.025n

.meas tran vdout0_128ck360 FIND v(dout0_128) AT=185.025n

.meas tran vdout0_129ck360 FIND v(dout0_129) AT=185.025n

.meas tran vdout0_130ck360 FIND v(dout0_130) AT=185.025n

.meas tran vdout0_131ck360 FIND v(dout0_131) AT=185.025n

.meas tran vdout0_132ck360 FIND v(dout0_132) AT=185.025n

.meas tran vdout0_133ck360 FIND v(dout0_133) AT=185.025n

.meas tran vdout0_134ck360 FIND v(dout0_134) AT=185.025n

.meas tran vdout0_135ck360 FIND v(dout0_135) AT=185.025n

.meas tran vdout0_136ck360 FIND v(dout0_136) AT=185.025n

.meas tran vdout0_137ck360 FIND v(dout0_137) AT=185.025n

.meas tran vdout0_138ck360 FIND v(dout0_138) AT=185.025n

.meas tran vdout0_139ck360 FIND v(dout0_139) AT=185.025n

.meas tran vdout0_140ck360 FIND v(dout0_140) AT=185.025n

.meas tran vdout0_141ck360 FIND v(dout0_141) AT=185.025n

.meas tran vdout0_142ck360 FIND v(dout0_142) AT=185.025n

.meas tran vdout0_143ck360 FIND v(dout0_143) AT=185.025n

.meas tran vdout0_144ck360 FIND v(dout0_144) AT=185.025n

.meas tran vdout0_145ck360 FIND v(dout0_145) AT=185.025n

.meas tran vdout0_146ck360 FIND v(dout0_146) AT=185.025n

.meas tran vdout0_147ck360 FIND v(dout0_147) AT=185.025n

.meas tran vdout0_148ck360 FIND v(dout0_148) AT=185.025n

.meas tran vdout0_149ck360 FIND v(dout0_149) AT=185.025n

.meas tran vdout0_150ck360 FIND v(dout0_150) AT=185.025n

.meas tran vdout0_151ck360 FIND v(dout0_151) AT=185.025n

.meas tran vdout0_152ck360 FIND v(dout0_152) AT=185.025n

.meas tran vdout0_153ck360 FIND v(dout0_153) AT=185.025n

.meas tran vdout0_154ck360 FIND v(dout0_154) AT=185.025n

.meas tran vdout0_155ck360 FIND v(dout0_155) AT=185.025n

.meas tran vdout0_156ck360 FIND v(dout0_156) AT=185.025n

.meas tran vdout0_157ck360 FIND v(dout0_157) AT=185.025n

.meas tran vdout0_158ck360 FIND v(dout0_158) AT=185.025n

.meas tran vdout0_159ck360 FIND v(dout0_159) AT=185.025n

.meas tran vdout0_160ck360 FIND v(dout0_160) AT=185.025n

.meas tran vdout0_161ck360 FIND v(dout0_161) AT=185.025n

.meas tran vdout0_162ck360 FIND v(dout0_162) AT=185.025n

.meas tran vdout0_163ck360 FIND v(dout0_163) AT=185.025n

.meas tran vdout0_164ck360 FIND v(dout0_164) AT=185.025n

.meas tran vdout0_165ck360 FIND v(dout0_165) AT=185.025n

.meas tran vdout0_166ck360 FIND v(dout0_166) AT=185.025n

.meas tran vdout0_167ck360 FIND v(dout0_167) AT=185.025n

.meas tran vdout0_168ck360 FIND v(dout0_168) AT=185.025n

.meas tran vdout0_169ck360 FIND v(dout0_169) AT=185.025n

.meas tran vdout0_170ck360 FIND v(dout0_170) AT=185.025n

.meas tran vdout0_171ck360 FIND v(dout0_171) AT=185.025n

.meas tran vdout0_172ck360 FIND v(dout0_172) AT=185.025n

.meas tran vdout0_173ck360 FIND v(dout0_173) AT=185.025n

.meas tran vdout0_174ck360 FIND v(dout0_174) AT=185.025n

.meas tran vdout0_175ck360 FIND v(dout0_175) AT=185.025n

.meas tran vdout0_176ck360 FIND v(dout0_176) AT=185.025n

.meas tran vdout0_177ck360 FIND v(dout0_177) AT=185.025n

.meas tran vdout0_178ck360 FIND v(dout0_178) AT=185.025n

.meas tran vdout0_179ck360 FIND v(dout0_179) AT=185.025n

.meas tran vdout0_180ck360 FIND v(dout0_180) AT=185.025n

.meas tran vdout0_181ck360 FIND v(dout0_181) AT=185.025n

.meas tran vdout0_182ck360 FIND v(dout0_182) AT=185.025n

.meas tran vdout0_183ck360 FIND v(dout0_183) AT=185.025n

.meas tran vdout0_184ck360 FIND v(dout0_184) AT=185.025n

.meas tran vdout0_185ck360 FIND v(dout0_185) AT=185.025n

.meas tran vdout0_186ck360 FIND v(dout0_186) AT=185.025n

.meas tran vdout0_187ck360 FIND v(dout0_187) AT=185.025n

.meas tran vdout0_188ck360 FIND v(dout0_188) AT=185.025n

.meas tran vdout0_189ck360 FIND v(dout0_189) AT=185.025n

.meas tran vdout0_190ck360 FIND v(dout0_190) AT=185.025n

.meas tran vdout0_191ck360 FIND v(dout0_191) AT=185.025n

.meas tran vdout0_192ck360 FIND v(dout0_192) AT=185.025n

.meas tran vdout0_193ck360 FIND v(dout0_193) AT=185.025n

.meas tran vdout0_194ck360 FIND v(dout0_194) AT=185.025n

.meas tran vdout0_195ck360 FIND v(dout0_195) AT=185.025n

.meas tran vdout0_196ck360 FIND v(dout0_196) AT=185.025n

.meas tran vdout0_197ck360 FIND v(dout0_197) AT=185.025n

.meas tran vdout0_198ck360 FIND v(dout0_198) AT=185.025n

.meas tran vdout0_199ck360 FIND v(dout0_199) AT=185.025n

.meas tran vdout0_200ck360 FIND v(dout0_200) AT=185.025n

.meas tran vdout0_201ck360 FIND v(dout0_201) AT=185.025n

.meas tran vdout0_202ck360 FIND v(dout0_202) AT=185.025n

.meas tran vdout0_203ck360 FIND v(dout0_203) AT=185.025n

.meas tran vdout0_204ck360 FIND v(dout0_204) AT=185.025n

.meas tran vdout0_205ck360 FIND v(dout0_205) AT=185.025n

.meas tran vdout0_206ck360 FIND v(dout0_206) AT=185.025n

.meas tran vdout0_207ck360 FIND v(dout0_207) AT=185.025n

.meas tran vdout0_208ck360 FIND v(dout0_208) AT=185.025n

.meas tran vdout0_209ck360 FIND v(dout0_209) AT=185.025n

.meas tran vdout0_210ck360 FIND v(dout0_210) AT=185.025n

.meas tran vdout0_211ck360 FIND v(dout0_211) AT=185.025n

.meas tran vdout0_212ck360 FIND v(dout0_212) AT=185.025n

.meas tran vdout0_213ck360 FIND v(dout0_213) AT=185.025n

.meas tran vdout0_214ck360 FIND v(dout0_214) AT=185.025n

.meas tran vdout0_215ck360 FIND v(dout0_215) AT=185.025n

.meas tran vdout0_216ck360 FIND v(dout0_216) AT=185.025n

.meas tran vdout0_217ck360 FIND v(dout0_217) AT=185.025n

.meas tran vdout0_218ck360 FIND v(dout0_218) AT=185.025n

.meas tran vdout0_219ck360 FIND v(dout0_219) AT=185.025n

.meas tran vdout0_220ck360 FIND v(dout0_220) AT=185.025n

.meas tran vdout0_221ck360 FIND v(dout0_221) AT=185.025n

.meas tran vdout0_222ck360 FIND v(dout0_222) AT=185.025n

.meas tran vdout0_223ck360 FIND v(dout0_223) AT=185.025n

.meas tran vdout0_224ck360 FIND v(dout0_224) AT=185.025n

.meas tran vdout0_225ck360 FIND v(dout0_225) AT=185.025n

.meas tran vdout0_226ck360 FIND v(dout0_226) AT=185.025n

.meas tran vdout0_227ck360 FIND v(dout0_227) AT=185.025n

.meas tran vdout0_228ck360 FIND v(dout0_228) AT=185.025n

.meas tran vdout0_229ck360 FIND v(dout0_229) AT=185.025n

.meas tran vdout0_230ck360 FIND v(dout0_230) AT=185.025n

.meas tran vdout0_231ck360 FIND v(dout0_231) AT=185.025n

.meas tran vdout0_232ck360 FIND v(dout0_232) AT=185.025n

.meas tran vdout0_233ck360 FIND v(dout0_233) AT=185.025n

.meas tran vdout0_234ck360 FIND v(dout0_234) AT=185.025n

.meas tran vdout0_235ck360 FIND v(dout0_235) AT=185.025n

.meas tran vdout0_236ck360 FIND v(dout0_236) AT=185.025n

.meas tran vdout0_237ck360 FIND v(dout0_237) AT=185.025n

.meas tran vdout0_238ck360 FIND v(dout0_238) AT=185.025n

.meas tran vdout0_239ck360 FIND v(dout0_239) AT=185.025n

.meas tran vdout0_240ck360 FIND v(dout0_240) AT=185.025n

.meas tran vdout0_241ck360 FIND v(dout0_241) AT=185.025n

.meas tran vdout0_242ck360 FIND v(dout0_242) AT=185.025n

.meas tran vdout0_243ck360 FIND v(dout0_243) AT=185.025n

.meas tran vdout0_244ck360 FIND v(dout0_244) AT=185.025n

.meas tran vdout0_245ck360 FIND v(dout0_245) AT=185.025n

.meas tran vdout0_246ck360 FIND v(dout0_246) AT=185.025n

.meas tran vdout0_247ck360 FIND v(dout0_247) AT=185.025n

.meas tran vdout0_248ck360 FIND v(dout0_248) AT=185.025n

.meas tran vdout0_249ck360 FIND v(dout0_249) AT=185.025n

.meas tran vdout0_250ck360 FIND v(dout0_250) AT=185.025n

.meas tran vdout0_251ck360 FIND v(dout0_251) AT=185.025n

.meas tran vdout0_252ck360 FIND v(dout0_252) AT=185.025n

.meas tran vdout0_253ck360 FIND v(dout0_253) AT=185.025n

.meas tran vdout0_254ck360 FIND v(dout0_254) AT=185.025n

.meas tran vdout0_255ck360 FIND v(dout0_255) AT=185.025n

.meas tran vdout0_0ck380 FIND v(dout0_0) AT=195.025n

.meas tran vdout0_1ck380 FIND v(dout0_1) AT=195.025n

.meas tran vdout0_2ck380 FIND v(dout0_2) AT=195.025n

.meas tran vdout0_3ck380 FIND v(dout0_3) AT=195.025n

.meas tran vdout0_4ck380 FIND v(dout0_4) AT=195.025n

.meas tran vdout0_5ck380 FIND v(dout0_5) AT=195.025n

.meas tran vdout0_6ck380 FIND v(dout0_6) AT=195.025n

.meas tran vdout0_7ck380 FIND v(dout0_7) AT=195.025n

.meas tran vdout0_8ck380 FIND v(dout0_8) AT=195.025n

.meas tran vdout0_9ck380 FIND v(dout0_9) AT=195.025n

.meas tran vdout0_10ck380 FIND v(dout0_10) AT=195.025n

.meas tran vdout0_11ck380 FIND v(dout0_11) AT=195.025n

.meas tran vdout0_12ck380 FIND v(dout0_12) AT=195.025n

.meas tran vdout0_13ck380 FIND v(dout0_13) AT=195.025n

.meas tran vdout0_14ck380 FIND v(dout0_14) AT=195.025n

.meas tran vdout0_15ck380 FIND v(dout0_15) AT=195.025n

.meas tran vdout0_16ck380 FIND v(dout0_16) AT=195.025n

.meas tran vdout0_17ck380 FIND v(dout0_17) AT=195.025n

.meas tran vdout0_18ck380 FIND v(dout0_18) AT=195.025n

.meas tran vdout0_19ck380 FIND v(dout0_19) AT=195.025n

.meas tran vdout0_20ck380 FIND v(dout0_20) AT=195.025n

.meas tran vdout0_21ck380 FIND v(dout0_21) AT=195.025n

.meas tran vdout0_22ck380 FIND v(dout0_22) AT=195.025n

.meas tran vdout0_23ck380 FIND v(dout0_23) AT=195.025n

.meas tran vdout0_24ck380 FIND v(dout0_24) AT=195.025n

.meas tran vdout0_25ck380 FIND v(dout0_25) AT=195.025n

.meas tran vdout0_26ck380 FIND v(dout0_26) AT=195.025n

.meas tran vdout0_27ck380 FIND v(dout0_27) AT=195.025n

.meas tran vdout0_28ck380 FIND v(dout0_28) AT=195.025n

.meas tran vdout0_29ck380 FIND v(dout0_29) AT=195.025n

.meas tran vdout0_30ck380 FIND v(dout0_30) AT=195.025n

.meas tran vdout0_31ck380 FIND v(dout0_31) AT=195.025n

.meas tran vdout0_32ck380 FIND v(dout0_32) AT=195.025n

.meas tran vdout0_33ck380 FIND v(dout0_33) AT=195.025n

.meas tran vdout0_34ck380 FIND v(dout0_34) AT=195.025n

.meas tran vdout0_35ck380 FIND v(dout0_35) AT=195.025n

.meas tran vdout0_36ck380 FIND v(dout0_36) AT=195.025n

.meas tran vdout0_37ck380 FIND v(dout0_37) AT=195.025n

.meas tran vdout0_38ck380 FIND v(dout0_38) AT=195.025n

.meas tran vdout0_39ck380 FIND v(dout0_39) AT=195.025n

.meas tran vdout0_40ck380 FIND v(dout0_40) AT=195.025n

.meas tran vdout0_41ck380 FIND v(dout0_41) AT=195.025n

.meas tran vdout0_42ck380 FIND v(dout0_42) AT=195.025n

.meas tran vdout0_43ck380 FIND v(dout0_43) AT=195.025n

.meas tran vdout0_44ck380 FIND v(dout0_44) AT=195.025n

.meas tran vdout0_45ck380 FIND v(dout0_45) AT=195.025n

.meas tran vdout0_46ck380 FIND v(dout0_46) AT=195.025n

.meas tran vdout0_47ck380 FIND v(dout0_47) AT=195.025n

.meas tran vdout0_48ck380 FIND v(dout0_48) AT=195.025n

.meas tran vdout0_49ck380 FIND v(dout0_49) AT=195.025n

.meas tran vdout0_50ck380 FIND v(dout0_50) AT=195.025n

.meas tran vdout0_51ck380 FIND v(dout0_51) AT=195.025n

.meas tran vdout0_52ck380 FIND v(dout0_52) AT=195.025n

.meas tran vdout0_53ck380 FIND v(dout0_53) AT=195.025n

.meas tran vdout0_54ck380 FIND v(dout0_54) AT=195.025n

.meas tran vdout0_55ck380 FIND v(dout0_55) AT=195.025n

.meas tran vdout0_56ck380 FIND v(dout0_56) AT=195.025n

.meas tran vdout0_57ck380 FIND v(dout0_57) AT=195.025n

.meas tran vdout0_58ck380 FIND v(dout0_58) AT=195.025n

.meas tran vdout0_59ck380 FIND v(dout0_59) AT=195.025n

.meas tran vdout0_60ck380 FIND v(dout0_60) AT=195.025n

.meas tran vdout0_61ck380 FIND v(dout0_61) AT=195.025n

.meas tran vdout0_62ck380 FIND v(dout0_62) AT=195.025n

.meas tran vdout0_63ck380 FIND v(dout0_63) AT=195.025n

.meas tran vdout0_64ck380 FIND v(dout0_64) AT=195.025n

.meas tran vdout0_65ck380 FIND v(dout0_65) AT=195.025n

.meas tran vdout0_66ck380 FIND v(dout0_66) AT=195.025n

.meas tran vdout0_67ck380 FIND v(dout0_67) AT=195.025n

.meas tran vdout0_68ck380 FIND v(dout0_68) AT=195.025n

.meas tran vdout0_69ck380 FIND v(dout0_69) AT=195.025n

.meas tran vdout0_70ck380 FIND v(dout0_70) AT=195.025n

.meas tran vdout0_71ck380 FIND v(dout0_71) AT=195.025n

.meas tran vdout0_72ck380 FIND v(dout0_72) AT=195.025n

.meas tran vdout0_73ck380 FIND v(dout0_73) AT=195.025n

.meas tran vdout0_74ck380 FIND v(dout0_74) AT=195.025n

.meas tran vdout0_75ck380 FIND v(dout0_75) AT=195.025n

.meas tran vdout0_76ck380 FIND v(dout0_76) AT=195.025n

.meas tran vdout0_77ck380 FIND v(dout0_77) AT=195.025n

.meas tran vdout0_78ck380 FIND v(dout0_78) AT=195.025n

.meas tran vdout0_79ck380 FIND v(dout0_79) AT=195.025n

.meas tran vdout0_80ck380 FIND v(dout0_80) AT=195.025n

.meas tran vdout0_81ck380 FIND v(dout0_81) AT=195.025n

.meas tran vdout0_82ck380 FIND v(dout0_82) AT=195.025n

.meas tran vdout0_83ck380 FIND v(dout0_83) AT=195.025n

.meas tran vdout0_84ck380 FIND v(dout0_84) AT=195.025n

.meas tran vdout0_85ck380 FIND v(dout0_85) AT=195.025n

.meas tran vdout0_86ck380 FIND v(dout0_86) AT=195.025n

.meas tran vdout0_87ck380 FIND v(dout0_87) AT=195.025n

.meas tran vdout0_88ck380 FIND v(dout0_88) AT=195.025n

.meas tran vdout0_89ck380 FIND v(dout0_89) AT=195.025n

.meas tran vdout0_90ck380 FIND v(dout0_90) AT=195.025n

.meas tran vdout0_91ck380 FIND v(dout0_91) AT=195.025n

.meas tran vdout0_92ck380 FIND v(dout0_92) AT=195.025n

.meas tran vdout0_93ck380 FIND v(dout0_93) AT=195.025n

.meas tran vdout0_94ck380 FIND v(dout0_94) AT=195.025n

.meas tran vdout0_95ck380 FIND v(dout0_95) AT=195.025n

.meas tran vdout0_96ck380 FIND v(dout0_96) AT=195.025n

.meas tran vdout0_97ck380 FIND v(dout0_97) AT=195.025n

.meas tran vdout0_98ck380 FIND v(dout0_98) AT=195.025n

.meas tran vdout0_99ck380 FIND v(dout0_99) AT=195.025n

.meas tran vdout0_100ck380 FIND v(dout0_100) AT=195.025n

.meas tran vdout0_101ck380 FIND v(dout0_101) AT=195.025n

.meas tran vdout0_102ck380 FIND v(dout0_102) AT=195.025n

.meas tran vdout0_103ck380 FIND v(dout0_103) AT=195.025n

.meas tran vdout0_104ck380 FIND v(dout0_104) AT=195.025n

.meas tran vdout0_105ck380 FIND v(dout0_105) AT=195.025n

.meas tran vdout0_106ck380 FIND v(dout0_106) AT=195.025n

.meas tran vdout0_107ck380 FIND v(dout0_107) AT=195.025n

.meas tran vdout0_108ck380 FIND v(dout0_108) AT=195.025n

.meas tran vdout0_109ck380 FIND v(dout0_109) AT=195.025n

.meas tran vdout0_110ck380 FIND v(dout0_110) AT=195.025n

.meas tran vdout0_111ck380 FIND v(dout0_111) AT=195.025n

.meas tran vdout0_112ck380 FIND v(dout0_112) AT=195.025n

.meas tran vdout0_113ck380 FIND v(dout0_113) AT=195.025n

.meas tran vdout0_114ck380 FIND v(dout0_114) AT=195.025n

.meas tran vdout0_115ck380 FIND v(dout0_115) AT=195.025n

.meas tran vdout0_116ck380 FIND v(dout0_116) AT=195.025n

.meas tran vdout0_117ck380 FIND v(dout0_117) AT=195.025n

.meas tran vdout0_118ck380 FIND v(dout0_118) AT=195.025n

.meas tran vdout0_119ck380 FIND v(dout0_119) AT=195.025n

.meas tran vdout0_120ck380 FIND v(dout0_120) AT=195.025n

.meas tran vdout0_121ck380 FIND v(dout0_121) AT=195.025n

.meas tran vdout0_122ck380 FIND v(dout0_122) AT=195.025n

.meas tran vdout0_123ck380 FIND v(dout0_123) AT=195.025n

.meas tran vdout0_124ck380 FIND v(dout0_124) AT=195.025n

.meas tran vdout0_125ck380 FIND v(dout0_125) AT=195.025n

.meas tran vdout0_126ck380 FIND v(dout0_126) AT=195.025n

.meas tran vdout0_127ck380 FIND v(dout0_127) AT=195.025n

.meas tran vdout0_128ck380 FIND v(dout0_128) AT=195.025n

.meas tran vdout0_129ck380 FIND v(dout0_129) AT=195.025n

.meas tran vdout0_130ck380 FIND v(dout0_130) AT=195.025n

.meas tran vdout0_131ck380 FIND v(dout0_131) AT=195.025n

.meas tran vdout0_132ck380 FIND v(dout0_132) AT=195.025n

.meas tran vdout0_133ck380 FIND v(dout0_133) AT=195.025n

.meas tran vdout0_134ck380 FIND v(dout0_134) AT=195.025n

.meas tran vdout0_135ck380 FIND v(dout0_135) AT=195.025n

.meas tran vdout0_136ck380 FIND v(dout0_136) AT=195.025n

.meas tran vdout0_137ck380 FIND v(dout0_137) AT=195.025n

.meas tran vdout0_138ck380 FIND v(dout0_138) AT=195.025n

.meas tran vdout0_139ck380 FIND v(dout0_139) AT=195.025n

.meas tran vdout0_140ck380 FIND v(dout0_140) AT=195.025n

.meas tran vdout0_141ck380 FIND v(dout0_141) AT=195.025n

.meas tran vdout0_142ck380 FIND v(dout0_142) AT=195.025n

.meas tran vdout0_143ck380 FIND v(dout0_143) AT=195.025n

.meas tran vdout0_144ck380 FIND v(dout0_144) AT=195.025n

.meas tran vdout0_145ck380 FIND v(dout0_145) AT=195.025n

.meas tran vdout0_146ck380 FIND v(dout0_146) AT=195.025n

.meas tran vdout0_147ck380 FIND v(dout0_147) AT=195.025n

.meas tran vdout0_148ck380 FIND v(dout0_148) AT=195.025n

.meas tran vdout0_149ck380 FIND v(dout0_149) AT=195.025n

.meas tran vdout0_150ck380 FIND v(dout0_150) AT=195.025n

.meas tran vdout0_151ck380 FIND v(dout0_151) AT=195.025n

.meas tran vdout0_152ck380 FIND v(dout0_152) AT=195.025n

.meas tran vdout0_153ck380 FIND v(dout0_153) AT=195.025n

.meas tran vdout0_154ck380 FIND v(dout0_154) AT=195.025n

.meas tran vdout0_155ck380 FIND v(dout0_155) AT=195.025n

.meas tran vdout0_156ck380 FIND v(dout0_156) AT=195.025n

.meas tran vdout0_157ck380 FIND v(dout0_157) AT=195.025n

.meas tran vdout0_158ck380 FIND v(dout0_158) AT=195.025n

.meas tran vdout0_159ck380 FIND v(dout0_159) AT=195.025n

.meas tran vdout0_160ck380 FIND v(dout0_160) AT=195.025n

.meas tran vdout0_161ck380 FIND v(dout0_161) AT=195.025n

.meas tran vdout0_162ck380 FIND v(dout0_162) AT=195.025n

.meas tran vdout0_163ck380 FIND v(dout0_163) AT=195.025n

.meas tran vdout0_164ck380 FIND v(dout0_164) AT=195.025n

.meas tran vdout0_165ck380 FIND v(dout0_165) AT=195.025n

.meas tran vdout0_166ck380 FIND v(dout0_166) AT=195.025n

.meas tran vdout0_167ck380 FIND v(dout0_167) AT=195.025n

.meas tran vdout0_168ck380 FIND v(dout0_168) AT=195.025n

.meas tran vdout0_169ck380 FIND v(dout0_169) AT=195.025n

.meas tran vdout0_170ck380 FIND v(dout0_170) AT=195.025n

.meas tran vdout0_171ck380 FIND v(dout0_171) AT=195.025n

.meas tran vdout0_172ck380 FIND v(dout0_172) AT=195.025n

.meas tran vdout0_173ck380 FIND v(dout0_173) AT=195.025n

.meas tran vdout0_174ck380 FIND v(dout0_174) AT=195.025n

.meas tran vdout0_175ck380 FIND v(dout0_175) AT=195.025n

.meas tran vdout0_176ck380 FIND v(dout0_176) AT=195.025n

.meas tran vdout0_177ck380 FIND v(dout0_177) AT=195.025n

.meas tran vdout0_178ck380 FIND v(dout0_178) AT=195.025n

.meas tran vdout0_179ck380 FIND v(dout0_179) AT=195.025n

.meas tran vdout0_180ck380 FIND v(dout0_180) AT=195.025n

.meas tran vdout0_181ck380 FIND v(dout0_181) AT=195.025n

.meas tran vdout0_182ck380 FIND v(dout0_182) AT=195.025n

.meas tran vdout0_183ck380 FIND v(dout0_183) AT=195.025n

.meas tran vdout0_184ck380 FIND v(dout0_184) AT=195.025n

.meas tran vdout0_185ck380 FIND v(dout0_185) AT=195.025n

.meas tran vdout0_186ck380 FIND v(dout0_186) AT=195.025n

.meas tran vdout0_187ck380 FIND v(dout0_187) AT=195.025n

.meas tran vdout0_188ck380 FIND v(dout0_188) AT=195.025n

.meas tran vdout0_189ck380 FIND v(dout0_189) AT=195.025n

.meas tran vdout0_190ck380 FIND v(dout0_190) AT=195.025n

.meas tran vdout0_191ck380 FIND v(dout0_191) AT=195.025n

.meas tran vdout0_192ck380 FIND v(dout0_192) AT=195.025n

.meas tran vdout0_193ck380 FIND v(dout0_193) AT=195.025n

.meas tran vdout0_194ck380 FIND v(dout0_194) AT=195.025n

.meas tran vdout0_195ck380 FIND v(dout0_195) AT=195.025n

.meas tran vdout0_196ck380 FIND v(dout0_196) AT=195.025n

.meas tran vdout0_197ck380 FIND v(dout0_197) AT=195.025n

.meas tran vdout0_198ck380 FIND v(dout0_198) AT=195.025n

.meas tran vdout0_199ck380 FIND v(dout0_199) AT=195.025n

.meas tran vdout0_200ck380 FIND v(dout0_200) AT=195.025n

.meas tran vdout0_201ck380 FIND v(dout0_201) AT=195.025n

.meas tran vdout0_202ck380 FIND v(dout0_202) AT=195.025n

.meas tran vdout0_203ck380 FIND v(dout0_203) AT=195.025n

.meas tran vdout0_204ck380 FIND v(dout0_204) AT=195.025n

.meas tran vdout0_205ck380 FIND v(dout0_205) AT=195.025n

.meas tran vdout0_206ck380 FIND v(dout0_206) AT=195.025n

.meas tran vdout0_207ck380 FIND v(dout0_207) AT=195.025n

.meas tran vdout0_208ck380 FIND v(dout0_208) AT=195.025n

.meas tran vdout0_209ck380 FIND v(dout0_209) AT=195.025n

.meas tran vdout0_210ck380 FIND v(dout0_210) AT=195.025n

.meas tran vdout0_211ck380 FIND v(dout0_211) AT=195.025n

.meas tran vdout0_212ck380 FIND v(dout0_212) AT=195.025n

.meas tran vdout0_213ck380 FIND v(dout0_213) AT=195.025n

.meas tran vdout0_214ck380 FIND v(dout0_214) AT=195.025n

.meas tran vdout0_215ck380 FIND v(dout0_215) AT=195.025n

.meas tran vdout0_216ck380 FIND v(dout0_216) AT=195.025n

.meas tran vdout0_217ck380 FIND v(dout0_217) AT=195.025n

.meas tran vdout0_218ck380 FIND v(dout0_218) AT=195.025n

.meas tran vdout0_219ck380 FIND v(dout0_219) AT=195.025n

.meas tran vdout0_220ck380 FIND v(dout0_220) AT=195.025n

.meas tran vdout0_221ck380 FIND v(dout0_221) AT=195.025n

.meas tran vdout0_222ck380 FIND v(dout0_222) AT=195.025n

.meas tran vdout0_223ck380 FIND v(dout0_223) AT=195.025n

.meas tran vdout0_224ck380 FIND v(dout0_224) AT=195.025n

.meas tran vdout0_225ck380 FIND v(dout0_225) AT=195.025n

.meas tran vdout0_226ck380 FIND v(dout0_226) AT=195.025n

.meas tran vdout0_227ck380 FIND v(dout0_227) AT=195.025n

.meas tran vdout0_228ck380 FIND v(dout0_228) AT=195.025n

.meas tran vdout0_229ck380 FIND v(dout0_229) AT=195.025n

.meas tran vdout0_230ck380 FIND v(dout0_230) AT=195.025n

.meas tran vdout0_231ck380 FIND v(dout0_231) AT=195.025n

.meas tran vdout0_232ck380 FIND v(dout0_232) AT=195.025n

.meas tran vdout0_233ck380 FIND v(dout0_233) AT=195.025n

.meas tran vdout0_234ck380 FIND v(dout0_234) AT=195.025n

.meas tran vdout0_235ck380 FIND v(dout0_235) AT=195.025n

.meas tran vdout0_236ck380 FIND v(dout0_236) AT=195.025n

.meas tran vdout0_237ck380 FIND v(dout0_237) AT=195.025n

.meas tran vdout0_238ck380 FIND v(dout0_238) AT=195.025n

.meas tran vdout0_239ck380 FIND v(dout0_239) AT=195.025n

.meas tran vdout0_240ck380 FIND v(dout0_240) AT=195.025n

.meas tran vdout0_241ck380 FIND v(dout0_241) AT=195.025n

.meas tran vdout0_242ck380 FIND v(dout0_242) AT=195.025n

.meas tran vdout0_243ck380 FIND v(dout0_243) AT=195.025n

.meas tran vdout0_244ck380 FIND v(dout0_244) AT=195.025n

.meas tran vdout0_245ck380 FIND v(dout0_245) AT=195.025n

.meas tran vdout0_246ck380 FIND v(dout0_246) AT=195.025n

.meas tran vdout0_247ck380 FIND v(dout0_247) AT=195.025n

.meas tran vdout0_248ck380 FIND v(dout0_248) AT=195.025n

.meas tran vdout0_249ck380 FIND v(dout0_249) AT=195.025n

.meas tran vdout0_250ck380 FIND v(dout0_250) AT=195.025n

.meas tran vdout0_251ck380 FIND v(dout0_251) AT=195.025n

.meas tran vdout0_252ck380 FIND v(dout0_252) AT=195.025n

.meas tran vdout0_253ck380 FIND v(dout0_253) AT=195.025n

.meas tran vdout0_254ck380 FIND v(dout0_254) AT=195.025n

.meas tran vdout0_255ck380 FIND v(dout0_255) AT=195.025n

.meas tran vdout0_0ck390 FIND v(dout0_0) AT=200.025n

.meas tran vdout0_1ck390 FIND v(dout0_1) AT=200.025n

.meas tran vdout0_2ck390 FIND v(dout0_2) AT=200.025n

.meas tran vdout0_3ck390 FIND v(dout0_3) AT=200.025n

.meas tran vdout0_4ck390 FIND v(dout0_4) AT=200.025n

.meas tran vdout0_5ck390 FIND v(dout0_5) AT=200.025n

.meas tran vdout0_6ck390 FIND v(dout0_6) AT=200.025n

.meas tran vdout0_7ck390 FIND v(dout0_7) AT=200.025n

.meas tran vdout0_8ck390 FIND v(dout0_8) AT=200.025n

.meas tran vdout0_9ck390 FIND v(dout0_9) AT=200.025n

.meas tran vdout0_10ck390 FIND v(dout0_10) AT=200.025n

.meas tran vdout0_11ck390 FIND v(dout0_11) AT=200.025n

.meas tran vdout0_12ck390 FIND v(dout0_12) AT=200.025n

.meas tran vdout0_13ck390 FIND v(dout0_13) AT=200.025n

.meas tran vdout0_14ck390 FIND v(dout0_14) AT=200.025n

.meas tran vdout0_15ck390 FIND v(dout0_15) AT=200.025n

.meas tran vdout0_16ck390 FIND v(dout0_16) AT=200.025n

.meas tran vdout0_17ck390 FIND v(dout0_17) AT=200.025n

.meas tran vdout0_18ck390 FIND v(dout0_18) AT=200.025n

.meas tran vdout0_19ck390 FIND v(dout0_19) AT=200.025n

.meas tran vdout0_20ck390 FIND v(dout0_20) AT=200.025n

.meas tran vdout0_21ck390 FIND v(dout0_21) AT=200.025n

.meas tran vdout0_22ck390 FIND v(dout0_22) AT=200.025n

.meas tran vdout0_23ck390 FIND v(dout0_23) AT=200.025n

.meas tran vdout0_24ck390 FIND v(dout0_24) AT=200.025n

.meas tran vdout0_25ck390 FIND v(dout0_25) AT=200.025n

.meas tran vdout0_26ck390 FIND v(dout0_26) AT=200.025n

.meas tran vdout0_27ck390 FIND v(dout0_27) AT=200.025n

.meas tran vdout0_28ck390 FIND v(dout0_28) AT=200.025n

.meas tran vdout0_29ck390 FIND v(dout0_29) AT=200.025n

.meas tran vdout0_30ck390 FIND v(dout0_30) AT=200.025n

.meas tran vdout0_31ck390 FIND v(dout0_31) AT=200.025n

.meas tran vdout0_32ck390 FIND v(dout0_32) AT=200.025n

.meas tran vdout0_33ck390 FIND v(dout0_33) AT=200.025n

.meas tran vdout0_34ck390 FIND v(dout0_34) AT=200.025n

.meas tran vdout0_35ck390 FIND v(dout0_35) AT=200.025n

.meas tran vdout0_36ck390 FIND v(dout0_36) AT=200.025n

.meas tran vdout0_37ck390 FIND v(dout0_37) AT=200.025n

.meas tran vdout0_38ck390 FIND v(dout0_38) AT=200.025n

.meas tran vdout0_39ck390 FIND v(dout0_39) AT=200.025n

.meas tran vdout0_40ck390 FIND v(dout0_40) AT=200.025n

.meas tran vdout0_41ck390 FIND v(dout0_41) AT=200.025n

.meas tran vdout0_42ck390 FIND v(dout0_42) AT=200.025n

.meas tran vdout0_43ck390 FIND v(dout0_43) AT=200.025n

.meas tran vdout0_44ck390 FIND v(dout0_44) AT=200.025n

.meas tran vdout0_45ck390 FIND v(dout0_45) AT=200.025n

.meas tran vdout0_46ck390 FIND v(dout0_46) AT=200.025n

.meas tran vdout0_47ck390 FIND v(dout0_47) AT=200.025n

.meas tran vdout0_48ck390 FIND v(dout0_48) AT=200.025n

.meas tran vdout0_49ck390 FIND v(dout0_49) AT=200.025n

.meas tran vdout0_50ck390 FIND v(dout0_50) AT=200.025n

.meas tran vdout0_51ck390 FIND v(dout0_51) AT=200.025n

.meas tran vdout0_52ck390 FIND v(dout0_52) AT=200.025n

.meas tran vdout0_53ck390 FIND v(dout0_53) AT=200.025n

.meas tran vdout0_54ck390 FIND v(dout0_54) AT=200.025n

.meas tran vdout0_55ck390 FIND v(dout0_55) AT=200.025n

.meas tran vdout0_56ck390 FIND v(dout0_56) AT=200.025n

.meas tran vdout0_57ck390 FIND v(dout0_57) AT=200.025n

.meas tran vdout0_58ck390 FIND v(dout0_58) AT=200.025n

.meas tran vdout0_59ck390 FIND v(dout0_59) AT=200.025n

.meas tran vdout0_60ck390 FIND v(dout0_60) AT=200.025n

.meas tran vdout0_61ck390 FIND v(dout0_61) AT=200.025n

.meas tran vdout0_62ck390 FIND v(dout0_62) AT=200.025n

.meas tran vdout0_63ck390 FIND v(dout0_63) AT=200.025n

.meas tran vdout0_64ck390 FIND v(dout0_64) AT=200.025n

.meas tran vdout0_65ck390 FIND v(dout0_65) AT=200.025n

.meas tran vdout0_66ck390 FIND v(dout0_66) AT=200.025n

.meas tran vdout0_67ck390 FIND v(dout0_67) AT=200.025n

.meas tran vdout0_68ck390 FIND v(dout0_68) AT=200.025n

.meas tran vdout0_69ck390 FIND v(dout0_69) AT=200.025n

.meas tran vdout0_70ck390 FIND v(dout0_70) AT=200.025n

.meas tran vdout0_71ck390 FIND v(dout0_71) AT=200.025n

.meas tran vdout0_72ck390 FIND v(dout0_72) AT=200.025n

.meas tran vdout0_73ck390 FIND v(dout0_73) AT=200.025n

.meas tran vdout0_74ck390 FIND v(dout0_74) AT=200.025n

.meas tran vdout0_75ck390 FIND v(dout0_75) AT=200.025n

.meas tran vdout0_76ck390 FIND v(dout0_76) AT=200.025n

.meas tran vdout0_77ck390 FIND v(dout0_77) AT=200.025n

.meas tran vdout0_78ck390 FIND v(dout0_78) AT=200.025n

.meas tran vdout0_79ck390 FIND v(dout0_79) AT=200.025n

.meas tran vdout0_80ck390 FIND v(dout0_80) AT=200.025n

.meas tran vdout0_81ck390 FIND v(dout0_81) AT=200.025n

.meas tran vdout0_82ck390 FIND v(dout0_82) AT=200.025n

.meas tran vdout0_83ck390 FIND v(dout0_83) AT=200.025n

.meas tran vdout0_84ck390 FIND v(dout0_84) AT=200.025n

.meas tran vdout0_85ck390 FIND v(dout0_85) AT=200.025n

.meas tran vdout0_86ck390 FIND v(dout0_86) AT=200.025n

.meas tran vdout0_87ck390 FIND v(dout0_87) AT=200.025n

.meas tran vdout0_88ck390 FIND v(dout0_88) AT=200.025n

.meas tran vdout0_89ck390 FIND v(dout0_89) AT=200.025n

.meas tran vdout0_90ck390 FIND v(dout0_90) AT=200.025n

.meas tran vdout0_91ck390 FIND v(dout0_91) AT=200.025n

.meas tran vdout0_92ck390 FIND v(dout0_92) AT=200.025n

.meas tran vdout0_93ck390 FIND v(dout0_93) AT=200.025n

.meas tran vdout0_94ck390 FIND v(dout0_94) AT=200.025n

.meas tran vdout0_95ck390 FIND v(dout0_95) AT=200.025n

.meas tran vdout0_96ck390 FIND v(dout0_96) AT=200.025n

.meas tran vdout0_97ck390 FIND v(dout0_97) AT=200.025n

.meas tran vdout0_98ck390 FIND v(dout0_98) AT=200.025n

.meas tran vdout0_99ck390 FIND v(dout0_99) AT=200.025n

.meas tran vdout0_100ck390 FIND v(dout0_100) AT=200.025n

.meas tran vdout0_101ck390 FIND v(dout0_101) AT=200.025n

.meas tran vdout0_102ck390 FIND v(dout0_102) AT=200.025n

.meas tran vdout0_103ck390 FIND v(dout0_103) AT=200.025n

.meas tran vdout0_104ck390 FIND v(dout0_104) AT=200.025n

.meas tran vdout0_105ck390 FIND v(dout0_105) AT=200.025n

.meas tran vdout0_106ck390 FIND v(dout0_106) AT=200.025n

.meas tran vdout0_107ck390 FIND v(dout0_107) AT=200.025n

.meas tran vdout0_108ck390 FIND v(dout0_108) AT=200.025n

.meas tran vdout0_109ck390 FIND v(dout0_109) AT=200.025n

.meas tran vdout0_110ck390 FIND v(dout0_110) AT=200.025n

.meas tran vdout0_111ck390 FIND v(dout0_111) AT=200.025n

.meas tran vdout0_112ck390 FIND v(dout0_112) AT=200.025n

.meas tran vdout0_113ck390 FIND v(dout0_113) AT=200.025n

.meas tran vdout0_114ck390 FIND v(dout0_114) AT=200.025n

.meas tran vdout0_115ck390 FIND v(dout0_115) AT=200.025n

.meas tran vdout0_116ck390 FIND v(dout0_116) AT=200.025n

.meas tran vdout0_117ck390 FIND v(dout0_117) AT=200.025n

.meas tran vdout0_118ck390 FIND v(dout0_118) AT=200.025n

.meas tran vdout0_119ck390 FIND v(dout0_119) AT=200.025n

.meas tran vdout0_120ck390 FIND v(dout0_120) AT=200.025n

.meas tran vdout0_121ck390 FIND v(dout0_121) AT=200.025n

.meas tran vdout0_122ck390 FIND v(dout0_122) AT=200.025n

.meas tran vdout0_123ck390 FIND v(dout0_123) AT=200.025n

.meas tran vdout0_124ck390 FIND v(dout0_124) AT=200.025n

.meas tran vdout0_125ck390 FIND v(dout0_125) AT=200.025n

.meas tran vdout0_126ck390 FIND v(dout0_126) AT=200.025n

.meas tran vdout0_127ck390 FIND v(dout0_127) AT=200.025n

.meas tran vdout0_128ck390 FIND v(dout0_128) AT=200.025n

.meas tran vdout0_129ck390 FIND v(dout0_129) AT=200.025n

.meas tran vdout0_130ck390 FIND v(dout0_130) AT=200.025n

.meas tran vdout0_131ck390 FIND v(dout0_131) AT=200.025n

.meas tran vdout0_132ck390 FIND v(dout0_132) AT=200.025n

.meas tran vdout0_133ck390 FIND v(dout0_133) AT=200.025n

.meas tran vdout0_134ck390 FIND v(dout0_134) AT=200.025n

.meas tran vdout0_135ck390 FIND v(dout0_135) AT=200.025n

.meas tran vdout0_136ck390 FIND v(dout0_136) AT=200.025n

.meas tran vdout0_137ck390 FIND v(dout0_137) AT=200.025n

.meas tran vdout0_138ck390 FIND v(dout0_138) AT=200.025n

.meas tran vdout0_139ck390 FIND v(dout0_139) AT=200.025n

.meas tran vdout0_140ck390 FIND v(dout0_140) AT=200.025n

.meas tran vdout0_141ck390 FIND v(dout0_141) AT=200.025n

.meas tran vdout0_142ck390 FIND v(dout0_142) AT=200.025n

.meas tran vdout0_143ck390 FIND v(dout0_143) AT=200.025n

.meas tran vdout0_144ck390 FIND v(dout0_144) AT=200.025n

.meas tran vdout0_145ck390 FIND v(dout0_145) AT=200.025n

.meas tran vdout0_146ck390 FIND v(dout0_146) AT=200.025n

.meas tran vdout0_147ck390 FIND v(dout0_147) AT=200.025n

.meas tran vdout0_148ck390 FIND v(dout0_148) AT=200.025n

.meas tran vdout0_149ck390 FIND v(dout0_149) AT=200.025n

.meas tran vdout0_150ck390 FIND v(dout0_150) AT=200.025n

.meas tran vdout0_151ck390 FIND v(dout0_151) AT=200.025n

.meas tran vdout0_152ck390 FIND v(dout0_152) AT=200.025n

.meas tran vdout0_153ck390 FIND v(dout0_153) AT=200.025n

.meas tran vdout0_154ck390 FIND v(dout0_154) AT=200.025n

.meas tran vdout0_155ck390 FIND v(dout0_155) AT=200.025n

.meas tran vdout0_156ck390 FIND v(dout0_156) AT=200.025n

.meas tran vdout0_157ck390 FIND v(dout0_157) AT=200.025n

.meas tran vdout0_158ck390 FIND v(dout0_158) AT=200.025n

.meas tran vdout0_159ck390 FIND v(dout0_159) AT=200.025n

.meas tran vdout0_160ck390 FIND v(dout0_160) AT=200.025n

.meas tran vdout0_161ck390 FIND v(dout0_161) AT=200.025n

.meas tran vdout0_162ck390 FIND v(dout0_162) AT=200.025n

.meas tran vdout0_163ck390 FIND v(dout0_163) AT=200.025n

.meas tran vdout0_164ck390 FIND v(dout0_164) AT=200.025n

.meas tran vdout0_165ck390 FIND v(dout0_165) AT=200.025n

.meas tran vdout0_166ck390 FIND v(dout0_166) AT=200.025n

.meas tran vdout0_167ck390 FIND v(dout0_167) AT=200.025n

.meas tran vdout0_168ck390 FIND v(dout0_168) AT=200.025n

.meas tran vdout0_169ck390 FIND v(dout0_169) AT=200.025n

.meas tran vdout0_170ck390 FIND v(dout0_170) AT=200.025n

.meas tran vdout0_171ck390 FIND v(dout0_171) AT=200.025n

.meas tran vdout0_172ck390 FIND v(dout0_172) AT=200.025n

.meas tran vdout0_173ck390 FIND v(dout0_173) AT=200.025n

.meas tran vdout0_174ck390 FIND v(dout0_174) AT=200.025n

.meas tran vdout0_175ck390 FIND v(dout0_175) AT=200.025n

.meas tran vdout0_176ck390 FIND v(dout0_176) AT=200.025n

.meas tran vdout0_177ck390 FIND v(dout0_177) AT=200.025n

.meas tran vdout0_178ck390 FIND v(dout0_178) AT=200.025n

.meas tran vdout0_179ck390 FIND v(dout0_179) AT=200.025n

.meas tran vdout0_180ck390 FIND v(dout0_180) AT=200.025n

.meas tran vdout0_181ck390 FIND v(dout0_181) AT=200.025n

.meas tran vdout0_182ck390 FIND v(dout0_182) AT=200.025n

.meas tran vdout0_183ck390 FIND v(dout0_183) AT=200.025n

.meas tran vdout0_184ck390 FIND v(dout0_184) AT=200.025n

.meas tran vdout0_185ck390 FIND v(dout0_185) AT=200.025n

.meas tran vdout0_186ck390 FIND v(dout0_186) AT=200.025n

.meas tran vdout0_187ck390 FIND v(dout0_187) AT=200.025n

.meas tran vdout0_188ck390 FIND v(dout0_188) AT=200.025n

.meas tran vdout0_189ck390 FIND v(dout0_189) AT=200.025n

.meas tran vdout0_190ck390 FIND v(dout0_190) AT=200.025n

.meas tran vdout0_191ck390 FIND v(dout0_191) AT=200.025n

.meas tran vdout0_192ck390 FIND v(dout0_192) AT=200.025n

.meas tran vdout0_193ck390 FIND v(dout0_193) AT=200.025n

.meas tran vdout0_194ck390 FIND v(dout0_194) AT=200.025n

.meas tran vdout0_195ck390 FIND v(dout0_195) AT=200.025n

.meas tran vdout0_196ck390 FIND v(dout0_196) AT=200.025n

.meas tran vdout0_197ck390 FIND v(dout0_197) AT=200.025n

.meas tran vdout0_198ck390 FIND v(dout0_198) AT=200.025n

.meas tran vdout0_199ck390 FIND v(dout0_199) AT=200.025n

.meas tran vdout0_200ck390 FIND v(dout0_200) AT=200.025n

.meas tran vdout0_201ck390 FIND v(dout0_201) AT=200.025n

.meas tran vdout0_202ck390 FIND v(dout0_202) AT=200.025n

.meas tran vdout0_203ck390 FIND v(dout0_203) AT=200.025n

.meas tran vdout0_204ck390 FIND v(dout0_204) AT=200.025n

.meas tran vdout0_205ck390 FIND v(dout0_205) AT=200.025n

.meas tran vdout0_206ck390 FIND v(dout0_206) AT=200.025n

.meas tran vdout0_207ck390 FIND v(dout0_207) AT=200.025n

.meas tran vdout0_208ck390 FIND v(dout0_208) AT=200.025n

.meas tran vdout0_209ck390 FIND v(dout0_209) AT=200.025n

.meas tran vdout0_210ck390 FIND v(dout0_210) AT=200.025n

.meas tran vdout0_211ck390 FIND v(dout0_211) AT=200.025n

.meas tran vdout0_212ck390 FIND v(dout0_212) AT=200.025n

.meas tran vdout0_213ck390 FIND v(dout0_213) AT=200.025n

.meas tran vdout0_214ck390 FIND v(dout0_214) AT=200.025n

.meas tran vdout0_215ck390 FIND v(dout0_215) AT=200.025n

.meas tran vdout0_216ck390 FIND v(dout0_216) AT=200.025n

.meas tran vdout0_217ck390 FIND v(dout0_217) AT=200.025n

.meas tran vdout0_218ck390 FIND v(dout0_218) AT=200.025n

.meas tran vdout0_219ck390 FIND v(dout0_219) AT=200.025n

.meas tran vdout0_220ck390 FIND v(dout0_220) AT=200.025n

.meas tran vdout0_221ck390 FIND v(dout0_221) AT=200.025n

.meas tran vdout0_222ck390 FIND v(dout0_222) AT=200.025n

.meas tran vdout0_223ck390 FIND v(dout0_223) AT=200.025n

.meas tran vdout0_224ck390 FIND v(dout0_224) AT=200.025n

.meas tran vdout0_225ck390 FIND v(dout0_225) AT=200.025n

.meas tran vdout0_226ck390 FIND v(dout0_226) AT=200.025n

.meas tran vdout0_227ck390 FIND v(dout0_227) AT=200.025n

.meas tran vdout0_228ck390 FIND v(dout0_228) AT=200.025n

.meas tran vdout0_229ck390 FIND v(dout0_229) AT=200.025n

.meas tran vdout0_230ck390 FIND v(dout0_230) AT=200.025n

.meas tran vdout0_231ck390 FIND v(dout0_231) AT=200.025n

.meas tran vdout0_232ck390 FIND v(dout0_232) AT=200.025n

.meas tran vdout0_233ck390 FIND v(dout0_233) AT=200.025n

.meas tran vdout0_234ck390 FIND v(dout0_234) AT=200.025n

.meas tran vdout0_235ck390 FIND v(dout0_235) AT=200.025n

.meas tran vdout0_236ck390 FIND v(dout0_236) AT=200.025n

.meas tran vdout0_237ck390 FIND v(dout0_237) AT=200.025n

.meas tran vdout0_238ck390 FIND v(dout0_238) AT=200.025n

.meas tran vdout0_239ck390 FIND v(dout0_239) AT=200.025n

.meas tran vdout0_240ck390 FIND v(dout0_240) AT=200.025n

.meas tran vdout0_241ck390 FIND v(dout0_241) AT=200.025n

.meas tran vdout0_242ck390 FIND v(dout0_242) AT=200.025n

.meas tran vdout0_243ck390 FIND v(dout0_243) AT=200.025n

.meas tran vdout0_244ck390 FIND v(dout0_244) AT=200.025n

.meas tran vdout0_245ck390 FIND v(dout0_245) AT=200.025n

.meas tran vdout0_246ck390 FIND v(dout0_246) AT=200.025n

.meas tran vdout0_247ck390 FIND v(dout0_247) AT=200.025n

.meas tran vdout0_248ck390 FIND v(dout0_248) AT=200.025n

.meas tran vdout0_249ck390 FIND v(dout0_249) AT=200.025n

.meas tran vdout0_250ck390 FIND v(dout0_250) AT=200.025n

.meas tran vdout0_251ck390 FIND v(dout0_251) AT=200.025n

.meas tran vdout0_252ck390 FIND v(dout0_252) AT=200.025n

.meas tran vdout0_253ck390 FIND v(dout0_253) AT=200.025n

.meas tran vdout0_254ck390 FIND v(dout0_254) AT=200.025n

.meas tran vdout0_255ck390 FIND v(dout0_255) AT=200.025n

.meas tran vdout0_0ck400 FIND v(dout0_0) AT=205.025n

.meas tran vdout0_1ck400 FIND v(dout0_1) AT=205.025n

.meas tran vdout0_2ck400 FIND v(dout0_2) AT=205.025n

.meas tran vdout0_3ck400 FIND v(dout0_3) AT=205.025n

.meas tran vdout0_4ck400 FIND v(dout0_4) AT=205.025n

.meas tran vdout0_5ck400 FIND v(dout0_5) AT=205.025n

.meas tran vdout0_6ck400 FIND v(dout0_6) AT=205.025n

.meas tran vdout0_7ck400 FIND v(dout0_7) AT=205.025n

.meas tran vdout0_8ck400 FIND v(dout0_8) AT=205.025n

.meas tran vdout0_9ck400 FIND v(dout0_9) AT=205.025n

.meas tran vdout0_10ck400 FIND v(dout0_10) AT=205.025n

.meas tran vdout0_11ck400 FIND v(dout0_11) AT=205.025n

.meas tran vdout0_12ck400 FIND v(dout0_12) AT=205.025n

.meas tran vdout0_13ck400 FIND v(dout0_13) AT=205.025n

.meas tran vdout0_14ck400 FIND v(dout0_14) AT=205.025n

.meas tran vdout0_15ck400 FIND v(dout0_15) AT=205.025n

.meas tran vdout0_16ck400 FIND v(dout0_16) AT=205.025n

.meas tran vdout0_17ck400 FIND v(dout0_17) AT=205.025n

.meas tran vdout0_18ck400 FIND v(dout0_18) AT=205.025n

.meas tran vdout0_19ck400 FIND v(dout0_19) AT=205.025n

.meas tran vdout0_20ck400 FIND v(dout0_20) AT=205.025n

.meas tran vdout0_21ck400 FIND v(dout0_21) AT=205.025n

.meas tran vdout0_22ck400 FIND v(dout0_22) AT=205.025n

.meas tran vdout0_23ck400 FIND v(dout0_23) AT=205.025n

.meas tran vdout0_24ck400 FIND v(dout0_24) AT=205.025n

.meas tran vdout0_25ck400 FIND v(dout0_25) AT=205.025n

.meas tran vdout0_26ck400 FIND v(dout0_26) AT=205.025n

.meas tran vdout0_27ck400 FIND v(dout0_27) AT=205.025n

.meas tran vdout0_28ck400 FIND v(dout0_28) AT=205.025n

.meas tran vdout0_29ck400 FIND v(dout0_29) AT=205.025n

.meas tran vdout0_30ck400 FIND v(dout0_30) AT=205.025n

.meas tran vdout0_31ck400 FIND v(dout0_31) AT=205.025n

.meas tran vdout0_32ck400 FIND v(dout0_32) AT=205.025n

.meas tran vdout0_33ck400 FIND v(dout0_33) AT=205.025n

.meas tran vdout0_34ck400 FIND v(dout0_34) AT=205.025n

.meas tran vdout0_35ck400 FIND v(dout0_35) AT=205.025n

.meas tran vdout0_36ck400 FIND v(dout0_36) AT=205.025n

.meas tran vdout0_37ck400 FIND v(dout0_37) AT=205.025n

.meas tran vdout0_38ck400 FIND v(dout0_38) AT=205.025n

.meas tran vdout0_39ck400 FIND v(dout0_39) AT=205.025n

.meas tran vdout0_40ck400 FIND v(dout0_40) AT=205.025n

.meas tran vdout0_41ck400 FIND v(dout0_41) AT=205.025n

.meas tran vdout0_42ck400 FIND v(dout0_42) AT=205.025n

.meas tran vdout0_43ck400 FIND v(dout0_43) AT=205.025n

.meas tran vdout0_44ck400 FIND v(dout0_44) AT=205.025n

.meas tran vdout0_45ck400 FIND v(dout0_45) AT=205.025n

.meas tran vdout0_46ck400 FIND v(dout0_46) AT=205.025n

.meas tran vdout0_47ck400 FIND v(dout0_47) AT=205.025n

.meas tran vdout0_48ck400 FIND v(dout0_48) AT=205.025n

.meas tran vdout0_49ck400 FIND v(dout0_49) AT=205.025n

.meas tran vdout0_50ck400 FIND v(dout0_50) AT=205.025n

.meas tran vdout0_51ck400 FIND v(dout0_51) AT=205.025n

.meas tran vdout0_52ck400 FIND v(dout0_52) AT=205.025n

.meas tran vdout0_53ck400 FIND v(dout0_53) AT=205.025n

.meas tran vdout0_54ck400 FIND v(dout0_54) AT=205.025n

.meas tran vdout0_55ck400 FIND v(dout0_55) AT=205.025n

.meas tran vdout0_56ck400 FIND v(dout0_56) AT=205.025n

.meas tran vdout0_57ck400 FIND v(dout0_57) AT=205.025n

.meas tran vdout0_58ck400 FIND v(dout0_58) AT=205.025n

.meas tran vdout0_59ck400 FIND v(dout0_59) AT=205.025n

.meas tran vdout0_60ck400 FIND v(dout0_60) AT=205.025n

.meas tran vdout0_61ck400 FIND v(dout0_61) AT=205.025n

.meas tran vdout0_62ck400 FIND v(dout0_62) AT=205.025n

.meas tran vdout0_63ck400 FIND v(dout0_63) AT=205.025n

.meas tran vdout0_64ck400 FIND v(dout0_64) AT=205.025n

.meas tran vdout0_65ck400 FIND v(dout0_65) AT=205.025n

.meas tran vdout0_66ck400 FIND v(dout0_66) AT=205.025n

.meas tran vdout0_67ck400 FIND v(dout0_67) AT=205.025n

.meas tran vdout0_68ck400 FIND v(dout0_68) AT=205.025n

.meas tran vdout0_69ck400 FIND v(dout0_69) AT=205.025n

.meas tran vdout0_70ck400 FIND v(dout0_70) AT=205.025n

.meas tran vdout0_71ck400 FIND v(dout0_71) AT=205.025n

.meas tran vdout0_72ck400 FIND v(dout0_72) AT=205.025n

.meas tran vdout0_73ck400 FIND v(dout0_73) AT=205.025n

.meas tran vdout0_74ck400 FIND v(dout0_74) AT=205.025n

.meas tran vdout0_75ck400 FIND v(dout0_75) AT=205.025n

.meas tran vdout0_76ck400 FIND v(dout0_76) AT=205.025n

.meas tran vdout0_77ck400 FIND v(dout0_77) AT=205.025n

.meas tran vdout0_78ck400 FIND v(dout0_78) AT=205.025n

.meas tran vdout0_79ck400 FIND v(dout0_79) AT=205.025n

.meas tran vdout0_80ck400 FIND v(dout0_80) AT=205.025n

.meas tran vdout0_81ck400 FIND v(dout0_81) AT=205.025n

.meas tran vdout0_82ck400 FIND v(dout0_82) AT=205.025n

.meas tran vdout0_83ck400 FIND v(dout0_83) AT=205.025n

.meas tran vdout0_84ck400 FIND v(dout0_84) AT=205.025n

.meas tran vdout0_85ck400 FIND v(dout0_85) AT=205.025n

.meas tran vdout0_86ck400 FIND v(dout0_86) AT=205.025n

.meas tran vdout0_87ck400 FIND v(dout0_87) AT=205.025n

.meas tran vdout0_88ck400 FIND v(dout0_88) AT=205.025n

.meas tran vdout0_89ck400 FIND v(dout0_89) AT=205.025n

.meas tran vdout0_90ck400 FIND v(dout0_90) AT=205.025n

.meas tran vdout0_91ck400 FIND v(dout0_91) AT=205.025n

.meas tran vdout0_92ck400 FIND v(dout0_92) AT=205.025n

.meas tran vdout0_93ck400 FIND v(dout0_93) AT=205.025n

.meas tran vdout0_94ck400 FIND v(dout0_94) AT=205.025n

.meas tran vdout0_95ck400 FIND v(dout0_95) AT=205.025n

.meas tran vdout0_96ck400 FIND v(dout0_96) AT=205.025n

.meas tran vdout0_97ck400 FIND v(dout0_97) AT=205.025n

.meas tran vdout0_98ck400 FIND v(dout0_98) AT=205.025n

.meas tran vdout0_99ck400 FIND v(dout0_99) AT=205.025n

.meas tran vdout0_100ck400 FIND v(dout0_100) AT=205.025n

.meas tran vdout0_101ck400 FIND v(dout0_101) AT=205.025n

.meas tran vdout0_102ck400 FIND v(dout0_102) AT=205.025n

.meas tran vdout0_103ck400 FIND v(dout0_103) AT=205.025n

.meas tran vdout0_104ck400 FIND v(dout0_104) AT=205.025n

.meas tran vdout0_105ck400 FIND v(dout0_105) AT=205.025n

.meas tran vdout0_106ck400 FIND v(dout0_106) AT=205.025n

.meas tran vdout0_107ck400 FIND v(dout0_107) AT=205.025n

.meas tran vdout0_108ck400 FIND v(dout0_108) AT=205.025n

.meas tran vdout0_109ck400 FIND v(dout0_109) AT=205.025n

.meas tran vdout0_110ck400 FIND v(dout0_110) AT=205.025n

.meas tran vdout0_111ck400 FIND v(dout0_111) AT=205.025n

.meas tran vdout0_112ck400 FIND v(dout0_112) AT=205.025n

.meas tran vdout0_113ck400 FIND v(dout0_113) AT=205.025n

.meas tran vdout0_114ck400 FIND v(dout0_114) AT=205.025n

.meas tran vdout0_115ck400 FIND v(dout0_115) AT=205.025n

.meas tran vdout0_116ck400 FIND v(dout0_116) AT=205.025n

.meas tran vdout0_117ck400 FIND v(dout0_117) AT=205.025n

.meas tran vdout0_118ck400 FIND v(dout0_118) AT=205.025n

.meas tran vdout0_119ck400 FIND v(dout0_119) AT=205.025n

.meas tran vdout0_120ck400 FIND v(dout0_120) AT=205.025n

.meas tran vdout0_121ck400 FIND v(dout0_121) AT=205.025n

.meas tran vdout0_122ck400 FIND v(dout0_122) AT=205.025n

.meas tran vdout0_123ck400 FIND v(dout0_123) AT=205.025n

.meas tran vdout0_124ck400 FIND v(dout0_124) AT=205.025n

.meas tran vdout0_125ck400 FIND v(dout0_125) AT=205.025n

.meas tran vdout0_126ck400 FIND v(dout0_126) AT=205.025n

.meas tran vdout0_127ck400 FIND v(dout0_127) AT=205.025n

.meas tran vdout0_128ck400 FIND v(dout0_128) AT=205.025n

.meas tran vdout0_129ck400 FIND v(dout0_129) AT=205.025n

.meas tran vdout0_130ck400 FIND v(dout0_130) AT=205.025n

.meas tran vdout0_131ck400 FIND v(dout0_131) AT=205.025n

.meas tran vdout0_132ck400 FIND v(dout0_132) AT=205.025n

.meas tran vdout0_133ck400 FIND v(dout0_133) AT=205.025n

.meas tran vdout0_134ck400 FIND v(dout0_134) AT=205.025n

.meas tran vdout0_135ck400 FIND v(dout0_135) AT=205.025n

.meas tran vdout0_136ck400 FIND v(dout0_136) AT=205.025n

.meas tran vdout0_137ck400 FIND v(dout0_137) AT=205.025n

.meas tran vdout0_138ck400 FIND v(dout0_138) AT=205.025n

.meas tran vdout0_139ck400 FIND v(dout0_139) AT=205.025n

.meas tran vdout0_140ck400 FIND v(dout0_140) AT=205.025n

.meas tran vdout0_141ck400 FIND v(dout0_141) AT=205.025n

.meas tran vdout0_142ck400 FIND v(dout0_142) AT=205.025n

.meas tran vdout0_143ck400 FIND v(dout0_143) AT=205.025n

.meas tran vdout0_144ck400 FIND v(dout0_144) AT=205.025n

.meas tran vdout0_145ck400 FIND v(dout0_145) AT=205.025n

.meas tran vdout0_146ck400 FIND v(dout0_146) AT=205.025n

.meas tran vdout0_147ck400 FIND v(dout0_147) AT=205.025n

.meas tran vdout0_148ck400 FIND v(dout0_148) AT=205.025n

.meas tran vdout0_149ck400 FIND v(dout0_149) AT=205.025n

.meas tran vdout0_150ck400 FIND v(dout0_150) AT=205.025n

.meas tran vdout0_151ck400 FIND v(dout0_151) AT=205.025n

.meas tran vdout0_152ck400 FIND v(dout0_152) AT=205.025n

.meas tran vdout0_153ck400 FIND v(dout0_153) AT=205.025n

.meas tran vdout0_154ck400 FIND v(dout0_154) AT=205.025n

.meas tran vdout0_155ck400 FIND v(dout0_155) AT=205.025n

.meas tran vdout0_156ck400 FIND v(dout0_156) AT=205.025n

.meas tran vdout0_157ck400 FIND v(dout0_157) AT=205.025n

.meas tran vdout0_158ck400 FIND v(dout0_158) AT=205.025n

.meas tran vdout0_159ck400 FIND v(dout0_159) AT=205.025n

.meas tran vdout0_160ck400 FIND v(dout0_160) AT=205.025n

.meas tran vdout0_161ck400 FIND v(dout0_161) AT=205.025n

.meas tran vdout0_162ck400 FIND v(dout0_162) AT=205.025n

.meas tran vdout0_163ck400 FIND v(dout0_163) AT=205.025n

.meas tran vdout0_164ck400 FIND v(dout0_164) AT=205.025n

.meas tran vdout0_165ck400 FIND v(dout0_165) AT=205.025n

.meas tran vdout0_166ck400 FIND v(dout0_166) AT=205.025n

.meas tran vdout0_167ck400 FIND v(dout0_167) AT=205.025n

.meas tran vdout0_168ck400 FIND v(dout0_168) AT=205.025n

.meas tran vdout0_169ck400 FIND v(dout0_169) AT=205.025n

.meas tran vdout0_170ck400 FIND v(dout0_170) AT=205.025n

.meas tran vdout0_171ck400 FIND v(dout0_171) AT=205.025n

.meas tran vdout0_172ck400 FIND v(dout0_172) AT=205.025n

.meas tran vdout0_173ck400 FIND v(dout0_173) AT=205.025n

.meas tran vdout0_174ck400 FIND v(dout0_174) AT=205.025n

.meas tran vdout0_175ck400 FIND v(dout0_175) AT=205.025n

.meas tran vdout0_176ck400 FIND v(dout0_176) AT=205.025n

.meas tran vdout0_177ck400 FIND v(dout0_177) AT=205.025n

.meas tran vdout0_178ck400 FIND v(dout0_178) AT=205.025n

.meas tran vdout0_179ck400 FIND v(dout0_179) AT=205.025n

.meas tran vdout0_180ck400 FIND v(dout0_180) AT=205.025n

.meas tran vdout0_181ck400 FIND v(dout0_181) AT=205.025n

.meas tran vdout0_182ck400 FIND v(dout0_182) AT=205.025n

.meas tran vdout0_183ck400 FIND v(dout0_183) AT=205.025n

.meas tran vdout0_184ck400 FIND v(dout0_184) AT=205.025n

.meas tran vdout0_185ck400 FIND v(dout0_185) AT=205.025n

.meas tran vdout0_186ck400 FIND v(dout0_186) AT=205.025n

.meas tran vdout0_187ck400 FIND v(dout0_187) AT=205.025n

.meas tran vdout0_188ck400 FIND v(dout0_188) AT=205.025n

.meas tran vdout0_189ck400 FIND v(dout0_189) AT=205.025n

.meas tran vdout0_190ck400 FIND v(dout0_190) AT=205.025n

.meas tran vdout0_191ck400 FIND v(dout0_191) AT=205.025n

.meas tran vdout0_192ck400 FIND v(dout0_192) AT=205.025n

.meas tran vdout0_193ck400 FIND v(dout0_193) AT=205.025n

.meas tran vdout0_194ck400 FIND v(dout0_194) AT=205.025n

.meas tran vdout0_195ck400 FIND v(dout0_195) AT=205.025n

.meas tran vdout0_196ck400 FIND v(dout0_196) AT=205.025n

.meas tran vdout0_197ck400 FIND v(dout0_197) AT=205.025n

.meas tran vdout0_198ck400 FIND v(dout0_198) AT=205.025n

.meas tran vdout0_199ck400 FIND v(dout0_199) AT=205.025n

.meas tran vdout0_200ck400 FIND v(dout0_200) AT=205.025n

.meas tran vdout0_201ck400 FIND v(dout0_201) AT=205.025n

.meas tran vdout0_202ck400 FIND v(dout0_202) AT=205.025n

.meas tran vdout0_203ck400 FIND v(dout0_203) AT=205.025n

.meas tran vdout0_204ck400 FIND v(dout0_204) AT=205.025n

.meas tran vdout0_205ck400 FIND v(dout0_205) AT=205.025n

.meas tran vdout0_206ck400 FIND v(dout0_206) AT=205.025n

.meas tran vdout0_207ck400 FIND v(dout0_207) AT=205.025n

.meas tran vdout0_208ck400 FIND v(dout0_208) AT=205.025n

.meas tran vdout0_209ck400 FIND v(dout0_209) AT=205.025n

.meas tran vdout0_210ck400 FIND v(dout0_210) AT=205.025n

.meas tran vdout0_211ck400 FIND v(dout0_211) AT=205.025n

.meas tran vdout0_212ck400 FIND v(dout0_212) AT=205.025n

.meas tran vdout0_213ck400 FIND v(dout0_213) AT=205.025n

.meas tran vdout0_214ck400 FIND v(dout0_214) AT=205.025n

.meas tran vdout0_215ck400 FIND v(dout0_215) AT=205.025n

.meas tran vdout0_216ck400 FIND v(dout0_216) AT=205.025n

.meas tran vdout0_217ck400 FIND v(dout0_217) AT=205.025n

.meas tran vdout0_218ck400 FIND v(dout0_218) AT=205.025n

.meas tran vdout0_219ck400 FIND v(dout0_219) AT=205.025n

.meas tran vdout0_220ck400 FIND v(dout0_220) AT=205.025n

.meas tran vdout0_221ck400 FIND v(dout0_221) AT=205.025n

.meas tran vdout0_222ck400 FIND v(dout0_222) AT=205.025n

.meas tran vdout0_223ck400 FIND v(dout0_223) AT=205.025n

.meas tran vdout0_224ck400 FIND v(dout0_224) AT=205.025n

.meas tran vdout0_225ck400 FIND v(dout0_225) AT=205.025n

.meas tran vdout0_226ck400 FIND v(dout0_226) AT=205.025n

.meas tran vdout0_227ck400 FIND v(dout0_227) AT=205.025n

.meas tran vdout0_228ck400 FIND v(dout0_228) AT=205.025n

.meas tran vdout0_229ck400 FIND v(dout0_229) AT=205.025n

.meas tran vdout0_230ck400 FIND v(dout0_230) AT=205.025n

.meas tran vdout0_231ck400 FIND v(dout0_231) AT=205.025n

.meas tran vdout0_232ck400 FIND v(dout0_232) AT=205.025n

.meas tran vdout0_233ck400 FIND v(dout0_233) AT=205.025n

.meas tran vdout0_234ck400 FIND v(dout0_234) AT=205.025n

.meas tran vdout0_235ck400 FIND v(dout0_235) AT=205.025n

.meas tran vdout0_236ck400 FIND v(dout0_236) AT=205.025n

.meas tran vdout0_237ck400 FIND v(dout0_237) AT=205.025n

.meas tran vdout0_238ck400 FIND v(dout0_238) AT=205.025n

.meas tran vdout0_239ck400 FIND v(dout0_239) AT=205.025n

.meas tran vdout0_240ck400 FIND v(dout0_240) AT=205.025n

.meas tran vdout0_241ck400 FIND v(dout0_241) AT=205.025n

.meas tran vdout0_242ck400 FIND v(dout0_242) AT=205.025n

.meas tran vdout0_243ck400 FIND v(dout0_243) AT=205.025n

.meas tran vdout0_244ck400 FIND v(dout0_244) AT=205.025n

.meas tran vdout0_245ck400 FIND v(dout0_245) AT=205.025n

.meas tran vdout0_246ck400 FIND v(dout0_246) AT=205.025n

.meas tran vdout0_247ck400 FIND v(dout0_247) AT=205.025n

.meas tran vdout0_248ck400 FIND v(dout0_248) AT=205.025n

.meas tran vdout0_249ck400 FIND v(dout0_249) AT=205.025n

.meas tran vdout0_250ck400 FIND v(dout0_250) AT=205.025n

.meas tran vdout0_251ck400 FIND v(dout0_251) AT=205.025n

.meas tran vdout0_252ck400 FIND v(dout0_252) AT=205.025n

.meas tran vdout0_253ck400 FIND v(dout0_253) AT=205.025n

.meas tran vdout0_254ck400 FIND v(dout0_254) AT=205.025n

.meas tran vdout0_255ck400 FIND v(dout0_255) AT=205.025n

.meas tran vdout0_0ck450 FIND v(dout0_0) AT=230.025n

.meas tran vdout0_1ck450 FIND v(dout0_1) AT=230.025n

.meas tran vdout0_2ck450 FIND v(dout0_2) AT=230.025n

.meas tran vdout0_3ck450 FIND v(dout0_3) AT=230.025n

.meas tran vdout0_4ck450 FIND v(dout0_4) AT=230.025n

.meas tran vdout0_5ck450 FIND v(dout0_5) AT=230.025n

.meas tran vdout0_6ck450 FIND v(dout0_6) AT=230.025n

.meas tran vdout0_7ck450 FIND v(dout0_7) AT=230.025n

.meas tran vdout0_8ck450 FIND v(dout0_8) AT=230.025n

.meas tran vdout0_9ck450 FIND v(dout0_9) AT=230.025n

.meas tran vdout0_10ck450 FIND v(dout0_10) AT=230.025n

.meas tran vdout0_11ck450 FIND v(dout0_11) AT=230.025n

.meas tran vdout0_12ck450 FIND v(dout0_12) AT=230.025n

.meas tran vdout0_13ck450 FIND v(dout0_13) AT=230.025n

.meas tran vdout0_14ck450 FIND v(dout0_14) AT=230.025n

.meas tran vdout0_15ck450 FIND v(dout0_15) AT=230.025n

.meas tran vdout0_16ck450 FIND v(dout0_16) AT=230.025n

.meas tran vdout0_17ck450 FIND v(dout0_17) AT=230.025n

.meas tran vdout0_18ck450 FIND v(dout0_18) AT=230.025n

.meas tran vdout0_19ck450 FIND v(dout0_19) AT=230.025n

.meas tran vdout0_20ck450 FIND v(dout0_20) AT=230.025n

.meas tran vdout0_21ck450 FIND v(dout0_21) AT=230.025n

.meas tran vdout0_22ck450 FIND v(dout0_22) AT=230.025n

.meas tran vdout0_23ck450 FIND v(dout0_23) AT=230.025n

.meas tran vdout0_24ck450 FIND v(dout0_24) AT=230.025n

.meas tran vdout0_25ck450 FIND v(dout0_25) AT=230.025n

.meas tran vdout0_26ck450 FIND v(dout0_26) AT=230.025n

.meas tran vdout0_27ck450 FIND v(dout0_27) AT=230.025n

.meas tran vdout0_28ck450 FIND v(dout0_28) AT=230.025n

.meas tran vdout0_29ck450 FIND v(dout0_29) AT=230.025n

.meas tran vdout0_30ck450 FIND v(dout0_30) AT=230.025n

.meas tran vdout0_31ck450 FIND v(dout0_31) AT=230.025n

.meas tran vdout0_32ck450 FIND v(dout0_32) AT=230.025n

.meas tran vdout0_33ck450 FIND v(dout0_33) AT=230.025n

.meas tran vdout0_34ck450 FIND v(dout0_34) AT=230.025n

.meas tran vdout0_35ck450 FIND v(dout0_35) AT=230.025n

.meas tran vdout0_36ck450 FIND v(dout0_36) AT=230.025n

.meas tran vdout0_37ck450 FIND v(dout0_37) AT=230.025n

.meas tran vdout0_38ck450 FIND v(dout0_38) AT=230.025n

.meas tran vdout0_39ck450 FIND v(dout0_39) AT=230.025n

.meas tran vdout0_40ck450 FIND v(dout0_40) AT=230.025n

.meas tran vdout0_41ck450 FIND v(dout0_41) AT=230.025n

.meas tran vdout0_42ck450 FIND v(dout0_42) AT=230.025n

.meas tran vdout0_43ck450 FIND v(dout0_43) AT=230.025n

.meas tran vdout0_44ck450 FIND v(dout0_44) AT=230.025n

.meas tran vdout0_45ck450 FIND v(dout0_45) AT=230.025n

.meas tran vdout0_46ck450 FIND v(dout0_46) AT=230.025n

.meas tran vdout0_47ck450 FIND v(dout0_47) AT=230.025n

.meas tran vdout0_48ck450 FIND v(dout0_48) AT=230.025n

.meas tran vdout0_49ck450 FIND v(dout0_49) AT=230.025n

.meas tran vdout0_50ck450 FIND v(dout0_50) AT=230.025n

.meas tran vdout0_51ck450 FIND v(dout0_51) AT=230.025n

.meas tran vdout0_52ck450 FIND v(dout0_52) AT=230.025n

.meas tran vdout0_53ck450 FIND v(dout0_53) AT=230.025n

.meas tran vdout0_54ck450 FIND v(dout0_54) AT=230.025n

.meas tran vdout0_55ck450 FIND v(dout0_55) AT=230.025n

.meas tran vdout0_56ck450 FIND v(dout0_56) AT=230.025n

.meas tran vdout0_57ck450 FIND v(dout0_57) AT=230.025n

.meas tran vdout0_58ck450 FIND v(dout0_58) AT=230.025n

.meas tran vdout0_59ck450 FIND v(dout0_59) AT=230.025n

.meas tran vdout0_60ck450 FIND v(dout0_60) AT=230.025n

.meas tran vdout0_61ck450 FIND v(dout0_61) AT=230.025n

.meas tran vdout0_62ck450 FIND v(dout0_62) AT=230.025n

.meas tran vdout0_63ck450 FIND v(dout0_63) AT=230.025n

.meas tran vdout0_64ck450 FIND v(dout0_64) AT=230.025n

.meas tran vdout0_65ck450 FIND v(dout0_65) AT=230.025n

.meas tran vdout0_66ck450 FIND v(dout0_66) AT=230.025n

.meas tran vdout0_67ck450 FIND v(dout0_67) AT=230.025n

.meas tran vdout0_68ck450 FIND v(dout0_68) AT=230.025n

.meas tran vdout0_69ck450 FIND v(dout0_69) AT=230.025n

.meas tran vdout0_70ck450 FIND v(dout0_70) AT=230.025n

.meas tran vdout0_71ck450 FIND v(dout0_71) AT=230.025n

.meas tran vdout0_72ck450 FIND v(dout0_72) AT=230.025n

.meas tran vdout0_73ck450 FIND v(dout0_73) AT=230.025n

.meas tran vdout0_74ck450 FIND v(dout0_74) AT=230.025n

.meas tran vdout0_75ck450 FIND v(dout0_75) AT=230.025n

.meas tran vdout0_76ck450 FIND v(dout0_76) AT=230.025n

.meas tran vdout0_77ck450 FIND v(dout0_77) AT=230.025n

.meas tran vdout0_78ck450 FIND v(dout0_78) AT=230.025n

.meas tran vdout0_79ck450 FIND v(dout0_79) AT=230.025n

.meas tran vdout0_80ck450 FIND v(dout0_80) AT=230.025n

.meas tran vdout0_81ck450 FIND v(dout0_81) AT=230.025n

.meas tran vdout0_82ck450 FIND v(dout0_82) AT=230.025n

.meas tran vdout0_83ck450 FIND v(dout0_83) AT=230.025n

.meas tran vdout0_84ck450 FIND v(dout0_84) AT=230.025n

.meas tran vdout0_85ck450 FIND v(dout0_85) AT=230.025n

.meas tran vdout0_86ck450 FIND v(dout0_86) AT=230.025n

.meas tran vdout0_87ck450 FIND v(dout0_87) AT=230.025n

.meas tran vdout0_88ck450 FIND v(dout0_88) AT=230.025n

.meas tran vdout0_89ck450 FIND v(dout0_89) AT=230.025n

.meas tran vdout0_90ck450 FIND v(dout0_90) AT=230.025n

.meas tran vdout0_91ck450 FIND v(dout0_91) AT=230.025n

.meas tran vdout0_92ck450 FIND v(dout0_92) AT=230.025n

.meas tran vdout0_93ck450 FIND v(dout0_93) AT=230.025n

.meas tran vdout0_94ck450 FIND v(dout0_94) AT=230.025n

.meas tran vdout0_95ck450 FIND v(dout0_95) AT=230.025n

.meas tran vdout0_96ck450 FIND v(dout0_96) AT=230.025n

.meas tran vdout0_97ck450 FIND v(dout0_97) AT=230.025n

.meas tran vdout0_98ck450 FIND v(dout0_98) AT=230.025n

.meas tran vdout0_99ck450 FIND v(dout0_99) AT=230.025n

.meas tran vdout0_100ck450 FIND v(dout0_100) AT=230.025n

.meas tran vdout0_101ck450 FIND v(dout0_101) AT=230.025n

.meas tran vdout0_102ck450 FIND v(dout0_102) AT=230.025n

.meas tran vdout0_103ck450 FIND v(dout0_103) AT=230.025n

.meas tran vdout0_104ck450 FIND v(dout0_104) AT=230.025n

.meas tran vdout0_105ck450 FIND v(dout0_105) AT=230.025n

.meas tran vdout0_106ck450 FIND v(dout0_106) AT=230.025n

.meas tran vdout0_107ck450 FIND v(dout0_107) AT=230.025n

.meas tran vdout0_108ck450 FIND v(dout0_108) AT=230.025n

.meas tran vdout0_109ck450 FIND v(dout0_109) AT=230.025n

.meas tran vdout0_110ck450 FIND v(dout0_110) AT=230.025n

.meas tran vdout0_111ck450 FIND v(dout0_111) AT=230.025n

.meas tran vdout0_112ck450 FIND v(dout0_112) AT=230.025n

.meas tran vdout0_113ck450 FIND v(dout0_113) AT=230.025n

.meas tran vdout0_114ck450 FIND v(dout0_114) AT=230.025n

.meas tran vdout0_115ck450 FIND v(dout0_115) AT=230.025n

.meas tran vdout0_116ck450 FIND v(dout0_116) AT=230.025n

.meas tran vdout0_117ck450 FIND v(dout0_117) AT=230.025n

.meas tran vdout0_118ck450 FIND v(dout0_118) AT=230.025n

.meas tran vdout0_119ck450 FIND v(dout0_119) AT=230.025n

.meas tran vdout0_120ck450 FIND v(dout0_120) AT=230.025n

.meas tran vdout0_121ck450 FIND v(dout0_121) AT=230.025n

.meas tran vdout0_122ck450 FIND v(dout0_122) AT=230.025n

.meas tran vdout0_123ck450 FIND v(dout0_123) AT=230.025n

.meas tran vdout0_124ck450 FIND v(dout0_124) AT=230.025n

.meas tran vdout0_125ck450 FIND v(dout0_125) AT=230.025n

.meas tran vdout0_126ck450 FIND v(dout0_126) AT=230.025n

.meas tran vdout0_127ck450 FIND v(dout0_127) AT=230.025n

.meas tran vdout0_128ck450 FIND v(dout0_128) AT=230.025n

.meas tran vdout0_129ck450 FIND v(dout0_129) AT=230.025n

.meas tran vdout0_130ck450 FIND v(dout0_130) AT=230.025n

.meas tran vdout0_131ck450 FIND v(dout0_131) AT=230.025n

.meas tran vdout0_132ck450 FIND v(dout0_132) AT=230.025n

.meas tran vdout0_133ck450 FIND v(dout0_133) AT=230.025n

.meas tran vdout0_134ck450 FIND v(dout0_134) AT=230.025n

.meas tran vdout0_135ck450 FIND v(dout0_135) AT=230.025n

.meas tran vdout0_136ck450 FIND v(dout0_136) AT=230.025n

.meas tran vdout0_137ck450 FIND v(dout0_137) AT=230.025n

.meas tran vdout0_138ck450 FIND v(dout0_138) AT=230.025n

.meas tran vdout0_139ck450 FIND v(dout0_139) AT=230.025n

.meas tran vdout0_140ck450 FIND v(dout0_140) AT=230.025n

.meas tran vdout0_141ck450 FIND v(dout0_141) AT=230.025n

.meas tran vdout0_142ck450 FIND v(dout0_142) AT=230.025n

.meas tran vdout0_143ck450 FIND v(dout0_143) AT=230.025n

.meas tran vdout0_144ck450 FIND v(dout0_144) AT=230.025n

.meas tran vdout0_145ck450 FIND v(dout0_145) AT=230.025n

.meas tran vdout0_146ck450 FIND v(dout0_146) AT=230.025n

.meas tran vdout0_147ck450 FIND v(dout0_147) AT=230.025n

.meas tran vdout0_148ck450 FIND v(dout0_148) AT=230.025n

.meas tran vdout0_149ck450 FIND v(dout0_149) AT=230.025n

.meas tran vdout0_150ck450 FIND v(dout0_150) AT=230.025n

.meas tran vdout0_151ck450 FIND v(dout0_151) AT=230.025n

.meas tran vdout0_152ck450 FIND v(dout0_152) AT=230.025n

.meas tran vdout0_153ck450 FIND v(dout0_153) AT=230.025n

.meas tran vdout0_154ck450 FIND v(dout0_154) AT=230.025n

.meas tran vdout0_155ck450 FIND v(dout0_155) AT=230.025n

.meas tran vdout0_156ck450 FIND v(dout0_156) AT=230.025n

.meas tran vdout0_157ck450 FIND v(dout0_157) AT=230.025n

.meas tran vdout0_158ck450 FIND v(dout0_158) AT=230.025n

.meas tran vdout0_159ck450 FIND v(dout0_159) AT=230.025n

.meas tran vdout0_160ck450 FIND v(dout0_160) AT=230.025n

.meas tran vdout0_161ck450 FIND v(dout0_161) AT=230.025n

.meas tran vdout0_162ck450 FIND v(dout0_162) AT=230.025n

.meas tran vdout0_163ck450 FIND v(dout0_163) AT=230.025n

.meas tran vdout0_164ck450 FIND v(dout0_164) AT=230.025n

.meas tran vdout0_165ck450 FIND v(dout0_165) AT=230.025n

.meas tran vdout0_166ck450 FIND v(dout0_166) AT=230.025n

.meas tran vdout0_167ck450 FIND v(dout0_167) AT=230.025n

.meas tran vdout0_168ck450 FIND v(dout0_168) AT=230.025n

.meas tran vdout0_169ck450 FIND v(dout0_169) AT=230.025n

.meas tran vdout0_170ck450 FIND v(dout0_170) AT=230.025n

.meas tran vdout0_171ck450 FIND v(dout0_171) AT=230.025n

.meas tran vdout0_172ck450 FIND v(dout0_172) AT=230.025n

.meas tran vdout0_173ck450 FIND v(dout0_173) AT=230.025n

.meas tran vdout0_174ck450 FIND v(dout0_174) AT=230.025n

.meas tran vdout0_175ck450 FIND v(dout0_175) AT=230.025n

.meas tran vdout0_176ck450 FIND v(dout0_176) AT=230.025n

.meas tran vdout0_177ck450 FIND v(dout0_177) AT=230.025n

.meas tran vdout0_178ck450 FIND v(dout0_178) AT=230.025n

.meas tran vdout0_179ck450 FIND v(dout0_179) AT=230.025n

.meas tran vdout0_180ck450 FIND v(dout0_180) AT=230.025n

.meas tran vdout0_181ck450 FIND v(dout0_181) AT=230.025n

.meas tran vdout0_182ck450 FIND v(dout0_182) AT=230.025n

.meas tran vdout0_183ck450 FIND v(dout0_183) AT=230.025n

.meas tran vdout0_184ck450 FIND v(dout0_184) AT=230.025n

.meas tran vdout0_185ck450 FIND v(dout0_185) AT=230.025n

.meas tran vdout0_186ck450 FIND v(dout0_186) AT=230.025n

.meas tran vdout0_187ck450 FIND v(dout0_187) AT=230.025n

.meas tran vdout0_188ck450 FIND v(dout0_188) AT=230.025n

.meas tran vdout0_189ck450 FIND v(dout0_189) AT=230.025n

.meas tran vdout0_190ck450 FIND v(dout0_190) AT=230.025n

.meas tran vdout0_191ck450 FIND v(dout0_191) AT=230.025n

.meas tran vdout0_192ck450 FIND v(dout0_192) AT=230.025n

.meas tran vdout0_193ck450 FIND v(dout0_193) AT=230.025n

.meas tran vdout0_194ck450 FIND v(dout0_194) AT=230.025n

.meas tran vdout0_195ck450 FIND v(dout0_195) AT=230.025n

.meas tran vdout0_196ck450 FIND v(dout0_196) AT=230.025n

.meas tran vdout0_197ck450 FIND v(dout0_197) AT=230.025n

.meas tran vdout0_198ck450 FIND v(dout0_198) AT=230.025n

.meas tran vdout0_199ck450 FIND v(dout0_199) AT=230.025n

.meas tran vdout0_200ck450 FIND v(dout0_200) AT=230.025n

.meas tran vdout0_201ck450 FIND v(dout0_201) AT=230.025n

.meas tran vdout0_202ck450 FIND v(dout0_202) AT=230.025n

.meas tran vdout0_203ck450 FIND v(dout0_203) AT=230.025n

.meas tran vdout0_204ck450 FIND v(dout0_204) AT=230.025n

.meas tran vdout0_205ck450 FIND v(dout0_205) AT=230.025n

.meas tran vdout0_206ck450 FIND v(dout0_206) AT=230.025n

.meas tran vdout0_207ck450 FIND v(dout0_207) AT=230.025n

.meas tran vdout0_208ck450 FIND v(dout0_208) AT=230.025n

.meas tran vdout0_209ck450 FIND v(dout0_209) AT=230.025n

.meas tran vdout0_210ck450 FIND v(dout0_210) AT=230.025n

.meas tran vdout0_211ck450 FIND v(dout0_211) AT=230.025n

.meas tran vdout0_212ck450 FIND v(dout0_212) AT=230.025n

.meas tran vdout0_213ck450 FIND v(dout0_213) AT=230.025n

.meas tran vdout0_214ck450 FIND v(dout0_214) AT=230.025n

.meas tran vdout0_215ck450 FIND v(dout0_215) AT=230.025n

.meas tran vdout0_216ck450 FIND v(dout0_216) AT=230.025n

.meas tran vdout0_217ck450 FIND v(dout0_217) AT=230.025n

.meas tran vdout0_218ck450 FIND v(dout0_218) AT=230.025n

.meas tran vdout0_219ck450 FIND v(dout0_219) AT=230.025n

.meas tran vdout0_220ck450 FIND v(dout0_220) AT=230.025n

.meas tran vdout0_221ck450 FIND v(dout0_221) AT=230.025n

.meas tran vdout0_222ck450 FIND v(dout0_222) AT=230.025n

.meas tran vdout0_223ck450 FIND v(dout0_223) AT=230.025n

.meas tran vdout0_224ck450 FIND v(dout0_224) AT=230.025n

.meas tran vdout0_225ck450 FIND v(dout0_225) AT=230.025n

.meas tran vdout0_226ck450 FIND v(dout0_226) AT=230.025n

.meas tran vdout0_227ck450 FIND v(dout0_227) AT=230.025n

.meas tran vdout0_228ck450 FIND v(dout0_228) AT=230.025n

.meas tran vdout0_229ck450 FIND v(dout0_229) AT=230.025n

.meas tran vdout0_230ck450 FIND v(dout0_230) AT=230.025n

.meas tran vdout0_231ck450 FIND v(dout0_231) AT=230.025n

.meas tran vdout0_232ck450 FIND v(dout0_232) AT=230.025n

.meas tran vdout0_233ck450 FIND v(dout0_233) AT=230.025n

.meas tran vdout0_234ck450 FIND v(dout0_234) AT=230.025n

.meas tran vdout0_235ck450 FIND v(dout0_235) AT=230.025n

.meas tran vdout0_236ck450 FIND v(dout0_236) AT=230.025n

.meas tran vdout0_237ck450 FIND v(dout0_237) AT=230.025n

.meas tran vdout0_238ck450 FIND v(dout0_238) AT=230.025n

.meas tran vdout0_239ck450 FIND v(dout0_239) AT=230.025n

.meas tran vdout0_240ck450 FIND v(dout0_240) AT=230.025n

.meas tran vdout0_241ck450 FIND v(dout0_241) AT=230.025n

.meas tran vdout0_242ck450 FIND v(dout0_242) AT=230.025n

.meas tran vdout0_243ck450 FIND v(dout0_243) AT=230.025n

.meas tran vdout0_244ck450 FIND v(dout0_244) AT=230.025n

.meas tran vdout0_245ck450 FIND v(dout0_245) AT=230.025n

.meas tran vdout0_246ck450 FIND v(dout0_246) AT=230.025n

.meas tran vdout0_247ck450 FIND v(dout0_247) AT=230.025n

.meas tran vdout0_248ck450 FIND v(dout0_248) AT=230.025n

.meas tran vdout0_249ck450 FIND v(dout0_249) AT=230.025n

.meas tran vdout0_250ck450 FIND v(dout0_250) AT=230.025n

.meas tran vdout0_251ck450 FIND v(dout0_251) AT=230.025n

.meas tran vdout0_252ck450 FIND v(dout0_252) AT=230.025n

.meas tran vdout0_253ck450 FIND v(dout0_253) AT=230.025n

.meas tran vdout0_254ck450 FIND v(dout0_254) AT=230.025n

.meas tran vdout0_255ck450 FIND v(dout0_255) AT=230.025n

.meas tran vdout0_0ck460 FIND v(dout0_0) AT=235.025n

.meas tran vdout0_1ck460 FIND v(dout0_1) AT=235.025n

.meas tran vdout0_2ck460 FIND v(dout0_2) AT=235.025n

.meas tran vdout0_3ck460 FIND v(dout0_3) AT=235.025n

.meas tran vdout0_4ck460 FIND v(dout0_4) AT=235.025n

.meas tran vdout0_5ck460 FIND v(dout0_5) AT=235.025n

.meas tran vdout0_6ck460 FIND v(dout0_6) AT=235.025n

.meas tran vdout0_7ck460 FIND v(dout0_7) AT=235.025n

.meas tran vdout0_8ck460 FIND v(dout0_8) AT=235.025n

.meas tran vdout0_9ck460 FIND v(dout0_9) AT=235.025n

.meas tran vdout0_10ck460 FIND v(dout0_10) AT=235.025n

.meas tran vdout0_11ck460 FIND v(dout0_11) AT=235.025n

.meas tran vdout0_12ck460 FIND v(dout0_12) AT=235.025n

.meas tran vdout0_13ck460 FIND v(dout0_13) AT=235.025n

.meas tran vdout0_14ck460 FIND v(dout0_14) AT=235.025n

.meas tran vdout0_15ck460 FIND v(dout0_15) AT=235.025n

.meas tran vdout0_16ck460 FIND v(dout0_16) AT=235.025n

.meas tran vdout0_17ck460 FIND v(dout0_17) AT=235.025n

.meas tran vdout0_18ck460 FIND v(dout0_18) AT=235.025n

.meas tran vdout0_19ck460 FIND v(dout0_19) AT=235.025n

.meas tran vdout0_20ck460 FIND v(dout0_20) AT=235.025n

.meas tran vdout0_21ck460 FIND v(dout0_21) AT=235.025n

.meas tran vdout0_22ck460 FIND v(dout0_22) AT=235.025n

.meas tran vdout0_23ck460 FIND v(dout0_23) AT=235.025n

.meas tran vdout0_24ck460 FIND v(dout0_24) AT=235.025n

.meas tran vdout0_25ck460 FIND v(dout0_25) AT=235.025n

.meas tran vdout0_26ck460 FIND v(dout0_26) AT=235.025n

.meas tran vdout0_27ck460 FIND v(dout0_27) AT=235.025n

.meas tran vdout0_28ck460 FIND v(dout0_28) AT=235.025n

.meas tran vdout0_29ck460 FIND v(dout0_29) AT=235.025n

.meas tran vdout0_30ck460 FIND v(dout0_30) AT=235.025n

.meas tran vdout0_31ck460 FIND v(dout0_31) AT=235.025n

.meas tran vdout0_32ck460 FIND v(dout0_32) AT=235.025n

.meas tran vdout0_33ck460 FIND v(dout0_33) AT=235.025n

.meas tran vdout0_34ck460 FIND v(dout0_34) AT=235.025n

.meas tran vdout0_35ck460 FIND v(dout0_35) AT=235.025n

.meas tran vdout0_36ck460 FIND v(dout0_36) AT=235.025n

.meas tran vdout0_37ck460 FIND v(dout0_37) AT=235.025n

.meas tran vdout0_38ck460 FIND v(dout0_38) AT=235.025n

.meas tran vdout0_39ck460 FIND v(dout0_39) AT=235.025n

.meas tran vdout0_40ck460 FIND v(dout0_40) AT=235.025n

.meas tran vdout0_41ck460 FIND v(dout0_41) AT=235.025n

.meas tran vdout0_42ck460 FIND v(dout0_42) AT=235.025n

.meas tran vdout0_43ck460 FIND v(dout0_43) AT=235.025n

.meas tran vdout0_44ck460 FIND v(dout0_44) AT=235.025n

.meas tran vdout0_45ck460 FIND v(dout0_45) AT=235.025n

.meas tran vdout0_46ck460 FIND v(dout0_46) AT=235.025n

.meas tran vdout0_47ck460 FIND v(dout0_47) AT=235.025n

.meas tran vdout0_48ck460 FIND v(dout0_48) AT=235.025n

.meas tran vdout0_49ck460 FIND v(dout0_49) AT=235.025n

.meas tran vdout0_50ck460 FIND v(dout0_50) AT=235.025n

.meas tran vdout0_51ck460 FIND v(dout0_51) AT=235.025n

.meas tran vdout0_52ck460 FIND v(dout0_52) AT=235.025n

.meas tran vdout0_53ck460 FIND v(dout0_53) AT=235.025n

.meas tran vdout0_54ck460 FIND v(dout0_54) AT=235.025n

.meas tran vdout0_55ck460 FIND v(dout0_55) AT=235.025n

.meas tran vdout0_56ck460 FIND v(dout0_56) AT=235.025n

.meas tran vdout0_57ck460 FIND v(dout0_57) AT=235.025n

.meas tran vdout0_58ck460 FIND v(dout0_58) AT=235.025n

.meas tran vdout0_59ck460 FIND v(dout0_59) AT=235.025n

.meas tran vdout0_60ck460 FIND v(dout0_60) AT=235.025n

.meas tran vdout0_61ck460 FIND v(dout0_61) AT=235.025n

.meas tran vdout0_62ck460 FIND v(dout0_62) AT=235.025n

.meas tran vdout0_63ck460 FIND v(dout0_63) AT=235.025n

.meas tran vdout0_64ck460 FIND v(dout0_64) AT=235.025n

.meas tran vdout0_65ck460 FIND v(dout0_65) AT=235.025n

.meas tran vdout0_66ck460 FIND v(dout0_66) AT=235.025n

.meas tran vdout0_67ck460 FIND v(dout0_67) AT=235.025n

.meas tran vdout0_68ck460 FIND v(dout0_68) AT=235.025n

.meas tran vdout0_69ck460 FIND v(dout0_69) AT=235.025n

.meas tran vdout0_70ck460 FIND v(dout0_70) AT=235.025n

.meas tran vdout0_71ck460 FIND v(dout0_71) AT=235.025n

.meas tran vdout0_72ck460 FIND v(dout0_72) AT=235.025n

.meas tran vdout0_73ck460 FIND v(dout0_73) AT=235.025n

.meas tran vdout0_74ck460 FIND v(dout0_74) AT=235.025n

.meas tran vdout0_75ck460 FIND v(dout0_75) AT=235.025n

.meas tran vdout0_76ck460 FIND v(dout0_76) AT=235.025n

.meas tran vdout0_77ck460 FIND v(dout0_77) AT=235.025n

.meas tran vdout0_78ck460 FIND v(dout0_78) AT=235.025n

.meas tran vdout0_79ck460 FIND v(dout0_79) AT=235.025n

.meas tran vdout0_80ck460 FIND v(dout0_80) AT=235.025n

.meas tran vdout0_81ck460 FIND v(dout0_81) AT=235.025n

.meas tran vdout0_82ck460 FIND v(dout0_82) AT=235.025n

.meas tran vdout0_83ck460 FIND v(dout0_83) AT=235.025n

.meas tran vdout0_84ck460 FIND v(dout0_84) AT=235.025n

.meas tran vdout0_85ck460 FIND v(dout0_85) AT=235.025n

.meas tran vdout0_86ck460 FIND v(dout0_86) AT=235.025n

.meas tran vdout0_87ck460 FIND v(dout0_87) AT=235.025n

.meas tran vdout0_88ck460 FIND v(dout0_88) AT=235.025n

.meas tran vdout0_89ck460 FIND v(dout0_89) AT=235.025n

.meas tran vdout0_90ck460 FIND v(dout0_90) AT=235.025n

.meas tran vdout0_91ck460 FIND v(dout0_91) AT=235.025n

.meas tran vdout0_92ck460 FIND v(dout0_92) AT=235.025n

.meas tran vdout0_93ck460 FIND v(dout0_93) AT=235.025n

.meas tran vdout0_94ck460 FIND v(dout0_94) AT=235.025n

.meas tran vdout0_95ck460 FIND v(dout0_95) AT=235.025n

.meas tran vdout0_96ck460 FIND v(dout0_96) AT=235.025n

.meas tran vdout0_97ck460 FIND v(dout0_97) AT=235.025n

.meas tran vdout0_98ck460 FIND v(dout0_98) AT=235.025n

.meas tran vdout0_99ck460 FIND v(dout0_99) AT=235.025n

.meas tran vdout0_100ck460 FIND v(dout0_100) AT=235.025n

.meas tran vdout0_101ck460 FIND v(dout0_101) AT=235.025n

.meas tran vdout0_102ck460 FIND v(dout0_102) AT=235.025n

.meas tran vdout0_103ck460 FIND v(dout0_103) AT=235.025n

.meas tran vdout0_104ck460 FIND v(dout0_104) AT=235.025n

.meas tran vdout0_105ck460 FIND v(dout0_105) AT=235.025n

.meas tran vdout0_106ck460 FIND v(dout0_106) AT=235.025n

.meas tran vdout0_107ck460 FIND v(dout0_107) AT=235.025n

.meas tran vdout0_108ck460 FIND v(dout0_108) AT=235.025n

.meas tran vdout0_109ck460 FIND v(dout0_109) AT=235.025n

.meas tran vdout0_110ck460 FIND v(dout0_110) AT=235.025n

.meas tran vdout0_111ck460 FIND v(dout0_111) AT=235.025n

.meas tran vdout0_112ck460 FIND v(dout0_112) AT=235.025n

.meas tran vdout0_113ck460 FIND v(dout0_113) AT=235.025n

.meas tran vdout0_114ck460 FIND v(dout0_114) AT=235.025n

.meas tran vdout0_115ck460 FIND v(dout0_115) AT=235.025n

.meas tran vdout0_116ck460 FIND v(dout0_116) AT=235.025n

.meas tran vdout0_117ck460 FIND v(dout0_117) AT=235.025n

.meas tran vdout0_118ck460 FIND v(dout0_118) AT=235.025n

.meas tran vdout0_119ck460 FIND v(dout0_119) AT=235.025n

.meas tran vdout0_120ck460 FIND v(dout0_120) AT=235.025n

.meas tran vdout0_121ck460 FIND v(dout0_121) AT=235.025n

.meas tran vdout0_122ck460 FIND v(dout0_122) AT=235.025n

.meas tran vdout0_123ck460 FIND v(dout0_123) AT=235.025n

.meas tran vdout0_124ck460 FIND v(dout0_124) AT=235.025n

.meas tran vdout0_125ck460 FIND v(dout0_125) AT=235.025n

.meas tran vdout0_126ck460 FIND v(dout0_126) AT=235.025n

.meas tran vdout0_127ck460 FIND v(dout0_127) AT=235.025n

.meas tran vdout0_128ck460 FIND v(dout0_128) AT=235.025n

.meas tran vdout0_129ck460 FIND v(dout0_129) AT=235.025n

.meas tran vdout0_130ck460 FIND v(dout0_130) AT=235.025n

.meas tran vdout0_131ck460 FIND v(dout0_131) AT=235.025n

.meas tran vdout0_132ck460 FIND v(dout0_132) AT=235.025n

.meas tran vdout0_133ck460 FIND v(dout0_133) AT=235.025n

.meas tran vdout0_134ck460 FIND v(dout0_134) AT=235.025n

.meas tran vdout0_135ck460 FIND v(dout0_135) AT=235.025n

.meas tran vdout0_136ck460 FIND v(dout0_136) AT=235.025n

.meas tran vdout0_137ck460 FIND v(dout0_137) AT=235.025n

.meas tran vdout0_138ck460 FIND v(dout0_138) AT=235.025n

.meas tran vdout0_139ck460 FIND v(dout0_139) AT=235.025n

.meas tran vdout0_140ck460 FIND v(dout0_140) AT=235.025n

.meas tran vdout0_141ck460 FIND v(dout0_141) AT=235.025n

.meas tran vdout0_142ck460 FIND v(dout0_142) AT=235.025n

.meas tran vdout0_143ck460 FIND v(dout0_143) AT=235.025n

.meas tran vdout0_144ck460 FIND v(dout0_144) AT=235.025n

.meas tran vdout0_145ck460 FIND v(dout0_145) AT=235.025n

.meas tran vdout0_146ck460 FIND v(dout0_146) AT=235.025n

.meas tran vdout0_147ck460 FIND v(dout0_147) AT=235.025n

.meas tran vdout0_148ck460 FIND v(dout0_148) AT=235.025n

.meas tran vdout0_149ck460 FIND v(dout0_149) AT=235.025n

.meas tran vdout0_150ck460 FIND v(dout0_150) AT=235.025n

.meas tran vdout0_151ck460 FIND v(dout0_151) AT=235.025n

.meas tran vdout0_152ck460 FIND v(dout0_152) AT=235.025n

.meas tran vdout0_153ck460 FIND v(dout0_153) AT=235.025n

.meas tran vdout0_154ck460 FIND v(dout0_154) AT=235.025n

.meas tran vdout0_155ck460 FIND v(dout0_155) AT=235.025n

.meas tran vdout0_156ck460 FIND v(dout0_156) AT=235.025n

.meas tran vdout0_157ck460 FIND v(dout0_157) AT=235.025n

.meas tran vdout0_158ck460 FIND v(dout0_158) AT=235.025n

.meas tran vdout0_159ck460 FIND v(dout0_159) AT=235.025n

.meas tran vdout0_160ck460 FIND v(dout0_160) AT=235.025n

.meas tran vdout0_161ck460 FIND v(dout0_161) AT=235.025n

.meas tran vdout0_162ck460 FIND v(dout0_162) AT=235.025n

.meas tran vdout0_163ck460 FIND v(dout0_163) AT=235.025n

.meas tran vdout0_164ck460 FIND v(dout0_164) AT=235.025n

.meas tran vdout0_165ck460 FIND v(dout0_165) AT=235.025n

.meas tran vdout0_166ck460 FIND v(dout0_166) AT=235.025n

.meas tran vdout0_167ck460 FIND v(dout0_167) AT=235.025n

.meas tran vdout0_168ck460 FIND v(dout0_168) AT=235.025n

.meas tran vdout0_169ck460 FIND v(dout0_169) AT=235.025n

.meas tran vdout0_170ck460 FIND v(dout0_170) AT=235.025n

.meas tran vdout0_171ck460 FIND v(dout0_171) AT=235.025n

.meas tran vdout0_172ck460 FIND v(dout0_172) AT=235.025n

.meas tran vdout0_173ck460 FIND v(dout0_173) AT=235.025n

.meas tran vdout0_174ck460 FIND v(dout0_174) AT=235.025n

.meas tran vdout0_175ck460 FIND v(dout0_175) AT=235.025n

.meas tran vdout0_176ck460 FIND v(dout0_176) AT=235.025n

.meas tran vdout0_177ck460 FIND v(dout0_177) AT=235.025n

.meas tran vdout0_178ck460 FIND v(dout0_178) AT=235.025n

.meas tran vdout0_179ck460 FIND v(dout0_179) AT=235.025n

.meas tran vdout0_180ck460 FIND v(dout0_180) AT=235.025n

.meas tran vdout0_181ck460 FIND v(dout0_181) AT=235.025n

.meas tran vdout0_182ck460 FIND v(dout0_182) AT=235.025n

.meas tran vdout0_183ck460 FIND v(dout0_183) AT=235.025n

.meas tran vdout0_184ck460 FIND v(dout0_184) AT=235.025n

.meas tran vdout0_185ck460 FIND v(dout0_185) AT=235.025n

.meas tran vdout0_186ck460 FIND v(dout0_186) AT=235.025n

.meas tran vdout0_187ck460 FIND v(dout0_187) AT=235.025n

.meas tran vdout0_188ck460 FIND v(dout0_188) AT=235.025n

.meas tran vdout0_189ck460 FIND v(dout0_189) AT=235.025n

.meas tran vdout0_190ck460 FIND v(dout0_190) AT=235.025n

.meas tran vdout0_191ck460 FIND v(dout0_191) AT=235.025n

.meas tran vdout0_192ck460 FIND v(dout0_192) AT=235.025n

.meas tran vdout0_193ck460 FIND v(dout0_193) AT=235.025n

.meas tran vdout0_194ck460 FIND v(dout0_194) AT=235.025n

.meas tran vdout0_195ck460 FIND v(dout0_195) AT=235.025n

.meas tran vdout0_196ck460 FIND v(dout0_196) AT=235.025n

.meas tran vdout0_197ck460 FIND v(dout0_197) AT=235.025n

.meas tran vdout0_198ck460 FIND v(dout0_198) AT=235.025n

.meas tran vdout0_199ck460 FIND v(dout0_199) AT=235.025n

.meas tran vdout0_200ck460 FIND v(dout0_200) AT=235.025n

.meas tran vdout0_201ck460 FIND v(dout0_201) AT=235.025n

.meas tran vdout0_202ck460 FIND v(dout0_202) AT=235.025n

.meas tran vdout0_203ck460 FIND v(dout0_203) AT=235.025n

.meas tran vdout0_204ck460 FIND v(dout0_204) AT=235.025n

.meas tran vdout0_205ck460 FIND v(dout0_205) AT=235.025n

.meas tran vdout0_206ck460 FIND v(dout0_206) AT=235.025n

.meas tran vdout0_207ck460 FIND v(dout0_207) AT=235.025n

.meas tran vdout0_208ck460 FIND v(dout0_208) AT=235.025n

.meas tran vdout0_209ck460 FIND v(dout0_209) AT=235.025n

.meas tran vdout0_210ck460 FIND v(dout0_210) AT=235.025n

.meas tran vdout0_211ck460 FIND v(dout0_211) AT=235.025n

.meas tran vdout0_212ck460 FIND v(dout0_212) AT=235.025n

.meas tran vdout0_213ck460 FIND v(dout0_213) AT=235.025n

.meas tran vdout0_214ck460 FIND v(dout0_214) AT=235.025n

.meas tran vdout0_215ck460 FIND v(dout0_215) AT=235.025n

.meas tran vdout0_216ck460 FIND v(dout0_216) AT=235.025n

.meas tran vdout0_217ck460 FIND v(dout0_217) AT=235.025n

.meas tran vdout0_218ck460 FIND v(dout0_218) AT=235.025n

.meas tran vdout0_219ck460 FIND v(dout0_219) AT=235.025n

.meas tran vdout0_220ck460 FIND v(dout0_220) AT=235.025n

.meas tran vdout0_221ck460 FIND v(dout0_221) AT=235.025n

.meas tran vdout0_222ck460 FIND v(dout0_222) AT=235.025n

.meas tran vdout0_223ck460 FIND v(dout0_223) AT=235.025n

.meas tran vdout0_224ck460 FIND v(dout0_224) AT=235.025n

.meas tran vdout0_225ck460 FIND v(dout0_225) AT=235.025n

.meas tran vdout0_226ck460 FIND v(dout0_226) AT=235.025n

.meas tran vdout0_227ck460 FIND v(dout0_227) AT=235.025n

.meas tran vdout0_228ck460 FIND v(dout0_228) AT=235.025n

.meas tran vdout0_229ck460 FIND v(dout0_229) AT=235.025n

.meas tran vdout0_230ck460 FIND v(dout0_230) AT=235.025n

.meas tran vdout0_231ck460 FIND v(dout0_231) AT=235.025n

.meas tran vdout0_232ck460 FIND v(dout0_232) AT=235.025n

.meas tran vdout0_233ck460 FIND v(dout0_233) AT=235.025n

.meas tran vdout0_234ck460 FIND v(dout0_234) AT=235.025n

.meas tran vdout0_235ck460 FIND v(dout0_235) AT=235.025n

.meas tran vdout0_236ck460 FIND v(dout0_236) AT=235.025n

.meas tran vdout0_237ck460 FIND v(dout0_237) AT=235.025n

.meas tran vdout0_238ck460 FIND v(dout0_238) AT=235.025n

.meas tran vdout0_239ck460 FIND v(dout0_239) AT=235.025n

.meas tran vdout0_240ck460 FIND v(dout0_240) AT=235.025n

.meas tran vdout0_241ck460 FIND v(dout0_241) AT=235.025n

.meas tran vdout0_242ck460 FIND v(dout0_242) AT=235.025n

.meas tran vdout0_243ck460 FIND v(dout0_243) AT=235.025n

.meas tran vdout0_244ck460 FIND v(dout0_244) AT=235.025n

.meas tran vdout0_245ck460 FIND v(dout0_245) AT=235.025n

.meas tran vdout0_246ck460 FIND v(dout0_246) AT=235.025n

.meas tran vdout0_247ck460 FIND v(dout0_247) AT=235.025n

.meas tran vdout0_248ck460 FIND v(dout0_248) AT=235.025n

.meas tran vdout0_249ck460 FIND v(dout0_249) AT=235.025n

.meas tran vdout0_250ck460 FIND v(dout0_250) AT=235.025n

.meas tran vdout0_251ck460 FIND v(dout0_251) AT=235.025n

.meas tran vdout0_252ck460 FIND v(dout0_252) AT=235.025n

.meas tran vdout0_253ck460 FIND v(dout0_253) AT=235.025n

.meas tran vdout0_254ck460 FIND v(dout0_254) AT=235.025n

.meas tran vdout0_255ck460 FIND v(dout0_255) AT=235.025n

.meas tran vdout0_0ck470 FIND v(dout0_0) AT=240.025n

.meas tran vdout0_1ck470 FIND v(dout0_1) AT=240.025n

.meas tran vdout0_2ck470 FIND v(dout0_2) AT=240.025n

.meas tran vdout0_3ck470 FIND v(dout0_3) AT=240.025n

.meas tran vdout0_4ck470 FIND v(dout0_4) AT=240.025n

.meas tran vdout0_5ck470 FIND v(dout0_5) AT=240.025n

.meas tran vdout0_6ck470 FIND v(dout0_6) AT=240.025n

.meas tran vdout0_7ck470 FIND v(dout0_7) AT=240.025n

.meas tran vdout0_8ck470 FIND v(dout0_8) AT=240.025n

.meas tran vdout0_9ck470 FIND v(dout0_9) AT=240.025n

.meas tran vdout0_10ck470 FIND v(dout0_10) AT=240.025n

.meas tran vdout0_11ck470 FIND v(dout0_11) AT=240.025n

.meas tran vdout0_12ck470 FIND v(dout0_12) AT=240.025n

.meas tran vdout0_13ck470 FIND v(dout0_13) AT=240.025n

.meas tran vdout0_14ck470 FIND v(dout0_14) AT=240.025n

.meas tran vdout0_15ck470 FIND v(dout0_15) AT=240.025n

.meas tran vdout0_16ck470 FIND v(dout0_16) AT=240.025n

.meas tran vdout0_17ck470 FIND v(dout0_17) AT=240.025n

.meas tran vdout0_18ck470 FIND v(dout0_18) AT=240.025n

.meas tran vdout0_19ck470 FIND v(dout0_19) AT=240.025n

.meas tran vdout0_20ck470 FIND v(dout0_20) AT=240.025n

.meas tran vdout0_21ck470 FIND v(dout0_21) AT=240.025n

.meas tran vdout0_22ck470 FIND v(dout0_22) AT=240.025n

.meas tran vdout0_23ck470 FIND v(dout0_23) AT=240.025n

.meas tran vdout0_24ck470 FIND v(dout0_24) AT=240.025n

.meas tran vdout0_25ck470 FIND v(dout0_25) AT=240.025n

.meas tran vdout0_26ck470 FIND v(dout0_26) AT=240.025n

.meas tran vdout0_27ck470 FIND v(dout0_27) AT=240.025n

.meas tran vdout0_28ck470 FIND v(dout0_28) AT=240.025n

.meas tran vdout0_29ck470 FIND v(dout0_29) AT=240.025n

.meas tran vdout0_30ck470 FIND v(dout0_30) AT=240.025n

.meas tran vdout0_31ck470 FIND v(dout0_31) AT=240.025n

.meas tran vdout0_32ck470 FIND v(dout0_32) AT=240.025n

.meas tran vdout0_33ck470 FIND v(dout0_33) AT=240.025n

.meas tran vdout0_34ck470 FIND v(dout0_34) AT=240.025n

.meas tran vdout0_35ck470 FIND v(dout0_35) AT=240.025n

.meas tran vdout0_36ck470 FIND v(dout0_36) AT=240.025n

.meas tran vdout0_37ck470 FIND v(dout0_37) AT=240.025n

.meas tran vdout0_38ck470 FIND v(dout0_38) AT=240.025n

.meas tran vdout0_39ck470 FIND v(dout0_39) AT=240.025n

.meas tran vdout0_40ck470 FIND v(dout0_40) AT=240.025n

.meas tran vdout0_41ck470 FIND v(dout0_41) AT=240.025n

.meas tran vdout0_42ck470 FIND v(dout0_42) AT=240.025n

.meas tran vdout0_43ck470 FIND v(dout0_43) AT=240.025n

.meas tran vdout0_44ck470 FIND v(dout0_44) AT=240.025n

.meas tran vdout0_45ck470 FIND v(dout0_45) AT=240.025n

.meas tran vdout0_46ck470 FIND v(dout0_46) AT=240.025n

.meas tran vdout0_47ck470 FIND v(dout0_47) AT=240.025n

.meas tran vdout0_48ck470 FIND v(dout0_48) AT=240.025n

.meas tran vdout0_49ck470 FIND v(dout0_49) AT=240.025n

.meas tran vdout0_50ck470 FIND v(dout0_50) AT=240.025n

.meas tran vdout0_51ck470 FIND v(dout0_51) AT=240.025n

.meas tran vdout0_52ck470 FIND v(dout0_52) AT=240.025n

.meas tran vdout0_53ck470 FIND v(dout0_53) AT=240.025n

.meas tran vdout0_54ck470 FIND v(dout0_54) AT=240.025n

.meas tran vdout0_55ck470 FIND v(dout0_55) AT=240.025n

.meas tran vdout0_56ck470 FIND v(dout0_56) AT=240.025n

.meas tran vdout0_57ck470 FIND v(dout0_57) AT=240.025n

.meas tran vdout0_58ck470 FIND v(dout0_58) AT=240.025n

.meas tran vdout0_59ck470 FIND v(dout0_59) AT=240.025n

.meas tran vdout0_60ck470 FIND v(dout0_60) AT=240.025n

.meas tran vdout0_61ck470 FIND v(dout0_61) AT=240.025n

.meas tran vdout0_62ck470 FIND v(dout0_62) AT=240.025n

.meas tran vdout0_63ck470 FIND v(dout0_63) AT=240.025n

.meas tran vdout0_64ck470 FIND v(dout0_64) AT=240.025n

.meas tran vdout0_65ck470 FIND v(dout0_65) AT=240.025n

.meas tran vdout0_66ck470 FIND v(dout0_66) AT=240.025n

.meas tran vdout0_67ck470 FIND v(dout0_67) AT=240.025n

.meas tran vdout0_68ck470 FIND v(dout0_68) AT=240.025n

.meas tran vdout0_69ck470 FIND v(dout0_69) AT=240.025n

.meas tran vdout0_70ck470 FIND v(dout0_70) AT=240.025n

.meas tran vdout0_71ck470 FIND v(dout0_71) AT=240.025n

.meas tran vdout0_72ck470 FIND v(dout0_72) AT=240.025n

.meas tran vdout0_73ck470 FIND v(dout0_73) AT=240.025n

.meas tran vdout0_74ck470 FIND v(dout0_74) AT=240.025n

.meas tran vdout0_75ck470 FIND v(dout0_75) AT=240.025n

.meas tran vdout0_76ck470 FIND v(dout0_76) AT=240.025n

.meas tran vdout0_77ck470 FIND v(dout0_77) AT=240.025n

.meas tran vdout0_78ck470 FIND v(dout0_78) AT=240.025n

.meas tran vdout0_79ck470 FIND v(dout0_79) AT=240.025n

.meas tran vdout0_80ck470 FIND v(dout0_80) AT=240.025n

.meas tran vdout0_81ck470 FIND v(dout0_81) AT=240.025n

.meas tran vdout0_82ck470 FIND v(dout0_82) AT=240.025n

.meas tran vdout0_83ck470 FIND v(dout0_83) AT=240.025n

.meas tran vdout0_84ck470 FIND v(dout0_84) AT=240.025n

.meas tran vdout0_85ck470 FIND v(dout0_85) AT=240.025n

.meas tran vdout0_86ck470 FIND v(dout0_86) AT=240.025n

.meas tran vdout0_87ck470 FIND v(dout0_87) AT=240.025n

.meas tran vdout0_88ck470 FIND v(dout0_88) AT=240.025n

.meas tran vdout0_89ck470 FIND v(dout0_89) AT=240.025n

.meas tran vdout0_90ck470 FIND v(dout0_90) AT=240.025n

.meas tran vdout0_91ck470 FIND v(dout0_91) AT=240.025n

.meas tran vdout0_92ck470 FIND v(dout0_92) AT=240.025n

.meas tran vdout0_93ck470 FIND v(dout0_93) AT=240.025n

.meas tran vdout0_94ck470 FIND v(dout0_94) AT=240.025n

.meas tran vdout0_95ck470 FIND v(dout0_95) AT=240.025n

.meas tran vdout0_96ck470 FIND v(dout0_96) AT=240.025n

.meas tran vdout0_97ck470 FIND v(dout0_97) AT=240.025n

.meas tran vdout0_98ck470 FIND v(dout0_98) AT=240.025n

.meas tran vdout0_99ck470 FIND v(dout0_99) AT=240.025n

.meas tran vdout0_100ck470 FIND v(dout0_100) AT=240.025n

.meas tran vdout0_101ck470 FIND v(dout0_101) AT=240.025n

.meas tran vdout0_102ck470 FIND v(dout0_102) AT=240.025n

.meas tran vdout0_103ck470 FIND v(dout0_103) AT=240.025n

.meas tran vdout0_104ck470 FIND v(dout0_104) AT=240.025n

.meas tran vdout0_105ck470 FIND v(dout0_105) AT=240.025n

.meas tran vdout0_106ck470 FIND v(dout0_106) AT=240.025n

.meas tran vdout0_107ck470 FIND v(dout0_107) AT=240.025n

.meas tran vdout0_108ck470 FIND v(dout0_108) AT=240.025n

.meas tran vdout0_109ck470 FIND v(dout0_109) AT=240.025n

.meas tran vdout0_110ck470 FIND v(dout0_110) AT=240.025n

.meas tran vdout0_111ck470 FIND v(dout0_111) AT=240.025n

.meas tran vdout0_112ck470 FIND v(dout0_112) AT=240.025n

.meas tran vdout0_113ck470 FIND v(dout0_113) AT=240.025n

.meas tran vdout0_114ck470 FIND v(dout0_114) AT=240.025n

.meas tran vdout0_115ck470 FIND v(dout0_115) AT=240.025n

.meas tran vdout0_116ck470 FIND v(dout0_116) AT=240.025n

.meas tran vdout0_117ck470 FIND v(dout0_117) AT=240.025n

.meas tran vdout0_118ck470 FIND v(dout0_118) AT=240.025n

.meas tran vdout0_119ck470 FIND v(dout0_119) AT=240.025n

.meas tran vdout0_120ck470 FIND v(dout0_120) AT=240.025n

.meas tran vdout0_121ck470 FIND v(dout0_121) AT=240.025n

.meas tran vdout0_122ck470 FIND v(dout0_122) AT=240.025n

.meas tran vdout0_123ck470 FIND v(dout0_123) AT=240.025n

.meas tran vdout0_124ck470 FIND v(dout0_124) AT=240.025n

.meas tran vdout0_125ck470 FIND v(dout0_125) AT=240.025n

.meas tran vdout0_126ck470 FIND v(dout0_126) AT=240.025n

.meas tran vdout0_127ck470 FIND v(dout0_127) AT=240.025n

.meas tran vdout0_128ck470 FIND v(dout0_128) AT=240.025n

.meas tran vdout0_129ck470 FIND v(dout0_129) AT=240.025n

.meas tran vdout0_130ck470 FIND v(dout0_130) AT=240.025n

.meas tran vdout0_131ck470 FIND v(dout0_131) AT=240.025n

.meas tran vdout0_132ck470 FIND v(dout0_132) AT=240.025n

.meas tran vdout0_133ck470 FIND v(dout0_133) AT=240.025n

.meas tran vdout0_134ck470 FIND v(dout0_134) AT=240.025n

.meas tran vdout0_135ck470 FIND v(dout0_135) AT=240.025n

.meas tran vdout0_136ck470 FIND v(dout0_136) AT=240.025n

.meas tran vdout0_137ck470 FIND v(dout0_137) AT=240.025n

.meas tran vdout0_138ck470 FIND v(dout0_138) AT=240.025n

.meas tran vdout0_139ck470 FIND v(dout0_139) AT=240.025n

.meas tran vdout0_140ck470 FIND v(dout0_140) AT=240.025n

.meas tran vdout0_141ck470 FIND v(dout0_141) AT=240.025n

.meas tran vdout0_142ck470 FIND v(dout0_142) AT=240.025n

.meas tran vdout0_143ck470 FIND v(dout0_143) AT=240.025n

.meas tran vdout0_144ck470 FIND v(dout0_144) AT=240.025n

.meas tran vdout0_145ck470 FIND v(dout0_145) AT=240.025n

.meas tran vdout0_146ck470 FIND v(dout0_146) AT=240.025n

.meas tran vdout0_147ck470 FIND v(dout0_147) AT=240.025n

.meas tran vdout0_148ck470 FIND v(dout0_148) AT=240.025n

.meas tran vdout0_149ck470 FIND v(dout0_149) AT=240.025n

.meas tran vdout0_150ck470 FIND v(dout0_150) AT=240.025n

.meas tran vdout0_151ck470 FIND v(dout0_151) AT=240.025n

.meas tran vdout0_152ck470 FIND v(dout0_152) AT=240.025n

.meas tran vdout0_153ck470 FIND v(dout0_153) AT=240.025n

.meas tran vdout0_154ck470 FIND v(dout0_154) AT=240.025n

.meas tran vdout0_155ck470 FIND v(dout0_155) AT=240.025n

.meas tran vdout0_156ck470 FIND v(dout0_156) AT=240.025n

.meas tran vdout0_157ck470 FIND v(dout0_157) AT=240.025n

.meas tran vdout0_158ck470 FIND v(dout0_158) AT=240.025n

.meas tran vdout0_159ck470 FIND v(dout0_159) AT=240.025n

.meas tran vdout0_160ck470 FIND v(dout0_160) AT=240.025n

.meas tran vdout0_161ck470 FIND v(dout0_161) AT=240.025n

.meas tran vdout0_162ck470 FIND v(dout0_162) AT=240.025n

.meas tran vdout0_163ck470 FIND v(dout0_163) AT=240.025n

.meas tran vdout0_164ck470 FIND v(dout0_164) AT=240.025n

.meas tran vdout0_165ck470 FIND v(dout0_165) AT=240.025n

.meas tran vdout0_166ck470 FIND v(dout0_166) AT=240.025n

.meas tran vdout0_167ck470 FIND v(dout0_167) AT=240.025n

.meas tran vdout0_168ck470 FIND v(dout0_168) AT=240.025n

.meas tran vdout0_169ck470 FIND v(dout0_169) AT=240.025n

.meas tran vdout0_170ck470 FIND v(dout0_170) AT=240.025n

.meas tran vdout0_171ck470 FIND v(dout0_171) AT=240.025n

.meas tran vdout0_172ck470 FIND v(dout0_172) AT=240.025n

.meas tran vdout0_173ck470 FIND v(dout0_173) AT=240.025n

.meas tran vdout0_174ck470 FIND v(dout0_174) AT=240.025n

.meas tran vdout0_175ck470 FIND v(dout0_175) AT=240.025n

.meas tran vdout0_176ck470 FIND v(dout0_176) AT=240.025n

.meas tran vdout0_177ck470 FIND v(dout0_177) AT=240.025n

.meas tran vdout0_178ck470 FIND v(dout0_178) AT=240.025n

.meas tran vdout0_179ck470 FIND v(dout0_179) AT=240.025n

.meas tran vdout0_180ck470 FIND v(dout0_180) AT=240.025n

.meas tran vdout0_181ck470 FIND v(dout0_181) AT=240.025n

.meas tran vdout0_182ck470 FIND v(dout0_182) AT=240.025n

.meas tran vdout0_183ck470 FIND v(dout0_183) AT=240.025n

.meas tran vdout0_184ck470 FIND v(dout0_184) AT=240.025n

.meas tran vdout0_185ck470 FIND v(dout0_185) AT=240.025n

.meas tran vdout0_186ck470 FIND v(dout0_186) AT=240.025n

.meas tran vdout0_187ck470 FIND v(dout0_187) AT=240.025n

.meas tran vdout0_188ck470 FIND v(dout0_188) AT=240.025n

.meas tran vdout0_189ck470 FIND v(dout0_189) AT=240.025n

.meas tran vdout0_190ck470 FIND v(dout0_190) AT=240.025n

.meas tran vdout0_191ck470 FIND v(dout0_191) AT=240.025n

.meas tran vdout0_192ck470 FIND v(dout0_192) AT=240.025n

.meas tran vdout0_193ck470 FIND v(dout0_193) AT=240.025n

.meas tran vdout0_194ck470 FIND v(dout0_194) AT=240.025n

.meas tran vdout0_195ck470 FIND v(dout0_195) AT=240.025n

.meas tran vdout0_196ck470 FIND v(dout0_196) AT=240.025n

.meas tran vdout0_197ck470 FIND v(dout0_197) AT=240.025n

.meas tran vdout0_198ck470 FIND v(dout0_198) AT=240.025n

.meas tran vdout0_199ck470 FIND v(dout0_199) AT=240.025n

.meas tran vdout0_200ck470 FIND v(dout0_200) AT=240.025n

.meas tran vdout0_201ck470 FIND v(dout0_201) AT=240.025n

.meas tran vdout0_202ck470 FIND v(dout0_202) AT=240.025n

.meas tran vdout0_203ck470 FIND v(dout0_203) AT=240.025n

.meas tran vdout0_204ck470 FIND v(dout0_204) AT=240.025n

.meas tran vdout0_205ck470 FIND v(dout0_205) AT=240.025n

.meas tran vdout0_206ck470 FIND v(dout0_206) AT=240.025n

.meas tran vdout0_207ck470 FIND v(dout0_207) AT=240.025n

.meas tran vdout0_208ck470 FIND v(dout0_208) AT=240.025n

.meas tran vdout0_209ck470 FIND v(dout0_209) AT=240.025n

.meas tran vdout0_210ck470 FIND v(dout0_210) AT=240.025n

.meas tran vdout0_211ck470 FIND v(dout0_211) AT=240.025n

.meas tran vdout0_212ck470 FIND v(dout0_212) AT=240.025n

.meas tran vdout0_213ck470 FIND v(dout0_213) AT=240.025n

.meas tran vdout0_214ck470 FIND v(dout0_214) AT=240.025n

.meas tran vdout0_215ck470 FIND v(dout0_215) AT=240.025n

.meas tran vdout0_216ck470 FIND v(dout0_216) AT=240.025n

.meas tran vdout0_217ck470 FIND v(dout0_217) AT=240.025n

.meas tran vdout0_218ck470 FIND v(dout0_218) AT=240.025n

.meas tran vdout0_219ck470 FIND v(dout0_219) AT=240.025n

.meas tran vdout0_220ck470 FIND v(dout0_220) AT=240.025n

.meas tran vdout0_221ck470 FIND v(dout0_221) AT=240.025n

.meas tran vdout0_222ck470 FIND v(dout0_222) AT=240.025n

.meas tran vdout0_223ck470 FIND v(dout0_223) AT=240.025n

.meas tran vdout0_224ck470 FIND v(dout0_224) AT=240.025n

.meas tran vdout0_225ck470 FIND v(dout0_225) AT=240.025n

.meas tran vdout0_226ck470 FIND v(dout0_226) AT=240.025n

.meas tran vdout0_227ck470 FIND v(dout0_227) AT=240.025n

.meas tran vdout0_228ck470 FIND v(dout0_228) AT=240.025n

.meas tran vdout0_229ck470 FIND v(dout0_229) AT=240.025n

.meas tran vdout0_230ck470 FIND v(dout0_230) AT=240.025n

.meas tran vdout0_231ck470 FIND v(dout0_231) AT=240.025n

.meas tran vdout0_232ck470 FIND v(dout0_232) AT=240.025n

.meas tran vdout0_233ck470 FIND v(dout0_233) AT=240.025n

.meas tran vdout0_234ck470 FIND v(dout0_234) AT=240.025n

.meas tran vdout0_235ck470 FIND v(dout0_235) AT=240.025n

.meas tran vdout0_236ck470 FIND v(dout0_236) AT=240.025n

.meas tran vdout0_237ck470 FIND v(dout0_237) AT=240.025n

.meas tran vdout0_238ck470 FIND v(dout0_238) AT=240.025n

.meas tran vdout0_239ck470 FIND v(dout0_239) AT=240.025n

.meas tran vdout0_240ck470 FIND v(dout0_240) AT=240.025n

.meas tran vdout0_241ck470 FIND v(dout0_241) AT=240.025n

.meas tran vdout0_242ck470 FIND v(dout0_242) AT=240.025n

.meas tran vdout0_243ck470 FIND v(dout0_243) AT=240.025n

.meas tran vdout0_244ck470 FIND v(dout0_244) AT=240.025n

.meas tran vdout0_245ck470 FIND v(dout0_245) AT=240.025n

.meas tran vdout0_246ck470 FIND v(dout0_246) AT=240.025n

.meas tran vdout0_247ck470 FIND v(dout0_247) AT=240.025n

.meas tran vdout0_248ck470 FIND v(dout0_248) AT=240.025n

.meas tran vdout0_249ck470 FIND v(dout0_249) AT=240.025n

.meas tran vdout0_250ck470 FIND v(dout0_250) AT=240.025n

.meas tran vdout0_251ck470 FIND v(dout0_251) AT=240.025n

.meas tran vdout0_252ck470 FIND v(dout0_252) AT=240.025n

.meas tran vdout0_253ck470 FIND v(dout0_253) AT=240.025n

.meas tran vdout0_254ck470 FIND v(dout0_254) AT=240.025n

.meas tran vdout0_255ck470 FIND v(dout0_255) AT=240.025n

.meas tran vdout0_0ck480 FIND v(dout0_0) AT=245.025n

.meas tran vdout0_1ck480 FIND v(dout0_1) AT=245.025n

.meas tran vdout0_2ck480 FIND v(dout0_2) AT=245.025n

.meas tran vdout0_3ck480 FIND v(dout0_3) AT=245.025n

.meas tran vdout0_4ck480 FIND v(dout0_4) AT=245.025n

.meas tran vdout0_5ck480 FIND v(dout0_5) AT=245.025n

.meas tran vdout0_6ck480 FIND v(dout0_6) AT=245.025n

.meas tran vdout0_7ck480 FIND v(dout0_7) AT=245.025n

.meas tran vdout0_8ck480 FIND v(dout0_8) AT=245.025n

.meas tran vdout0_9ck480 FIND v(dout0_9) AT=245.025n

.meas tran vdout0_10ck480 FIND v(dout0_10) AT=245.025n

.meas tran vdout0_11ck480 FIND v(dout0_11) AT=245.025n

.meas tran vdout0_12ck480 FIND v(dout0_12) AT=245.025n

.meas tran vdout0_13ck480 FIND v(dout0_13) AT=245.025n

.meas tran vdout0_14ck480 FIND v(dout0_14) AT=245.025n

.meas tran vdout0_15ck480 FIND v(dout0_15) AT=245.025n

.meas tran vdout0_16ck480 FIND v(dout0_16) AT=245.025n

.meas tran vdout0_17ck480 FIND v(dout0_17) AT=245.025n

.meas tran vdout0_18ck480 FIND v(dout0_18) AT=245.025n

.meas tran vdout0_19ck480 FIND v(dout0_19) AT=245.025n

.meas tran vdout0_20ck480 FIND v(dout0_20) AT=245.025n

.meas tran vdout0_21ck480 FIND v(dout0_21) AT=245.025n

.meas tran vdout0_22ck480 FIND v(dout0_22) AT=245.025n

.meas tran vdout0_23ck480 FIND v(dout0_23) AT=245.025n

.meas tran vdout0_24ck480 FIND v(dout0_24) AT=245.025n

.meas tran vdout0_25ck480 FIND v(dout0_25) AT=245.025n

.meas tran vdout0_26ck480 FIND v(dout0_26) AT=245.025n

.meas tran vdout0_27ck480 FIND v(dout0_27) AT=245.025n

.meas tran vdout0_28ck480 FIND v(dout0_28) AT=245.025n

.meas tran vdout0_29ck480 FIND v(dout0_29) AT=245.025n

.meas tran vdout0_30ck480 FIND v(dout0_30) AT=245.025n

.meas tran vdout0_31ck480 FIND v(dout0_31) AT=245.025n

.meas tran vdout0_32ck480 FIND v(dout0_32) AT=245.025n

.meas tran vdout0_33ck480 FIND v(dout0_33) AT=245.025n

.meas tran vdout0_34ck480 FIND v(dout0_34) AT=245.025n

.meas tran vdout0_35ck480 FIND v(dout0_35) AT=245.025n

.meas tran vdout0_36ck480 FIND v(dout0_36) AT=245.025n

.meas tran vdout0_37ck480 FIND v(dout0_37) AT=245.025n

.meas tran vdout0_38ck480 FIND v(dout0_38) AT=245.025n

.meas tran vdout0_39ck480 FIND v(dout0_39) AT=245.025n

.meas tran vdout0_40ck480 FIND v(dout0_40) AT=245.025n

.meas tran vdout0_41ck480 FIND v(dout0_41) AT=245.025n

.meas tran vdout0_42ck480 FIND v(dout0_42) AT=245.025n

.meas tran vdout0_43ck480 FIND v(dout0_43) AT=245.025n

.meas tran vdout0_44ck480 FIND v(dout0_44) AT=245.025n

.meas tran vdout0_45ck480 FIND v(dout0_45) AT=245.025n

.meas tran vdout0_46ck480 FIND v(dout0_46) AT=245.025n

.meas tran vdout0_47ck480 FIND v(dout0_47) AT=245.025n

.meas tran vdout0_48ck480 FIND v(dout0_48) AT=245.025n

.meas tran vdout0_49ck480 FIND v(dout0_49) AT=245.025n

.meas tran vdout0_50ck480 FIND v(dout0_50) AT=245.025n

.meas tran vdout0_51ck480 FIND v(dout0_51) AT=245.025n

.meas tran vdout0_52ck480 FIND v(dout0_52) AT=245.025n

.meas tran vdout0_53ck480 FIND v(dout0_53) AT=245.025n

.meas tran vdout0_54ck480 FIND v(dout0_54) AT=245.025n

.meas tran vdout0_55ck480 FIND v(dout0_55) AT=245.025n

.meas tran vdout0_56ck480 FIND v(dout0_56) AT=245.025n

.meas tran vdout0_57ck480 FIND v(dout0_57) AT=245.025n

.meas tran vdout0_58ck480 FIND v(dout0_58) AT=245.025n

.meas tran vdout0_59ck480 FIND v(dout0_59) AT=245.025n

.meas tran vdout0_60ck480 FIND v(dout0_60) AT=245.025n

.meas tran vdout0_61ck480 FIND v(dout0_61) AT=245.025n

.meas tran vdout0_62ck480 FIND v(dout0_62) AT=245.025n

.meas tran vdout0_63ck480 FIND v(dout0_63) AT=245.025n

.meas tran vdout0_64ck480 FIND v(dout0_64) AT=245.025n

.meas tran vdout0_65ck480 FIND v(dout0_65) AT=245.025n

.meas tran vdout0_66ck480 FIND v(dout0_66) AT=245.025n

.meas tran vdout0_67ck480 FIND v(dout0_67) AT=245.025n

.meas tran vdout0_68ck480 FIND v(dout0_68) AT=245.025n

.meas tran vdout0_69ck480 FIND v(dout0_69) AT=245.025n

.meas tran vdout0_70ck480 FIND v(dout0_70) AT=245.025n

.meas tran vdout0_71ck480 FIND v(dout0_71) AT=245.025n

.meas tran vdout0_72ck480 FIND v(dout0_72) AT=245.025n

.meas tran vdout0_73ck480 FIND v(dout0_73) AT=245.025n

.meas tran vdout0_74ck480 FIND v(dout0_74) AT=245.025n

.meas tran vdout0_75ck480 FIND v(dout0_75) AT=245.025n

.meas tran vdout0_76ck480 FIND v(dout0_76) AT=245.025n

.meas tran vdout0_77ck480 FIND v(dout0_77) AT=245.025n

.meas tran vdout0_78ck480 FIND v(dout0_78) AT=245.025n

.meas tran vdout0_79ck480 FIND v(dout0_79) AT=245.025n

.meas tran vdout0_80ck480 FIND v(dout0_80) AT=245.025n

.meas tran vdout0_81ck480 FIND v(dout0_81) AT=245.025n

.meas tran vdout0_82ck480 FIND v(dout0_82) AT=245.025n

.meas tran vdout0_83ck480 FIND v(dout0_83) AT=245.025n

.meas tran vdout0_84ck480 FIND v(dout0_84) AT=245.025n

.meas tran vdout0_85ck480 FIND v(dout0_85) AT=245.025n

.meas tran vdout0_86ck480 FIND v(dout0_86) AT=245.025n

.meas tran vdout0_87ck480 FIND v(dout0_87) AT=245.025n

.meas tran vdout0_88ck480 FIND v(dout0_88) AT=245.025n

.meas tran vdout0_89ck480 FIND v(dout0_89) AT=245.025n

.meas tran vdout0_90ck480 FIND v(dout0_90) AT=245.025n

.meas tran vdout0_91ck480 FIND v(dout0_91) AT=245.025n

.meas tran vdout0_92ck480 FIND v(dout0_92) AT=245.025n

.meas tran vdout0_93ck480 FIND v(dout0_93) AT=245.025n

.meas tran vdout0_94ck480 FIND v(dout0_94) AT=245.025n

.meas tran vdout0_95ck480 FIND v(dout0_95) AT=245.025n

.meas tran vdout0_96ck480 FIND v(dout0_96) AT=245.025n

.meas tran vdout0_97ck480 FIND v(dout0_97) AT=245.025n

.meas tran vdout0_98ck480 FIND v(dout0_98) AT=245.025n

.meas tran vdout0_99ck480 FIND v(dout0_99) AT=245.025n

.meas tran vdout0_100ck480 FIND v(dout0_100) AT=245.025n

.meas tran vdout0_101ck480 FIND v(dout0_101) AT=245.025n

.meas tran vdout0_102ck480 FIND v(dout0_102) AT=245.025n

.meas tran vdout0_103ck480 FIND v(dout0_103) AT=245.025n

.meas tran vdout0_104ck480 FIND v(dout0_104) AT=245.025n

.meas tran vdout0_105ck480 FIND v(dout0_105) AT=245.025n

.meas tran vdout0_106ck480 FIND v(dout0_106) AT=245.025n

.meas tran vdout0_107ck480 FIND v(dout0_107) AT=245.025n

.meas tran vdout0_108ck480 FIND v(dout0_108) AT=245.025n

.meas tran vdout0_109ck480 FIND v(dout0_109) AT=245.025n

.meas tran vdout0_110ck480 FIND v(dout0_110) AT=245.025n

.meas tran vdout0_111ck480 FIND v(dout0_111) AT=245.025n

.meas tran vdout0_112ck480 FIND v(dout0_112) AT=245.025n

.meas tran vdout0_113ck480 FIND v(dout0_113) AT=245.025n

.meas tran vdout0_114ck480 FIND v(dout0_114) AT=245.025n

.meas tran vdout0_115ck480 FIND v(dout0_115) AT=245.025n

.meas tran vdout0_116ck480 FIND v(dout0_116) AT=245.025n

.meas tran vdout0_117ck480 FIND v(dout0_117) AT=245.025n

.meas tran vdout0_118ck480 FIND v(dout0_118) AT=245.025n

.meas tran vdout0_119ck480 FIND v(dout0_119) AT=245.025n

.meas tran vdout0_120ck480 FIND v(dout0_120) AT=245.025n

.meas tran vdout0_121ck480 FIND v(dout0_121) AT=245.025n

.meas tran vdout0_122ck480 FIND v(dout0_122) AT=245.025n

.meas tran vdout0_123ck480 FIND v(dout0_123) AT=245.025n

.meas tran vdout0_124ck480 FIND v(dout0_124) AT=245.025n

.meas tran vdout0_125ck480 FIND v(dout0_125) AT=245.025n

.meas tran vdout0_126ck480 FIND v(dout0_126) AT=245.025n

.meas tran vdout0_127ck480 FIND v(dout0_127) AT=245.025n

.meas tran vdout0_128ck480 FIND v(dout0_128) AT=245.025n

.meas tran vdout0_129ck480 FIND v(dout0_129) AT=245.025n

.meas tran vdout0_130ck480 FIND v(dout0_130) AT=245.025n

.meas tran vdout0_131ck480 FIND v(dout0_131) AT=245.025n

.meas tran vdout0_132ck480 FIND v(dout0_132) AT=245.025n

.meas tran vdout0_133ck480 FIND v(dout0_133) AT=245.025n

.meas tran vdout0_134ck480 FIND v(dout0_134) AT=245.025n

.meas tran vdout0_135ck480 FIND v(dout0_135) AT=245.025n

.meas tran vdout0_136ck480 FIND v(dout0_136) AT=245.025n

.meas tran vdout0_137ck480 FIND v(dout0_137) AT=245.025n

.meas tran vdout0_138ck480 FIND v(dout0_138) AT=245.025n

.meas tran vdout0_139ck480 FIND v(dout0_139) AT=245.025n

.meas tran vdout0_140ck480 FIND v(dout0_140) AT=245.025n

.meas tran vdout0_141ck480 FIND v(dout0_141) AT=245.025n

.meas tran vdout0_142ck480 FIND v(dout0_142) AT=245.025n

.meas tran vdout0_143ck480 FIND v(dout0_143) AT=245.025n

.meas tran vdout0_144ck480 FIND v(dout0_144) AT=245.025n

.meas tran vdout0_145ck480 FIND v(dout0_145) AT=245.025n

.meas tran vdout0_146ck480 FIND v(dout0_146) AT=245.025n

.meas tran vdout0_147ck480 FIND v(dout0_147) AT=245.025n

.meas tran vdout0_148ck480 FIND v(dout0_148) AT=245.025n

.meas tran vdout0_149ck480 FIND v(dout0_149) AT=245.025n

.meas tran vdout0_150ck480 FIND v(dout0_150) AT=245.025n

.meas tran vdout0_151ck480 FIND v(dout0_151) AT=245.025n

.meas tran vdout0_152ck480 FIND v(dout0_152) AT=245.025n

.meas tran vdout0_153ck480 FIND v(dout0_153) AT=245.025n

.meas tran vdout0_154ck480 FIND v(dout0_154) AT=245.025n

.meas tran vdout0_155ck480 FIND v(dout0_155) AT=245.025n

.meas tran vdout0_156ck480 FIND v(dout0_156) AT=245.025n

.meas tran vdout0_157ck480 FIND v(dout0_157) AT=245.025n

.meas tran vdout0_158ck480 FIND v(dout0_158) AT=245.025n

.meas tran vdout0_159ck480 FIND v(dout0_159) AT=245.025n

.meas tran vdout0_160ck480 FIND v(dout0_160) AT=245.025n

.meas tran vdout0_161ck480 FIND v(dout0_161) AT=245.025n

.meas tran vdout0_162ck480 FIND v(dout0_162) AT=245.025n

.meas tran vdout0_163ck480 FIND v(dout0_163) AT=245.025n

.meas tran vdout0_164ck480 FIND v(dout0_164) AT=245.025n

.meas tran vdout0_165ck480 FIND v(dout0_165) AT=245.025n

.meas tran vdout0_166ck480 FIND v(dout0_166) AT=245.025n

.meas tran vdout0_167ck480 FIND v(dout0_167) AT=245.025n

.meas tran vdout0_168ck480 FIND v(dout0_168) AT=245.025n

.meas tran vdout0_169ck480 FIND v(dout0_169) AT=245.025n

.meas tran vdout0_170ck480 FIND v(dout0_170) AT=245.025n

.meas tran vdout0_171ck480 FIND v(dout0_171) AT=245.025n

.meas tran vdout0_172ck480 FIND v(dout0_172) AT=245.025n

.meas tran vdout0_173ck480 FIND v(dout0_173) AT=245.025n

.meas tran vdout0_174ck480 FIND v(dout0_174) AT=245.025n

.meas tran vdout0_175ck480 FIND v(dout0_175) AT=245.025n

.meas tran vdout0_176ck480 FIND v(dout0_176) AT=245.025n

.meas tran vdout0_177ck480 FIND v(dout0_177) AT=245.025n

.meas tran vdout0_178ck480 FIND v(dout0_178) AT=245.025n

.meas tran vdout0_179ck480 FIND v(dout0_179) AT=245.025n

.meas tran vdout0_180ck480 FIND v(dout0_180) AT=245.025n

.meas tran vdout0_181ck480 FIND v(dout0_181) AT=245.025n

.meas tran vdout0_182ck480 FIND v(dout0_182) AT=245.025n

.meas tran vdout0_183ck480 FIND v(dout0_183) AT=245.025n

.meas tran vdout0_184ck480 FIND v(dout0_184) AT=245.025n

.meas tran vdout0_185ck480 FIND v(dout0_185) AT=245.025n

.meas tran vdout0_186ck480 FIND v(dout0_186) AT=245.025n

.meas tran vdout0_187ck480 FIND v(dout0_187) AT=245.025n

.meas tran vdout0_188ck480 FIND v(dout0_188) AT=245.025n

.meas tran vdout0_189ck480 FIND v(dout0_189) AT=245.025n

.meas tran vdout0_190ck480 FIND v(dout0_190) AT=245.025n

.meas tran vdout0_191ck480 FIND v(dout0_191) AT=245.025n

.meas tran vdout0_192ck480 FIND v(dout0_192) AT=245.025n

.meas tran vdout0_193ck480 FIND v(dout0_193) AT=245.025n

.meas tran vdout0_194ck480 FIND v(dout0_194) AT=245.025n

.meas tran vdout0_195ck480 FIND v(dout0_195) AT=245.025n

.meas tran vdout0_196ck480 FIND v(dout0_196) AT=245.025n

.meas tran vdout0_197ck480 FIND v(dout0_197) AT=245.025n

.meas tran vdout0_198ck480 FIND v(dout0_198) AT=245.025n

.meas tran vdout0_199ck480 FIND v(dout0_199) AT=245.025n

.meas tran vdout0_200ck480 FIND v(dout0_200) AT=245.025n

.meas tran vdout0_201ck480 FIND v(dout0_201) AT=245.025n

.meas tran vdout0_202ck480 FIND v(dout0_202) AT=245.025n

.meas tran vdout0_203ck480 FIND v(dout0_203) AT=245.025n

.meas tran vdout0_204ck480 FIND v(dout0_204) AT=245.025n

.meas tran vdout0_205ck480 FIND v(dout0_205) AT=245.025n

.meas tran vdout0_206ck480 FIND v(dout0_206) AT=245.025n

.meas tran vdout0_207ck480 FIND v(dout0_207) AT=245.025n

.meas tran vdout0_208ck480 FIND v(dout0_208) AT=245.025n

.meas tran vdout0_209ck480 FIND v(dout0_209) AT=245.025n

.meas tran vdout0_210ck480 FIND v(dout0_210) AT=245.025n

.meas tran vdout0_211ck480 FIND v(dout0_211) AT=245.025n

.meas tran vdout0_212ck480 FIND v(dout0_212) AT=245.025n

.meas tran vdout0_213ck480 FIND v(dout0_213) AT=245.025n

.meas tran vdout0_214ck480 FIND v(dout0_214) AT=245.025n

.meas tran vdout0_215ck480 FIND v(dout0_215) AT=245.025n

.meas tran vdout0_216ck480 FIND v(dout0_216) AT=245.025n

.meas tran vdout0_217ck480 FIND v(dout0_217) AT=245.025n

.meas tran vdout0_218ck480 FIND v(dout0_218) AT=245.025n

.meas tran vdout0_219ck480 FIND v(dout0_219) AT=245.025n

.meas tran vdout0_220ck480 FIND v(dout0_220) AT=245.025n

.meas tran vdout0_221ck480 FIND v(dout0_221) AT=245.025n

.meas tran vdout0_222ck480 FIND v(dout0_222) AT=245.025n

.meas tran vdout0_223ck480 FIND v(dout0_223) AT=245.025n

.meas tran vdout0_224ck480 FIND v(dout0_224) AT=245.025n

.meas tran vdout0_225ck480 FIND v(dout0_225) AT=245.025n

.meas tran vdout0_226ck480 FIND v(dout0_226) AT=245.025n

.meas tran vdout0_227ck480 FIND v(dout0_227) AT=245.025n

.meas tran vdout0_228ck480 FIND v(dout0_228) AT=245.025n

.meas tran vdout0_229ck480 FIND v(dout0_229) AT=245.025n

.meas tran vdout0_230ck480 FIND v(dout0_230) AT=245.025n

.meas tran vdout0_231ck480 FIND v(dout0_231) AT=245.025n

.meas tran vdout0_232ck480 FIND v(dout0_232) AT=245.025n

.meas tran vdout0_233ck480 FIND v(dout0_233) AT=245.025n

.meas tran vdout0_234ck480 FIND v(dout0_234) AT=245.025n

.meas tran vdout0_235ck480 FIND v(dout0_235) AT=245.025n

.meas tran vdout0_236ck480 FIND v(dout0_236) AT=245.025n

.meas tran vdout0_237ck480 FIND v(dout0_237) AT=245.025n

.meas tran vdout0_238ck480 FIND v(dout0_238) AT=245.025n

.meas tran vdout0_239ck480 FIND v(dout0_239) AT=245.025n

.meas tran vdout0_240ck480 FIND v(dout0_240) AT=245.025n

.meas tran vdout0_241ck480 FIND v(dout0_241) AT=245.025n

.meas tran vdout0_242ck480 FIND v(dout0_242) AT=245.025n

.meas tran vdout0_243ck480 FIND v(dout0_243) AT=245.025n

.meas tran vdout0_244ck480 FIND v(dout0_244) AT=245.025n

.meas tran vdout0_245ck480 FIND v(dout0_245) AT=245.025n

.meas tran vdout0_246ck480 FIND v(dout0_246) AT=245.025n

.meas tran vdout0_247ck480 FIND v(dout0_247) AT=245.025n

.meas tran vdout0_248ck480 FIND v(dout0_248) AT=245.025n

.meas tran vdout0_249ck480 FIND v(dout0_249) AT=245.025n

.meas tran vdout0_250ck480 FIND v(dout0_250) AT=245.025n

.meas tran vdout0_251ck480 FIND v(dout0_251) AT=245.025n

.meas tran vdout0_252ck480 FIND v(dout0_252) AT=245.025n

.meas tran vdout0_253ck480 FIND v(dout0_253) AT=245.025n

.meas tran vdout0_254ck480 FIND v(dout0_254) AT=245.025n

.meas tran vdout0_255ck480 FIND v(dout0_255) AT=245.025n

.meas tran vdout0_0ck520 FIND v(dout0_0) AT=265.025n

.meas tran vdout0_1ck520 FIND v(dout0_1) AT=265.025n

.meas tran vdout0_2ck520 FIND v(dout0_2) AT=265.025n

.meas tran vdout0_3ck520 FIND v(dout0_3) AT=265.025n

.meas tran vdout0_4ck520 FIND v(dout0_4) AT=265.025n

.meas tran vdout0_5ck520 FIND v(dout0_5) AT=265.025n

.meas tran vdout0_6ck520 FIND v(dout0_6) AT=265.025n

.meas tran vdout0_7ck520 FIND v(dout0_7) AT=265.025n

.meas tran vdout0_8ck520 FIND v(dout0_8) AT=265.025n

.meas tran vdout0_9ck520 FIND v(dout0_9) AT=265.025n

.meas tran vdout0_10ck520 FIND v(dout0_10) AT=265.025n

.meas tran vdout0_11ck520 FIND v(dout0_11) AT=265.025n

.meas tran vdout0_12ck520 FIND v(dout0_12) AT=265.025n

.meas tran vdout0_13ck520 FIND v(dout0_13) AT=265.025n

.meas tran vdout0_14ck520 FIND v(dout0_14) AT=265.025n

.meas tran vdout0_15ck520 FIND v(dout0_15) AT=265.025n

.meas tran vdout0_16ck520 FIND v(dout0_16) AT=265.025n

.meas tran vdout0_17ck520 FIND v(dout0_17) AT=265.025n

.meas tran vdout0_18ck520 FIND v(dout0_18) AT=265.025n

.meas tran vdout0_19ck520 FIND v(dout0_19) AT=265.025n

.meas tran vdout0_20ck520 FIND v(dout0_20) AT=265.025n

.meas tran vdout0_21ck520 FIND v(dout0_21) AT=265.025n

.meas tran vdout0_22ck520 FIND v(dout0_22) AT=265.025n

.meas tran vdout0_23ck520 FIND v(dout0_23) AT=265.025n

.meas tran vdout0_24ck520 FIND v(dout0_24) AT=265.025n

.meas tran vdout0_25ck520 FIND v(dout0_25) AT=265.025n

.meas tran vdout0_26ck520 FIND v(dout0_26) AT=265.025n

.meas tran vdout0_27ck520 FIND v(dout0_27) AT=265.025n

.meas tran vdout0_28ck520 FIND v(dout0_28) AT=265.025n

.meas tran vdout0_29ck520 FIND v(dout0_29) AT=265.025n

.meas tran vdout0_30ck520 FIND v(dout0_30) AT=265.025n

.meas tran vdout0_31ck520 FIND v(dout0_31) AT=265.025n

.meas tran vdout0_32ck520 FIND v(dout0_32) AT=265.025n

.meas tran vdout0_33ck520 FIND v(dout0_33) AT=265.025n

.meas tran vdout0_34ck520 FIND v(dout0_34) AT=265.025n

.meas tran vdout0_35ck520 FIND v(dout0_35) AT=265.025n

.meas tran vdout0_36ck520 FIND v(dout0_36) AT=265.025n

.meas tran vdout0_37ck520 FIND v(dout0_37) AT=265.025n

.meas tran vdout0_38ck520 FIND v(dout0_38) AT=265.025n

.meas tran vdout0_39ck520 FIND v(dout0_39) AT=265.025n

.meas tran vdout0_40ck520 FIND v(dout0_40) AT=265.025n

.meas tran vdout0_41ck520 FIND v(dout0_41) AT=265.025n

.meas tran vdout0_42ck520 FIND v(dout0_42) AT=265.025n

.meas tran vdout0_43ck520 FIND v(dout0_43) AT=265.025n

.meas tran vdout0_44ck520 FIND v(dout0_44) AT=265.025n

.meas tran vdout0_45ck520 FIND v(dout0_45) AT=265.025n

.meas tran vdout0_46ck520 FIND v(dout0_46) AT=265.025n

.meas tran vdout0_47ck520 FIND v(dout0_47) AT=265.025n

.meas tran vdout0_48ck520 FIND v(dout0_48) AT=265.025n

.meas tran vdout0_49ck520 FIND v(dout0_49) AT=265.025n

.meas tran vdout0_50ck520 FIND v(dout0_50) AT=265.025n

.meas tran vdout0_51ck520 FIND v(dout0_51) AT=265.025n

.meas tran vdout0_52ck520 FIND v(dout0_52) AT=265.025n

.meas tran vdout0_53ck520 FIND v(dout0_53) AT=265.025n

.meas tran vdout0_54ck520 FIND v(dout0_54) AT=265.025n

.meas tran vdout0_55ck520 FIND v(dout0_55) AT=265.025n

.meas tran vdout0_56ck520 FIND v(dout0_56) AT=265.025n

.meas tran vdout0_57ck520 FIND v(dout0_57) AT=265.025n

.meas tran vdout0_58ck520 FIND v(dout0_58) AT=265.025n

.meas tran vdout0_59ck520 FIND v(dout0_59) AT=265.025n

.meas tran vdout0_60ck520 FIND v(dout0_60) AT=265.025n

.meas tran vdout0_61ck520 FIND v(dout0_61) AT=265.025n

.meas tran vdout0_62ck520 FIND v(dout0_62) AT=265.025n

.meas tran vdout0_63ck520 FIND v(dout0_63) AT=265.025n

.meas tran vdout0_64ck520 FIND v(dout0_64) AT=265.025n

.meas tran vdout0_65ck520 FIND v(dout0_65) AT=265.025n

.meas tran vdout0_66ck520 FIND v(dout0_66) AT=265.025n

.meas tran vdout0_67ck520 FIND v(dout0_67) AT=265.025n

.meas tran vdout0_68ck520 FIND v(dout0_68) AT=265.025n

.meas tran vdout0_69ck520 FIND v(dout0_69) AT=265.025n

.meas tran vdout0_70ck520 FIND v(dout0_70) AT=265.025n

.meas tran vdout0_71ck520 FIND v(dout0_71) AT=265.025n

.meas tran vdout0_72ck520 FIND v(dout0_72) AT=265.025n

.meas tran vdout0_73ck520 FIND v(dout0_73) AT=265.025n

.meas tran vdout0_74ck520 FIND v(dout0_74) AT=265.025n

.meas tran vdout0_75ck520 FIND v(dout0_75) AT=265.025n

.meas tran vdout0_76ck520 FIND v(dout0_76) AT=265.025n

.meas tran vdout0_77ck520 FIND v(dout0_77) AT=265.025n

.meas tran vdout0_78ck520 FIND v(dout0_78) AT=265.025n

.meas tran vdout0_79ck520 FIND v(dout0_79) AT=265.025n

.meas tran vdout0_80ck520 FIND v(dout0_80) AT=265.025n

.meas tran vdout0_81ck520 FIND v(dout0_81) AT=265.025n

.meas tran vdout0_82ck520 FIND v(dout0_82) AT=265.025n

.meas tran vdout0_83ck520 FIND v(dout0_83) AT=265.025n

.meas tran vdout0_84ck520 FIND v(dout0_84) AT=265.025n

.meas tran vdout0_85ck520 FIND v(dout0_85) AT=265.025n

.meas tran vdout0_86ck520 FIND v(dout0_86) AT=265.025n

.meas tran vdout0_87ck520 FIND v(dout0_87) AT=265.025n

.meas tran vdout0_88ck520 FIND v(dout0_88) AT=265.025n

.meas tran vdout0_89ck520 FIND v(dout0_89) AT=265.025n

.meas tran vdout0_90ck520 FIND v(dout0_90) AT=265.025n

.meas tran vdout0_91ck520 FIND v(dout0_91) AT=265.025n

.meas tran vdout0_92ck520 FIND v(dout0_92) AT=265.025n

.meas tran vdout0_93ck520 FIND v(dout0_93) AT=265.025n

.meas tran vdout0_94ck520 FIND v(dout0_94) AT=265.025n

.meas tran vdout0_95ck520 FIND v(dout0_95) AT=265.025n

.meas tran vdout0_96ck520 FIND v(dout0_96) AT=265.025n

.meas tran vdout0_97ck520 FIND v(dout0_97) AT=265.025n

.meas tran vdout0_98ck520 FIND v(dout0_98) AT=265.025n

.meas tran vdout0_99ck520 FIND v(dout0_99) AT=265.025n

.meas tran vdout0_100ck520 FIND v(dout0_100) AT=265.025n

.meas tran vdout0_101ck520 FIND v(dout0_101) AT=265.025n

.meas tran vdout0_102ck520 FIND v(dout0_102) AT=265.025n

.meas tran vdout0_103ck520 FIND v(dout0_103) AT=265.025n

.meas tran vdout0_104ck520 FIND v(dout0_104) AT=265.025n

.meas tran vdout0_105ck520 FIND v(dout0_105) AT=265.025n

.meas tran vdout0_106ck520 FIND v(dout0_106) AT=265.025n

.meas tran vdout0_107ck520 FIND v(dout0_107) AT=265.025n

.meas tran vdout0_108ck520 FIND v(dout0_108) AT=265.025n

.meas tran vdout0_109ck520 FIND v(dout0_109) AT=265.025n

.meas tran vdout0_110ck520 FIND v(dout0_110) AT=265.025n

.meas tran vdout0_111ck520 FIND v(dout0_111) AT=265.025n

.meas tran vdout0_112ck520 FIND v(dout0_112) AT=265.025n

.meas tran vdout0_113ck520 FIND v(dout0_113) AT=265.025n

.meas tran vdout0_114ck520 FIND v(dout0_114) AT=265.025n

.meas tran vdout0_115ck520 FIND v(dout0_115) AT=265.025n

.meas tran vdout0_116ck520 FIND v(dout0_116) AT=265.025n

.meas tran vdout0_117ck520 FIND v(dout0_117) AT=265.025n

.meas tran vdout0_118ck520 FIND v(dout0_118) AT=265.025n

.meas tran vdout0_119ck520 FIND v(dout0_119) AT=265.025n

.meas tran vdout0_120ck520 FIND v(dout0_120) AT=265.025n

.meas tran vdout0_121ck520 FIND v(dout0_121) AT=265.025n

.meas tran vdout0_122ck520 FIND v(dout0_122) AT=265.025n

.meas tran vdout0_123ck520 FIND v(dout0_123) AT=265.025n

.meas tran vdout0_124ck520 FIND v(dout0_124) AT=265.025n

.meas tran vdout0_125ck520 FIND v(dout0_125) AT=265.025n

.meas tran vdout0_126ck520 FIND v(dout0_126) AT=265.025n

.meas tran vdout0_127ck520 FIND v(dout0_127) AT=265.025n

.meas tran vdout0_128ck520 FIND v(dout0_128) AT=265.025n

.meas tran vdout0_129ck520 FIND v(dout0_129) AT=265.025n

.meas tran vdout0_130ck520 FIND v(dout0_130) AT=265.025n

.meas tran vdout0_131ck520 FIND v(dout0_131) AT=265.025n

.meas tran vdout0_132ck520 FIND v(dout0_132) AT=265.025n

.meas tran vdout0_133ck520 FIND v(dout0_133) AT=265.025n

.meas tran vdout0_134ck520 FIND v(dout0_134) AT=265.025n

.meas tran vdout0_135ck520 FIND v(dout0_135) AT=265.025n

.meas tran vdout0_136ck520 FIND v(dout0_136) AT=265.025n

.meas tran vdout0_137ck520 FIND v(dout0_137) AT=265.025n

.meas tran vdout0_138ck520 FIND v(dout0_138) AT=265.025n

.meas tran vdout0_139ck520 FIND v(dout0_139) AT=265.025n

.meas tran vdout0_140ck520 FIND v(dout0_140) AT=265.025n

.meas tran vdout0_141ck520 FIND v(dout0_141) AT=265.025n

.meas tran vdout0_142ck520 FIND v(dout0_142) AT=265.025n

.meas tran vdout0_143ck520 FIND v(dout0_143) AT=265.025n

.meas tran vdout0_144ck520 FIND v(dout0_144) AT=265.025n

.meas tran vdout0_145ck520 FIND v(dout0_145) AT=265.025n

.meas tran vdout0_146ck520 FIND v(dout0_146) AT=265.025n

.meas tran vdout0_147ck520 FIND v(dout0_147) AT=265.025n

.meas tran vdout0_148ck520 FIND v(dout0_148) AT=265.025n

.meas tran vdout0_149ck520 FIND v(dout0_149) AT=265.025n

.meas tran vdout0_150ck520 FIND v(dout0_150) AT=265.025n

.meas tran vdout0_151ck520 FIND v(dout0_151) AT=265.025n

.meas tran vdout0_152ck520 FIND v(dout0_152) AT=265.025n

.meas tran vdout0_153ck520 FIND v(dout0_153) AT=265.025n

.meas tran vdout0_154ck520 FIND v(dout0_154) AT=265.025n

.meas tran vdout0_155ck520 FIND v(dout0_155) AT=265.025n

.meas tran vdout0_156ck520 FIND v(dout0_156) AT=265.025n

.meas tran vdout0_157ck520 FIND v(dout0_157) AT=265.025n

.meas tran vdout0_158ck520 FIND v(dout0_158) AT=265.025n

.meas tran vdout0_159ck520 FIND v(dout0_159) AT=265.025n

.meas tran vdout0_160ck520 FIND v(dout0_160) AT=265.025n

.meas tran vdout0_161ck520 FIND v(dout0_161) AT=265.025n

.meas tran vdout0_162ck520 FIND v(dout0_162) AT=265.025n

.meas tran vdout0_163ck520 FIND v(dout0_163) AT=265.025n

.meas tran vdout0_164ck520 FIND v(dout0_164) AT=265.025n

.meas tran vdout0_165ck520 FIND v(dout0_165) AT=265.025n

.meas tran vdout0_166ck520 FIND v(dout0_166) AT=265.025n

.meas tran vdout0_167ck520 FIND v(dout0_167) AT=265.025n

.meas tran vdout0_168ck520 FIND v(dout0_168) AT=265.025n

.meas tran vdout0_169ck520 FIND v(dout0_169) AT=265.025n

.meas tran vdout0_170ck520 FIND v(dout0_170) AT=265.025n

.meas tran vdout0_171ck520 FIND v(dout0_171) AT=265.025n

.meas tran vdout0_172ck520 FIND v(dout0_172) AT=265.025n

.meas tran vdout0_173ck520 FIND v(dout0_173) AT=265.025n

.meas tran vdout0_174ck520 FIND v(dout0_174) AT=265.025n

.meas tran vdout0_175ck520 FIND v(dout0_175) AT=265.025n

.meas tran vdout0_176ck520 FIND v(dout0_176) AT=265.025n

.meas tran vdout0_177ck520 FIND v(dout0_177) AT=265.025n

.meas tran vdout0_178ck520 FIND v(dout0_178) AT=265.025n

.meas tran vdout0_179ck520 FIND v(dout0_179) AT=265.025n

.meas tran vdout0_180ck520 FIND v(dout0_180) AT=265.025n

.meas tran vdout0_181ck520 FIND v(dout0_181) AT=265.025n

.meas tran vdout0_182ck520 FIND v(dout0_182) AT=265.025n

.meas tran vdout0_183ck520 FIND v(dout0_183) AT=265.025n

.meas tran vdout0_184ck520 FIND v(dout0_184) AT=265.025n

.meas tran vdout0_185ck520 FIND v(dout0_185) AT=265.025n

.meas tran vdout0_186ck520 FIND v(dout0_186) AT=265.025n

.meas tran vdout0_187ck520 FIND v(dout0_187) AT=265.025n

.meas tran vdout0_188ck520 FIND v(dout0_188) AT=265.025n

.meas tran vdout0_189ck520 FIND v(dout0_189) AT=265.025n

.meas tran vdout0_190ck520 FIND v(dout0_190) AT=265.025n

.meas tran vdout0_191ck520 FIND v(dout0_191) AT=265.025n

.meas tran vdout0_192ck520 FIND v(dout0_192) AT=265.025n

.meas tran vdout0_193ck520 FIND v(dout0_193) AT=265.025n

.meas tran vdout0_194ck520 FIND v(dout0_194) AT=265.025n

.meas tran vdout0_195ck520 FIND v(dout0_195) AT=265.025n

.meas tran vdout0_196ck520 FIND v(dout0_196) AT=265.025n

.meas tran vdout0_197ck520 FIND v(dout0_197) AT=265.025n

.meas tran vdout0_198ck520 FIND v(dout0_198) AT=265.025n

.meas tran vdout0_199ck520 FIND v(dout0_199) AT=265.025n

.meas tran vdout0_200ck520 FIND v(dout0_200) AT=265.025n

.meas tran vdout0_201ck520 FIND v(dout0_201) AT=265.025n

.meas tran vdout0_202ck520 FIND v(dout0_202) AT=265.025n

.meas tran vdout0_203ck520 FIND v(dout0_203) AT=265.025n

.meas tran vdout0_204ck520 FIND v(dout0_204) AT=265.025n

.meas tran vdout0_205ck520 FIND v(dout0_205) AT=265.025n

.meas tran vdout0_206ck520 FIND v(dout0_206) AT=265.025n

.meas tran vdout0_207ck520 FIND v(dout0_207) AT=265.025n

.meas tran vdout0_208ck520 FIND v(dout0_208) AT=265.025n

.meas tran vdout0_209ck520 FIND v(dout0_209) AT=265.025n

.meas tran vdout0_210ck520 FIND v(dout0_210) AT=265.025n

.meas tran vdout0_211ck520 FIND v(dout0_211) AT=265.025n

.meas tran vdout0_212ck520 FIND v(dout0_212) AT=265.025n

.meas tran vdout0_213ck520 FIND v(dout0_213) AT=265.025n

.meas tran vdout0_214ck520 FIND v(dout0_214) AT=265.025n

.meas tran vdout0_215ck520 FIND v(dout0_215) AT=265.025n

.meas tran vdout0_216ck520 FIND v(dout0_216) AT=265.025n

.meas tran vdout0_217ck520 FIND v(dout0_217) AT=265.025n

.meas tran vdout0_218ck520 FIND v(dout0_218) AT=265.025n

.meas tran vdout0_219ck520 FIND v(dout0_219) AT=265.025n

.meas tran vdout0_220ck520 FIND v(dout0_220) AT=265.025n

.meas tran vdout0_221ck520 FIND v(dout0_221) AT=265.025n

.meas tran vdout0_222ck520 FIND v(dout0_222) AT=265.025n

.meas tran vdout0_223ck520 FIND v(dout0_223) AT=265.025n

.meas tran vdout0_224ck520 FIND v(dout0_224) AT=265.025n

.meas tran vdout0_225ck520 FIND v(dout0_225) AT=265.025n

.meas tran vdout0_226ck520 FIND v(dout0_226) AT=265.025n

.meas tran vdout0_227ck520 FIND v(dout0_227) AT=265.025n

.meas tran vdout0_228ck520 FIND v(dout0_228) AT=265.025n

.meas tran vdout0_229ck520 FIND v(dout0_229) AT=265.025n

.meas tran vdout0_230ck520 FIND v(dout0_230) AT=265.025n

.meas tran vdout0_231ck520 FIND v(dout0_231) AT=265.025n

.meas tran vdout0_232ck520 FIND v(dout0_232) AT=265.025n

.meas tran vdout0_233ck520 FIND v(dout0_233) AT=265.025n

.meas tran vdout0_234ck520 FIND v(dout0_234) AT=265.025n

.meas tran vdout0_235ck520 FIND v(dout0_235) AT=265.025n

.meas tran vdout0_236ck520 FIND v(dout0_236) AT=265.025n

.meas tran vdout0_237ck520 FIND v(dout0_237) AT=265.025n

.meas tran vdout0_238ck520 FIND v(dout0_238) AT=265.025n

.meas tran vdout0_239ck520 FIND v(dout0_239) AT=265.025n

.meas tran vdout0_240ck520 FIND v(dout0_240) AT=265.025n

.meas tran vdout0_241ck520 FIND v(dout0_241) AT=265.025n

.meas tran vdout0_242ck520 FIND v(dout0_242) AT=265.025n

.meas tran vdout0_243ck520 FIND v(dout0_243) AT=265.025n

.meas tran vdout0_244ck520 FIND v(dout0_244) AT=265.025n

.meas tran vdout0_245ck520 FIND v(dout0_245) AT=265.025n

.meas tran vdout0_246ck520 FIND v(dout0_246) AT=265.025n

.meas tran vdout0_247ck520 FIND v(dout0_247) AT=265.025n

.meas tran vdout0_248ck520 FIND v(dout0_248) AT=265.025n

.meas tran vdout0_249ck520 FIND v(dout0_249) AT=265.025n

.meas tran vdout0_250ck520 FIND v(dout0_250) AT=265.025n

.meas tran vdout0_251ck520 FIND v(dout0_251) AT=265.025n

.meas tran vdout0_252ck520 FIND v(dout0_252) AT=265.025n

.meas tran vdout0_253ck520 FIND v(dout0_253) AT=265.025n

.meas tran vdout0_254ck520 FIND v(dout0_254) AT=265.025n

.meas tran vdout0_255ck520 FIND v(dout0_255) AT=265.025n

.meas tran vdout0_0ck570 FIND v(dout0_0) AT=290.025n

.meas tran vdout0_1ck570 FIND v(dout0_1) AT=290.025n

.meas tran vdout0_2ck570 FIND v(dout0_2) AT=290.025n

.meas tran vdout0_3ck570 FIND v(dout0_3) AT=290.025n

.meas tran vdout0_4ck570 FIND v(dout0_4) AT=290.025n

.meas tran vdout0_5ck570 FIND v(dout0_5) AT=290.025n

.meas tran vdout0_6ck570 FIND v(dout0_6) AT=290.025n

.meas tran vdout0_7ck570 FIND v(dout0_7) AT=290.025n

.meas tran vdout0_8ck570 FIND v(dout0_8) AT=290.025n

.meas tran vdout0_9ck570 FIND v(dout0_9) AT=290.025n

.meas tran vdout0_10ck570 FIND v(dout0_10) AT=290.025n

.meas tran vdout0_11ck570 FIND v(dout0_11) AT=290.025n

.meas tran vdout0_12ck570 FIND v(dout0_12) AT=290.025n

.meas tran vdout0_13ck570 FIND v(dout0_13) AT=290.025n

.meas tran vdout0_14ck570 FIND v(dout0_14) AT=290.025n

.meas tran vdout0_15ck570 FIND v(dout0_15) AT=290.025n

.meas tran vdout0_16ck570 FIND v(dout0_16) AT=290.025n

.meas tran vdout0_17ck570 FIND v(dout0_17) AT=290.025n

.meas tran vdout0_18ck570 FIND v(dout0_18) AT=290.025n

.meas tran vdout0_19ck570 FIND v(dout0_19) AT=290.025n

.meas tran vdout0_20ck570 FIND v(dout0_20) AT=290.025n

.meas tran vdout0_21ck570 FIND v(dout0_21) AT=290.025n

.meas tran vdout0_22ck570 FIND v(dout0_22) AT=290.025n

.meas tran vdout0_23ck570 FIND v(dout0_23) AT=290.025n

.meas tran vdout0_24ck570 FIND v(dout0_24) AT=290.025n

.meas tran vdout0_25ck570 FIND v(dout0_25) AT=290.025n

.meas tran vdout0_26ck570 FIND v(dout0_26) AT=290.025n

.meas tran vdout0_27ck570 FIND v(dout0_27) AT=290.025n

.meas tran vdout0_28ck570 FIND v(dout0_28) AT=290.025n

.meas tran vdout0_29ck570 FIND v(dout0_29) AT=290.025n

.meas tran vdout0_30ck570 FIND v(dout0_30) AT=290.025n

.meas tran vdout0_31ck570 FIND v(dout0_31) AT=290.025n

.meas tran vdout0_32ck570 FIND v(dout0_32) AT=290.025n

.meas tran vdout0_33ck570 FIND v(dout0_33) AT=290.025n

.meas tran vdout0_34ck570 FIND v(dout0_34) AT=290.025n

.meas tran vdout0_35ck570 FIND v(dout0_35) AT=290.025n

.meas tran vdout0_36ck570 FIND v(dout0_36) AT=290.025n

.meas tran vdout0_37ck570 FIND v(dout0_37) AT=290.025n

.meas tran vdout0_38ck570 FIND v(dout0_38) AT=290.025n

.meas tran vdout0_39ck570 FIND v(dout0_39) AT=290.025n

.meas tran vdout0_40ck570 FIND v(dout0_40) AT=290.025n

.meas tran vdout0_41ck570 FIND v(dout0_41) AT=290.025n

.meas tran vdout0_42ck570 FIND v(dout0_42) AT=290.025n

.meas tran vdout0_43ck570 FIND v(dout0_43) AT=290.025n

.meas tran vdout0_44ck570 FIND v(dout0_44) AT=290.025n

.meas tran vdout0_45ck570 FIND v(dout0_45) AT=290.025n

.meas tran vdout0_46ck570 FIND v(dout0_46) AT=290.025n

.meas tran vdout0_47ck570 FIND v(dout0_47) AT=290.025n

.meas tran vdout0_48ck570 FIND v(dout0_48) AT=290.025n

.meas tran vdout0_49ck570 FIND v(dout0_49) AT=290.025n

.meas tran vdout0_50ck570 FIND v(dout0_50) AT=290.025n

.meas tran vdout0_51ck570 FIND v(dout0_51) AT=290.025n

.meas tran vdout0_52ck570 FIND v(dout0_52) AT=290.025n

.meas tran vdout0_53ck570 FIND v(dout0_53) AT=290.025n

.meas tran vdout0_54ck570 FIND v(dout0_54) AT=290.025n

.meas tran vdout0_55ck570 FIND v(dout0_55) AT=290.025n

.meas tran vdout0_56ck570 FIND v(dout0_56) AT=290.025n

.meas tran vdout0_57ck570 FIND v(dout0_57) AT=290.025n

.meas tran vdout0_58ck570 FIND v(dout0_58) AT=290.025n

.meas tran vdout0_59ck570 FIND v(dout0_59) AT=290.025n

.meas tran vdout0_60ck570 FIND v(dout0_60) AT=290.025n

.meas tran vdout0_61ck570 FIND v(dout0_61) AT=290.025n

.meas tran vdout0_62ck570 FIND v(dout0_62) AT=290.025n

.meas tran vdout0_63ck570 FIND v(dout0_63) AT=290.025n

.meas tran vdout0_64ck570 FIND v(dout0_64) AT=290.025n

.meas tran vdout0_65ck570 FIND v(dout0_65) AT=290.025n

.meas tran vdout0_66ck570 FIND v(dout0_66) AT=290.025n

.meas tran vdout0_67ck570 FIND v(dout0_67) AT=290.025n

.meas tran vdout0_68ck570 FIND v(dout0_68) AT=290.025n

.meas tran vdout0_69ck570 FIND v(dout0_69) AT=290.025n

.meas tran vdout0_70ck570 FIND v(dout0_70) AT=290.025n

.meas tran vdout0_71ck570 FIND v(dout0_71) AT=290.025n

.meas tran vdout0_72ck570 FIND v(dout0_72) AT=290.025n

.meas tran vdout0_73ck570 FIND v(dout0_73) AT=290.025n

.meas tran vdout0_74ck570 FIND v(dout0_74) AT=290.025n

.meas tran vdout0_75ck570 FIND v(dout0_75) AT=290.025n

.meas tran vdout0_76ck570 FIND v(dout0_76) AT=290.025n

.meas tran vdout0_77ck570 FIND v(dout0_77) AT=290.025n

.meas tran vdout0_78ck570 FIND v(dout0_78) AT=290.025n

.meas tran vdout0_79ck570 FIND v(dout0_79) AT=290.025n

.meas tran vdout0_80ck570 FIND v(dout0_80) AT=290.025n

.meas tran vdout0_81ck570 FIND v(dout0_81) AT=290.025n

.meas tran vdout0_82ck570 FIND v(dout0_82) AT=290.025n

.meas tran vdout0_83ck570 FIND v(dout0_83) AT=290.025n

.meas tran vdout0_84ck570 FIND v(dout0_84) AT=290.025n

.meas tran vdout0_85ck570 FIND v(dout0_85) AT=290.025n

.meas tran vdout0_86ck570 FIND v(dout0_86) AT=290.025n

.meas tran vdout0_87ck570 FIND v(dout0_87) AT=290.025n

.meas tran vdout0_88ck570 FIND v(dout0_88) AT=290.025n

.meas tran vdout0_89ck570 FIND v(dout0_89) AT=290.025n

.meas tran vdout0_90ck570 FIND v(dout0_90) AT=290.025n

.meas tran vdout0_91ck570 FIND v(dout0_91) AT=290.025n

.meas tran vdout0_92ck570 FIND v(dout0_92) AT=290.025n

.meas tran vdout0_93ck570 FIND v(dout0_93) AT=290.025n

.meas tran vdout0_94ck570 FIND v(dout0_94) AT=290.025n

.meas tran vdout0_95ck570 FIND v(dout0_95) AT=290.025n

.meas tran vdout0_96ck570 FIND v(dout0_96) AT=290.025n

.meas tran vdout0_97ck570 FIND v(dout0_97) AT=290.025n

.meas tran vdout0_98ck570 FIND v(dout0_98) AT=290.025n

.meas tran vdout0_99ck570 FIND v(dout0_99) AT=290.025n

.meas tran vdout0_100ck570 FIND v(dout0_100) AT=290.025n

.meas tran vdout0_101ck570 FIND v(dout0_101) AT=290.025n

.meas tran vdout0_102ck570 FIND v(dout0_102) AT=290.025n

.meas tran vdout0_103ck570 FIND v(dout0_103) AT=290.025n

.meas tran vdout0_104ck570 FIND v(dout0_104) AT=290.025n

.meas tran vdout0_105ck570 FIND v(dout0_105) AT=290.025n

.meas tran vdout0_106ck570 FIND v(dout0_106) AT=290.025n

.meas tran vdout0_107ck570 FIND v(dout0_107) AT=290.025n

.meas tran vdout0_108ck570 FIND v(dout0_108) AT=290.025n

.meas tran vdout0_109ck570 FIND v(dout0_109) AT=290.025n

.meas tran vdout0_110ck570 FIND v(dout0_110) AT=290.025n

.meas tran vdout0_111ck570 FIND v(dout0_111) AT=290.025n

.meas tran vdout0_112ck570 FIND v(dout0_112) AT=290.025n

.meas tran vdout0_113ck570 FIND v(dout0_113) AT=290.025n

.meas tran vdout0_114ck570 FIND v(dout0_114) AT=290.025n

.meas tran vdout0_115ck570 FIND v(dout0_115) AT=290.025n

.meas tran vdout0_116ck570 FIND v(dout0_116) AT=290.025n

.meas tran vdout0_117ck570 FIND v(dout0_117) AT=290.025n

.meas tran vdout0_118ck570 FIND v(dout0_118) AT=290.025n

.meas tran vdout0_119ck570 FIND v(dout0_119) AT=290.025n

.meas tran vdout0_120ck570 FIND v(dout0_120) AT=290.025n

.meas tran vdout0_121ck570 FIND v(dout0_121) AT=290.025n

.meas tran vdout0_122ck570 FIND v(dout0_122) AT=290.025n

.meas tran vdout0_123ck570 FIND v(dout0_123) AT=290.025n

.meas tran vdout0_124ck570 FIND v(dout0_124) AT=290.025n

.meas tran vdout0_125ck570 FIND v(dout0_125) AT=290.025n

.meas tran vdout0_126ck570 FIND v(dout0_126) AT=290.025n

.meas tran vdout0_127ck570 FIND v(dout0_127) AT=290.025n

.meas tran vdout0_128ck570 FIND v(dout0_128) AT=290.025n

.meas tran vdout0_129ck570 FIND v(dout0_129) AT=290.025n

.meas tran vdout0_130ck570 FIND v(dout0_130) AT=290.025n

.meas tran vdout0_131ck570 FIND v(dout0_131) AT=290.025n

.meas tran vdout0_132ck570 FIND v(dout0_132) AT=290.025n

.meas tran vdout0_133ck570 FIND v(dout0_133) AT=290.025n

.meas tran vdout0_134ck570 FIND v(dout0_134) AT=290.025n

.meas tran vdout0_135ck570 FIND v(dout0_135) AT=290.025n

.meas tran vdout0_136ck570 FIND v(dout0_136) AT=290.025n

.meas tran vdout0_137ck570 FIND v(dout0_137) AT=290.025n

.meas tran vdout0_138ck570 FIND v(dout0_138) AT=290.025n

.meas tran vdout0_139ck570 FIND v(dout0_139) AT=290.025n

.meas tran vdout0_140ck570 FIND v(dout0_140) AT=290.025n

.meas tran vdout0_141ck570 FIND v(dout0_141) AT=290.025n

.meas tran vdout0_142ck570 FIND v(dout0_142) AT=290.025n

.meas tran vdout0_143ck570 FIND v(dout0_143) AT=290.025n

.meas tran vdout0_144ck570 FIND v(dout0_144) AT=290.025n

.meas tran vdout0_145ck570 FIND v(dout0_145) AT=290.025n

.meas tran vdout0_146ck570 FIND v(dout0_146) AT=290.025n

.meas tran vdout0_147ck570 FIND v(dout0_147) AT=290.025n

.meas tran vdout0_148ck570 FIND v(dout0_148) AT=290.025n

.meas tran vdout0_149ck570 FIND v(dout0_149) AT=290.025n

.meas tran vdout0_150ck570 FIND v(dout0_150) AT=290.025n

.meas tran vdout0_151ck570 FIND v(dout0_151) AT=290.025n

.meas tran vdout0_152ck570 FIND v(dout0_152) AT=290.025n

.meas tran vdout0_153ck570 FIND v(dout0_153) AT=290.025n

.meas tran vdout0_154ck570 FIND v(dout0_154) AT=290.025n

.meas tran vdout0_155ck570 FIND v(dout0_155) AT=290.025n

.meas tran vdout0_156ck570 FIND v(dout0_156) AT=290.025n

.meas tran vdout0_157ck570 FIND v(dout0_157) AT=290.025n

.meas tran vdout0_158ck570 FIND v(dout0_158) AT=290.025n

.meas tran vdout0_159ck570 FIND v(dout0_159) AT=290.025n

.meas tran vdout0_160ck570 FIND v(dout0_160) AT=290.025n

.meas tran vdout0_161ck570 FIND v(dout0_161) AT=290.025n

.meas tran vdout0_162ck570 FIND v(dout0_162) AT=290.025n

.meas tran vdout0_163ck570 FIND v(dout0_163) AT=290.025n

.meas tran vdout0_164ck570 FIND v(dout0_164) AT=290.025n

.meas tran vdout0_165ck570 FIND v(dout0_165) AT=290.025n

.meas tran vdout0_166ck570 FIND v(dout0_166) AT=290.025n

.meas tran vdout0_167ck570 FIND v(dout0_167) AT=290.025n

.meas tran vdout0_168ck570 FIND v(dout0_168) AT=290.025n

.meas tran vdout0_169ck570 FIND v(dout0_169) AT=290.025n

.meas tran vdout0_170ck570 FIND v(dout0_170) AT=290.025n

.meas tran vdout0_171ck570 FIND v(dout0_171) AT=290.025n

.meas tran vdout0_172ck570 FIND v(dout0_172) AT=290.025n

.meas tran vdout0_173ck570 FIND v(dout0_173) AT=290.025n

.meas tran vdout0_174ck570 FIND v(dout0_174) AT=290.025n

.meas tran vdout0_175ck570 FIND v(dout0_175) AT=290.025n

.meas tran vdout0_176ck570 FIND v(dout0_176) AT=290.025n

.meas tran vdout0_177ck570 FIND v(dout0_177) AT=290.025n

.meas tran vdout0_178ck570 FIND v(dout0_178) AT=290.025n

.meas tran vdout0_179ck570 FIND v(dout0_179) AT=290.025n

.meas tran vdout0_180ck570 FIND v(dout0_180) AT=290.025n

.meas tran vdout0_181ck570 FIND v(dout0_181) AT=290.025n

.meas tran vdout0_182ck570 FIND v(dout0_182) AT=290.025n

.meas tran vdout0_183ck570 FIND v(dout0_183) AT=290.025n

.meas tran vdout0_184ck570 FIND v(dout0_184) AT=290.025n

.meas tran vdout0_185ck570 FIND v(dout0_185) AT=290.025n

.meas tran vdout0_186ck570 FIND v(dout0_186) AT=290.025n

.meas tran vdout0_187ck570 FIND v(dout0_187) AT=290.025n

.meas tran vdout0_188ck570 FIND v(dout0_188) AT=290.025n

.meas tran vdout0_189ck570 FIND v(dout0_189) AT=290.025n

.meas tran vdout0_190ck570 FIND v(dout0_190) AT=290.025n

.meas tran vdout0_191ck570 FIND v(dout0_191) AT=290.025n

.meas tran vdout0_192ck570 FIND v(dout0_192) AT=290.025n

.meas tran vdout0_193ck570 FIND v(dout0_193) AT=290.025n

.meas tran vdout0_194ck570 FIND v(dout0_194) AT=290.025n

.meas tran vdout0_195ck570 FIND v(dout0_195) AT=290.025n

.meas tran vdout0_196ck570 FIND v(dout0_196) AT=290.025n

.meas tran vdout0_197ck570 FIND v(dout0_197) AT=290.025n

.meas tran vdout0_198ck570 FIND v(dout0_198) AT=290.025n

.meas tran vdout0_199ck570 FIND v(dout0_199) AT=290.025n

.meas tran vdout0_200ck570 FIND v(dout0_200) AT=290.025n

.meas tran vdout0_201ck570 FIND v(dout0_201) AT=290.025n

.meas tran vdout0_202ck570 FIND v(dout0_202) AT=290.025n

.meas tran vdout0_203ck570 FIND v(dout0_203) AT=290.025n

.meas tran vdout0_204ck570 FIND v(dout0_204) AT=290.025n

.meas tran vdout0_205ck570 FIND v(dout0_205) AT=290.025n

.meas tran vdout0_206ck570 FIND v(dout0_206) AT=290.025n

.meas tran vdout0_207ck570 FIND v(dout0_207) AT=290.025n

.meas tran vdout0_208ck570 FIND v(dout0_208) AT=290.025n

.meas tran vdout0_209ck570 FIND v(dout0_209) AT=290.025n

.meas tran vdout0_210ck570 FIND v(dout0_210) AT=290.025n

.meas tran vdout0_211ck570 FIND v(dout0_211) AT=290.025n

.meas tran vdout0_212ck570 FIND v(dout0_212) AT=290.025n

.meas tran vdout0_213ck570 FIND v(dout0_213) AT=290.025n

.meas tran vdout0_214ck570 FIND v(dout0_214) AT=290.025n

.meas tran vdout0_215ck570 FIND v(dout0_215) AT=290.025n

.meas tran vdout0_216ck570 FIND v(dout0_216) AT=290.025n

.meas tran vdout0_217ck570 FIND v(dout0_217) AT=290.025n

.meas tran vdout0_218ck570 FIND v(dout0_218) AT=290.025n

.meas tran vdout0_219ck570 FIND v(dout0_219) AT=290.025n

.meas tran vdout0_220ck570 FIND v(dout0_220) AT=290.025n

.meas tran vdout0_221ck570 FIND v(dout0_221) AT=290.025n

.meas tran vdout0_222ck570 FIND v(dout0_222) AT=290.025n

.meas tran vdout0_223ck570 FIND v(dout0_223) AT=290.025n

.meas tran vdout0_224ck570 FIND v(dout0_224) AT=290.025n

.meas tran vdout0_225ck570 FIND v(dout0_225) AT=290.025n

.meas tran vdout0_226ck570 FIND v(dout0_226) AT=290.025n

.meas tran vdout0_227ck570 FIND v(dout0_227) AT=290.025n

.meas tran vdout0_228ck570 FIND v(dout0_228) AT=290.025n

.meas tran vdout0_229ck570 FIND v(dout0_229) AT=290.025n

.meas tran vdout0_230ck570 FIND v(dout0_230) AT=290.025n

.meas tran vdout0_231ck570 FIND v(dout0_231) AT=290.025n

.meas tran vdout0_232ck570 FIND v(dout0_232) AT=290.025n

.meas tran vdout0_233ck570 FIND v(dout0_233) AT=290.025n

.meas tran vdout0_234ck570 FIND v(dout0_234) AT=290.025n

.meas tran vdout0_235ck570 FIND v(dout0_235) AT=290.025n

.meas tran vdout0_236ck570 FIND v(dout0_236) AT=290.025n

.meas tran vdout0_237ck570 FIND v(dout0_237) AT=290.025n

.meas tran vdout0_238ck570 FIND v(dout0_238) AT=290.025n

.meas tran vdout0_239ck570 FIND v(dout0_239) AT=290.025n

.meas tran vdout0_240ck570 FIND v(dout0_240) AT=290.025n

.meas tran vdout0_241ck570 FIND v(dout0_241) AT=290.025n

.meas tran vdout0_242ck570 FIND v(dout0_242) AT=290.025n

.meas tran vdout0_243ck570 FIND v(dout0_243) AT=290.025n

.meas tran vdout0_244ck570 FIND v(dout0_244) AT=290.025n

.meas tran vdout0_245ck570 FIND v(dout0_245) AT=290.025n

.meas tran vdout0_246ck570 FIND v(dout0_246) AT=290.025n

.meas tran vdout0_247ck570 FIND v(dout0_247) AT=290.025n

.meas tran vdout0_248ck570 FIND v(dout0_248) AT=290.025n

.meas tran vdout0_249ck570 FIND v(dout0_249) AT=290.025n

.meas tran vdout0_250ck570 FIND v(dout0_250) AT=290.025n

.meas tran vdout0_251ck570 FIND v(dout0_251) AT=290.025n

.meas tran vdout0_252ck570 FIND v(dout0_252) AT=290.025n

.meas tran vdout0_253ck570 FIND v(dout0_253) AT=290.025n

.meas tran vdout0_254ck570 FIND v(dout0_254) AT=290.025n

.meas tran vdout0_255ck570 FIND v(dout0_255) AT=290.025n

.meas tran vdout0_0ck580 FIND v(dout0_0) AT=295.025n

.meas tran vdout0_1ck580 FIND v(dout0_1) AT=295.025n

.meas tran vdout0_2ck580 FIND v(dout0_2) AT=295.025n

.meas tran vdout0_3ck580 FIND v(dout0_3) AT=295.025n

.meas tran vdout0_4ck580 FIND v(dout0_4) AT=295.025n

.meas tran vdout0_5ck580 FIND v(dout0_5) AT=295.025n

.meas tran vdout0_6ck580 FIND v(dout0_6) AT=295.025n

.meas tran vdout0_7ck580 FIND v(dout0_7) AT=295.025n

.meas tran vdout0_8ck580 FIND v(dout0_8) AT=295.025n

.meas tran vdout0_9ck580 FIND v(dout0_9) AT=295.025n

.meas tran vdout0_10ck580 FIND v(dout0_10) AT=295.025n

.meas tran vdout0_11ck580 FIND v(dout0_11) AT=295.025n

.meas tran vdout0_12ck580 FIND v(dout0_12) AT=295.025n

.meas tran vdout0_13ck580 FIND v(dout0_13) AT=295.025n

.meas tran vdout0_14ck580 FIND v(dout0_14) AT=295.025n

.meas tran vdout0_15ck580 FIND v(dout0_15) AT=295.025n

.meas tran vdout0_16ck580 FIND v(dout0_16) AT=295.025n

.meas tran vdout0_17ck580 FIND v(dout0_17) AT=295.025n

.meas tran vdout0_18ck580 FIND v(dout0_18) AT=295.025n

.meas tran vdout0_19ck580 FIND v(dout0_19) AT=295.025n

.meas tran vdout0_20ck580 FIND v(dout0_20) AT=295.025n

.meas tran vdout0_21ck580 FIND v(dout0_21) AT=295.025n

.meas tran vdout0_22ck580 FIND v(dout0_22) AT=295.025n

.meas tran vdout0_23ck580 FIND v(dout0_23) AT=295.025n

.meas tran vdout0_24ck580 FIND v(dout0_24) AT=295.025n

.meas tran vdout0_25ck580 FIND v(dout0_25) AT=295.025n

.meas tran vdout0_26ck580 FIND v(dout0_26) AT=295.025n

.meas tran vdout0_27ck580 FIND v(dout0_27) AT=295.025n

.meas tran vdout0_28ck580 FIND v(dout0_28) AT=295.025n

.meas tran vdout0_29ck580 FIND v(dout0_29) AT=295.025n

.meas tran vdout0_30ck580 FIND v(dout0_30) AT=295.025n

.meas tran vdout0_31ck580 FIND v(dout0_31) AT=295.025n

.meas tran vdout0_32ck580 FIND v(dout0_32) AT=295.025n

.meas tran vdout0_33ck580 FIND v(dout0_33) AT=295.025n

.meas tran vdout0_34ck580 FIND v(dout0_34) AT=295.025n

.meas tran vdout0_35ck580 FIND v(dout0_35) AT=295.025n

.meas tran vdout0_36ck580 FIND v(dout0_36) AT=295.025n

.meas tran vdout0_37ck580 FIND v(dout0_37) AT=295.025n

.meas tran vdout0_38ck580 FIND v(dout0_38) AT=295.025n

.meas tran vdout0_39ck580 FIND v(dout0_39) AT=295.025n

.meas tran vdout0_40ck580 FIND v(dout0_40) AT=295.025n

.meas tran vdout0_41ck580 FIND v(dout0_41) AT=295.025n

.meas tran vdout0_42ck580 FIND v(dout0_42) AT=295.025n

.meas tran vdout0_43ck580 FIND v(dout0_43) AT=295.025n

.meas tran vdout0_44ck580 FIND v(dout0_44) AT=295.025n

.meas tran vdout0_45ck580 FIND v(dout0_45) AT=295.025n

.meas tran vdout0_46ck580 FIND v(dout0_46) AT=295.025n

.meas tran vdout0_47ck580 FIND v(dout0_47) AT=295.025n

.meas tran vdout0_48ck580 FIND v(dout0_48) AT=295.025n

.meas tran vdout0_49ck580 FIND v(dout0_49) AT=295.025n

.meas tran vdout0_50ck580 FIND v(dout0_50) AT=295.025n

.meas tran vdout0_51ck580 FIND v(dout0_51) AT=295.025n

.meas tran vdout0_52ck580 FIND v(dout0_52) AT=295.025n

.meas tran vdout0_53ck580 FIND v(dout0_53) AT=295.025n

.meas tran vdout0_54ck580 FIND v(dout0_54) AT=295.025n

.meas tran vdout0_55ck580 FIND v(dout0_55) AT=295.025n

.meas tran vdout0_56ck580 FIND v(dout0_56) AT=295.025n

.meas tran vdout0_57ck580 FIND v(dout0_57) AT=295.025n

.meas tran vdout0_58ck580 FIND v(dout0_58) AT=295.025n

.meas tran vdout0_59ck580 FIND v(dout0_59) AT=295.025n

.meas tran vdout0_60ck580 FIND v(dout0_60) AT=295.025n

.meas tran vdout0_61ck580 FIND v(dout0_61) AT=295.025n

.meas tran vdout0_62ck580 FIND v(dout0_62) AT=295.025n

.meas tran vdout0_63ck580 FIND v(dout0_63) AT=295.025n

.meas tran vdout0_64ck580 FIND v(dout0_64) AT=295.025n

.meas tran vdout0_65ck580 FIND v(dout0_65) AT=295.025n

.meas tran vdout0_66ck580 FIND v(dout0_66) AT=295.025n

.meas tran vdout0_67ck580 FIND v(dout0_67) AT=295.025n

.meas tran vdout0_68ck580 FIND v(dout0_68) AT=295.025n

.meas tran vdout0_69ck580 FIND v(dout0_69) AT=295.025n

.meas tran vdout0_70ck580 FIND v(dout0_70) AT=295.025n

.meas tran vdout0_71ck580 FIND v(dout0_71) AT=295.025n

.meas tran vdout0_72ck580 FIND v(dout0_72) AT=295.025n

.meas tran vdout0_73ck580 FIND v(dout0_73) AT=295.025n

.meas tran vdout0_74ck580 FIND v(dout0_74) AT=295.025n

.meas tran vdout0_75ck580 FIND v(dout0_75) AT=295.025n

.meas tran vdout0_76ck580 FIND v(dout0_76) AT=295.025n

.meas tran vdout0_77ck580 FIND v(dout0_77) AT=295.025n

.meas tran vdout0_78ck580 FIND v(dout0_78) AT=295.025n

.meas tran vdout0_79ck580 FIND v(dout0_79) AT=295.025n

.meas tran vdout0_80ck580 FIND v(dout0_80) AT=295.025n

.meas tran vdout0_81ck580 FIND v(dout0_81) AT=295.025n

.meas tran vdout0_82ck580 FIND v(dout0_82) AT=295.025n

.meas tran vdout0_83ck580 FIND v(dout0_83) AT=295.025n

.meas tran vdout0_84ck580 FIND v(dout0_84) AT=295.025n

.meas tran vdout0_85ck580 FIND v(dout0_85) AT=295.025n

.meas tran vdout0_86ck580 FIND v(dout0_86) AT=295.025n

.meas tran vdout0_87ck580 FIND v(dout0_87) AT=295.025n

.meas tran vdout0_88ck580 FIND v(dout0_88) AT=295.025n

.meas tran vdout0_89ck580 FIND v(dout0_89) AT=295.025n

.meas tran vdout0_90ck580 FIND v(dout0_90) AT=295.025n

.meas tran vdout0_91ck580 FIND v(dout0_91) AT=295.025n

.meas tran vdout0_92ck580 FIND v(dout0_92) AT=295.025n

.meas tran vdout0_93ck580 FIND v(dout0_93) AT=295.025n

.meas tran vdout0_94ck580 FIND v(dout0_94) AT=295.025n

.meas tran vdout0_95ck580 FIND v(dout0_95) AT=295.025n

.meas tran vdout0_96ck580 FIND v(dout0_96) AT=295.025n

.meas tran vdout0_97ck580 FIND v(dout0_97) AT=295.025n

.meas tran vdout0_98ck580 FIND v(dout0_98) AT=295.025n

.meas tran vdout0_99ck580 FIND v(dout0_99) AT=295.025n

.meas tran vdout0_100ck580 FIND v(dout0_100) AT=295.025n

.meas tran vdout0_101ck580 FIND v(dout0_101) AT=295.025n

.meas tran vdout0_102ck580 FIND v(dout0_102) AT=295.025n

.meas tran vdout0_103ck580 FIND v(dout0_103) AT=295.025n

.meas tran vdout0_104ck580 FIND v(dout0_104) AT=295.025n

.meas tran vdout0_105ck580 FIND v(dout0_105) AT=295.025n

.meas tran vdout0_106ck580 FIND v(dout0_106) AT=295.025n

.meas tran vdout0_107ck580 FIND v(dout0_107) AT=295.025n

.meas tran vdout0_108ck580 FIND v(dout0_108) AT=295.025n

.meas tran vdout0_109ck580 FIND v(dout0_109) AT=295.025n

.meas tran vdout0_110ck580 FIND v(dout0_110) AT=295.025n

.meas tran vdout0_111ck580 FIND v(dout0_111) AT=295.025n

.meas tran vdout0_112ck580 FIND v(dout0_112) AT=295.025n

.meas tran vdout0_113ck580 FIND v(dout0_113) AT=295.025n

.meas tran vdout0_114ck580 FIND v(dout0_114) AT=295.025n

.meas tran vdout0_115ck580 FIND v(dout0_115) AT=295.025n

.meas tran vdout0_116ck580 FIND v(dout0_116) AT=295.025n

.meas tran vdout0_117ck580 FIND v(dout0_117) AT=295.025n

.meas tran vdout0_118ck580 FIND v(dout0_118) AT=295.025n

.meas tran vdout0_119ck580 FIND v(dout0_119) AT=295.025n

.meas tran vdout0_120ck580 FIND v(dout0_120) AT=295.025n

.meas tran vdout0_121ck580 FIND v(dout0_121) AT=295.025n

.meas tran vdout0_122ck580 FIND v(dout0_122) AT=295.025n

.meas tran vdout0_123ck580 FIND v(dout0_123) AT=295.025n

.meas tran vdout0_124ck580 FIND v(dout0_124) AT=295.025n

.meas tran vdout0_125ck580 FIND v(dout0_125) AT=295.025n

.meas tran vdout0_126ck580 FIND v(dout0_126) AT=295.025n

.meas tran vdout0_127ck580 FIND v(dout0_127) AT=295.025n

.meas tran vdout0_128ck580 FIND v(dout0_128) AT=295.025n

.meas tran vdout0_129ck580 FIND v(dout0_129) AT=295.025n

.meas tran vdout0_130ck580 FIND v(dout0_130) AT=295.025n

.meas tran vdout0_131ck580 FIND v(dout0_131) AT=295.025n

.meas tran vdout0_132ck580 FIND v(dout0_132) AT=295.025n

.meas tran vdout0_133ck580 FIND v(dout0_133) AT=295.025n

.meas tran vdout0_134ck580 FIND v(dout0_134) AT=295.025n

.meas tran vdout0_135ck580 FIND v(dout0_135) AT=295.025n

.meas tran vdout0_136ck580 FIND v(dout0_136) AT=295.025n

.meas tran vdout0_137ck580 FIND v(dout0_137) AT=295.025n

.meas tran vdout0_138ck580 FIND v(dout0_138) AT=295.025n

.meas tran vdout0_139ck580 FIND v(dout0_139) AT=295.025n

.meas tran vdout0_140ck580 FIND v(dout0_140) AT=295.025n

.meas tran vdout0_141ck580 FIND v(dout0_141) AT=295.025n

.meas tran vdout0_142ck580 FIND v(dout0_142) AT=295.025n

.meas tran vdout0_143ck580 FIND v(dout0_143) AT=295.025n

.meas tran vdout0_144ck580 FIND v(dout0_144) AT=295.025n

.meas tran vdout0_145ck580 FIND v(dout0_145) AT=295.025n

.meas tran vdout0_146ck580 FIND v(dout0_146) AT=295.025n

.meas tran vdout0_147ck580 FIND v(dout0_147) AT=295.025n

.meas tran vdout0_148ck580 FIND v(dout0_148) AT=295.025n

.meas tran vdout0_149ck580 FIND v(dout0_149) AT=295.025n

.meas tran vdout0_150ck580 FIND v(dout0_150) AT=295.025n

.meas tran vdout0_151ck580 FIND v(dout0_151) AT=295.025n

.meas tran vdout0_152ck580 FIND v(dout0_152) AT=295.025n

.meas tran vdout0_153ck580 FIND v(dout0_153) AT=295.025n

.meas tran vdout0_154ck580 FIND v(dout0_154) AT=295.025n

.meas tran vdout0_155ck580 FIND v(dout0_155) AT=295.025n

.meas tran vdout0_156ck580 FIND v(dout0_156) AT=295.025n

.meas tran vdout0_157ck580 FIND v(dout0_157) AT=295.025n

.meas tran vdout0_158ck580 FIND v(dout0_158) AT=295.025n

.meas tran vdout0_159ck580 FIND v(dout0_159) AT=295.025n

.meas tran vdout0_160ck580 FIND v(dout0_160) AT=295.025n

.meas tran vdout0_161ck580 FIND v(dout0_161) AT=295.025n

.meas tran vdout0_162ck580 FIND v(dout0_162) AT=295.025n

.meas tran vdout0_163ck580 FIND v(dout0_163) AT=295.025n

.meas tran vdout0_164ck580 FIND v(dout0_164) AT=295.025n

.meas tran vdout0_165ck580 FIND v(dout0_165) AT=295.025n

.meas tran vdout0_166ck580 FIND v(dout0_166) AT=295.025n

.meas tran vdout0_167ck580 FIND v(dout0_167) AT=295.025n

.meas tran vdout0_168ck580 FIND v(dout0_168) AT=295.025n

.meas tran vdout0_169ck580 FIND v(dout0_169) AT=295.025n

.meas tran vdout0_170ck580 FIND v(dout0_170) AT=295.025n

.meas tran vdout0_171ck580 FIND v(dout0_171) AT=295.025n

.meas tran vdout0_172ck580 FIND v(dout0_172) AT=295.025n

.meas tran vdout0_173ck580 FIND v(dout0_173) AT=295.025n

.meas tran vdout0_174ck580 FIND v(dout0_174) AT=295.025n

.meas tran vdout0_175ck580 FIND v(dout0_175) AT=295.025n

.meas tran vdout0_176ck580 FIND v(dout0_176) AT=295.025n

.meas tran vdout0_177ck580 FIND v(dout0_177) AT=295.025n

.meas tran vdout0_178ck580 FIND v(dout0_178) AT=295.025n

.meas tran vdout0_179ck580 FIND v(dout0_179) AT=295.025n

.meas tran vdout0_180ck580 FIND v(dout0_180) AT=295.025n

.meas tran vdout0_181ck580 FIND v(dout0_181) AT=295.025n

.meas tran vdout0_182ck580 FIND v(dout0_182) AT=295.025n

.meas tran vdout0_183ck580 FIND v(dout0_183) AT=295.025n

.meas tran vdout0_184ck580 FIND v(dout0_184) AT=295.025n

.meas tran vdout0_185ck580 FIND v(dout0_185) AT=295.025n

.meas tran vdout0_186ck580 FIND v(dout0_186) AT=295.025n

.meas tran vdout0_187ck580 FIND v(dout0_187) AT=295.025n

.meas tran vdout0_188ck580 FIND v(dout0_188) AT=295.025n

.meas tran vdout0_189ck580 FIND v(dout0_189) AT=295.025n

.meas tran vdout0_190ck580 FIND v(dout0_190) AT=295.025n

.meas tran vdout0_191ck580 FIND v(dout0_191) AT=295.025n

.meas tran vdout0_192ck580 FIND v(dout0_192) AT=295.025n

.meas tran vdout0_193ck580 FIND v(dout0_193) AT=295.025n

.meas tran vdout0_194ck580 FIND v(dout0_194) AT=295.025n

.meas tran vdout0_195ck580 FIND v(dout0_195) AT=295.025n

.meas tran vdout0_196ck580 FIND v(dout0_196) AT=295.025n

.meas tran vdout0_197ck580 FIND v(dout0_197) AT=295.025n

.meas tran vdout0_198ck580 FIND v(dout0_198) AT=295.025n

.meas tran vdout0_199ck580 FIND v(dout0_199) AT=295.025n

.meas tran vdout0_200ck580 FIND v(dout0_200) AT=295.025n

.meas tran vdout0_201ck580 FIND v(dout0_201) AT=295.025n

.meas tran vdout0_202ck580 FIND v(dout0_202) AT=295.025n

.meas tran vdout0_203ck580 FIND v(dout0_203) AT=295.025n

.meas tran vdout0_204ck580 FIND v(dout0_204) AT=295.025n

.meas tran vdout0_205ck580 FIND v(dout0_205) AT=295.025n

.meas tran vdout0_206ck580 FIND v(dout0_206) AT=295.025n

.meas tran vdout0_207ck580 FIND v(dout0_207) AT=295.025n

.meas tran vdout0_208ck580 FIND v(dout0_208) AT=295.025n

.meas tran vdout0_209ck580 FIND v(dout0_209) AT=295.025n

.meas tran vdout0_210ck580 FIND v(dout0_210) AT=295.025n

.meas tran vdout0_211ck580 FIND v(dout0_211) AT=295.025n

.meas tran vdout0_212ck580 FIND v(dout0_212) AT=295.025n

.meas tran vdout0_213ck580 FIND v(dout0_213) AT=295.025n

.meas tran vdout0_214ck580 FIND v(dout0_214) AT=295.025n

.meas tran vdout0_215ck580 FIND v(dout0_215) AT=295.025n

.meas tran vdout0_216ck580 FIND v(dout0_216) AT=295.025n

.meas tran vdout0_217ck580 FIND v(dout0_217) AT=295.025n

.meas tran vdout0_218ck580 FIND v(dout0_218) AT=295.025n

.meas tran vdout0_219ck580 FIND v(dout0_219) AT=295.025n

.meas tran vdout0_220ck580 FIND v(dout0_220) AT=295.025n

.meas tran vdout0_221ck580 FIND v(dout0_221) AT=295.025n

.meas tran vdout0_222ck580 FIND v(dout0_222) AT=295.025n

.meas tran vdout0_223ck580 FIND v(dout0_223) AT=295.025n

.meas tran vdout0_224ck580 FIND v(dout0_224) AT=295.025n

.meas tran vdout0_225ck580 FIND v(dout0_225) AT=295.025n

.meas tran vdout0_226ck580 FIND v(dout0_226) AT=295.025n

.meas tran vdout0_227ck580 FIND v(dout0_227) AT=295.025n

.meas tran vdout0_228ck580 FIND v(dout0_228) AT=295.025n

.meas tran vdout0_229ck580 FIND v(dout0_229) AT=295.025n

.meas tran vdout0_230ck580 FIND v(dout0_230) AT=295.025n

.meas tran vdout0_231ck580 FIND v(dout0_231) AT=295.025n

.meas tran vdout0_232ck580 FIND v(dout0_232) AT=295.025n

.meas tran vdout0_233ck580 FIND v(dout0_233) AT=295.025n

.meas tran vdout0_234ck580 FIND v(dout0_234) AT=295.025n

.meas tran vdout0_235ck580 FIND v(dout0_235) AT=295.025n

.meas tran vdout0_236ck580 FIND v(dout0_236) AT=295.025n

.meas tran vdout0_237ck580 FIND v(dout0_237) AT=295.025n

.meas tran vdout0_238ck580 FIND v(dout0_238) AT=295.025n

.meas tran vdout0_239ck580 FIND v(dout0_239) AT=295.025n

.meas tran vdout0_240ck580 FIND v(dout0_240) AT=295.025n

.meas tran vdout0_241ck580 FIND v(dout0_241) AT=295.025n

.meas tran vdout0_242ck580 FIND v(dout0_242) AT=295.025n

.meas tran vdout0_243ck580 FIND v(dout0_243) AT=295.025n

.meas tran vdout0_244ck580 FIND v(dout0_244) AT=295.025n

.meas tran vdout0_245ck580 FIND v(dout0_245) AT=295.025n

.meas tran vdout0_246ck580 FIND v(dout0_246) AT=295.025n

.meas tran vdout0_247ck580 FIND v(dout0_247) AT=295.025n

.meas tran vdout0_248ck580 FIND v(dout0_248) AT=295.025n

.meas tran vdout0_249ck580 FIND v(dout0_249) AT=295.025n

.meas tran vdout0_250ck580 FIND v(dout0_250) AT=295.025n

.meas tran vdout0_251ck580 FIND v(dout0_251) AT=295.025n

.meas tran vdout0_252ck580 FIND v(dout0_252) AT=295.025n

.meas tran vdout0_253ck580 FIND v(dout0_253) AT=295.025n

.meas tran vdout0_254ck580 FIND v(dout0_254) AT=295.025n

.meas tran vdout0_255ck580 FIND v(dout0_255) AT=295.025n

.meas tran vdout0_0ck650 FIND v(dout0_0) AT=330.025n

.meas tran vdout0_1ck650 FIND v(dout0_1) AT=330.025n

.meas tran vdout0_2ck650 FIND v(dout0_2) AT=330.025n

.meas tran vdout0_3ck650 FIND v(dout0_3) AT=330.025n

.meas tran vdout0_4ck650 FIND v(dout0_4) AT=330.025n

.meas tran vdout0_5ck650 FIND v(dout0_5) AT=330.025n

.meas tran vdout0_6ck650 FIND v(dout0_6) AT=330.025n

.meas tran vdout0_7ck650 FIND v(dout0_7) AT=330.025n

.meas tran vdout0_8ck650 FIND v(dout0_8) AT=330.025n

.meas tran vdout0_9ck650 FIND v(dout0_9) AT=330.025n

.meas tran vdout0_10ck650 FIND v(dout0_10) AT=330.025n

.meas tran vdout0_11ck650 FIND v(dout0_11) AT=330.025n

.meas tran vdout0_12ck650 FIND v(dout0_12) AT=330.025n

.meas tran vdout0_13ck650 FIND v(dout0_13) AT=330.025n

.meas tran vdout0_14ck650 FIND v(dout0_14) AT=330.025n

.meas tran vdout0_15ck650 FIND v(dout0_15) AT=330.025n

.meas tran vdout0_16ck650 FIND v(dout0_16) AT=330.025n

.meas tran vdout0_17ck650 FIND v(dout0_17) AT=330.025n

.meas tran vdout0_18ck650 FIND v(dout0_18) AT=330.025n

.meas tran vdout0_19ck650 FIND v(dout0_19) AT=330.025n

.meas tran vdout0_20ck650 FIND v(dout0_20) AT=330.025n

.meas tran vdout0_21ck650 FIND v(dout0_21) AT=330.025n

.meas tran vdout0_22ck650 FIND v(dout0_22) AT=330.025n

.meas tran vdout0_23ck650 FIND v(dout0_23) AT=330.025n

.meas tran vdout0_24ck650 FIND v(dout0_24) AT=330.025n

.meas tran vdout0_25ck650 FIND v(dout0_25) AT=330.025n

.meas tran vdout0_26ck650 FIND v(dout0_26) AT=330.025n

.meas tran vdout0_27ck650 FIND v(dout0_27) AT=330.025n

.meas tran vdout0_28ck650 FIND v(dout0_28) AT=330.025n

.meas tran vdout0_29ck650 FIND v(dout0_29) AT=330.025n

.meas tran vdout0_30ck650 FIND v(dout0_30) AT=330.025n

.meas tran vdout0_31ck650 FIND v(dout0_31) AT=330.025n

.meas tran vdout0_32ck650 FIND v(dout0_32) AT=330.025n

.meas tran vdout0_33ck650 FIND v(dout0_33) AT=330.025n

.meas tran vdout0_34ck650 FIND v(dout0_34) AT=330.025n

.meas tran vdout0_35ck650 FIND v(dout0_35) AT=330.025n

.meas tran vdout0_36ck650 FIND v(dout0_36) AT=330.025n

.meas tran vdout0_37ck650 FIND v(dout0_37) AT=330.025n

.meas tran vdout0_38ck650 FIND v(dout0_38) AT=330.025n

.meas tran vdout0_39ck650 FIND v(dout0_39) AT=330.025n

.meas tran vdout0_40ck650 FIND v(dout0_40) AT=330.025n

.meas tran vdout0_41ck650 FIND v(dout0_41) AT=330.025n

.meas tran vdout0_42ck650 FIND v(dout0_42) AT=330.025n

.meas tran vdout0_43ck650 FIND v(dout0_43) AT=330.025n

.meas tran vdout0_44ck650 FIND v(dout0_44) AT=330.025n

.meas tran vdout0_45ck650 FIND v(dout0_45) AT=330.025n

.meas tran vdout0_46ck650 FIND v(dout0_46) AT=330.025n

.meas tran vdout0_47ck650 FIND v(dout0_47) AT=330.025n

.meas tran vdout0_48ck650 FIND v(dout0_48) AT=330.025n

.meas tran vdout0_49ck650 FIND v(dout0_49) AT=330.025n

.meas tran vdout0_50ck650 FIND v(dout0_50) AT=330.025n

.meas tran vdout0_51ck650 FIND v(dout0_51) AT=330.025n

.meas tran vdout0_52ck650 FIND v(dout0_52) AT=330.025n

.meas tran vdout0_53ck650 FIND v(dout0_53) AT=330.025n

.meas tran vdout0_54ck650 FIND v(dout0_54) AT=330.025n

.meas tran vdout0_55ck650 FIND v(dout0_55) AT=330.025n

.meas tran vdout0_56ck650 FIND v(dout0_56) AT=330.025n

.meas tran vdout0_57ck650 FIND v(dout0_57) AT=330.025n

.meas tran vdout0_58ck650 FIND v(dout0_58) AT=330.025n

.meas tran vdout0_59ck650 FIND v(dout0_59) AT=330.025n

.meas tran vdout0_60ck650 FIND v(dout0_60) AT=330.025n

.meas tran vdout0_61ck650 FIND v(dout0_61) AT=330.025n

.meas tran vdout0_62ck650 FIND v(dout0_62) AT=330.025n

.meas tran vdout0_63ck650 FIND v(dout0_63) AT=330.025n

.meas tran vdout0_64ck650 FIND v(dout0_64) AT=330.025n

.meas tran vdout0_65ck650 FIND v(dout0_65) AT=330.025n

.meas tran vdout0_66ck650 FIND v(dout0_66) AT=330.025n

.meas tran vdout0_67ck650 FIND v(dout0_67) AT=330.025n

.meas tran vdout0_68ck650 FIND v(dout0_68) AT=330.025n

.meas tran vdout0_69ck650 FIND v(dout0_69) AT=330.025n

.meas tran vdout0_70ck650 FIND v(dout0_70) AT=330.025n

.meas tran vdout0_71ck650 FIND v(dout0_71) AT=330.025n

.meas tran vdout0_72ck650 FIND v(dout0_72) AT=330.025n

.meas tran vdout0_73ck650 FIND v(dout0_73) AT=330.025n

.meas tran vdout0_74ck650 FIND v(dout0_74) AT=330.025n

.meas tran vdout0_75ck650 FIND v(dout0_75) AT=330.025n

.meas tran vdout0_76ck650 FIND v(dout0_76) AT=330.025n

.meas tran vdout0_77ck650 FIND v(dout0_77) AT=330.025n

.meas tran vdout0_78ck650 FIND v(dout0_78) AT=330.025n

.meas tran vdout0_79ck650 FIND v(dout0_79) AT=330.025n

.meas tran vdout0_80ck650 FIND v(dout0_80) AT=330.025n

.meas tran vdout0_81ck650 FIND v(dout0_81) AT=330.025n

.meas tran vdout0_82ck650 FIND v(dout0_82) AT=330.025n

.meas tran vdout0_83ck650 FIND v(dout0_83) AT=330.025n

.meas tran vdout0_84ck650 FIND v(dout0_84) AT=330.025n

.meas tran vdout0_85ck650 FIND v(dout0_85) AT=330.025n

.meas tran vdout0_86ck650 FIND v(dout0_86) AT=330.025n

.meas tran vdout0_87ck650 FIND v(dout0_87) AT=330.025n

.meas tran vdout0_88ck650 FIND v(dout0_88) AT=330.025n

.meas tran vdout0_89ck650 FIND v(dout0_89) AT=330.025n

.meas tran vdout0_90ck650 FIND v(dout0_90) AT=330.025n

.meas tran vdout0_91ck650 FIND v(dout0_91) AT=330.025n

.meas tran vdout0_92ck650 FIND v(dout0_92) AT=330.025n

.meas tran vdout0_93ck650 FIND v(dout0_93) AT=330.025n

.meas tran vdout0_94ck650 FIND v(dout0_94) AT=330.025n

.meas tran vdout0_95ck650 FIND v(dout0_95) AT=330.025n

.meas tran vdout0_96ck650 FIND v(dout0_96) AT=330.025n

.meas tran vdout0_97ck650 FIND v(dout0_97) AT=330.025n

.meas tran vdout0_98ck650 FIND v(dout0_98) AT=330.025n

.meas tran vdout0_99ck650 FIND v(dout0_99) AT=330.025n

.meas tran vdout0_100ck650 FIND v(dout0_100) AT=330.025n

.meas tran vdout0_101ck650 FIND v(dout0_101) AT=330.025n

.meas tran vdout0_102ck650 FIND v(dout0_102) AT=330.025n

.meas tran vdout0_103ck650 FIND v(dout0_103) AT=330.025n

.meas tran vdout0_104ck650 FIND v(dout0_104) AT=330.025n

.meas tran vdout0_105ck650 FIND v(dout0_105) AT=330.025n

.meas tran vdout0_106ck650 FIND v(dout0_106) AT=330.025n

.meas tran vdout0_107ck650 FIND v(dout0_107) AT=330.025n

.meas tran vdout0_108ck650 FIND v(dout0_108) AT=330.025n

.meas tran vdout0_109ck650 FIND v(dout0_109) AT=330.025n

.meas tran vdout0_110ck650 FIND v(dout0_110) AT=330.025n

.meas tran vdout0_111ck650 FIND v(dout0_111) AT=330.025n

.meas tran vdout0_112ck650 FIND v(dout0_112) AT=330.025n

.meas tran vdout0_113ck650 FIND v(dout0_113) AT=330.025n

.meas tran vdout0_114ck650 FIND v(dout0_114) AT=330.025n

.meas tran vdout0_115ck650 FIND v(dout0_115) AT=330.025n

.meas tran vdout0_116ck650 FIND v(dout0_116) AT=330.025n

.meas tran vdout0_117ck650 FIND v(dout0_117) AT=330.025n

.meas tran vdout0_118ck650 FIND v(dout0_118) AT=330.025n

.meas tran vdout0_119ck650 FIND v(dout0_119) AT=330.025n

.meas tran vdout0_120ck650 FIND v(dout0_120) AT=330.025n

.meas tran vdout0_121ck650 FIND v(dout0_121) AT=330.025n

.meas tran vdout0_122ck650 FIND v(dout0_122) AT=330.025n

.meas tran vdout0_123ck650 FIND v(dout0_123) AT=330.025n

.meas tran vdout0_124ck650 FIND v(dout0_124) AT=330.025n

.meas tran vdout0_125ck650 FIND v(dout0_125) AT=330.025n

.meas tran vdout0_126ck650 FIND v(dout0_126) AT=330.025n

.meas tran vdout0_127ck650 FIND v(dout0_127) AT=330.025n

.meas tran vdout0_128ck650 FIND v(dout0_128) AT=330.025n

.meas tran vdout0_129ck650 FIND v(dout0_129) AT=330.025n

.meas tran vdout0_130ck650 FIND v(dout0_130) AT=330.025n

.meas tran vdout0_131ck650 FIND v(dout0_131) AT=330.025n

.meas tran vdout0_132ck650 FIND v(dout0_132) AT=330.025n

.meas tran vdout0_133ck650 FIND v(dout0_133) AT=330.025n

.meas tran vdout0_134ck650 FIND v(dout0_134) AT=330.025n

.meas tran vdout0_135ck650 FIND v(dout0_135) AT=330.025n

.meas tran vdout0_136ck650 FIND v(dout0_136) AT=330.025n

.meas tran vdout0_137ck650 FIND v(dout0_137) AT=330.025n

.meas tran vdout0_138ck650 FIND v(dout0_138) AT=330.025n

.meas tran vdout0_139ck650 FIND v(dout0_139) AT=330.025n

.meas tran vdout0_140ck650 FIND v(dout0_140) AT=330.025n

.meas tran vdout0_141ck650 FIND v(dout0_141) AT=330.025n

.meas tran vdout0_142ck650 FIND v(dout0_142) AT=330.025n

.meas tran vdout0_143ck650 FIND v(dout0_143) AT=330.025n

.meas tran vdout0_144ck650 FIND v(dout0_144) AT=330.025n

.meas tran vdout0_145ck650 FIND v(dout0_145) AT=330.025n

.meas tran vdout0_146ck650 FIND v(dout0_146) AT=330.025n

.meas tran vdout0_147ck650 FIND v(dout0_147) AT=330.025n

.meas tran vdout0_148ck650 FIND v(dout0_148) AT=330.025n

.meas tran vdout0_149ck650 FIND v(dout0_149) AT=330.025n

.meas tran vdout0_150ck650 FIND v(dout0_150) AT=330.025n

.meas tran vdout0_151ck650 FIND v(dout0_151) AT=330.025n

.meas tran vdout0_152ck650 FIND v(dout0_152) AT=330.025n

.meas tran vdout0_153ck650 FIND v(dout0_153) AT=330.025n

.meas tran vdout0_154ck650 FIND v(dout0_154) AT=330.025n

.meas tran vdout0_155ck650 FIND v(dout0_155) AT=330.025n

.meas tran vdout0_156ck650 FIND v(dout0_156) AT=330.025n

.meas tran vdout0_157ck650 FIND v(dout0_157) AT=330.025n

.meas tran vdout0_158ck650 FIND v(dout0_158) AT=330.025n

.meas tran vdout0_159ck650 FIND v(dout0_159) AT=330.025n

.meas tran vdout0_160ck650 FIND v(dout0_160) AT=330.025n

.meas tran vdout0_161ck650 FIND v(dout0_161) AT=330.025n

.meas tran vdout0_162ck650 FIND v(dout0_162) AT=330.025n

.meas tran vdout0_163ck650 FIND v(dout0_163) AT=330.025n

.meas tran vdout0_164ck650 FIND v(dout0_164) AT=330.025n

.meas tran vdout0_165ck650 FIND v(dout0_165) AT=330.025n

.meas tran vdout0_166ck650 FIND v(dout0_166) AT=330.025n

.meas tran vdout0_167ck650 FIND v(dout0_167) AT=330.025n

.meas tran vdout0_168ck650 FIND v(dout0_168) AT=330.025n

.meas tran vdout0_169ck650 FIND v(dout0_169) AT=330.025n

.meas tran vdout0_170ck650 FIND v(dout0_170) AT=330.025n

.meas tran vdout0_171ck650 FIND v(dout0_171) AT=330.025n

.meas tran vdout0_172ck650 FIND v(dout0_172) AT=330.025n

.meas tran vdout0_173ck650 FIND v(dout0_173) AT=330.025n

.meas tran vdout0_174ck650 FIND v(dout0_174) AT=330.025n

.meas tran vdout0_175ck650 FIND v(dout0_175) AT=330.025n

.meas tran vdout0_176ck650 FIND v(dout0_176) AT=330.025n

.meas tran vdout0_177ck650 FIND v(dout0_177) AT=330.025n

.meas tran vdout0_178ck650 FIND v(dout0_178) AT=330.025n

.meas tran vdout0_179ck650 FIND v(dout0_179) AT=330.025n

.meas tran vdout0_180ck650 FIND v(dout0_180) AT=330.025n

.meas tran vdout0_181ck650 FIND v(dout0_181) AT=330.025n

.meas tran vdout0_182ck650 FIND v(dout0_182) AT=330.025n

.meas tran vdout0_183ck650 FIND v(dout0_183) AT=330.025n

.meas tran vdout0_184ck650 FIND v(dout0_184) AT=330.025n

.meas tran vdout0_185ck650 FIND v(dout0_185) AT=330.025n

.meas tran vdout0_186ck650 FIND v(dout0_186) AT=330.025n

.meas tran vdout0_187ck650 FIND v(dout0_187) AT=330.025n

.meas tran vdout0_188ck650 FIND v(dout0_188) AT=330.025n

.meas tran vdout0_189ck650 FIND v(dout0_189) AT=330.025n

.meas tran vdout0_190ck650 FIND v(dout0_190) AT=330.025n

.meas tran vdout0_191ck650 FIND v(dout0_191) AT=330.025n

.meas tran vdout0_192ck650 FIND v(dout0_192) AT=330.025n

.meas tran vdout0_193ck650 FIND v(dout0_193) AT=330.025n

.meas tran vdout0_194ck650 FIND v(dout0_194) AT=330.025n

.meas tran vdout0_195ck650 FIND v(dout0_195) AT=330.025n

.meas tran vdout0_196ck650 FIND v(dout0_196) AT=330.025n

.meas tran vdout0_197ck650 FIND v(dout0_197) AT=330.025n

.meas tran vdout0_198ck650 FIND v(dout0_198) AT=330.025n

.meas tran vdout0_199ck650 FIND v(dout0_199) AT=330.025n

.meas tran vdout0_200ck650 FIND v(dout0_200) AT=330.025n

.meas tran vdout0_201ck650 FIND v(dout0_201) AT=330.025n

.meas tran vdout0_202ck650 FIND v(dout0_202) AT=330.025n

.meas tran vdout0_203ck650 FIND v(dout0_203) AT=330.025n

.meas tran vdout0_204ck650 FIND v(dout0_204) AT=330.025n

.meas tran vdout0_205ck650 FIND v(dout0_205) AT=330.025n

.meas tran vdout0_206ck650 FIND v(dout0_206) AT=330.025n

.meas tran vdout0_207ck650 FIND v(dout0_207) AT=330.025n

.meas tran vdout0_208ck650 FIND v(dout0_208) AT=330.025n

.meas tran vdout0_209ck650 FIND v(dout0_209) AT=330.025n

.meas tran vdout0_210ck650 FIND v(dout0_210) AT=330.025n

.meas tran vdout0_211ck650 FIND v(dout0_211) AT=330.025n

.meas tran vdout0_212ck650 FIND v(dout0_212) AT=330.025n

.meas tran vdout0_213ck650 FIND v(dout0_213) AT=330.025n

.meas tran vdout0_214ck650 FIND v(dout0_214) AT=330.025n

.meas tran vdout0_215ck650 FIND v(dout0_215) AT=330.025n

.meas tran vdout0_216ck650 FIND v(dout0_216) AT=330.025n

.meas tran vdout0_217ck650 FIND v(dout0_217) AT=330.025n

.meas tran vdout0_218ck650 FIND v(dout0_218) AT=330.025n

.meas tran vdout0_219ck650 FIND v(dout0_219) AT=330.025n

.meas tran vdout0_220ck650 FIND v(dout0_220) AT=330.025n

.meas tran vdout0_221ck650 FIND v(dout0_221) AT=330.025n

.meas tran vdout0_222ck650 FIND v(dout0_222) AT=330.025n

.meas tran vdout0_223ck650 FIND v(dout0_223) AT=330.025n

.meas tran vdout0_224ck650 FIND v(dout0_224) AT=330.025n

.meas tran vdout0_225ck650 FIND v(dout0_225) AT=330.025n

.meas tran vdout0_226ck650 FIND v(dout0_226) AT=330.025n

.meas tran vdout0_227ck650 FIND v(dout0_227) AT=330.025n

.meas tran vdout0_228ck650 FIND v(dout0_228) AT=330.025n

.meas tran vdout0_229ck650 FIND v(dout0_229) AT=330.025n

.meas tran vdout0_230ck650 FIND v(dout0_230) AT=330.025n

.meas tran vdout0_231ck650 FIND v(dout0_231) AT=330.025n

.meas tran vdout0_232ck650 FIND v(dout0_232) AT=330.025n

.meas tran vdout0_233ck650 FIND v(dout0_233) AT=330.025n

.meas tran vdout0_234ck650 FIND v(dout0_234) AT=330.025n

.meas tran vdout0_235ck650 FIND v(dout0_235) AT=330.025n

.meas tran vdout0_236ck650 FIND v(dout0_236) AT=330.025n

.meas tran vdout0_237ck650 FIND v(dout0_237) AT=330.025n

.meas tran vdout0_238ck650 FIND v(dout0_238) AT=330.025n

.meas tran vdout0_239ck650 FIND v(dout0_239) AT=330.025n

.meas tran vdout0_240ck650 FIND v(dout0_240) AT=330.025n

.meas tran vdout0_241ck650 FIND v(dout0_241) AT=330.025n

.meas tran vdout0_242ck650 FIND v(dout0_242) AT=330.025n

.meas tran vdout0_243ck650 FIND v(dout0_243) AT=330.025n

.meas tran vdout0_244ck650 FIND v(dout0_244) AT=330.025n

.meas tran vdout0_245ck650 FIND v(dout0_245) AT=330.025n

.meas tran vdout0_246ck650 FIND v(dout0_246) AT=330.025n

.meas tran vdout0_247ck650 FIND v(dout0_247) AT=330.025n

.meas tran vdout0_248ck650 FIND v(dout0_248) AT=330.025n

.meas tran vdout0_249ck650 FIND v(dout0_249) AT=330.025n

.meas tran vdout0_250ck650 FIND v(dout0_250) AT=330.025n

.meas tran vdout0_251ck650 FIND v(dout0_251) AT=330.025n

.meas tran vdout0_252ck650 FIND v(dout0_252) AT=330.025n

.meas tran vdout0_253ck650 FIND v(dout0_253) AT=330.025n

.meas tran vdout0_254ck650 FIND v(dout0_254) AT=330.025n

.meas tran vdout0_255ck650 FIND v(dout0_255) AT=330.025n

.meas tran vdout0_0ck660 FIND v(dout0_0) AT=335.025n

.meas tran vdout0_1ck660 FIND v(dout0_1) AT=335.025n

.meas tran vdout0_2ck660 FIND v(dout0_2) AT=335.025n

.meas tran vdout0_3ck660 FIND v(dout0_3) AT=335.025n

.meas tran vdout0_4ck660 FIND v(dout0_4) AT=335.025n

.meas tran vdout0_5ck660 FIND v(dout0_5) AT=335.025n

.meas tran vdout0_6ck660 FIND v(dout0_6) AT=335.025n

.meas tran vdout0_7ck660 FIND v(dout0_7) AT=335.025n

.meas tran vdout0_8ck660 FIND v(dout0_8) AT=335.025n

.meas tran vdout0_9ck660 FIND v(dout0_9) AT=335.025n

.meas tran vdout0_10ck660 FIND v(dout0_10) AT=335.025n

.meas tran vdout0_11ck660 FIND v(dout0_11) AT=335.025n

.meas tran vdout0_12ck660 FIND v(dout0_12) AT=335.025n

.meas tran vdout0_13ck660 FIND v(dout0_13) AT=335.025n

.meas tran vdout0_14ck660 FIND v(dout0_14) AT=335.025n

.meas tran vdout0_15ck660 FIND v(dout0_15) AT=335.025n

.meas tran vdout0_16ck660 FIND v(dout0_16) AT=335.025n

.meas tran vdout0_17ck660 FIND v(dout0_17) AT=335.025n

.meas tran vdout0_18ck660 FIND v(dout0_18) AT=335.025n

.meas tran vdout0_19ck660 FIND v(dout0_19) AT=335.025n

.meas tran vdout0_20ck660 FIND v(dout0_20) AT=335.025n

.meas tran vdout0_21ck660 FIND v(dout0_21) AT=335.025n

.meas tran vdout0_22ck660 FIND v(dout0_22) AT=335.025n

.meas tran vdout0_23ck660 FIND v(dout0_23) AT=335.025n

.meas tran vdout0_24ck660 FIND v(dout0_24) AT=335.025n

.meas tran vdout0_25ck660 FIND v(dout0_25) AT=335.025n

.meas tran vdout0_26ck660 FIND v(dout0_26) AT=335.025n

.meas tran vdout0_27ck660 FIND v(dout0_27) AT=335.025n

.meas tran vdout0_28ck660 FIND v(dout0_28) AT=335.025n

.meas tran vdout0_29ck660 FIND v(dout0_29) AT=335.025n

.meas tran vdout0_30ck660 FIND v(dout0_30) AT=335.025n

.meas tran vdout0_31ck660 FIND v(dout0_31) AT=335.025n

.meas tran vdout0_32ck660 FIND v(dout0_32) AT=335.025n

.meas tran vdout0_33ck660 FIND v(dout0_33) AT=335.025n

.meas tran vdout0_34ck660 FIND v(dout0_34) AT=335.025n

.meas tran vdout0_35ck660 FIND v(dout0_35) AT=335.025n

.meas tran vdout0_36ck660 FIND v(dout0_36) AT=335.025n

.meas tran vdout0_37ck660 FIND v(dout0_37) AT=335.025n

.meas tran vdout0_38ck660 FIND v(dout0_38) AT=335.025n

.meas tran vdout0_39ck660 FIND v(dout0_39) AT=335.025n

.meas tran vdout0_40ck660 FIND v(dout0_40) AT=335.025n

.meas tran vdout0_41ck660 FIND v(dout0_41) AT=335.025n

.meas tran vdout0_42ck660 FIND v(dout0_42) AT=335.025n

.meas tran vdout0_43ck660 FIND v(dout0_43) AT=335.025n

.meas tran vdout0_44ck660 FIND v(dout0_44) AT=335.025n

.meas tran vdout0_45ck660 FIND v(dout0_45) AT=335.025n

.meas tran vdout0_46ck660 FIND v(dout0_46) AT=335.025n

.meas tran vdout0_47ck660 FIND v(dout0_47) AT=335.025n

.meas tran vdout0_48ck660 FIND v(dout0_48) AT=335.025n

.meas tran vdout0_49ck660 FIND v(dout0_49) AT=335.025n

.meas tran vdout0_50ck660 FIND v(dout0_50) AT=335.025n

.meas tran vdout0_51ck660 FIND v(dout0_51) AT=335.025n

.meas tran vdout0_52ck660 FIND v(dout0_52) AT=335.025n

.meas tran vdout0_53ck660 FIND v(dout0_53) AT=335.025n

.meas tran vdout0_54ck660 FIND v(dout0_54) AT=335.025n

.meas tran vdout0_55ck660 FIND v(dout0_55) AT=335.025n

.meas tran vdout0_56ck660 FIND v(dout0_56) AT=335.025n

.meas tran vdout0_57ck660 FIND v(dout0_57) AT=335.025n

.meas tran vdout0_58ck660 FIND v(dout0_58) AT=335.025n

.meas tran vdout0_59ck660 FIND v(dout0_59) AT=335.025n

.meas tran vdout0_60ck660 FIND v(dout0_60) AT=335.025n

.meas tran vdout0_61ck660 FIND v(dout0_61) AT=335.025n

.meas tran vdout0_62ck660 FIND v(dout0_62) AT=335.025n

.meas tran vdout0_63ck660 FIND v(dout0_63) AT=335.025n

.meas tran vdout0_64ck660 FIND v(dout0_64) AT=335.025n

.meas tran vdout0_65ck660 FIND v(dout0_65) AT=335.025n

.meas tran vdout0_66ck660 FIND v(dout0_66) AT=335.025n

.meas tran vdout0_67ck660 FIND v(dout0_67) AT=335.025n

.meas tran vdout0_68ck660 FIND v(dout0_68) AT=335.025n

.meas tran vdout0_69ck660 FIND v(dout0_69) AT=335.025n

.meas tran vdout0_70ck660 FIND v(dout0_70) AT=335.025n

.meas tran vdout0_71ck660 FIND v(dout0_71) AT=335.025n

.meas tran vdout0_72ck660 FIND v(dout0_72) AT=335.025n

.meas tran vdout0_73ck660 FIND v(dout0_73) AT=335.025n

.meas tran vdout0_74ck660 FIND v(dout0_74) AT=335.025n

.meas tran vdout0_75ck660 FIND v(dout0_75) AT=335.025n

.meas tran vdout0_76ck660 FIND v(dout0_76) AT=335.025n

.meas tran vdout0_77ck660 FIND v(dout0_77) AT=335.025n

.meas tran vdout0_78ck660 FIND v(dout0_78) AT=335.025n

.meas tran vdout0_79ck660 FIND v(dout0_79) AT=335.025n

.meas tran vdout0_80ck660 FIND v(dout0_80) AT=335.025n

.meas tran vdout0_81ck660 FIND v(dout0_81) AT=335.025n

.meas tran vdout0_82ck660 FIND v(dout0_82) AT=335.025n

.meas tran vdout0_83ck660 FIND v(dout0_83) AT=335.025n

.meas tran vdout0_84ck660 FIND v(dout0_84) AT=335.025n

.meas tran vdout0_85ck660 FIND v(dout0_85) AT=335.025n

.meas tran vdout0_86ck660 FIND v(dout0_86) AT=335.025n

.meas tran vdout0_87ck660 FIND v(dout0_87) AT=335.025n

.meas tran vdout0_88ck660 FIND v(dout0_88) AT=335.025n

.meas tran vdout0_89ck660 FIND v(dout0_89) AT=335.025n

.meas tran vdout0_90ck660 FIND v(dout0_90) AT=335.025n

.meas tran vdout0_91ck660 FIND v(dout0_91) AT=335.025n

.meas tran vdout0_92ck660 FIND v(dout0_92) AT=335.025n

.meas tran vdout0_93ck660 FIND v(dout0_93) AT=335.025n

.meas tran vdout0_94ck660 FIND v(dout0_94) AT=335.025n

.meas tran vdout0_95ck660 FIND v(dout0_95) AT=335.025n

.meas tran vdout0_96ck660 FIND v(dout0_96) AT=335.025n

.meas tran vdout0_97ck660 FIND v(dout0_97) AT=335.025n

.meas tran vdout0_98ck660 FIND v(dout0_98) AT=335.025n

.meas tran vdout0_99ck660 FIND v(dout0_99) AT=335.025n

.meas tran vdout0_100ck660 FIND v(dout0_100) AT=335.025n

.meas tran vdout0_101ck660 FIND v(dout0_101) AT=335.025n

.meas tran vdout0_102ck660 FIND v(dout0_102) AT=335.025n

.meas tran vdout0_103ck660 FIND v(dout0_103) AT=335.025n

.meas tran vdout0_104ck660 FIND v(dout0_104) AT=335.025n

.meas tran vdout0_105ck660 FIND v(dout0_105) AT=335.025n

.meas tran vdout0_106ck660 FIND v(dout0_106) AT=335.025n

.meas tran vdout0_107ck660 FIND v(dout0_107) AT=335.025n

.meas tran vdout0_108ck660 FIND v(dout0_108) AT=335.025n

.meas tran vdout0_109ck660 FIND v(dout0_109) AT=335.025n

.meas tran vdout0_110ck660 FIND v(dout0_110) AT=335.025n

.meas tran vdout0_111ck660 FIND v(dout0_111) AT=335.025n

.meas tran vdout0_112ck660 FIND v(dout0_112) AT=335.025n

.meas tran vdout0_113ck660 FIND v(dout0_113) AT=335.025n

.meas tran vdout0_114ck660 FIND v(dout0_114) AT=335.025n

.meas tran vdout0_115ck660 FIND v(dout0_115) AT=335.025n

.meas tran vdout0_116ck660 FIND v(dout0_116) AT=335.025n

.meas tran vdout0_117ck660 FIND v(dout0_117) AT=335.025n

.meas tran vdout0_118ck660 FIND v(dout0_118) AT=335.025n

.meas tran vdout0_119ck660 FIND v(dout0_119) AT=335.025n

.meas tran vdout0_120ck660 FIND v(dout0_120) AT=335.025n

.meas tran vdout0_121ck660 FIND v(dout0_121) AT=335.025n

.meas tran vdout0_122ck660 FIND v(dout0_122) AT=335.025n

.meas tran vdout0_123ck660 FIND v(dout0_123) AT=335.025n

.meas tran vdout0_124ck660 FIND v(dout0_124) AT=335.025n

.meas tran vdout0_125ck660 FIND v(dout0_125) AT=335.025n

.meas tran vdout0_126ck660 FIND v(dout0_126) AT=335.025n

.meas tran vdout0_127ck660 FIND v(dout0_127) AT=335.025n

.meas tran vdout0_128ck660 FIND v(dout0_128) AT=335.025n

.meas tran vdout0_129ck660 FIND v(dout0_129) AT=335.025n

.meas tran vdout0_130ck660 FIND v(dout0_130) AT=335.025n

.meas tran vdout0_131ck660 FIND v(dout0_131) AT=335.025n

.meas tran vdout0_132ck660 FIND v(dout0_132) AT=335.025n

.meas tran vdout0_133ck660 FIND v(dout0_133) AT=335.025n

.meas tran vdout0_134ck660 FIND v(dout0_134) AT=335.025n

.meas tran vdout0_135ck660 FIND v(dout0_135) AT=335.025n

.meas tran vdout0_136ck660 FIND v(dout0_136) AT=335.025n

.meas tran vdout0_137ck660 FIND v(dout0_137) AT=335.025n

.meas tran vdout0_138ck660 FIND v(dout0_138) AT=335.025n

.meas tran vdout0_139ck660 FIND v(dout0_139) AT=335.025n

.meas tran vdout0_140ck660 FIND v(dout0_140) AT=335.025n

.meas tran vdout0_141ck660 FIND v(dout0_141) AT=335.025n

.meas tran vdout0_142ck660 FIND v(dout0_142) AT=335.025n

.meas tran vdout0_143ck660 FIND v(dout0_143) AT=335.025n

.meas tran vdout0_144ck660 FIND v(dout0_144) AT=335.025n

.meas tran vdout0_145ck660 FIND v(dout0_145) AT=335.025n

.meas tran vdout0_146ck660 FIND v(dout0_146) AT=335.025n

.meas tran vdout0_147ck660 FIND v(dout0_147) AT=335.025n

.meas tran vdout0_148ck660 FIND v(dout0_148) AT=335.025n

.meas tran vdout0_149ck660 FIND v(dout0_149) AT=335.025n

.meas tran vdout0_150ck660 FIND v(dout0_150) AT=335.025n

.meas tran vdout0_151ck660 FIND v(dout0_151) AT=335.025n

.meas tran vdout0_152ck660 FIND v(dout0_152) AT=335.025n

.meas tran vdout0_153ck660 FIND v(dout0_153) AT=335.025n

.meas tran vdout0_154ck660 FIND v(dout0_154) AT=335.025n

.meas tran vdout0_155ck660 FIND v(dout0_155) AT=335.025n

.meas tran vdout0_156ck660 FIND v(dout0_156) AT=335.025n

.meas tran vdout0_157ck660 FIND v(dout0_157) AT=335.025n

.meas tran vdout0_158ck660 FIND v(dout0_158) AT=335.025n

.meas tran vdout0_159ck660 FIND v(dout0_159) AT=335.025n

.meas tran vdout0_160ck660 FIND v(dout0_160) AT=335.025n

.meas tran vdout0_161ck660 FIND v(dout0_161) AT=335.025n

.meas tran vdout0_162ck660 FIND v(dout0_162) AT=335.025n

.meas tran vdout0_163ck660 FIND v(dout0_163) AT=335.025n

.meas tran vdout0_164ck660 FIND v(dout0_164) AT=335.025n

.meas tran vdout0_165ck660 FIND v(dout0_165) AT=335.025n

.meas tran vdout0_166ck660 FIND v(dout0_166) AT=335.025n

.meas tran vdout0_167ck660 FIND v(dout0_167) AT=335.025n

.meas tran vdout0_168ck660 FIND v(dout0_168) AT=335.025n

.meas tran vdout0_169ck660 FIND v(dout0_169) AT=335.025n

.meas tran vdout0_170ck660 FIND v(dout0_170) AT=335.025n

.meas tran vdout0_171ck660 FIND v(dout0_171) AT=335.025n

.meas tran vdout0_172ck660 FIND v(dout0_172) AT=335.025n

.meas tran vdout0_173ck660 FIND v(dout0_173) AT=335.025n

.meas tran vdout0_174ck660 FIND v(dout0_174) AT=335.025n

.meas tran vdout0_175ck660 FIND v(dout0_175) AT=335.025n

.meas tran vdout0_176ck660 FIND v(dout0_176) AT=335.025n

.meas tran vdout0_177ck660 FIND v(dout0_177) AT=335.025n

.meas tran vdout0_178ck660 FIND v(dout0_178) AT=335.025n

.meas tran vdout0_179ck660 FIND v(dout0_179) AT=335.025n

.meas tran vdout0_180ck660 FIND v(dout0_180) AT=335.025n

.meas tran vdout0_181ck660 FIND v(dout0_181) AT=335.025n

.meas tran vdout0_182ck660 FIND v(dout0_182) AT=335.025n

.meas tran vdout0_183ck660 FIND v(dout0_183) AT=335.025n

.meas tran vdout0_184ck660 FIND v(dout0_184) AT=335.025n

.meas tran vdout0_185ck660 FIND v(dout0_185) AT=335.025n

.meas tran vdout0_186ck660 FIND v(dout0_186) AT=335.025n

.meas tran vdout0_187ck660 FIND v(dout0_187) AT=335.025n

.meas tran vdout0_188ck660 FIND v(dout0_188) AT=335.025n

.meas tran vdout0_189ck660 FIND v(dout0_189) AT=335.025n

.meas tran vdout0_190ck660 FIND v(dout0_190) AT=335.025n

.meas tran vdout0_191ck660 FIND v(dout0_191) AT=335.025n

.meas tran vdout0_192ck660 FIND v(dout0_192) AT=335.025n

.meas tran vdout0_193ck660 FIND v(dout0_193) AT=335.025n

.meas tran vdout0_194ck660 FIND v(dout0_194) AT=335.025n

.meas tran vdout0_195ck660 FIND v(dout0_195) AT=335.025n

.meas tran vdout0_196ck660 FIND v(dout0_196) AT=335.025n

.meas tran vdout0_197ck660 FIND v(dout0_197) AT=335.025n

.meas tran vdout0_198ck660 FIND v(dout0_198) AT=335.025n

.meas tran vdout0_199ck660 FIND v(dout0_199) AT=335.025n

.meas tran vdout0_200ck660 FIND v(dout0_200) AT=335.025n

.meas tran vdout0_201ck660 FIND v(dout0_201) AT=335.025n

.meas tran vdout0_202ck660 FIND v(dout0_202) AT=335.025n

.meas tran vdout0_203ck660 FIND v(dout0_203) AT=335.025n

.meas tran vdout0_204ck660 FIND v(dout0_204) AT=335.025n

.meas tran vdout0_205ck660 FIND v(dout0_205) AT=335.025n

.meas tran vdout0_206ck660 FIND v(dout0_206) AT=335.025n

.meas tran vdout0_207ck660 FIND v(dout0_207) AT=335.025n

.meas tran vdout0_208ck660 FIND v(dout0_208) AT=335.025n

.meas tran vdout0_209ck660 FIND v(dout0_209) AT=335.025n

.meas tran vdout0_210ck660 FIND v(dout0_210) AT=335.025n

.meas tran vdout0_211ck660 FIND v(dout0_211) AT=335.025n

.meas tran vdout0_212ck660 FIND v(dout0_212) AT=335.025n

.meas tran vdout0_213ck660 FIND v(dout0_213) AT=335.025n

.meas tran vdout0_214ck660 FIND v(dout0_214) AT=335.025n

.meas tran vdout0_215ck660 FIND v(dout0_215) AT=335.025n

.meas tran vdout0_216ck660 FIND v(dout0_216) AT=335.025n

.meas tran vdout0_217ck660 FIND v(dout0_217) AT=335.025n

.meas tran vdout0_218ck660 FIND v(dout0_218) AT=335.025n

.meas tran vdout0_219ck660 FIND v(dout0_219) AT=335.025n

.meas tran vdout0_220ck660 FIND v(dout0_220) AT=335.025n

.meas tran vdout0_221ck660 FIND v(dout0_221) AT=335.025n

.meas tran vdout0_222ck660 FIND v(dout0_222) AT=335.025n

.meas tran vdout0_223ck660 FIND v(dout0_223) AT=335.025n

.meas tran vdout0_224ck660 FIND v(dout0_224) AT=335.025n

.meas tran vdout0_225ck660 FIND v(dout0_225) AT=335.025n

.meas tran vdout0_226ck660 FIND v(dout0_226) AT=335.025n

.meas tran vdout0_227ck660 FIND v(dout0_227) AT=335.025n

.meas tran vdout0_228ck660 FIND v(dout0_228) AT=335.025n

.meas tran vdout0_229ck660 FIND v(dout0_229) AT=335.025n

.meas tran vdout0_230ck660 FIND v(dout0_230) AT=335.025n

.meas tran vdout0_231ck660 FIND v(dout0_231) AT=335.025n

.meas tran vdout0_232ck660 FIND v(dout0_232) AT=335.025n

.meas tran vdout0_233ck660 FIND v(dout0_233) AT=335.025n

.meas tran vdout0_234ck660 FIND v(dout0_234) AT=335.025n

.meas tran vdout0_235ck660 FIND v(dout0_235) AT=335.025n

.meas tran vdout0_236ck660 FIND v(dout0_236) AT=335.025n

.meas tran vdout0_237ck660 FIND v(dout0_237) AT=335.025n

.meas tran vdout0_238ck660 FIND v(dout0_238) AT=335.025n

.meas tran vdout0_239ck660 FIND v(dout0_239) AT=335.025n

.meas tran vdout0_240ck660 FIND v(dout0_240) AT=335.025n

.meas tran vdout0_241ck660 FIND v(dout0_241) AT=335.025n

.meas tran vdout0_242ck660 FIND v(dout0_242) AT=335.025n

.meas tran vdout0_243ck660 FIND v(dout0_243) AT=335.025n

.meas tran vdout0_244ck660 FIND v(dout0_244) AT=335.025n

.meas tran vdout0_245ck660 FIND v(dout0_245) AT=335.025n

.meas tran vdout0_246ck660 FIND v(dout0_246) AT=335.025n

.meas tran vdout0_247ck660 FIND v(dout0_247) AT=335.025n

.meas tran vdout0_248ck660 FIND v(dout0_248) AT=335.025n

.meas tran vdout0_249ck660 FIND v(dout0_249) AT=335.025n

.meas tran vdout0_250ck660 FIND v(dout0_250) AT=335.025n

.meas tran vdout0_251ck660 FIND v(dout0_251) AT=335.025n

.meas tran vdout0_252ck660 FIND v(dout0_252) AT=335.025n

.meas tran vdout0_253ck660 FIND v(dout0_253) AT=335.025n

.meas tran vdout0_254ck660 FIND v(dout0_254) AT=335.025n

.meas tran vdout0_255ck660 FIND v(dout0_255) AT=335.025n

.meas tran vdout0_0ck670 FIND v(dout0_0) AT=340.025n

.meas tran vdout0_1ck670 FIND v(dout0_1) AT=340.025n

.meas tran vdout0_2ck670 FIND v(dout0_2) AT=340.025n

.meas tran vdout0_3ck670 FIND v(dout0_3) AT=340.025n

.meas tran vdout0_4ck670 FIND v(dout0_4) AT=340.025n

.meas tran vdout0_5ck670 FIND v(dout0_5) AT=340.025n

.meas tran vdout0_6ck670 FIND v(dout0_6) AT=340.025n

.meas tran vdout0_7ck670 FIND v(dout0_7) AT=340.025n

.meas tran vdout0_8ck670 FIND v(dout0_8) AT=340.025n

.meas tran vdout0_9ck670 FIND v(dout0_9) AT=340.025n

.meas tran vdout0_10ck670 FIND v(dout0_10) AT=340.025n

.meas tran vdout0_11ck670 FIND v(dout0_11) AT=340.025n

.meas tran vdout0_12ck670 FIND v(dout0_12) AT=340.025n

.meas tran vdout0_13ck670 FIND v(dout0_13) AT=340.025n

.meas tran vdout0_14ck670 FIND v(dout0_14) AT=340.025n

.meas tran vdout0_15ck670 FIND v(dout0_15) AT=340.025n

.meas tran vdout0_16ck670 FIND v(dout0_16) AT=340.025n

.meas tran vdout0_17ck670 FIND v(dout0_17) AT=340.025n

.meas tran vdout0_18ck670 FIND v(dout0_18) AT=340.025n

.meas tran vdout0_19ck670 FIND v(dout0_19) AT=340.025n

.meas tran vdout0_20ck670 FIND v(dout0_20) AT=340.025n

.meas tran vdout0_21ck670 FIND v(dout0_21) AT=340.025n

.meas tran vdout0_22ck670 FIND v(dout0_22) AT=340.025n

.meas tran vdout0_23ck670 FIND v(dout0_23) AT=340.025n

.meas tran vdout0_24ck670 FIND v(dout0_24) AT=340.025n

.meas tran vdout0_25ck670 FIND v(dout0_25) AT=340.025n

.meas tran vdout0_26ck670 FIND v(dout0_26) AT=340.025n

.meas tran vdout0_27ck670 FIND v(dout0_27) AT=340.025n

.meas tran vdout0_28ck670 FIND v(dout0_28) AT=340.025n

.meas tran vdout0_29ck670 FIND v(dout0_29) AT=340.025n

.meas tran vdout0_30ck670 FIND v(dout0_30) AT=340.025n

.meas tran vdout0_31ck670 FIND v(dout0_31) AT=340.025n

.meas tran vdout0_32ck670 FIND v(dout0_32) AT=340.025n

.meas tran vdout0_33ck670 FIND v(dout0_33) AT=340.025n

.meas tran vdout0_34ck670 FIND v(dout0_34) AT=340.025n

.meas tran vdout0_35ck670 FIND v(dout0_35) AT=340.025n

.meas tran vdout0_36ck670 FIND v(dout0_36) AT=340.025n

.meas tran vdout0_37ck670 FIND v(dout0_37) AT=340.025n

.meas tran vdout0_38ck670 FIND v(dout0_38) AT=340.025n

.meas tran vdout0_39ck670 FIND v(dout0_39) AT=340.025n

.meas tran vdout0_40ck670 FIND v(dout0_40) AT=340.025n

.meas tran vdout0_41ck670 FIND v(dout0_41) AT=340.025n

.meas tran vdout0_42ck670 FIND v(dout0_42) AT=340.025n

.meas tran vdout0_43ck670 FIND v(dout0_43) AT=340.025n

.meas tran vdout0_44ck670 FIND v(dout0_44) AT=340.025n

.meas tran vdout0_45ck670 FIND v(dout0_45) AT=340.025n

.meas tran vdout0_46ck670 FIND v(dout0_46) AT=340.025n

.meas tran vdout0_47ck670 FIND v(dout0_47) AT=340.025n

.meas tran vdout0_48ck670 FIND v(dout0_48) AT=340.025n

.meas tran vdout0_49ck670 FIND v(dout0_49) AT=340.025n

.meas tran vdout0_50ck670 FIND v(dout0_50) AT=340.025n

.meas tran vdout0_51ck670 FIND v(dout0_51) AT=340.025n

.meas tran vdout0_52ck670 FIND v(dout0_52) AT=340.025n

.meas tran vdout0_53ck670 FIND v(dout0_53) AT=340.025n

.meas tran vdout0_54ck670 FIND v(dout0_54) AT=340.025n

.meas tran vdout0_55ck670 FIND v(dout0_55) AT=340.025n

.meas tran vdout0_56ck670 FIND v(dout0_56) AT=340.025n

.meas tran vdout0_57ck670 FIND v(dout0_57) AT=340.025n

.meas tran vdout0_58ck670 FIND v(dout0_58) AT=340.025n

.meas tran vdout0_59ck670 FIND v(dout0_59) AT=340.025n

.meas tran vdout0_60ck670 FIND v(dout0_60) AT=340.025n

.meas tran vdout0_61ck670 FIND v(dout0_61) AT=340.025n

.meas tran vdout0_62ck670 FIND v(dout0_62) AT=340.025n

.meas tran vdout0_63ck670 FIND v(dout0_63) AT=340.025n

.meas tran vdout0_64ck670 FIND v(dout0_64) AT=340.025n

.meas tran vdout0_65ck670 FIND v(dout0_65) AT=340.025n

.meas tran vdout0_66ck670 FIND v(dout0_66) AT=340.025n

.meas tran vdout0_67ck670 FIND v(dout0_67) AT=340.025n

.meas tran vdout0_68ck670 FIND v(dout0_68) AT=340.025n

.meas tran vdout0_69ck670 FIND v(dout0_69) AT=340.025n

.meas tran vdout0_70ck670 FIND v(dout0_70) AT=340.025n

.meas tran vdout0_71ck670 FIND v(dout0_71) AT=340.025n

.meas tran vdout0_72ck670 FIND v(dout0_72) AT=340.025n

.meas tran vdout0_73ck670 FIND v(dout0_73) AT=340.025n

.meas tran vdout0_74ck670 FIND v(dout0_74) AT=340.025n

.meas tran vdout0_75ck670 FIND v(dout0_75) AT=340.025n

.meas tran vdout0_76ck670 FIND v(dout0_76) AT=340.025n

.meas tran vdout0_77ck670 FIND v(dout0_77) AT=340.025n

.meas tran vdout0_78ck670 FIND v(dout0_78) AT=340.025n

.meas tran vdout0_79ck670 FIND v(dout0_79) AT=340.025n

.meas tran vdout0_80ck670 FIND v(dout0_80) AT=340.025n

.meas tran vdout0_81ck670 FIND v(dout0_81) AT=340.025n

.meas tran vdout0_82ck670 FIND v(dout0_82) AT=340.025n

.meas tran vdout0_83ck670 FIND v(dout0_83) AT=340.025n

.meas tran vdout0_84ck670 FIND v(dout0_84) AT=340.025n

.meas tran vdout0_85ck670 FIND v(dout0_85) AT=340.025n

.meas tran vdout0_86ck670 FIND v(dout0_86) AT=340.025n

.meas tran vdout0_87ck670 FIND v(dout0_87) AT=340.025n

.meas tran vdout0_88ck670 FIND v(dout0_88) AT=340.025n

.meas tran vdout0_89ck670 FIND v(dout0_89) AT=340.025n

.meas tran vdout0_90ck670 FIND v(dout0_90) AT=340.025n

.meas tran vdout0_91ck670 FIND v(dout0_91) AT=340.025n

.meas tran vdout0_92ck670 FIND v(dout0_92) AT=340.025n

.meas tran vdout0_93ck670 FIND v(dout0_93) AT=340.025n

.meas tran vdout0_94ck670 FIND v(dout0_94) AT=340.025n

.meas tran vdout0_95ck670 FIND v(dout0_95) AT=340.025n

.meas tran vdout0_96ck670 FIND v(dout0_96) AT=340.025n

.meas tran vdout0_97ck670 FIND v(dout0_97) AT=340.025n

.meas tran vdout0_98ck670 FIND v(dout0_98) AT=340.025n

.meas tran vdout0_99ck670 FIND v(dout0_99) AT=340.025n

.meas tran vdout0_100ck670 FIND v(dout0_100) AT=340.025n

.meas tran vdout0_101ck670 FIND v(dout0_101) AT=340.025n

.meas tran vdout0_102ck670 FIND v(dout0_102) AT=340.025n

.meas tran vdout0_103ck670 FIND v(dout0_103) AT=340.025n

.meas tran vdout0_104ck670 FIND v(dout0_104) AT=340.025n

.meas tran vdout0_105ck670 FIND v(dout0_105) AT=340.025n

.meas tran vdout0_106ck670 FIND v(dout0_106) AT=340.025n

.meas tran vdout0_107ck670 FIND v(dout0_107) AT=340.025n

.meas tran vdout0_108ck670 FIND v(dout0_108) AT=340.025n

.meas tran vdout0_109ck670 FIND v(dout0_109) AT=340.025n

.meas tran vdout0_110ck670 FIND v(dout0_110) AT=340.025n

.meas tran vdout0_111ck670 FIND v(dout0_111) AT=340.025n

.meas tran vdout0_112ck670 FIND v(dout0_112) AT=340.025n

.meas tran vdout0_113ck670 FIND v(dout0_113) AT=340.025n

.meas tran vdout0_114ck670 FIND v(dout0_114) AT=340.025n

.meas tran vdout0_115ck670 FIND v(dout0_115) AT=340.025n

.meas tran vdout0_116ck670 FIND v(dout0_116) AT=340.025n

.meas tran vdout0_117ck670 FIND v(dout0_117) AT=340.025n

.meas tran vdout0_118ck670 FIND v(dout0_118) AT=340.025n

.meas tran vdout0_119ck670 FIND v(dout0_119) AT=340.025n

.meas tran vdout0_120ck670 FIND v(dout0_120) AT=340.025n

.meas tran vdout0_121ck670 FIND v(dout0_121) AT=340.025n

.meas tran vdout0_122ck670 FIND v(dout0_122) AT=340.025n

.meas tran vdout0_123ck670 FIND v(dout0_123) AT=340.025n

.meas tran vdout0_124ck670 FIND v(dout0_124) AT=340.025n

.meas tran vdout0_125ck670 FIND v(dout0_125) AT=340.025n

.meas tran vdout0_126ck670 FIND v(dout0_126) AT=340.025n

.meas tran vdout0_127ck670 FIND v(dout0_127) AT=340.025n

.meas tran vdout0_128ck670 FIND v(dout0_128) AT=340.025n

.meas tran vdout0_129ck670 FIND v(dout0_129) AT=340.025n

.meas tran vdout0_130ck670 FIND v(dout0_130) AT=340.025n

.meas tran vdout0_131ck670 FIND v(dout0_131) AT=340.025n

.meas tran vdout0_132ck670 FIND v(dout0_132) AT=340.025n

.meas tran vdout0_133ck670 FIND v(dout0_133) AT=340.025n

.meas tran vdout0_134ck670 FIND v(dout0_134) AT=340.025n

.meas tran vdout0_135ck670 FIND v(dout0_135) AT=340.025n

.meas tran vdout0_136ck670 FIND v(dout0_136) AT=340.025n

.meas tran vdout0_137ck670 FIND v(dout0_137) AT=340.025n

.meas tran vdout0_138ck670 FIND v(dout0_138) AT=340.025n

.meas tran vdout0_139ck670 FIND v(dout0_139) AT=340.025n

.meas tran vdout0_140ck670 FIND v(dout0_140) AT=340.025n

.meas tran vdout0_141ck670 FIND v(dout0_141) AT=340.025n

.meas tran vdout0_142ck670 FIND v(dout0_142) AT=340.025n

.meas tran vdout0_143ck670 FIND v(dout0_143) AT=340.025n

.meas tran vdout0_144ck670 FIND v(dout0_144) AT=340.025n

.meas tran vdout0_145ck670 FIND v(dout0_145) AT=340.025n

.meas tran vdout0_146ck670 FIND v(dout0_146) AT=340.025n

.meas tran vdout0_147ck670 FIND v(dout0_147) AT=340.025n

.meas tran vdout0_148ck670 FIND v(dout0_148) AT=340.025n

.meas tran vdout0_149ck670 FIND v(dout0_149) AT=340.025n

.meas tran vdout0_150ck670 FIND v(dout0_150) AT=340.025n

.meas tran vdout0_151ck670 FIND v(dout0_151) AT=340.025n

.meas tran vdout0_152ck670 FIND v(dout0_152) AT=340.025n

.meas tran vdout0_153ck670 FIND v(dout0_153) AT=340.025n

.meas tran vdout0_154ck670 FIND v(dout0_154) AT=340.025n

.meas tran vdout0_155ck670 FIND v(dout0_155) AT=340.025n

.meas tran vdout0_156ck670 FIND v(dout0_156) AT=340.025n

.meas tran vdout0_157ck670 FIND v(dout0_157) AT=340.025n

.meas tran vdout0_158ck670 FIND v(dout0_158) AT=340.025n

.meas tran vdout0_159ck670 FIND v(dout0_159) AT=340.025n

.meas tran vdout0_160ck670 FIND v(dout0_160) AT=340.025n

.meas tran vdout0_161ck670 FIND v(dout0_161) AT=340.025n

.meas tran vdout0_162ck670 FIND v(dout0_162) AT=340.025n

.meas tran vdout0_163ck670 FIND v(dout0_163) AT=340.025n

.meas tran vdout0_164ck670 FIND v(dout0_164) AT=340.025n

.meas tran vdout0_165ck670 FIND v(dout0_165) AT=340.025n

.meas tran vdout0_166ck670 FIND v(dout0_166) AT=340.025n

.meas tran vdout0_167ck670 FIND v(dout0_167) AT=340.025n

.meas tran vdout0_168ck670 FIND v(dout0_168) AT=340.025n

.meas tran vdout0_169ck670 FIND v(dout0_169) AT=340.025n

.meas tran vdout0_170ck670 FIND v(dout0_170) AT=340.025n

.meas tran vdout0_171ck670 FIND v(dout0_171) AT=340.025n

.meas tran vdout0_172ck670 FIND v(dout0_172) AT=340.025n

.meas tran vdout0_173ck670 FIND v(dout0_173) AT=340.025n

.meas tran vdout0_174ck670 FIND v(dout0_174) AT=340.025n

.meas tran vdout0_175ck670 FIND v(dout0_175) AT=340.025n

.meas tran vdout0_176ck670 FIND v(dout0_176) AT=340.025n

.meas tran vdout0_177ck670 FIND v(dout0_177) AT=340.025n

.meas tran vdout0_178ck670 FIND v(dout0_178) AT=340.025n

.meas tran vdout0_179ck670 FIND v(dout0_179) AT=340.025n

.meas tran vdout0_180ck670 FIND v(dout0_180) AT=340.025n

.meas tran vdout0_181ck670 FIND v(dout0_181) AT=340.025n

.meas tran vdout0_182ck670 FIND v(dout0_182) AT=340.025n

.meas tran vdout0_183ck670 FIND v(dout0_183) AT=340.025n

.meas tran vdout0_184ck670 FIND v(dout0_184) AT=340.025n

.meas tran vdout0_185ck670 FIND v(dout0_185) AT=340.025n

.meas tran vdout0_186ck670 FIND v(dout0_186) AT=340.025n

.meas tran vdout0_187ck670 FIND v(dout0_187) AT=340.025n

.meas tran vdout0_188ck670 FIND v(dout0_188) AT=340.025n

.meas tran vdout0_189ck670 FIND v(dout0_189) AT=340.025n

.meas tran vdout0_190ck670 FIND v(dout0_190) AT=340.025n

.meas tran vdout0_191ck670 FIND v(dout0_191) AT=340.025n

.meas tran vdout0_192ck670 FIND v(dout0_192) AT=340.025n

.meas tran vdout0_193ck670 FIND v(dout0_193) AT=340.025n

.meas tran vdout0_194ck670 FIND v(dout0_194) AT=340.025n

.meas tran vdout0_195ck670 FIND v(dout0_195) AT=340.025n

.meas tran vdout0_196ck670 FIND v(dout0_196) AT=340.025n

.meas tran vdout0_197ck670 FIND v(dout0_197) AT=340.025n

.meas tran vdout0_198ck670 FIND v(dout0_198) AT=340.025n

.meas tran vdout0_199ck670 FIND v(dout0_199) AT=340.025n

.meas tran vdout0_200ck670 FIND v(dout0_200) AT=340.025n

.meas tran vdout0_201ck670 FIND v(dout0_201) AT=340.025n

.meas tran vdout0_202ck670 FIND v(dout0_202) AT=340.025n

.meas tran vdout0_203ck670 FIND v(dout0_203) AT=340.025n

.meas tran vdout0_204ck670 FIND v(dout0_204) AT=340.025n

.meas tran vdout0_205ck670 FIND v(dout0_205) AT=340.025n

.meas tran vdout0_206ck670 FIND v(dout0_206) AT=340.025n

.meas tran vdout0_207ck670 FIND v(dout0_207) AT=340.025n

.meas tran vdout0_208ck670 FIND v(dout0_208) AT=340.025n

.meas tran vdout0_209ck670 FIND v(dout0_209) AT=340.025n

.meas tran vdout0_210ck670 FIND v(dout0_210) AT=340.025n

.meas tran vdout0_211ck670 FIND v(dout0_211) AT=340.025n

.meas tran vdout0_212ck670 FIND v(dout0_212) AT=340.025n

.meas tran vdout0_213ck670 FIND v(dout0_213) AT=340.025n

.meas tran vdout0_214ck670 FIND v(dout0_214) AT=340.025n

.meas tran vdout0_215ck670 FIND v(dout0_215) AT=340.025n

.meas tran vdout0_216ck670 FIND v(dout0_216) AT=340.025n

.meas tran vdout0_217ck670 FIND v(dout0_217) AT=340.025n

.meas tran vdout0_218ck670 FIND v(dout0_218) AT=340.025n

.meas tran vdout0_219ck670 FIND v(dout0_219) AT=340.025n

.meas tran vdout0_220ck670 FIND v(dout0_220) AT=340.025n

.meas tran vdout0_221ck670 FIND v(dout0_221) AT=340.025n

.meas tran vdout0_222ck670 FIND v(dout0_222) AT=340.025n

.meas tran vdout0_223ck670 FIND v(dout0_223) AT=340.025n

.meas tran vdout0_224ck670 FIND v(dout0_224) AT=340.025n

.meas tran vdout0_225ck670 FIND v(dout0_225) AT=340.025n

.meas tran vdout0_226ck670 FIND v(dout0_226) AT=340.025n

.meas tran vdout0_227ck670 FIND v(dout0_227) AT=340.025n

.meas tran vdout0_228ck670 FIND v(dout0_228) AT=340.025n

.meas tran vdout0_229ck670 FIND v(dout0_229) AT=340.025n

.meas tran vdout0_230ck670 FIND v(dout0_230) AT=340.025n

.meas tran vdout0_231ck670 FIND v(dout0_231) AT=340.025n

.meas tran vdout0_232ck670 FIND v(dout0_232) AT=340.025n

.meas tran vdout0_233ck670 FIND v(dout0_233) AT=340.025n

.meas tran vdout0_234ck670 FIND v(dout0_234) AT=340.025n

.meas tran vdout0_235ck670 FIND v(dout0_235) AT=340.025n

.meas tran vdout0_236ck670 FIND v(dout0_236) AT=340.025n

.meas tran vdout0_237ck670 FIND v(dout0_237) AT=340.025n

.meas tran vdout0_238ck670 FIND v(dout0_238) AT=340.025n

.meas tran vdout0_239ck670 FIND v(dout0_239) AT=340.025n

.meas tran vdout0_240ck670 FIND v(dout0_240) AT=340.025n

.meas tran vdout0_241ck670 FIND v(dout0_241) AT=340.025n

.meas tran vdout0_242ck670 FIND v(dout0_242) AT=340.025n

.meas tran vdout0_243ck670 FIND v(dout0_243) AT=340.025n

.meas tran vdout0_244ck670 FIND v(dout0_244) AT=340.025n

.meas tran vdout0_245ck670 FIND v(dout0_245) AT=340.025n

.meas tran vdout0_246ck670 FIND v(dout0_246) AT=340.025n

.meas tran vdout0_247ck670 FIND v(dout0_247) AT=340.025n

.meas tran vdout0_248ck670 FIND v(dout0_248) AT=340.025n

.meas tran vdout0_249ck670 FIND v(dout0_249) AT=340.025n

.meas tran vdout0_250ck670 FIND v(dout0_250) AT=340.025n

.meas tran vdout0_251ck670 FIND v(dout0_251) AT=340.025n

.meas tran vdout0_252ck670 FIND v(dout0_252) AT=340.025n

.meas tran vdout0_253ck670 FIND v(dout0_253) AT=340.025n

.meas tran vdout0_254ck670 FIND v(dout0_254) AT=340.025n

.meas tran vdout0_255ck670 FIND v(dout0_255) AT=340.025n

.meas tran vdout0_0ck690 FIND v(dout0_0) AT=350.025n

.meas tran vdout0_1ck690 FIND v(dout0_1) AT=350.025n

.meas tran vdout0_2ck690 FIND v(dout0_2) AT=350.025n

.meas tran vdout0_3ck690 FIND v(dout0_3) AT=350.025n

.meas tran vdout0_4ck690 FIND v(dout0_4) AT=350.025n

.meas tran vdout0_5ck690 FIND v(dout0_5) AT=350.025n

.meas tran vdout0_6ck690 FIND v(dout0_6) AT=350.025n

.meas tran vdout0_7ck690 FIND v(dout0_7) AT=350.025n

.meas tran vdout0_8ck690 FIND v(dout0_8) AT=350.025n

.meas tran vdout0_9ck690 FIND v(dout0_9) AT=350.025n

.meas tran vdout0_10ck690 FIND v(dout0_10) AT=350.025n

.meas tran vdout0_11ck690 FIND v(dout0_11) AT=350.025n

.meas tran vdout0_12ck690 FIND v(dout0_12) AT=350.025n

.meas tran vdout0_13ck690 FIND v(dout0_13) AT=350.025n

.meas tran vdout0_14ck690 FIND v(dout0_14) AT=350.025n

.meas tran vdout0_15ck690 FIND v(dout0_15) AT=350.025n

.meas tran vdout0_16ck690 FIND v(dout0_16) AT=350.025n

.meas tran vdout0_17ck690 FIND v(dout0_17) AT=350.025n

.meas tran vdout0_18ck690 FIND v(dout0_18) AT=350.025n

.meas tran vdout0_19ck690 FIND v(dout0_19) AT=350.025n

.meas tran vdout0_20ck690 FIND v(dout0_20) AT=350.025n

.meas tran vdout0_21ck690 FIND v(dout0_21) AT=350.025n

.meas tran vdout0_22ck690 FIND v(dout0_22) AT=350.025n

.meas tran vdout0_23ck690 FIND v(dout0_23) AT=350.025n

.meas tran vdout0_24ck690 FIND v(dout0_24) AT=350.025n

.meas tran vdout0_25ck690 FIND v(dout0_25) AT=350.025n

.meas tran vdout0_26ck690 FIND v(dout0_26) AT=350.025n

.meas tran vdout0_27ck690 FIND v(dout0_27) AT=350.025n

.meas tran vdout0_28ck690 FIND v(dout0_28) AT=350.025n

.meas tran vdout0_29ck690 FIND v(dout0_29) AT=350.025n

.meas tran vdout0_30ck690 FIND v(dout0_30) AT=350.025n

.meas tran vdout0_31ck690 FIND v(dout0_31) AT=350.025n

.meas tran vdout0_32ck690 FIND v(dout0_32) AT=350.025n

.meas tran vdout0_33ck690 FIND v(dout0_33) AT=350.025n

.meas tran vdout0_34ck690 FIND v(dout0_34) AT=350.025n

.meas tran vdout0_35ck690 FIND v(dout0_35) AT=350.025n

.meas tran vdout0_36ck690 FIND v(dout0_36) AT=350.025n

.meas tran vdout0_37ck690 FIND v(dout0_37) AT=350.025n

.meas tran vdout0_38ck690 FIND v(dout0_38) AT=350.025n

.meas tran vdout0_39ck690 FIND v(dout0_39) AT=350.025n

.meas tran vdout0_40ck690 FIND v(dout0_40) AT=350.025n

.meas tran vdout0_41ck690 FIND v(dout0_41) AT=350.025n

.meas tran vdout0_42ck690 FIND v(dout0_42) AT=350.025n

.meas tran vdout0_43ck690 FIND v(dout0_43) AT=350.025n

.meas tran vdout0_44ck690 FIND v(dout0_44) AT=350.025n

.meas tran vdout0_45ck690 FIND v(dout0_45) AT=350.025n

.meas tran vdout0_46ck690 FIND v(dout0_46) AT=350.025n

.meas tran vdout0_47ck690 FIND v(dout0_47) AT=350.025n

.meas tran vdout0_48ck690 FIND v(dout0_48) AT=350.025n

.meas tran vdout0_49ck690 FIND v(dout0_49) AT=350.025n

.meas tran vdout0_50ck690 FIND v(dout0_50) AT=350.025n

.meas tran vdout0_51ck690 FIND v(dout0_51) AT=350.025n

.meas tran vdout0_52ck690 FIND v(dout0_52) AT=350.025n

.meas tran vdout0_53ck690 FIND v(dout0_53) AT=350.025n

.meas tran vdout0_54ck690 FIND v(dout0_54) AT=350.025n

.meas tran vdout0_55ck690 FIND v(dout0_55) AT=350.025n

.meas tran vdout0_56ck690 FIND v(dout0_56) AT=350.025n

.meas tran vdout0_57ck690 FIND v(dout0_57) AT=350.025n

.meas tran vdout0_58ck690 FIND v(dout0_58) AT=350.025n

.meas tran vdout0_59ck690 FIND v(dout0_59) AT=350.025n

.meas tran vdout0_60ck690 FIND v(dout0_60) AT=350.025n

.meas tran vdout0_61ck690 FIND v(dout0_61) AT=350.025n

.meas tran vdout0_62ck690 FIND v(dout0_62) AT=350.025n

.meas tran vdout0_63ck690 FIND v(dout0_63) AT=350.025n

.meas tran vdout0_64ck690 FIND v(dout0_64) AT=350.025n

.meas tran vdout0_65ck690 FIND v(dout0_65) AT=350.025n

.meas tran vdout0_66ck690 FIND v(dout0_66) AT=350.025n

.meas tran vdout0_67ck690 FIND v(dout0_67) AT=350.025n

.meas tran vdout0_68ck690 FIND v(dout0_68) AT=350.025n

.meas tran vdout0_69ck690 FIND v(dout0_69) AT=350.025n

.meas tran vdout0_70ck690 FIND v(dout0_70) AT=350.025n

.meas tran vdout0_71ck690 FIND v(dout0_71) AT=350.025n

.meas tran vdout0_72ck690 FIND v(dout0_72) AT=350.025n

.meas tran vdout0_73ck690 FIND v(dout0_73) AT=350.025n

.meas tran vdout0_74ck690 FIND v(dout0_74) AT=350.025n

.meas tran vdout0_75ck690 FIND v(dout0_75) AT=350.025n

.meas tran vdout0_76ck690 FIND v(dout0_76) AT=350.025n

.meas tran vdout0_77ck690 FIND v(dout0_77) AT=350.025n

.meas tran vdout0_78ck690 FIND v(dout0_78) AT=350.025n

.meas tran vdout0_79ck690 FIND v(dout0_79) AT=350.025n

.meas tran vdout0_80ck690 FIND v(dout0_80) AT=350.025n

.meas tran vdout0_81ck690 FIND v(dout0_81) AT=350.025n

.meas tran vdout0_82ck690 FIND v(dout0_82) AT=350.025n

.meas tran vdout0_83ck690 FIND v(dout0_83) AT=350.025n

.meas tran vdout0_84ck690 FIND v(dout0_84) AT=350.025n

.meas tran vdout0_85ck690 FIND v(dout0_85) AT=350.025n

.meas tran vdout0_86ck690 FIND v(dout0_86) AT=350.025n

.meas tran vdout0_87ck690 FIND v(dout0_87) AT=350.025n

.meas tran vdout0_88ck690 FIND v(dout0_88) AT=350.025n

.meas tran vdout0_89ck690 FIND v(dout0_89) AT=350.025n

.meas tran vdout0_90ck690 FIND v(dout0_90) AT=350.025n

.meas tran vdout0_91ck690 FIND v(dout0_91) AT=350.025n

.meas tran vdout0_92ck690 FIND v(dout0_92) AT=350.025n

.meas tran vdout0_93ck690 FIND v(dout0_93) AT=350.025n

.meas tran vdout0_94ck690 FIND v(dout0_94) AT=350.025n

.meas tran vdout0_95ck690 FIND v(dout0_95) AT=350.025n

.meas tran vdout0_96ck690 FIND v(dout0_96) AT=350.025n

.meas tran vdout0_97ck690 FIND v(dout0_97) AT=350.025n

.meas tran vdout0_98ck690 FIND v(dout0_98) AT=350.025n

.meas tran vdout0_99ck690 FIND v(dout0_99) AT=350.025n

.meas tran vdout0_100ck690 FIND v(dout0_100) AT=350.025n

.meas tran vdout0_101ck690 FIND v(dout0_101) AT=350.025n

.meas tran vdout0_102ck690 FIND v(dout0_102) AT=350.025n

.meas tran vdout0_103ck690 FIND v(dout0_103) AT=350.025n

.meas tran vdout0_104ck690 FIND v(dout0_104) AT=350.025n

.meas tran vdout0_105ck690 FIND v(dout0_105) AT=350.025n

.meas tran vdout0_106ck690 FIND v(dout0_106) AT=350.025n

.meas tran vdout0_107ck690 FIND v(dout0_107) AT=350.025n

.meas tran vdout0_108ck690 FIND v(dout0_108) AT=350.025n

.meas tran vdout0_109ck690 FIND v(dout0_109) AT=350.025n

.meas tran vdout0_110ck690 FIND v(dout0_110) AT=350.025n

.meas tran vdout0_111ck690 FIND v(dout0_111) AT=350.025n

.meas tran vdout0_112ck690 FIND v(dout0_112) AT=350.025n

.meas tran vdout0_113ck690 FIND v(dout0_113) AT=350.025n

.meas tran vdout0_114ck690 FIND v(dout0_114) AT=350.025n

.meas tran vdout0_115ck690 FIND v(dout0_115) AT=350.025n

.meas tran vdout0_116ck690 FIND v(dout0_116) AT=350.025n

.meas tran vdout0_117ck690 FIND v(dout0_117) AT=350.025n

.meas tran vdout0_118ck690 FIND v(dout0_118) AT=350.025n

.meas tran vdout0_119ck690 FIND v(dout0_119) AT=350.025n

.meas tran vdout0_120ck690 FIND v(dout0_120) AT=350.025n

.meas tran vdout0_121ck690 FIND v(dout0_121) AT=350.025n

.meas tran vdout0_122ck690 FIND v(dout0_122) AT=350.025n

.meas tran vdout0_123ck690 FIND v(dout0_123) AT=350.025n

.meas tran vdout0_124ck690 FIND v(dout0_124) AT=350.025n

.meas tran vdout0_125ck690 FIND v(dout0_125) AT=350.025n

.meas tran vdout0_126ck690 FIND v(dout0_126) AT=350.025n

.meas tran vdout0_127ck690 FIND v(dout0_127) AT=350.025n

.meas tran vdout0_128ck690 FIND v(dout0_128) AT=350.025n

.meas tran vdout0_129ck690 FIND v(dout0_129) AT=350.025n

.meas tran vdout0_130ck690 FIND v(dout0_130) AT=350.025n

.meas tran vdout0_131ck690 FIND v(dout0_131) AT=350.025n

.meas tran vdout0_132ck690 FIND v(dout0_132) AT=350.025n

.meas tran vdout0_133ck690 FIND v(dout0_133) AT=350.025n

.meas tran vdout0_134ck690 FIND v(dout0_134) AT=350.025n

.meas tran vdout0_135ck690 FIND v(dout0_135) AT=350.025n

.meas tran vdout0_136ck690 FIND v(dout0_136) AT=350.025n

.meas tran vdout0_137ck690 FIND v(dout0_137) AT=350.025n

.meas tran vdout0_138ck690 FIND v(dout0_138) AT=350.025n

.meas tran vdout0_139ck690 FIND v(dout0_139) AT=350.025n

.meas tran vdout0_140ck690 FIND v(dout0_140) AT=350.025n

.meas tran vdout0_141ck690 FIND v(dout0_141) AT=350.025n

.meas tran vdout0_142ck690 FIND v(dout0_142) AT=350.025n

.meas tran vdout0_143ck690 FIND v(dout0_143) AT=350.025n

.meas tran vdout0_144ck690 FIND v(dout0_144) AT=350.025n

.meas tran vdout0_145ck690 FIND v(dout0_145) AT=350.025n

.meas tran vdout0_146ck690 FIND v(dout0_146) AT=350.025n

.meas tran vdout0_147ck690 FIND v(dout0_147) AT=350.025n

.meas tran vdout0_148ck690 FIND v(dout0_148) AT=350.025n

.meas tran vdout0_149ck690 FIND v(dout0_149) AT=350.025n

.meas tran vdout0_150ck690 FIND v(dout0_150) AT=350.025n

.meas tran vdout0_151ck690 FIND v(dout0_151) AT=350.025n

.meas tran vdout0_152ck690 FIND v(dout0_152) AT=350.025n

.meas tran vdout0_153ck690 FIND v(dout0_153) AT=350.025n

.meas tran vdout0_154ck690 FIND v(dout0_154) AT=350.025n

.meas tran vdout0_155ck690 FIND v(dout0_155) AT=350.025n

.meas tran vdout0_156ck690 FIND v(dout0_156) AT=350.025n

.meas tran vdout0_157ck690 FIND v(dout0_157) AT=350.025n

.meas tran vdout0_158ck690 FIND v(dout0_158) AT=350.025n

.meas tran vdout0_159ck690 FIND v(dout0_159) AT=350.025n

.meas tran vdout0_160ck690 FIND v(dout0_160) AT=350.025n

.meas tran vdout0_161ck690 FIND v(dout0_161) AT=350.025n

.meas tran vdout0_162ck690 FIND v(dout0_162) AT=350.025n

.meas tran vdout0_163ck690 FIND v(dout0_163) AT=350.025n

.meas tran vdout0_164ck690 FIND v(dout0_164) AT=350.025n

.meas tran vdout0_165ck690 FIND v(dout0_165) AT=350.025n

.meas tran vdout0_166ck690 FIND v(dout0_166) AT=350.025n

.meas tran vdout0_167ck690 FIND v(dout0_167) AT=350.025n

.meas tran vdout0_168ck690 FIND v(dout0_168) AT=350.025n

.meas tran vdout0_169ck690 FIND v(dout0_169) AT=350.025n

.meas tran vdout0_170ck690 FIND v(dout0_170) AT=350.025n

.meas tran vdout0_171ck690 FIND v(dout0_171) AT=350.025n

.meas tran vdout0_172ck690 FIND v(dout0_172) AT=350.025n

.meas tran vdout0_173ck690 FIND v(dout0_173) AT=350.025n

.meas tran vdout0_174ck690 FIND v(dout0_174) AT=350.025n

.meas tran vdout0_175ck690 FIND v(dout0_175) AT=350.025n

.meas tran vdout0_176ck690 FIND v(dout0_176) AT=350.025n

.meas tran vdout0_177ck690 FIND v(dout0_177) AT=350.025n

.meas tran vdout0_178ck690 FIND v(dout0_178) AT=350.025n

.meas tran vdout0_179ck690 FIND v(dout0_179) AT=350.025n

.meas tran vdout0_180ck690 FIND v(dout0_180) AT=350.025n

.meas tran vdout0_181ck690 FIND v(dout0_181) AT=350.025n

.meas tran vdout0_182ck690 FIND v(dout0_182) AT=350.025n

.meas tran vdout0_183ck690 FIND v(dout0_183) AT=350.025n

.meas tran vdout0_184ck690 FIND v(dout0_184) AT=350.025n

.meas tran vdout0_185ck690 FIND v(dout0_185) AT=350.025n

.meas tran vdout0_186ck690 FIND v(dout0_186) AT=350.025n

.meas tran vdout0_187ck690 FIND v(dout0_187) AT=350.025n

.meas tran vdout0_188ck690 FIND v(dout0_188) AT=350.025n

.meas tran vdout0_189ck690 FIND v(dout0_189) AT=350.025n

.meas tran vdout0_190ck690 FIND v(dout0_190) AT=350.025n

.meas tran vdout0_191ck690 FIND v(dout0_191) AT=350.025n

.meas tran vdout0_192ck690 FIND v(dout0_192) AT=350.025n

.meas tran vdout0_193ck690 FIND v(dout0_193) AT=350.025n

.meas tran vdout0_194ck690 FIND v(dout0_194) AT=350.025n

.meas tran vdout0_195ck690 FIND v(dout0_195) AT=350.025n

.meas tran vdout0_196ck690 FIND v(dout0_196) AT=350.025n

.meas tran vdout0_197ck690 FIND v(dout0_197) AT=350.025n

.meas tran vdout0_198ck690 FIND v(dout0_198) AT=350.025n

.meas tran vdout0_199ck690 FIND v(dout0_199) AT=350.025n

.meas tran vdout0_200ck690 FIND v(dout0_200) AT=350.025n

.meas tran vdout0_201ck690 FIND v(dout0_201) AT=350.025n

.meas tran vdout0_202ck690 FIND v(dout0_202) AT=350.025n

.meas tran vdout0_203ck690 FIND v(dout0_203) AT=350.025n

.meas tran vdout0_204ck690 FIND v(dout0_204) AT=350.025n

.meas tran vdout0_205ck690 FIND v(dout0_205) AT=350.025n

.meas tran vdout0_206ck690 FIND v(dout0_206) AT=350.025n

.meas tran vdout0_207ck690 FIND v(dout0_207) AT=350.025n

.meas tran vdout0_208ck690 FIND v(dout0_208) AT=350.025n

.meas tran vdout0_209ck690 FIND v(dout0_209) AT=350.025n

.meas tran vdout0_210ck690 FIND v(dout0_210) AT=350.025n

.meas tran vdout0_211ck690 FIND v(dout0_211) AT=350.025n

.meas tran vdout0_212ck690 FIND v(dout0_212) AT=350.025n

.meas tran vdout0_213ck690 FIND v(dout0_213) AT=350.025n

.meas tran vdout0_214ck690 FIND v(dout0_214) AT=350.025n

.meas tran vdout0_215ck690 FIND v(dout0_215) AT=350.025n

.meas tran vdout0_216ck690 FIND v(dout0_216) AT=350.025n

.meas tran vdout0_217ck690 FIND v(dout0_217) AT=350.025n

.meas tran vdout0_218ck690 FIND v(dout0_218) AT=350.025n

.meas tran vdout0_219ck690 FIND v(dout0_219) AT=350.025n

.meas tran vdout0_220ck690 FIND v(dout0_220) AT=350.025n

.meas tran vdout0_221ck690 FIND v(dout0_221) AT=350.025n

.meas tran vdout0_222ck690 FIND v(dout0_222) AT=350.025n

.meas tran vdout0_223ck690 FIND v(dout0_223) AT=350.025n

.meas tran vdout0_224ck690 FIND v(dout0_224) AT=350.025n

.meas tran vdout0_225ck690 FIND v(dout0_225) AT=350.025n

.meas tran vdout0_226ck690 FIND v(dout0_226) AT=350.025n

.meas tran vdout0_227ck690 FIND v(dout0_227) AT=350.025n

.meas tran vdout0_228ck690 FIND v(dout0_228) AT=350.025n

.meas tran vdout0_229ck690 FIND v(dout0_229) AT=350.025n

.meas tran vdout0_230ck690 FIND v(dout0_230) AT=350.025n

.meas tran vdout0_231ck690 FIND v(dout0_231) AT=350.025n

.meas tran vdout0_232ck690 FIND v(dout0_232) AT=350.025n

.meas tran vdout0_233ck690 FIND v(dout0_233) AT=350.025n

.meas tran vdout0_234ck690 FIND v(dout0_234) AT=350.025n

.meas tran vdout0_235ck690 FIND v(dout0_235) AT=350.025n

.meas tran vdout0_236ck690 FIND v(dout0_236) AT=350.025n

.meas tran vdout0_237ck690 FIND v(dout0_237) AT=350.025n

.meas tran vdout0_238ck690 FIND v(dout0_238) AT=350.025n

.meas tran vdout0_239ck690 FIND v(dout0_239) AT=350.025n

.meas tran vdout0_240ck690 FIND v(dout0_240) AT=350.025n

.meas tran vdout0_241ck690 FIND v(dout0_241) AT=350.025n

.meas tran vdout0_242ck690 FIND v(dout0_242) AT=350.025n

.meas tran vdout0_243ck690 FIND v(dout0_243) AT=350.025n

.meas tran vdout0_244ck690 FIND v(dout0_244) AT=350.025n

.meas tran vdout0_245ck690 FIND v(dout0_245) AT=350.025n

.meas tran vdout0_246ck690 FIND v(dout0_246) AT=350.025n

.meas tran vdout0_247ck690 FIND v(dout0_247) AT=350.025n

.meas tran vdout0_248ck690 FIND v(dout0_248) AT=350.025n

.meas tran vdout0_249ck690 FIND v(dout0_249) AT=350.025n

.meas tran vdout0_250ck690 FIND v(dout0_250) AT=350.025n

.meas tran vdout0_251ck690 FIND v(dout0_251) AT=350.025n

.meas tran vdout0_252ck690 FIND v(dout0_252) AT=350.025n

.meas tran vdout0_253ck690 FIND v(dout0_253) AT=350.025n

.meas tran vdout0_254ck690 FIND v(dout0_254) AT=350.025n

.meas tran vdout0_255ck690 FIND v(dout0_255) AT=350.025n

.meas tran vdout0_0ck740 FIND v(dout0_0) AT=375.025n

.meas tran vdout0_1ck740 FIND v(dout0_1) AT=375.025n

.meas tran vdout0_2ck740 FIND v(dout0_2) AT=375.025n

.meas tran vdout0_3ck740 FIND v(dout0_3) AT=375.025n

.meas tran vdout0_4ck740 FIND v(dout0_4) AT=375.025n

.meas tran vdout0_5ck740 FIND v(dout0_5) AT=375.025n

.meas tran vdout0_6ck740 FIND v(dout0_6) AT=375.025n

.meas tran vdout0_7ck740 FIND v(dout0_7) AT=375.025n

.meas tran vdout0_8ck740 FIND v(dout0_8) AT=375.025n

.meas tran vdout0_9ck740 FIND v(dout0_9) AT=375.025n

.meas tran vdout0_10ck740 FIND v(dout0_10) AT=375.025n

.meas tran vdout0_11ck740 FIND v(dout0_11) AT=375.025n

.meas tran vdout0_12ck740 FIND v(dout0_12) AT=375.025n

.meas tran vdout0_13ck740 FIND v(dout0_13) AT=375.025n

.meas tran vdout0_14ck740 FIND v(dout0_14) AT=375.025n

.meas tran vdout0_15ck740 FIND v(dout0_15) AT=375.025n

.meas tran vdout0_16ck740 FIND v(dout0_16) AT=375.025n

.meas tran vdout0_17ck740 FIND v(dout0_17) AT=375.025n

.meas tran vdout0_18ck740 FIND v(dout0_18) AT=375.025n

.meas tran vdout0_19ck740 FIND v(dout0_19) AT=375.025n

.meas tran vdout0_20ck740 FIND v(dout0_20) AT=375.025n

.meas tran vdout0_21ck740 FIND v(dout0_21) AT=375.025n

.meas tran vdout0_22ck740 FIND v(dout0_22) AT=375.025n

.meas tran vdout0_23ck740 FIND v(dout0_23) AT=375.025n

.meas tran vdout0_24ck740 FIND v(dout0_24) AT=375.025n

.meas tran vdout0_25ck740 FIND v(dout0_25) AT=375.025n

.meas tran vdout0_26ck740 FIND v(dout0_26) AT=375.025n

.meas tran vdout0_27ck740 FIND v(dout0_27) AT=375.025n

.meas tran vdout0_28ck740 FIND v(dout0_28) AT=375.025n

.meas tran vdout0_29ck740 FIND v(dout0_29) AT=375.025n

.meas tran vdout0_30ck740 FIND v(dout0_30) AT=375.025n

.meas tran vdout0_31ck740 FIND v(dout0_31) AT=375.025n

.meas tran vdout0_32ck740 FIND v(dout0_32) AT=375.025n

.meas tran vdout0_33ck740 FIND v(dout0_33) AT=375.025n

.meas tran vdout0_34ck740 FIND v(dout0_34) AT=375.025n

.meas tran vdout0_35ck740 FIND v(dout0_35) AT=375.025n

.meas tran vdout0_36ck740 FIND v(dout0_36) AT=375.025n

.meas tran vdout0_37ck740 FIND v(dout0_37) AT=375.025n

.meas tran vdout0_38ck740 FIND v(dout0_38) AT=375.025n

.meas tran vdout0_39ck740 FIND v(dout0_39) AT=375.025n

.meas tran vdout0_40ck740 FIND v(dout0_40) AT=375.025n

.meas tran vdout0_41ck740 FIND v(dout0_41) AT=375.025n

.meas tran vdout0_42ck740 FIND v(dout0_42) AT=375.025n

.meas tran vdout0_43ck740 FIND v(dout0_43) AT=375.025n

.meas tran vdout0_44ck740 FIND v(dout0_44) AT=375.025n

.meas tran vdout0_45ck740 FIND v(dout0_45) AT=375.025n

.meas tran vdout0_46ck740 FIND v(dout0_46) AT=375.025n

.meas tran vdout0_47ck740 FIND v(dout0_47) AT=375.025n

.meas tran vdout0_48ck740 FIND v(dout0_48) AT=375.025n

.meas tran vdout0_49ck740 FIND v(dout0_49) AT=375.025n

.meas tran vdout0_50ck740 FIND v(dout0_50) AT=375.025n

.meas tran vdout0_51ck740 FIND v(dout0_51) AT=375.025n

.meas tran vdout0_52ck740 FIND v(dout0_52) AT=375.025n

.meas tran vdout0_53ck740 FIND v(dout0_53) AT=375.025n

.meas tran vdout0_54ck740 FIND v(dout0_54) AT=375.025n

.meas tran vdout0_55ck740 FIND v(dout0_55) AT=375.025n

.meas tran vdout0_56ck740 FIND v(dout0_56) AT=375.025n

.meas tran vdout0_57ck740 FIND v(dout0_57) AT=375.025n

.meas tran vdout0_58ck740 FIND v(dout0_58) AT=375.025n

.meas tran vdout0_59ck740 FIND v(dout0_59) AT=375.025n

.meas tran vdout0_60ck740 FIND v(dout0_60) AT=375.025n

.meas tran vdout0_61ck740 FIND v(dout0_61) AT=375.025n

.meas tran vdout0_62ck740 FIND v(dout0_62) AT=375.025n

.meas tran vdout0_63ck740 FIND v(dout0_63) AT=375.025n

.meas tran vdout0_64ck740 FIND v(dout0_64) AT=375.025n

.meas tran vdout0_65ck740 FIND v(dout0_65) AT=375.025n

.meas tran vdout0_66ck740 FIND v(dout0_66) AT=375.025n

.meas tran vdout0_67ck740 FIND v(dout0_67) AT=375.025n

.meas tran vdout0_68ck740 FIND v(dout0_68) AT=375.025n

.meas tran vdout0_69ck740 FIND v(dout0_69) AT=375.025n

.meas tran vdout0_70ck740 FIND v(dout0_70) AT=375.025n

.meas tran vdout0_71ck740 FIND v(dout0_71) AT=375.025n

.meas tran vdout0_72ck740 FIND v(dout0_72) AT=375.025n

.meas tran vdout0_73ck740 FIND v(dout0_73) AT=375.025n

.meas tran vdout0_74ck740 FIND v(dout0_74) AT=375.025n

.meas tran vdout0_75ck740 FIND v(dout0_75) AT=375.025n

.meas tran vdout0_76ck740 FIND v(dout0_76) AT=375.025n

.meas tran vdout0_77ck740 FIND v(dout0_77) AT=375.025n

.meas tran vdout0_78ck740 FIND v(dout0_78) AT=375.025n

.meas tran vdout0_79ck740 FIND v(dout0_79) AT=375.025n

.meas tran vdout0_80ck740 FIND v(dout0_80) AT=375.025n

.meas tran vdout0_81ck740 FIND v(dout0_81) AT=375.025n

.meas tran vdout0_82ck740 FIND v(dout0_82) AT=375.025n

.meas tran vdout0_83ck740 FIND v(dout0_83) AT=375.025n

.meas tran vdout0_84ck740 FIND v(dout0_84) AT=375.025n

.meas tran vdout0_85ck740 FIND v(dout0_85) AT=375.025n

.meas tran vdout0_86ck740 FIND v(dout0_86) AT=375.025n

.meas tran vdout0_87ck740 FIND v(dout0_87) AT=375.025n

.meas tran vdout0_88ck740 FIND v(dout0_88) AT=375.025n

.meas tran vdout0_89ck740 FIND v(dout0_89) AT=375.025n

.meas tran vdout0_90ck740 FIND v(dout0_90) AT=375.025n

.meas tran vdout0_91ck740 FIND v(dout0_91) AT=375.025n

.meas tran vdout0_92ck740 FIND v(dout0_92) AT=375.025n

.meas tran vdout0_93ck740 FIND v(dout0_93) AT=375.025n

.meas tran vdout0_94ck740 FIND v(dout0_94) AT=375.025n

.meas tran vdout0_95ck740 FIND v(dout0_95) AT=375.025n

.meas tran vdout0_96ck740 FIND v(dout0_96) AT=375.025n

.meas tran vdout0_97ck740 FIND v(dout0_97) AT=375.025n

.meas tran vdout0_98ck740 FIND v(dout0_98) AT=375.025n

.meas tran vdout0_99ck740 FIND v(dout0_99) AT=375.025n

.meas tran vdout0_100ck740 FIND v(dout0_100) AT=375.025n

.meas tran vdout0_101ck740 FIND v(dout0_101) AT=375.025n

.meas tran vdout0_102ck740 FIND v(dout0_102) AT=375.025n

.meas tran vdout0_103ck740 FIND v(dout0_103) AT=375.025n

.meas tran vdout0_104ck740 FIND v(dout0_104) AT=375.025n

.meas tran vdout0_105ck740 FIND v(dout0_105) AT=375.025n

.meas tran vdout0_106ck740 FIND v(dout0_106) AT=375.025n

.meas tran vdout0_107ck740 FIND v(dout0_107) AT=375.025n

.meas tran vdout0_108ck740 FIND v(dout0_108) AT=375.025n

.meas tran vdout0_109ck740 FIND v(dout0_109) AT=375.025n

.meas tran vdout0_110ck740 FIND v(dout0_110) AT=375.025n

.meas tran vdout0_111ck740 FIND v(dout0_111) AT=375.025n

.meas tran vdout0_112ck740 FIND v(dout0_112) AT=375.025n

.meas tran vdout0_113ck740 FIND v(dout0_113) AT=375.025n

.meas tran vdout0_114ck740 FIND v(dout0_114) AT=375.025n

.meas tran vdout0_115ck740 FIND v(dout0_115) AT=375.025n

.meas tran vdout0_116ck740 FIND v(dout0_116) AT=375.025n

.meas tran vdout0_117ck740 FIND v(dout0_117) AT=375.025n

.meas tran vdout0_118ck740 FIND v(dout0_118) AT=375.025n

.meas tran vdout0_119ck740 FIND v(dout0_119) AT=375.025n

.meas tran vdout0_120ck740 FIND v(dout0_120) AT=375.025n

.meas tran vdout0_121ck740 FIND v(dout0_121) AT=375.025n

.meas tran vdout0_122ck740 FIND v(dout0_122) AT=375.025n

.meas tran vdout0_123ck740 FIND v(dout0_123) AT=375.025n

.meas tran vdout0_124ck740 FIND v(dout0_124) AT=375.025n

.meas tran vdout0_125ck740 FIND v(dout0_125) AT=375.025n

.meas tran vdout0_126ck740 FIND v(dout0_126) AT=375.025n

.meas tran vdout0_127ck740 FIND v(dout0_127) AT=375.025n

.meas tran vdout0_128ck740 FIND v(dout0_128) AT=375.025n

.meas tran vdout0_129ck740 FIND v(dout0_129) AT=375.025n

.meas tran vdout0_130ck740 FIND v(dout0_130) AT=375.025n

.meas tran vdout0_131ck740 FIND v(dout0_131) AT=375.025n

.meas tran vdout0_132ck740 FIND v(dout0_132) AT=375.025n

.meas tran vdout0_133ck740 FIND v(dout0_133) AT=375.025n

.meas tran vdout0_134ck740 FIND v(dout0_134) AT=375.025n

.meas tran vdout0_135ck740 FIND v(dout0_135) AT=375.025n

.meas tran vdout0_136ck740 FIND v(dout0_136) AT=375.025n

.meas tran vdout0_137ck740 FIND v(dout0_137) AT=375.025n

.meas tran vdout0_138ck740 FIND v(dout0_138) AT=375.025n

.meas tran vdout0_139ck740 FIND v(dout0_139) AT=375.025n

.meas tran vdout0_140ck740 FIND v(dout0_140) AT=375.025n

.meas tran vdout0_141ck740 FIND v(dout0_141) AT=375.025n

.meas tran vdout0_142ck740 FIND v(dout0_142) AT=375.025n

.meas tran vdout0_143ck740 FIND v(dout0_143) AT=375.025n

.meas tran vdout0_144ck740 FIND v(dout0_144) AT=375.025n

.meas tran vdout0_145ck740 FIND v(dout0_145) AT=375.025n

.meas tran vdout0_146ck740 FIND v(dout0_146) AT=375.025n

.meas tran vdout0_147ck740 FIND v(dout0_147) AT=375.025n

.meas tran vdout0_148ck740 FIND v(dout0_148) AT=375.025n

.meas tran vdout0_149ck740 FIND v(dout0_149) AT=375.025n

.meas tran vdout0_150ck740 FIND v(dout0_150) AT=375.025n

.meas tran vdout0_151ck740 FIND v(dout0_151) AT=375.025n

.meas tran vdout0_152ck740 FIND v(dout0_152) AT=375.025n

.meas tran vdout0_153ck740 FIND v(dout0_153) AT=375.025n

.meas tran vdout0_154ck740 FIND v(dout0_154) AT=375.025n

.meas tran vdout0_155ck740 FIND v(dout0_155) AT=375.025n

.meas tran vdout0_156ck740 FIND v(dout0_156) AT=375.025n

.meas tran vdout0_157ck740 FIND v(dout0_157) AT=375.025n

.meas tran vdout0_158ck740 FIND v(dout0_158) AT=375.025n

.meas tran vdout0_159ck740 FIND v(dout0_159) AT=375.025n

.meas tran vdout0_160ck740 FIND v(dout0_160) AT=375.025n

.meas tran vdout0_161ck740 FIND v(dout0_161) AT=375.025n

.meas tran vdout0_162ck740 FIND v(dout0_162) AT=375.025n

.meas tran vdout0_163ck740 FIND v(dout0_163) AT=375.025n

.meas tran vdout0_164ck740 FIND v(dout0_164) AT=375.025n

.meas tran vdout0_165ck740 FIND v(dout0_165) AT=375.025n

.meas tran vdout0_166ck740 FIND v(dout0_166) AT=375.025n

.meas tran vdout0_167ck740 FIND v(dout0_167) AT=375.025n

.meas tran vdout0_168ck740 FIND v(dout0_168) AT=375.025n

.meas tran vdout0_169ck740 FIND v(dout0_169) AT=375.025n

.meas tran vdout0_170ck740 FIND v(dout0_170) AT=375.025n

.meas tran vdout0_171ck740 FIND v(dout0_171) AT=375.025n

.meas tran vdout0_172ck740 FIND v(dout0_172) AT=375.025n

.meas tran vdout0_173ck740 FIND v(dout0_173) AT=375.025n

.meas tran vdout0_174ck740 FIND v(dout0_174) AT=375.025n

.meas tran vdout0_175ck740 FIND v(dout0_175) AT=375.025n

.meas tran vdout0_176ck740 FIND v(dout0_176) AT=375.025n

.meas tran vdout0_177ck740 FIND v(dout0_177) AT=375.025n

.meas tran vdout0_178ck740 FIND v(dout0_178) AT=375.025n

.meas tran vdout0_179ck740 FIND v(dout0_179) AT=375.025n

.meas tran vdout0_180ck740 FIND v(dout0_180) AT=375.025n

.meas tran vdout0_181ck740 FIND v(dout0_181) AT=375.025n

.meas tran vdout0_182ck740 FIND v(dout0_182) AT=375.025n

.meas tran vdout0_183ck740 FIND v(dout0_183) AT=375.025n

.meas tran vdout0_184ck740 FIND v(dout0_184) AT=375.025n

.meas tran vdout0_185ck740 FIND v(dout0_185) AT=375.025n

.meas tran vdout0_186ck740 FIND v(dout0_186) AT=375.025n

.meas tran vdout0_187ck740 FIND v(dout0_187) AT=375.025n

.meas tran vdout0_188ck740 FIND v(dout0_188) AT=375.025n

.meas tran vdout0_189ck740 FIND v(dout0_189) AT=375.025n

.meas tran vdout0_190ck740 FIND v(dout0_190) AT=375.025n

.meas tran vdout0_191ck740 FIND v(dout0_191) AT=375.025n

.meas tran vdout0_192ck740 FIND v(dout0_192) AT=375.025n

.meas tran vdout0_193ck740 FIND v(dout0_193) AT=375.025n

.meas tran vdout0_194ck740 FIND v(dout0_194) AT=375.025n

.meas tran vdout0_195ck740 FIND v(dout0_195) AT=375.025n

.meas tran vdout0_196ck740 FIND v(dout0_196) AT=375.025n

.meas tran vdout0_197ck740 FIND v(dout0_197) AT=375.025n

.meas tran vdout0_198ck740 FIND v(dout0_198) AT=375.025n

.meas tran vdout0_199ck740 FIND v(dout0_199) AT=375.025n

.meas tran vdout0_200ck740 FIND v(dout0_200) AT=375.025n

.meas tran vdout0_201ck740 FIND v(dout0_201) AT=375.025n

.meas tran vdout0_202ck740 FIND v(dout0_202) AT=375.025n

.meas tran vdout0_203ck740 FIND v(dout0_203) AT=375.025n

.meas tran vdout0_204ck740 FIND v(dout0_204) AT=375.025n

.meas tran vdout0_205ck740 FIND v(dout0_205) AT=375.025n

.meas tran vdout0_206ck740 FIND v(dout0_206) AT=375.025n

.meas tran vdout0_207ck740 FIND v(dout0_207) AT=375.025n

.meas tran vdout0_208ck740 FIND v(dout0_208) AT=375.025n

.meas tran vdout0_209ck740 FIND v(dout0_209) AT=375.025n

.meas tran vdout0_210ck740 FIND v(dout0_210) AT=375.025n

.meas tran vdout0_211ck740 FIND v(dout0_211) AT=375.025n

.meas tran vdout0_212ck740 FIND v(dout0_212) AT=375.025n

.meas tran vdout0_213ck740 FIND v(dout0_213) AT=375.025n

.meas tran vdout0_214ck740 FIND v(dout0_214) AT=375.025n

.meas tran vdout0_215ck740 FIND v(dout0_215) AT=375.025n

.meas tran vdout0_216ck740 FIND v(dout0_216) AT=375.025n

.meas tran vdout0_217ck740 FIND v(dout0_217) AT=375.025n

.meas tran vdout0_218ck740 FIND v(dout0_218) AT=375.025n

.meas tran vdout0_219ck740 FIND v(dout0_219) AT=375.025n

.meas tran vdout0_220ck740 FIND v(dout0_220) AT=375.025n

.meas tran vdout0_221ck740 FIND v(dout0_221) AT=375.025n

.meas tran vdout0_222ck740 FIND v(dout0_222) AT=375.025n

.meas tran vdout0_223ck740 FIND v(dout0_223) AT=375.025n

.meas tran vdout0_224ck740 FIND v(dout0_224) AT=375.025n

.meas tran vdout0_225ck740 FIND v(dout0_225) AT=375.025n

.meas tran vdout0_226ck740 FIND v(dout0_226) AT=375.025n

.meas tran vdout0_227ck740 FIND v(dout0_227) AT=375.025n

.meas tran vdout0_228ck740 FIND v(dout0_228) AT=375.025n

.meas tran vdout0_229ck740 FIND v(dout0_229) AT=375.025n

.meas tran vdout0_230ck740 FIND v(dout0_230) AT=375.025n

.meas tran vdout0_231ck740 FIND v(dout0_231) AT=375.025n

.meas tran vdout0_232ck740 FIND v(dout0_232) AT=375.025n

.meas tran vdout0_233ck740 FIND v(dout0_233) AT=375.025n

.meas tran vdout0_234ck740 FIND v(dout0_234) AT=375.025n

.meas tran vdout0_235ck740 FIND v(dout0_235) AT=375.025n

.meas tran vdout0_236ck740 FIND v(dout0_236) AT=375.025n

.meas tran vdout0_237ck740 FIND v(dout0_237) AT=375.025n

.meas tran vdout0_238ck740 FIND v(dout0_238) AT=375.025n

.meas tran vdout0_239ck740 FIND v(dout0_239) AT=375.025n

.meas tran vdout0_240ck740 FIND v(dout0_240) AT=375.025n

.meas tran vdout0_241ck740 FIND v(dout0_241) AT=375.025n

.meas tran vdout0_242ck740 FIND v(dout0_242) AT=375.025n

.meas tran vdout0_243ck740 FIND v(dout0_243) AT=375.025n

.meas tran vdout0_244ck740 FIND v(dout0_244) AT=375.025n

.meas tran vdout0_245ck740 FIND v(dout0_245) AT=375.025n

.meas tran vdout0_246ck740 FIND v(dout0_246) AT=375.025n

.meas tran vdout0_247ck740 FIND v(dout0_247) AT=375.025n

.meas tran vdout0_248ck740 FIND v(dout0_248) AT=375.025n

.meas tran vdout0_249ck740 FIND v(dout0_249) AT=375.025n

.meas tran vdout0_250ck740 FIND v(dout0_250) AT=375.025n

.meas tran vdout0_251ck740 FIND v(dout0_251) AT=375.025n

.meas tran vdout0_252ck740 FIND v(dout0_252) AT=375.025n

.meas tran vdout0_253ck740 FIND v(dout0_253) AT=375.025n

.meas tran vdout0_254ck740 FIND v(dout0_254) AT=375.025n

.meas tran vdout0_255ck740 FIND v(dout0_255) AT=375.025n

.meas tran vdout0_0ck820 FIND v(dout0_0) AT=415.025n

.meas tran vdout0_1ck820 FIND v(dout0_1) AT=415.025n

.meas tran vdout0_2ck820 FIND v(dout0_2) AT=415.025n

.meas tran vdout0_3ck820 FIND v(dout0_3) AT=415.025n

.meas tran vdout0_4ck820 FIND v(dout0_4) AT=415.025n

.meas tran vdout0_5ck820 FIND v(dout0_5) AT=415.025n

.meas tran vdout0_6ck820 FIND v(dout0_6) AT=415.025n

.meas tran vdout0_7ck820 FIND v(dout0_7) AT=415.025n

.meas tran vdout0_8ck820 FIND v(dout0_8) AT=415.025n

.meas tran vdout0_9ck820 FIND v(dout0_9) AT=415.025n

.meas tran vdout0_10ck820 FIND v(dout0_10) AT=415.025n

.meas tran vdout0_11ck820 FIND v(dout0_11) AT=415.025n

.meas tran vdout0_12ck820 FIND v(dout0_12) AT=415.025n

.meas tran vdout0_13ck820 FIND v(dout0_13) AT=415.025n

.meas tran vdout0_14ck820 FIND v(dout0_14) AT=415.025n

.meas tran vdout0_15ck820 FIND v(dout0_15) AT=415.025n

.meas tran vdout0_16ck820 FIND v(dout0_16) AT=415.025n

.meas tran vdout0_17ck820 FIND v(dout0_17) AT=415.025n

.meas tran vdout0_18ck820 FIND v(dout0_18) AT=415.025n

.meas tran vdout0_19ck820 FIND v(dout0_19) AT=415.025n

.meas tran vdout0_20ck820 FIND v(dout0_20) AT=415.025n

.meas tran vdout0_21ck820 FIND v(dout0_21) AT=415.025n

.meas tran vdout0_22ck820 FIND v(dout0_22) AT=415.025n

.meas tran vdout0_23ck820 FIND v(dout0_23) AT=415.025n

.meas tran vdout0_24ck820 FIND v(dout0_24) AT=415.025n

.meas tran vdout0_25ck820 FIND v(dout0_25) AT=415.025n

.meas tran vdout0_26ck820 FIND v(dout0_26) AT=415.025n

.meas tran vdout0_27ck820 FIND v(dout0_27) AT=415.025n

.meas tran vdout0_28ck820 FIND v(dout0_28) AT=415.025n

.meas tran vdout0_29ck820 FIND v(dout0_29) AT=415.025n

.meas tran vdout0_30ck820 FIND v(dout0_30) AT=415.025n

.meas tran vdout0_31ck820 FIND v(dout0_31) AT=415.025n

.meas tran vdout0_32ck820 FIND v(dout0_32) AT=415.025n

.meas tran vdout0_33ck820 FIND v(dout0_33) AT=415.025n

.meas tran vdout0_34ck820 FIND v(dout0_34) AT=415.025n

.meas tran vdout0_35ck820 FIND v(dout0_35) AT=415.025n

.meas tran vdout0_36ck820 FIND v(dout0_36) AT=415.025n

.meas tran vdout0_37ck820 FIND v(dout0_37) AT=415.025n

.meas tran vdout0_38ck820 FIND v(dout0_38) AT=415.025n

.meas tran vdout0_39ck820 FIND v(dout0_39) AT=415.025n

.meas tran vdout0_40ck820 FIND v(dout0_40) AT=415.025n

.meas tran vdout0_41ck820 FIND v(dout0_41) AT=415.025n

.meas tran vdout0_42ck820 FIND v(dout0_42) AT=415.025n

.meas tran vdout0_43ck820 FIND v(dout0_43) AT=415.025n

.meas tran vdout0_44ck820 FIND v(dout0_44) AT=415.025n

.meas tran vdout0_45ck820 FIND v(dout0_45) AT=415.025n

.meas tran vdout0_46ck820 FIND v(dout0_46) AT=415.025n

.meas tran vdout0_47ck820 FIND v(dout0_47) AT=415.025n

.meas tran vdout0_48ck820 FIND v(dout0_48) AT=415.025n

.meas tran vdout0_49ck820 FIND v(dout0_49) AT=415.025n

.meas tran vdout0_50ck820 FIND v(dout0_50) AT=415.025n

.meas tran vdout0_51ck820 FIND v(dout0_51) AT=415.025n

.meas tran vdout0_52ck820 FIND v(dout0_52) AT=415.025n

.meas tran vdout0_53ck820 FIND v(dout0_53) AT=415.025n

.meas tran vdout0_54ck820 FIND v(dout0_54) AT=415.025n

.meas tran vdout0_55ck820 FIND v(dout0_55) AT=415.025n

.meas tran vdout0_56ck820 FIND v(dout0_56) AT=415.025n

.meas tran vdout0_57ck820 FIND v(dout0_57) AT=415.025n

.meas tran vdout0_58ck820 FIND v(dout0_58) AT=415.025n

.meas tran vdout0_59ck820 FIND v(dout0_59) AT=415.025n

.meas tran vdout0_60ck820 FIND v(dout0_60) AT=415.025n

.meas tran vdout0_61ck820 FIND v(dout0_61) AT=415.025n

.meas tran vdout0_62ck820 FIND v(dout0_62) AT=415.025n

.meas tran vdout0_63ck820 FIND v(dout0_63) AT=415.025n

.meas tran vdout0_64ck820 FIND v(dout0_64) AT=415.025n

.meas tran vdout0_65ck820 FIND v(dout0_65) AT=415.025n

.meas tran vdout0_66ck820 FIND v(dout0_66) AT=415.025n

.meas tran vdout0_67ck820 FIND v(dout0_67) AT=415.025n

.meas tran vdout0_68ck820 FIND v(dout0_68) AT=415.025n

.meas tran vdout0_69ck820 FIND v(dout0_69) AT=415.025n

.meas tran vdout0_70ck820 FIND v(dout0_70) AT=415.025n

.meas tran vdout0_71ck820 FIND v(dout0_71) AT=415.025n

.meas tran vdout0_72ck820 FIND v(dout0_72) AT=415.025n

.meas tran vdout0_73ck820 FIND v(dout0_73) AT=415.025n

.meas tran vdout0_74ck820 FIND v(dout0_74) AT=415.025n

.meas tran vdout0_75ck820 FIND v(dout0_75) AT=415.025n

.meas tran vdout0_76ck820 FIND v(dout0_76) AT=415.025n

.meas tran vdout0_77ck820 FIND v(dout0_77) AT=415.025n

.meas tran vdout0_78ck820 FIND v(dout0_78) AT=415.025n

.meas tran vdout0_79ck820 FIND v(dout0_79) AT=415.025n

.meas tran vdout0_80ck820 FIND v(dout0_80) AT=415.025n

.meas tran vdout0_81ck820 FIND v(dout0_81) AT=415.025n

.meas tran vdout0_82ck820 FIND v(dout0_82) AT=415.025n

.meas tran vdout0_83ck820 FIND v(dout0_83) AT=415.025n

.meas tran vdout0_84ck820 FIND v(dout0_84) AT=415.025n

.meas tran vdout0_85ck820 FIND v(dout0_85) AT=415.025n

.meas tran vdout0_86ck820 FIND v(dout0_86) AT=415.025n

.meas tran vdout0_87ck820 FIND v(dout0_87) AT=415.025n

.meas tran vdout0_88ck820 FIND v(dout0_88) AT=415.025n

.meas tran vdout0_89ck820 FIND v(dout0_89) AT=415.025n

.meas tran vdout0_90ck820 FIND v(dout0_90) AT=415.025n

.meas tran vdout0_91ck820 FIND v(dout0_91) AT=415.025n

.meas tran vdout0_92ck820 FIND v(dout0_92) AT=415.025n

.meas tran vdout0_93ck820 FIND v(dout0_93) AT=415.025n

.meas tran vdout0_94ck820 FIND v(dout0_94) AT=415.025n

.meas tran vdout0_95ck820 FIND v(dout0_95) AT=415.025n

.meas tran vdout0_96ck820 FIND v(dout0_96) AT=415.025n

.meas tran vdout0_97ck820 FIND v(dout0_97) AT=415.025n

.meas tran vdout0_98ck820 FIND v(dout0_98) AT=415.025n

.meas tran vdout0_99ck820 FIND v(dout0_99) AT=415.025n

.meas tran vdout0_100ck820 FIND v(dout0_100) AT=415.025n

.meas tran vdout0_101ck820 FIND v(dout0_101) AT=415.025n

.meas tran vdout0_102ck820 FIND v(dout0_102) AT=415.025n

.meas tran vdout0_103ck820 FIND v(dout0_103) AT=415.025n

.meas tran vdout0_104ck820 FIND v(dout0_104) AT=415.025n

.meas tran vdout0_105ck820 FIND v(dout0_105) AT=415.025n

.meas tran vdout0_106ck820 FIND v(dout0_106) AT=415.025n

.meas tran vdout0_107ck820 FIND v(dout0_107) AT=415.025n

.meas tran vdout0_108ck820 FIND v(dout0_108) AT=415.025n

.meas tran vdout0_109ck820 FIND v(dout0_109) AT=415.025n

.meas tran vdout0_110ck820 FIND v(dout0_110) AT=415.025n

.meas tran vdout0_111ck820 FIND v(dout0_111) AT=415.025n

.meas tran vdout0_112ck820 FIND v(dout0_112) AT=415.025n

.meas tran vdout0_113ck820 FIND v(dout0_113) AT=415.025n

.meas tran vdout0_114ck820 FIND v(dout0_114) AT=415.025n

.meas tran vdout0_115ck820 FIND v(dout0_115) AT=415.025n

.meas tran vdout0_116ck820 FIND v(dout0_116) AT=415.025n

.meas tran vdout0_117ck820 FIND v(dout0_117) AT=415.025n

.meas tran vdout0_118ck820 FIND v(dout0_118) AT=415.025n

.meas tran vdout0_119ck820 FIND v(dout0_119) AT=415.025n

.meas tran vdout0_120ck820 FIND v(dout0_120) AT=415.025n

.meas tran vdout0_121ck820 FIND v(dout0_121) AT=415.025n

.meas tran vdout0_122ck820 FIND v(dout0_122) AT=415.025n

.meas tran vdout0_123ck820 FIND v(dout0_123) AT=415.025n

.meas tran vdout0_124ck820 FIND v(dout0_124) AT=415.025n

.meas tran vdout0_125ck820 FIND v(dout0_125) AT=415.025n

.meas tran vdout0_126ck820 FIND v(dout0_126) AT=415.025n

.meas tran vdout0_127ck820 FIND v(dout0_127) AT=415.025n

.meas tran vdout0_128ck820 FIND v(dout0_128) AT=415.025n

.meas tran vdout0_129ck820 FIND v(dout0_129) AT=415.025n

.meas tran vdout0_130ck820 FIND v(dout0_130) AT=415.025n

.meas tran vdout0_131ck820 FIND v(dout0_131) AT=415.025n

.meas tran vdout0_132ck820 FIND v(dout0_132) AT=415.025n

.meas tran vdout0_133ck820 FIND v(dout0_133) AT=415.025n

.meas tran vdout0_134ck820 FIND v(dout0_134) AT=415.025n

.meas tran vdout0_135ck820 FIND v(dout0_135) AT=415.025n

.meas tran vdout0_136ck820 FIND v(dout0_136) AT=415.025n

.meas tran vdout0_137ck820 FIND v(dout0_137) AT=415.025n

.meas tran vdout0_138ck820 FIND v(dout0_138) AT=415.025n

.meas tran vdout0_139ck820 FIND v(dout0_139) AT=415.025n

.meas tran vdout0_140ck820 FIND v(dout0_140) AT=415.025n

.meas tran vdout0_141ck820 FIND v(dout0_141) AT=415.025n

.meas tran vdout0_142ck820 FIND v(dout0_142) AT=415.025n

.meas tran vdout0_143ck820 FIND v(dout0_143) AT=415.025n

.meas tran vdout0_144ck820 FIND v(dout0_144) AT=415.025n

.meas tran vdout0_145ck820 FIND v(dout0_145) AT=415.025n

.meas tran vdout0_146ck820 FIND v(dout0_146) AT=415.025n

.meas tran vdout0_147ck820 FIND v(dout0_147) AT=415.025n

.meas tran vdout0_148ck820 FIND v(dout0_148) AT=415.025n

.meas tran vdout0_149ck820 FIND v(dout0_149) AT=415.025n

.meas tran vdout0_150ck820 FIND v(dout0_150) AT=415.025n

.meas tran vdout0_151ck820 FIND v(dout0_151) AT=415.025n

.meas tran vdout0_152ck820 FIND v(dout0_152) AT=415.025n

.meas tran vdout0_153ck820 FIND v(dout0_153) AT=415.025n

.meas tran vdout0_154ck820 FIND v(dout0_154) AT=415.025n

.meas tran vdout0_155ck820 FIND v(dout0_155) AT=415.025n

.meas tran vdout0_156ck820 FIND v(dout0_156) AT=415.025n

.meas tran vdout0_157ck820 FIND v(dout0_157) AT=415.025n

.meas tran vdout0_158ck820 FIND v(dout0_158) AT=415.025n

.meas tran vdout0_159ck820 FIND v(dout0_159) AT=415.025n

.meas tran vdout0_160ck820 FIND v(dout0_160) AT=415.025n

.meas tran vdout0_161ck820 FIND v(dout0_161) AT=415.025n

.meas tran vdout0_162ck820 FIND v(dout0_162) AT=415.025n

.meas tran vdout0_163ck820 FIND v(dout0_163) AT=415.025n

.meas tran vdout0_164ck820 FIND v(dout0_164) AT=415.025n

.meas tran vdout0_165ck820 FIND v(dout0_165) AT=415.025n

.meas tran vdout0_166ck820 FIND v(dout0_166) AT=415.025n

.meas tran vdout0_167ck820 FIND v(dout0_167) AT=415.025n

.meas tran vdout0_168ck820 FIND v(dout0_168) AT=415.025n

.meas tran vdout0_169ck820 FIND v(dout0_169) AT=415.025n

.meas tran vdout0_170ck820 FIND v(dout0_170) AT=415.025n

.meas tran vdout0_171ck820 FIND v(dout0_171) AT=415.025n

.meas tran vdout0_172ck820 FIND v(dout0_172) AT=415.025n

.meas tran vdout0_173ck820 FIND v(dout0_173) AT=415.025n

.meas tran vdout0_174ck820 FIND v(dout0_174) AT=415.025n

.meas tran vdout0_175ck820 FIND v(dout0_175) AT=415.025n

.meas tran vdout0_176ck820 FIND v(dout0_176) AT=415.025n

.meas tran vdout0_177ck820 FIND v(dout0_177) AT=415.025n

.meas tran vdout0_178ck820 FIND v(dout0_178) AT=415.025n

.meas tran vdout0_179ck820 FIND v(dout0_179) AT=415.025n

.meas tran vdout0_180ck820 FIND v(dout0_180) AT=415.025n

.meas tran vdout0_181ck820 FIND v(dout0_181) AT=415.025n

.meas tran vdout0_182ck820 FIND v(dout0_182) AT=415.025n

.meas tran vdout0_183ck820 FIND v(dout0_183) AT=415.025n

.meas tran vdout0_184ck820 FIND v(dout0_184) AT=415.025n

.meas tran vdout0_185ck820 FIND v(dout0_185) AT=415.025n

.meas tran vdout0_186ck820 FIND v(dout0_186) AT=415.025n

.meas tran vdout0_187ck820 FIND v(dout0_187) AT=415.025n

.meas tran vdout0_188ck820 FIND v(dout0_188) AT=415.025n

.meas tran vdout0_189ck820 FIND v(dout0_189) AT=415.025n

.meas tran vdout0_190ck820 FIND v(dout0_190) AT=415.025n

.meas tran vdout0_191ck820 FIND v(dout0_191) AT=415.025n

.meas tran vdout0_192ck820 FIND v(dout0_192) AT=415.025n

.meas tran vdout0_193ck820 FIND v(dout0_193) AT=415.025n

.meas tran vdout0_194ck820 FIND v(dout0_194) AT=415.025n

.meas tran vdout0_195ck820 FIND v(dout0_195) AT=415.025n

.meas tran vdout0_196ck820 FIND v(dout0_196) AT=415.025n

.meas tran vdout0_197ck820 FIND v(dout0_197) AT=415.025n

.meas tran vdout0_198ck820 FIND v(dout0_198) AT=415.025n

.meas tran vdout0_199ck820 FIND v(dout0_199) AT=415.025n

.meas tran vdout0_200ck820 FIND v(dout0_200) AT=415.025n

.meas tran vdout0_201ck820 FIND v(dout0_201) AT=415.025n

.meas tran vdout0_202ck820 FIND v(dout0_202) AT=415.025n

.meas tran vdout0_203ck820 FIND v(dout0_203) AT=415.025n

.meas tran vdout0_204ck820 FIND v(dout0_204) AT=415.025n

.meas tran vdout0_205ck820 FIND v(dout0_205) AT=415.025n

.meas tran vdout0_206ck820 FIND v(dout0_206) AT=415.025n

.meas tran vdout0_207ck820 FIND v(dout0_207) AT=415.025n

.meas tran vdout0_208ck820 FIND v(dout0_208) AT=415.025n

.meas tran vdout0_209ck820 FIND v(dout0_209) AT=415.025n

.meas tran vdout0_210ck820 FIND v(dout0_210) AT=415.025n

.meas tran vdout0_211ck820 FIND v(dout0_211) AT=415.025n

.meas tran vdout0_212ck820 FIND v(dout0_212) AT=415.025n

.meas tran vdout0_213ck820 FIND v(dout0_213) AT=415.025n

.meas tran vdout0_214ck820 FIND v(dout0_214) AT=415.025n

.meas tran vdout0_215ck820 FIND v(dout0_215) AT=415.025n

.meas tran vdout0_216ck820 FIND v(dout0_216) AT=415.025n

.meas tran vdout0_217ck820 FIND v(dout0_217) AT=415.025n

.meas tran vdout0_218ck820 FIND v(dout0_218) AT=415.025n

.meas tran vdout0_219ck820 FIND v(dout0_219) AT=415.025n

.meas tran vdout0_220ck820 FIND v(dout0_220) AT=415.025n

.meas tran vdout0_221ck820 FIND v(dout0_221) AT=415.025n

.meas tran vdout0_222ck820 FIND v(dout0_222) AT=415.025n

.meas tran vdout0_223ck820 FIND v(dout0_223) AT=415.025n

.meas tran vdout0_224ck820 FIND v(dout0_224) AT=415.025n

.meas tran vdout0_225ck820 FIND v(dout0_225) AT=415.025n

.meas tran vdout0_226ck820 FIND v(dout0_226) AT=415.025n

.meas tran vdout0_227ck820 FIND v(dout0_227) AT=415.025n

.meas tran vdout0_228ck820 FIND v(dout0_228) AT=415.025n

.meas tran vdout0_229ck820 FIND v(dout0_229) AT=415.025n

.meas tran vdout0_230ck820 FIND v(dout0_230) AT=415.025n

.meas tran vdout0_231ck820 FIND v(dout0_231) AT=415.025n

.meas tran vdout0_232ck820 FIND v(dout0_232) AT=415.025n

.meas tran vdout0_233ck820 FIND v(dout0_233) AT=415.025n

.meas tran vdout0_234ck820 FIND v(dout0_234) AT=415.025n

.meas tran vdout0_235ck820 FIND v(dout0_235) AT=415.025n

.meas tran vdout0_236ck820 FIND v(dout0_236) AT=415.025n

.meas tran vdout0_237ck820 FIND v(dout0_237) AT=415.025n

.meas tran vdout0_238ck820 FIND v(dout0_238) AT=415.025n

.meas tran vdout0_239ck820 FIND v(dout0_239) AT=415.025n

.meas tran vdout0_240ck820 FIND v(dout0_240) AT=415.025n

.meas tran vdout0_241ck820 FIND v(dout0_241) AT=415.025n

.meas tran vdout0_242ck820 FIND v(dout0_242) AT=415.025n

.meas tran vdout0_243ck820 FIND v(dout0_243) AT=415.025n

.meas tran vdout0_244ck820 FIND v(dout0_244) AT=415.025n

.meas tran vdout0_245ck820 FIND v(dout0_245) AT=415.025n

.meas tran vdout0_246ck820 FIND v(dout0_246) AT=415.025n

.meas tran vdout0_247ck820 FIND v(dout0_247) AT=415.025n

.meas tran vdout0_248ck820 FIND v(dout0_248) AT=415.025n

.meas tran vdout0_249ck820 FIND v(dout0_249) AT=415.025n

.meas tran vdout0_250ck820 FIND v(dout0_250) AT=415.025n

.meas tran vdout0_251ck820 FIND v(dout0_251) AT=415.025n

.meas tran vdout0_252ck820 FIND v(dout0_252) AT=415.025n

.meas tran vdout0_253ck820 FIND v(dout0_253) AT=415.025n

.meas tran vdout0_254ck820 FIND v(dout0_254) AT=415.025n

.meas tran vdout0_255ck820 FIND v(dout0_255) AT=415.025n

.meas tran vdout0_0ck830 FIND v(dout0_0) AT=420.025n

.meas tran vdout0_1ck830 FIND v(dout0_1) AT=420.025n

.meas tran vdout0_2ck830 FIND v(dout0_2) AT=420.025n

.meas tran vdout0_3ck830 FIND v(dout0_3) AT=420.025n

.meas tran vdout0_4ck830 FIND v(dout0_4) AT=420.025n

.meas tran vdout0_5ck830 FIND v(dout0_5) AT=420.025n

.meas tran vdout0_6ck830 FIND v(dout0_6) AT=420.025n

.meas tran vdout0_7ck830 FIND v(dout0_7) AT=420.025n

.meas tran vdout0_8ck830 FIND v(dout0_8) AT=420.025n

.meas tran vdout0_9ck830 FIND v(dout0_9) AT=420.025n

.meas tran vdout0_10ck830 FIND v(dout0_10) AT=420.025n

.meas tran vdout0_11ck830 FIND v(dout0_11) AT=420.025n

.meas tran vdout0_12ck830 FIND v(dout0_12) AT=420.025n

.meas tran vdout0_13ck830 FIND v(dout0_13) AT=420.025n

.meas tran vdout0_14ck830 FIND v(dout0_14) AT=420.025n

.meas tran vdout0_15ck830 FIND v(dout0_15) AT=420.025n

.meas tran vdout0_16ck830 FIND v(dout0_16) AT=420.025n

.meas tran vdout0_17ck830 FIND v(dout0_17) AT=420.025n

.meas tran vdout0_18ck830 FIND v(dout0_18) AT=420.025n

.meas tran vdout0_19ck830 FIND v(dout0_19) AT=420.025n

.meas tran vdout0_20ck830 FIND v(dout0_20) AT=420.025n

.meas tran vdout0_21ck830 FIND v(dout0_21) AT=420.025n

.meas tran vdout0_22ck830 FIND v(dout0_22) AT=420.025n

.meas tran vdout0_23ck830 FIND v(dout0_23) AT=420.025n

.meas tran vdout0_24ck830 FIND v(dout0_24) AT=420.025n

.meas tran vdout0_25ck830 FIND v(dout0_25) AT=420.025n

.meas tran vdout0_26ck830 FIND v(dout0_26) AT=420.025n

.meas tran vdout0_27ck830 FIND v(dout0_27) AT=420.025n

.meas tran vdout0_28ck830 FIND v(dout0_28) AT=420.025n

.meas tran vdout0_29ck830 FIND v(dout0_29) AT=420.025n

.meas tran vdout0_30ck830 FIND v(dout0_30) AT=420.025n

.meas tran vdout0_31ck830 FIND v(dout0_31) AT=420.025n

.meas tran vdout0_32ck830 FIND v(dout0_32) AT=420.025n

.meas tran vdout0_33ck830 FIND v(dout0_33) AT=420.025n

.meas tran vdout0_34ck830 FIND v(dout0_34) AT=420.025n

.meas tran vdout0_35ck830 FIND v(dout0_35) AT=420.025n

.meas tran vdout0_36ck830 FIND v(dout0_36) AT=420.025n

.meas tran vdout0_37ck830 FIND v(dout0_37) AT=420.025n

.meas tran vdout0_38ck830 FIND v(dout0_38) AT=420.025n

.meas tran vdout0_39ck830 FIND v(dout0_39) AT=420.025n

.meas tran vdout0_40ck830 FIND v(dout0_40) AT=420.025n

.meas tran vdout0_41ck830 FIND v(dout0_41) AT=420.025n

.meas tran vdout0_42ck830 FIND v(dout0_42) AT=420.025n

.meas tran vdout0_43ck830 FIND v(dout0_43) AT=420.025n

.meas tran vdout0_44ck830 FIND v(dout0_44) AT=420.025n

.meas tran vdout0_45ck830 FIND v(dout0_45) AT=420.025n

.meas tran vdout0_46ck830 FIND v(dout0_46) AT=420.025n

.meas tran vdout0_47ck830 FIND v(dout0_47) AT=420.025n

.meas tran vdout0_48ck830 FIND v(dout0_48) AT=420.025n

.meas tran vdout0_49ck830 FIND v(dout0_49) AT=420.025n

.meas tran vdout0_50ck830 FIND v(dout0_50) AT=420.025n

.meas tran vdout0_51ck830 FIND v(dout0_51) AT=420.025n

.meas tran vdout0_52ck830 FIND v(dout0_52) AT=420.025n

.meas tran vdout0_53ck830 FIND v(dout0_53) AT=420.025n

.meas tran vdout0_54ck830 FIND v(dout0_54) AT=420.025n

.meas tran vdout0_55ck830 FIND v(dout0_55) AT=420.025n

.meas tran vdout0_56ck830 FIND v(dout0_56) AT=420.025n

.meas tran vdout0_57ck830 FIND v(dout0_57) AT=420.025n

.meas tran vdout0_58ck830 FIND v(dout0_58) AT=420.025n

.meas tran vdout0_59ck830 FIND v(dout0_59) AT=420.025n

.meas tran vdout0_60ck830 FIND v(dout0_60) AT=420.025n

.meas tran vdout0_61ck830 FIND v(dout0_61) AT=420.025n

.meas tran vdout0_62ck830 FIND v(dout0_62) AT=420.025n

.meas tran vdout0_63ck830 FIND v(dout0_63) AT=420.025n

.meas tran vdout0_64ck830 FIND v(dout0_64) AT=420.025n

.meas tran vdout0_65ck830 FIND v(dout0_65) AT=420.025n

.meas tran vdout0_66ck830 FIND v(dout0_66) AT=420.025n

.meas tran vdout0_67ck830 FIND v(dout0_67) AT=420.025n

.meas tran vdout0_68ck830 FIND v(dout0_68) AT=420.025n

.meas tran vdout0_69ck830 FIND v(dout0_69) AT=420.025n

.meas tran vdout0_70ck830 FIND v(dout0_70) AT=420.025n

.meas tran vdout0_71ck830 FIND v(dout0_71) AT=420.025n

.meas tran vdout0_72ck830 FIND v(dout0_72) AT=420.025n

.meas tran vdout0_73ck830 FIND v(dout0_73) AT=420.025n

.meas tran vdout0_74ck830 FIND v(dout0_74) AT=420.025n

.meas tran vdout0_75ck830 FIND v(dout0_75) AT=420.025n

.meas tran vdout0_76ck830 FIND v(dout0_76) AT=420.025n

.meas tran vdout0_77ck830 FIND v(dout0_77) AT=420.025n

.meas tran vdout0_78ck830 FIND v(dout0_78) AT=420.025n

.meas tran vdout0_79ck830 FIND v(dout0_79) AT=420.025n

.meas tran vdout0_80ck830 FIND v(dout0_80) AT=420.025n

.meas tran vdout0_81ck830 FIND v(dout0_81) AT=420.025n

.meas tran vdout0_82ck830 FIND v(dout0_82) AT=420.025n

.meas tran vdout0_83ck830 FIND v(dout0_83) AT=420.025n

.meas tran vdout0_84ck830 FIND v(dout0_84) AT=420.025n

.meas tran vdout0_85ck830 FIND v(dout0_85) AT=420.025n

.meas tran vdout0_86ck830 FIND v(dout0_86) AT=420.025n

.meas tran vdout0_87ck830 FIND v(dout0_87) AT=420.025n

.meas tran vdout0_88ck830 FIND v(dout0_88) AT=420.025n

.meas tran vdout0_89ck830 FIND v(dout0_89) AT=420.025n

.meas tran vdout0_90ck830 FIND v(dout0_90) AT=420.025n

.meas tran vdout0_91ck830 FIND v(dout0_91) AT=420.025n

.meas tran vdout0_92ck830 FIND v(dout0_92) AT=420.025n

.meas tran vdout0_93ck830 FIND v(dout0_93) AT=420.025n

.meas tran vdout0_94ck830 FIND v(dout0_94) AT=420.025n

.meas tran vdout0_95ck830 FIND v(dout0_95) AT=420.025n

.meas tran vdout0_96ck830 FIND v(dout0_96) AT=420.025n

.meas tran vdout0_97ck830 FIND v(dout0_97) AT=420.025n

.meas tran vdout0_98ck830 FIND v(dout0_98) AT=420.025n

.meas tran vdout0_99ck830 FIND v(dout0_99) AT=420.025n

.meas tran vdout0_100ck830 FIND v(dout0_100) AT=420.025n

.meas tran vdout0_101ck830 FIND v(dout0_101) AT=420.025n

.meas tran vdout0_102ck830 FIND v(dout0_102) AT=420.025n

.meas tran vdout0_103ck830 FIND v(dout0_103) AT=420.025n

.meas tran vdout0_104ck830 FIND v(dout0_104) AT=420.025n

.meas tran vdout0_105ck830 FIND v(dout0_105) AT=420.025n

.meas tran vdout0_106ck830 FIND v(dout0_106) AT=420.025n

.meas tran vdout0_107ck830 FIND v(dout0_107) AT=420.025n

.meas tran vdout0_108ck830 FIND v(dout0_108) AT=420.025n

.meas tran vdout0_109ck830 FIND v(dout0_109) AT=420.025n

.meas tran vdout0_110ck830 FIND v(dout0_110) AT=420.025n

.meas tran vdout0_111ck830 FIND v(dout0_111) AT=420.025n

.meas tran vdout0_112ck830 FIND v(dout0_112) AT=420.025n

.meas tran vdout0_113ck830 FIND v(dout0_113) AT=420.025n

.meas tran vdout0_114ck830 FIND v(dout0_114) AT=420.025n

.meas tran vdout0_115ck830 FIND v(dout0_115) AT=420.025n

.meas tran vdout0_116ck830 FIND v(dout0_116) AT=420.025n

.meas tran vdout0_117ck830 FIND v(dout0_117) AT=420.025n

.meas tran vdout0_118ck830 FIND v(dout0_118) AT=420.025n

.meas tran vdout0_119ck830 FIND v(dout0_119) AT=420.025n

.meas tran vdout0_120ck830 FIND v(dout0_120) AT=420.025n

.meas tran vdout0_121ck830 FIND v(dout0_121) AT=420.025n

.meas tran vdout0_122ck830 FIND v(dout0_122) AT=420.025n

.meas tran vdout0_123ck830 FIND v(dout0_123) AT=420.025n

.meas tran vdout0_124ck830 FIND v(dout0_124) AT=420.025n

.meas tran vdout0_125ck830 FIND v(dout0_125) AT=420.025n

.meas tran vdout0_126ck830 FIND v(dout0_126) AT=420.025n

.meas tran vdout0_127ck830 FIND v(dout0_127) AT=420.025n

.meas tran vdout0_128ck830 FIND v(dout0_128) AT=420.025n

.meas tran vdout0_129ck830 FIND v(dout0_129) AT=420.025n

.meas tran vdout0_130ck830 FIND v(dout0_130) AT=420.025n

.meas tran vdout0_131ck830 FIND v(dout0_131) AT=420.025n

.meas tran vdout0_132ck830 FIND v(dout0_132) AT=420.025n

.meas tran vdout0_133ck830 FIND v(dout0_133) AT=420.025n

.meas tran vdout0_134ck830 FIND v(dout0_134) AT=420.025n

.meas tran vdout0_135ck830 FIND v(dout0_135) AT=420.025n

.meas tran vdout0_136ck830 FIND v(dout0_136) AT=420.025n

.meas tran vdout0_137ck830 FIND v(dout0_137) AT=420.025n

.meas tran vdout0_138ck830 FIND v(dout0_138) AT=420.025n

.meas tran vdout0_139ck830 FIND v(dout0_139) AT=420.025n

.meas tran vdout0_140ck830 FIND v(dout0_140) AT=420.025n

.meas tran vdout0_141ck830 FIND v(dout0_141) AT=420.025n

.meas tran vdout0_142ck830 FIND v(dout0_142) AT=420.025n

.meas tran vdout0_143ck830 FIND v(dout0_143) AT=420.025n

.meas tran vdout0_144ck830 FIND v(dout0_144) AT=420.025n

.meas tran vdout0_145ck830 FIND v(dout0_145) AT=420.025n

.meas tran vdout0_146ck830 FIND v(dout0_146) AT=420.025n

.meas tran vdout0_147ck830 FIND v(dout0_147) AT=420.025n

.meas tran vdout0_148ck830 FIND v(dout0_148) AT=420.025n

.meas tran vdout0_149ck830 FIND v(dout0_149) AT=420.025n

.meas tran vdout0_150ck830 FIND v(dout0_150) AT=420.025n

.meas tran vdout0_151ck830 FIND v(dout0_151) AT=420.025n

.meas tran vdout0_152ck830 FIND v(dout0_152) AT=420.025n

.meas tran vdout0_153ck830 FIND v(dout0_153) AT=420.025n

.meas tran vdout0_154ck830 FIND v(dout0_154) AT=420.025n

.meas tran vdout0_155ck830 FIND v(dout0_155) AT=420.025n

.meas tran vdout0_156ck830 FIND v(dout0_156) AT=420.025n

.meas tran vdout0_157ck830 FIND v(dout0_157) AT=420.025n

.meas tran vdout0_158ck830 FIND v(dout0_158) AT=420.025n

.meas tran vdout0_159ck830 FIND v(dout0_159) AT=420.025n

.meas tran vdout0_160ck830 FIND v(dout0_160) AT=420.025n

.meas tran vdout0_161ck830 FIND v(dout0_161) AT=420.025n

.meas tran vdout0_162ck830 FIND v(dout0_162) AT=420.025n

.meas tran vdout0_163ck830 FIND v(dout0_163) AT=420.025n

.meas tran vdout0_164ck830 FIND v(dout0_164) AT=420.025n

.meas tran vdout0_165ck830 FIND v(dout0_165) AT=420.025n

.meas tran vdout0_166ck830 FIND v(dout0_166) AT=420.025n

.meas tran vdout0_167ck830 FIND v(dout0_167) AT=420.025n

.meas tran vdout0_168ck830 FIND v(dout0_168) AT=420.025n

.meas tran vdout0_169ck830 FIND v(dout0_169) AT=420.025n

.meas tran vdout0_170ck830 FIND v(dout0_170) AT=420.025n

.meas tran vdout0_171ck830 FIND v(dout0_171) AT=420.025n

.meas tran vdout0_172ck830 FIND v(dout0_172) AT=420.025n

.meas tran vdout0_173ck830 FIND v(dout0_173) AT=420.025n

.meas tran vdout0_174ck830 FIND v(dout0_174) AT=420.025n

.meas tran vdout0_175ck830 FIND v(dout0_175) AT=420.025n

.meas tran vdout0_176ck830 FIND v(dout0_176) AT=420.025n

.meas tran vdout0_177ck830 FIND v(dout0_177) AT=420.025n

.meas tran vdout0_178ck830 FIND v(dout0_178) AT=420.025n

.meas tran vdout0_179ck830 FIND v(dout0_179) AT=420.025n

.meas tran vdout0_180ck830 FIND v(dout0_180) AT=420.025n

.meas tran vdout0_181ck830 FIND v(dout0_181) AT=420.025n

.meas tran vdout0_182ck830 FIND v(dout0_182) AT=420.025n

.meas tran vdout0_183ck830 FIND v(dout0_183) AT=420.025n

.meas tran vdout0_184ck830 FIND v(dout0_184) AT=420.025n

.meas tran vdout0_185ck830 FIND v(dout0_185) AT=420.025n

.meas tran vdout0_186ck830 FIND v(dout0_186) AT=420.025n

.meas tran vdout0_187ck830 FIND v(dout0_187) AT=420.025n

.meas tran vdout0_188ck830 FIND v(dout0_188) AT=420.025n

.meas tran vdout0_189ck830 FIND v(dout0_189) AT=420.025n

.meas tran vdout0_190ck830 FIND v(dout0_190) AT=420.025n

.meas tran vdout0_191ck830 FIND v(dout0_191) AT=420.025n

.meas tran vdout0_192ck830 FIND v(dout0_192) AT=420.025n

.meas tran vdout0_193ck830 FIND v(dout0_193) AT=420.025n

.meas tran vdout0_194ck830 FIND v(dout0_194) AT=420.025n

.meas tran vdout0_195ck830 FIND v(dout0_195) AT=420.025n

.meas tran vdout0_196ck830 FIND v(dout0_196) AT=420.025n

.meas tran vdout0_197ck830 FIND v(dout0_197) AT=420.025n

.meas tran vdout0_198ck830 FIND v(dout0_198) AT=420.025n

.meas tran vdout0_199ck830 FIND v(dout0_199) AT=420.025n

.meas tran vdout0_200ck830 FIND v(dout0_200) AT=420.025n

.meas tran vdout0_201ck830 FIND v(dout0_201) AT=420.025n

.meas tran vdout0_202ck830 FIND v(dout0_202) AT=420.025n

.meas tran vdout0_203ck830 FIND v(dout0_203) AT=420.025n

.meas tran vdout0_204ck830 FIND v(dout0_204) AT=420.025n

.meas tran vdout0_205ck830 FIND v(dout0_205) AT=420.025n

.meas tran vdout0_206ck830 FIND v(dout0_206) AT=420.025n

.meas tran vdout0_207ck830 FIND v(dout0_207) AT=420.025n

.meas tran vdout0_208ck830 FIND v(dout0_208) AT=420.025n

.meas tran vdout0_209ck830 FIND v(dout0_209) AT=420.025n

.meas tran vdout0_210ck830 FIND v(dout0_210) AT=420.025n

.meas tran vdout0_211ck830 FIND v(dout0_211) AT=420.025n

.meas tran vdout0_212ck830 FIND v(dout0_212) AT=420.025n

.meas tran vdout0_213ck830 FIND v(dout0_213) AT=420.025n

.meas tran vdout0_214ck830 FIND v(dout0_214) AT=420.025n

.meas tran vdout0_215ck830 FIND v(dout0_215) AT=420.025n

.meas tran vdout0_216ck830 FIND v(dout0_216) AT=420.025n

.meas tran vdout0_217ck830 FIND v(dout0_217) AT=420.025n

.meas tran vdout0_218ck830 FIND v(dout0_218) AT=420.025n

.meas tran vdout0_219ck830 FIND v(dout0_219) AT=420.025n

.meas tran vdout0_220ck830 FIND v(dout0_220) AT=420.025n

.meas tran vdout0_221ck830 FIND v(dout0_221) AT=420.025n

.meas tran vdout0_222ck830 FIND v(dout0_222) AT=420.025n

.meas tran vdout0_223ck830 FIND v(dout0_223) AT=420.025n

.meas tran vdout0_224ck830 FIND v(dout0_224) AT=420.025n

.meas tran vdout0_225ck830 FIND v(dout0_225) AT=420.025n

.meas tran vdout0_226ck830 FIND v(dout0_226) AT=420.025n

.meas tran vdout0_227ck830 FIND v(dout0_227) AT=420.025n

.meas tran vdout0_228ck830 FIND v(dout0_228) AT=420.025n

.meas tran vdout0_229ck830 FIND v(dout0_229) AT=420.025n

.meas tran vdout0_230ck830 FIND v(dout0_230) AT=420.025n

.meas tran vdout0_231ck830 FIND v(dout0_231) AT=420.025n

.meas tran vdout0_232ck830 FIND v(dout0_232) AT=420.025n

.meas tran vdout0_233ck830 FIND v(dout0_233) AT=420.025n

.meas tran vdout0_234ck830 FIND v(dout0_234) AT=420.025n

.meas tran vdout0_235ck830 FIND v(dout0_235) AT=420.025n

.meas tran vdout0_236ck830 FIND v(dout0_236) AT=420.025n

.meas tran vdout0_237ck830 FIND v(dout0_237) AT=420.025n

.meas tran vdout0_238ck830 FIND v(dout0_238) AT=420.025n

.meas tran vdout0_239ck830 FIND v(dout0_239) AT=420.025n

.meas tran vdout0_240ck830 FIND v(dout0_240) AT=420.025n

.meas tran vdout0_241ck830 FIND v(dout0_241) AT=420.025n

.meas tran vdout0_242ck830 FIND v(dout0_242) AT=420.025n

.meas tran vdout0_243ck830 FIND v(dout0_243) AT=420.025n

.meas tran vdout0_244ck830 FIND v(dout0_244) AT=420.025n

.meas tran vdout0_245ck830 FIND v(dout0_245) AT=420.025n

.meas tran vdout0_246ck830 FIND v(dout0_246) AT=420.025n

.meas tran vdout0_247ck830 FIND v(dout0_247) AT=420.025n

.meas tran vdout0_248ck830 FIND v(dout0_248) AT=420.025n

.meas tran vdout0_249ck830 FIND v(dout0_249) AT=420.025n

.meas tran vdout0_250ck830 FIND v(dout0_250) AT=420.025n

.meas tran vdout0_251ck830 FIND v(dout0_251) AT=420.025n

.meas tran vdout0_252ck830 FIND v(dout0_252) AT=420.025n

.meas tran vdout0_253ck830 FIND v(dout0_253) AT=420.025n

.meas tran vdout0_254ck830 FIND v(dout0_254) AT=420.025n

.meas tran vdout0_255ck830 FIND v(dout0_255) AT=420.025n

.meas tran vdout0_0ck840 FIND v(dout0_0) AT=425.025n

.meas tran vdout0_1ck840 FIND v(dout0_1) AT=425.025n

.meas tran vdout0_2ck840 FIND v(dout0_2) AT=425.025n

.meas tran vdout0_3ck840 FIND v(dout0_3) AT=425.025n

.meas tran vdout0_4ck840 FIND v(dout0_4) AT=425.025n

.meas tran vdout0_5ck840 FIND v(dout0_5) AT=425.025n

.meas tran vdout0_6ck840 FIND v(dout0_6) AT=425.025n

.meas tran vdout0_7ck840 FIND v(dout0_7) AT=425.025n

.meas tran vdout0_8ck840 FIND v(dout0_8) AT=425.025n

.meas tran vdout0_9ck840 FIND v(dout0_9) AT=425.025n

.meas tran vdout0_10ck840 FIND v(dout0_10) AT=425.025n

.meas tran vdout0_11ck840 FIND v(dout0_11) AT=425.025n

.meas tran vdout0_12ck840 FIND v(dout0_12) AT=425.025n

.meas tran vdout0_13ck840 FIND v(dout0_13) AT=425.025n

.meas tran vdout0_14ck840 FIND v(dout0_14) AT=425.025n

.meas tran vdout0_15ck840 FIND v(dout0_15) AT=425.025n

.meas tran vdout0_16ck840 FIND v(dout0_16) AT=425.025n

.meas tran vdout0_17ck840 FIND v(dout0_17) AT=425.025n

.meas tran vdout0_18ck840 FIND v(dout0_18) AT=425.025n

.meas tran vdout0_19ck840 FIND v(dout0_19) AT=425.025n

.meas tran vdout0_20ck840 FIND v(dout0_20) AT=425.025n

.meas tran vdout0_21ck840 FIND v(dout0_21) AT=425.025n

.meas tran vdout0_22ck840 FIND v(dout0_22) AT=425.025n

.meas tran vdout0_23ck840 FIND v(dout0_23) AT=425.025n

.meas tran vdout0_24ck840 FIND v(dout0_24) AT=425.025n

.meas tran vdout0_25ck840 FIND v(dout0_25) AT=425.025n

.meas tran vdout0_26ck840 FIND v(dout0_26) AT=425.025n

.meas tran vdout0_27ck840 FIND v(dout0_27) AT=425.025n

.meas tran vdout0_28ck840 FIND v(dout0_28) AT=425.025n

.meas tran vdout0_29ck840 FIND v(dout0_29) AT=425.025n

.meas tran vdout0_30ck840 FIND v(dout0_30) AT=425.025n

.meas tran vdout0_31ck840 FIND v(dout0_31) AT=425.025n

.meas tran vdout0_32ck840 FIND v(dout0_32) AT=425.025n

.meas tran vdout0_33ck840 FIND v(dout0_33) AT=425.025n

.meas tran vdout0_34ck840 FIND v(dout0_34) AT=425.025n

.meas tran vdout0_35ck840 FIND v(dout0_35) AT=425.025n

.meas tran vdout0_36ck840 FIND v(dout0_36) AT=425.025n

.meas tran vdout0_37ck840 FIND v(dout0_37) AT=425.025n

.meas tran vdout0_38ck840 FIND v(dout0_38) AT=425.025n

.meas tran vdout0_39ck840 FIND v(dout0_39) AT=425.025n

.meas tran vdout0_40ck840 FIND v(dout0_40) AT=425.025n

.meas tran vdout0_41ck840 FIND v(dout0_41) AT=425.025n

.meas tran vdout0_42ck840 FIND v(dout0_42) AT=425.025n

.meas tran vdout0_43ck840 FIND v(dout0_43) AT=425.025n

.meas tran vdout0_44ck840 FIND v(dout0_44) AT=425.025n

.meas tran vdout0_45ck840 FIND v(dout0_45) AT=425.025n

.meas tran vdout0_46ck840 FIND v(dout0_46) AT=425.025n

.meas tran vdout0_47ck840 FIND v(dout0_47) AT=425.025n

.meas tran vdout0_48ck840 FIND v(dout0_48) AT=425.025n

.meas tran vdout0_49ck840 FIND v(dout0_49) AT=425.025n

.meas tran vdout0_50ck840 FIND v(dout0_50) AT=425.025n

.meas tran vdout0_51ck840 FIND v(dout0_51) AT=425.025n

.meas tran vdout0_52ck840 FIND v(dout0_52) AT=425.025n

.meas tran vdout0_53ck840 FIND v(dout0_53) AT=425.025n

.meas tran vdout0_54ck840 FIND v(dout0_54) AT=425.025n

.meas tran vdout0_55ck840 FIND v(dout0_55) AT=425.025n

.meas tran vdout0_56ck840 FIND v(dout0_56) AT=425.025n

.meas tran vdout0_57ck840 FIND v(dout0_57) AT=425.025n

.meas tran vdout0_58ck840 FIND v(dout0_58) AT=425.025n

.meas tran vdout0_59ck840 FIND v(dout0_59) AT=425.025n

.meas tran vdout0_60ck840 FIND v(dout0_60) AT=425.025n

.meas tran vdout0_61ck840 FIND v(dout0_61) AT=425.025n

.meas tran vdout0_62ck840 FIND v(dout0_62) AT=425.025n

.meas tran vdout0_63ck840 FIND v(dout0_63) AT=425.025n

.meas tran vdout0_64ck840 FIND v(dout0_64) AT=425.025n

.meas tran vdout0_65ck840 FIND v(dout0_65) AT=425.025n

.meas tran vdout0_66ck840 FIND v(dout0_66) AT=425.025n

.meas tran vdout0_67ck840 FIND v(dout0_67) AT=425.025n

.meas tran vdout0_68ck840 FIND v(dout0_68) AT=425.025n

.meas tran vdout0_69ck840 FIND v(dout0_69) AT=425.025n

.meas tran vdout0_70ck840 FIND v(dout0_70) AT=425.025n

.meas tran vdout0_71ck840 FIND v(dout0_71) AT=425.025n

.meas tran vdout0_72ck840 FIND v(dout0_72) AT=425.025n

.meas tran vdout0_73ck840 FIND v(dout0_73) AT=425.025n

.meas tran vdout0_74ck840 FIND v(dout0_74) AT=425.025n

.meas tran vdout0_75ck840 FIND v(dout0_75) AT=425.025n

.meas tran vdout0_76ck840 FIND v(dout0_76) AT=425.025n

.meas tran vdout0_77ck840 FIND v(dout0_77) AT=425.025n

.meas tran vdout0_78ck840 FIND v(dout0_78) AT=425.025n

.meas tran vdout0_79ck840 FIND v(dout0_79) AT=425.025n

.meas tran vdout0_80ck840 FIND v(dout0_80) AT=425.025n

.meas tran vdout0_81ck840 FIND v(dout0_81) AT=425.025n

.meas tran vdout0_82ck840 FIND v(dout0_82) AT=425.025n

.meas tran vdout0_83ck840 FIND v(dout0_83) AT=425.025n

.meas tran vdout0_84ck840 FIND v(dout0_84) AT=425.025n

.meas tran vdout0_85ck840 FIND v(dout0_85) AT=425.025n

.meas tran vdout0_86ck840 FIND v(dout0_86) AT=425.025n

.meas tran vdout0_87ck840 FIND v(dout0_87) AT=425.025n

.meas tran vdout0_88ck840 FIND v(dout0_88) AT=425.025n

.meas tran vdout0_89ck840 FIND v(dout0_89) AT=425.025n

.meas tran vdout0_90ck840 FIND v(dout0_90) AT=425.025n

.meas tran vdout0_91ck840 FIND v(dout0_91) AT=425.025n

.meas tran vdout0_92ck840 FIND v(dout0_92) AT=425.025n

.meas tran vdout0_93ck840 FIND v(dout0_93) AT=425.025n

.meas tran vdout0_94ck840 FIND v(dout0_94) AT=425.025n

.meas tran vdout0_95ck840 FIND v(dout0_95) AT=425.025n

.meas tran vdout0_96ck840 FIND v(dout0_96) AT=425.025n

.meas tran vdout0_97ck840 FIND v(dout0_97) AT=425.025n

.meas tran vdout0_98ck840 FIND v(dout0_98) AT=425.025n

.meas tran vdout0_99ck840 FIND v(dout0_99) AT=425.025n

.meas tran vdout0_100ck840 FIND v(dout0_100) AT=425.025n

.meas tran vdout0_101ck840 FIND v(dout0_101) AT=425.025n

.meas tran vdout0_102ck840 FIND v(dout0_102) AT=425.025n

.meas tran vdout0_103ck840 FIND v(dout0_103) AT=425.025n

.meas tran vdout0_104ck840 FIND v(dout0_104) AT=425.025n

.meas tran vdout0_105ck840 FIND v(dout0_105) AT=425.025n

.meas tran vdout0_106ck840 FIND v(dout0_106) AT=425.025n

.meas tran vdout0_107ck840 FIND v(dout0_107) AT=425.025n

.meas tran vdout0_108ck840 FIND v(dout0_108) AT=425.025n

.meas tran vdout0_109ck840 FIND v(dout0_109) AT=425.025n

.meas tran vdout0_110ck840 FIND v(dout0_110) AT=425.025n

.meas tran vdout0_111ck840 FIND v(dout0_111) AT=425.025n

.meas tran vdout0_112ck840 FIND v(dout0_112) AT=425.025n

.meas tran vdout0_113ck840 FIND v(dout0_113) AT=425.025n

.meas tran vdout0_114ck840 FIND v(dout0_114) AT=425.025n

.meas tran vdout0_115ck840 FIND v(dout0_115) AT=425.025n

.meas tran vdout0_116ck840 FIND v(dout0_116) AT=425.025n

.meas tran vdout0_117ck840 FIND v(dout0_117) AT=425.025n

.meas tran vdout0_118ck840 FIND v(dout0_118) AT=425.025n

.meas tran vdout0_119ck840 FIND v(dout0_119) AT=425.025n

.meas tran vdout0_120ck840 FIND v(dout0_120) AT=425.025n

.meas tran vdout0_121ck840 FIND v(dout0_121) AT=425.025n

.meas tran vdout0_122ck840 FIND v(dout0_122) AT=425.025n

.meas tran vdout0_123ck840 FIND v(dout0_123) AT=425.025n

.meas tran vdout0_124ck840 FIND v(dout0_124) AT=425.025n

.meas tran vdout0_125ck840 FIND v(dout0_125) AT=425.025n

.meas tran vdout0_126ck840 FIND v(dout0_126) AT=425.025n

.meas tran vdout0_127ck840 FIND v(dout0_127) AT=425.025n

.meas tran vdout0_128ck840 FIND v(dout0_128) AT=425.025n

.meas tran vdout0_129ck840 FIND v(dout0_129) AT=425.025n

.meas tran vdout0_130ck840 FIND v(dout0_130) AT=425.025n

.meas tran vdout0_131ck840 FIND v(dout0_131) AT=425.025n

.meas tran vdout0_132ck840 FIND v(dout0_132) AT=425.025n

.meas tran vdout0_133ck840 FIND v(dout0_133) AT=425.025n

.meas tran vdout0_134ck840 FIND v(dout0_134) AT=425.025n

.meas tran vdout0_135ck840 FIND v(dout0_135) AT=425.025n

.meas tran vdout0_136ck840 FIND v(dout0_136) AT=425.025n

.meas tran vdout0_137ck840 FIND v(dout0_137) AT=425.025n

.meas tran vdout0_138ck840 FIND v(dout0_138) AT=425.025n

.meas tran vdout0_139ck840 FIND v(dout0_139) AT=425.025n

.meas tran vdout0_140ck840 FIND v(dout0_140) AT=425.025n

.meas tran vdout0_141ck840 FIND v(dout0_141) AT=425.025n

.meas tran vdout0_142ck840 FIND v(dout0_142) AT=425.025n

.meas tran vdout0_143ck840 FIND v(dout0_143) AT=425.025n

.meas tran vdout0_144ck840 FIND v(dout0_144) AT=425.025n

.meas tran vdout0_145ck840 FIND v(dout0_145) AT=425.025n

.meas tran vdout0_146ck840 FIND v(dout0_146) AT=425.025n

.meas tran vdout0_147ck840 FIND v(dout0_147) AT=425.025n

.meas tran vdout0_148ck840 FIND v(dout0_148) AT=425.025n

.meas tran vdout0_149ck840 FIND v(dout0_149) AT=425.025n

.meas tran vdout0_150ck840 FIND v(dout0_150) AT=425.025n

.meas tran vdout0_151ck840 FIND v(dout0_151) AT=425.025n

.meas tran vdout0_152ck840 FIND v(dout0_152) AT=425.025n

.meas tran vdout0_153ck840 FIND v(dout0_153) AT=425.025n

.meas tran vdout0_154ck840 FIND v(dout0_154) AT=425.025n

.meas tran vdout0_155ck840 FIND v(dout0_155) AT=425.025n

.meas tran vdout0_156ck840 FIND v(dout0_156) AT=425.025n

.meas tran vdout0_157ck840 FIND v(dout0_157) AT=425.025n

.meas tran vdout0_158ck840 FIND v(dout0_158) AT=425.025n

.meas tran vdout0_159ck840 FIND v(dout0_159) AT=425.025n

.meas tran vdout0_160ck840 FIND v(dout0_160) AT=425.025n

.meas tran vdout0_161ck840 FIND v(dout0_161) AT=425.025n

.meas tran vdout0_162ck840 FIND v(dout0_162) AT=425.025n

.meas tran vdout0_163ck840 FIND v(dout0_163) AT=425.025n

.meas tran vdout0_164ck840 FIND v(dout0_164) AT=425.025n

.meas tran vdout0_165ck840 FIND v(dout0_165) AT=425.025n

.meas tran vdout0_166ck840 FIND v(dout0_166) AT=425.025n

.meas tran vdout0_167ck840 FIND v(dout0_167) AT=425.025n

.meas tran vdout0_168ck840 FIND v(dout0_168) AT=425.025n

.meas tran vdout0_169ck840 FIND v(dout0_169) AT=425.025n

.meas tran vdout0_170ck840 FIND v(dout0_170) AT=425.025n

.meas tran vdout0_171ck840 FIND v(dout0_171) AT=425.025n

.meas tran vdout0_172ck840 FIND v(dout0_172) AT=425.025n

.meas tran vdout0_173ck840 FIND v(dout0_173) AT=425.025n

.meas tran vdout0_174ck840 FIND v(dout0_174) AT=425.025n

.meas tran vdout0_175ck840 FIND v(dout0_175) AT=425.025n

.meas tran vdout0_176ck840 FIND v(dout0_176) AT=425.025n

.meas tran vdout0_177ck840 FIND v(dout0_177) AT=425.025n

.meas tran vdout0_178ck840 FIND v(dout0_178) AT=425.025n

.meas tran vdout0_179ck840 FIND v(dout0_179) AT=425.025n

.meas tran vdout0_180ck840 FIND v(dout0_180) AT=425.025n

.meas tran vdout0_181ck840 FIND v(dout0_181) AT=425.025n

.meas tran vdout0_182ck840 FIND v(dout0_182) AT=425.025n

.meas tran vdout0_183ck840 FIND v(dout0_183) AT=425.025n

.meas tran vdout0_184ck840 FIND v(dout0_184) AT=425.025n

.meas tran vdout0_185ck840 FIND v(dout0_185) AT=425.025n

.meas tran vdout0_186ck840 FIND v(dout0_186) AT=425.025n

.meas tran vdout0_187ck840 FIND v(dout0_187) AT=425.025n

.meas tran vdout0_188ck840 FIND v(dout0_188) AT=425.025n

.meas tran vdout0_189ck840 FIND v(dout0_189) AT=425.025n

.meas tran vdout0_190ck840 FIND v(dout0_190) AT=425.025n

.meas tran vdout0_191ck840 FIND v(dout0_191) AT=425.025n

.meas tran vdout0_192ck840 FIND v(dout0_192) AT=425.025n

.meas tran vdout0_193ck840 FIND v(dout0_193) AT=425.025n

.meas tran vdout0_194ck840 FIND v(dout0_194) AT=425.025n

.meas tran vdout0_195ck840 FIND v(dout0_195) AT=425.025n

.meas tran vdout0_196ck840 FIND v(dout0_196) AT=425.025n

.meas tran vdout0_197ck840 FIND v(dout0_197) AT=425.025n

.meas tran vdout0_198ck840 FIND v(dout0_198) AT=425.025n

.meas tran vdout0_199ck840 FIND v(dout0_199) AT=425.025n

.meas tran vdout0_200ck840 FIND v(dout0_200) AT=425.025n

.meas tran vdout0_201ck840 FIND v(dout0_201) AT=425.025n

.meas tran vdout0_202ck840 FIND v(dout0_202) AT=425.025n

.meas tran vdout0_203ck840 FIND v(dout0_203) AT=425.025n

.meas tran vdout0_204ck840 FIND v(dout0_204) AT=425.025n

.meas tran vdout0_205ck840 FIND v(dout0_205) AT=425.025n

.meas tran vdout0_206ck840 FIND v(dout0_206) AT=425.025n

.meas tran vdout0_207ck840 FIND v(dout0_207) AT=425.025n

.meas tran vdout0_208ck840 FIND v(dout0_208) AT=425.025n

.meas tran vdout0_209ck840 FIND v(dout0_209) AT=425.025n

.meas tran vdout0_210ck840 FIND v(dout0_210) AT=425.025n

.meas tran vdout0_211ck840 FIND v(dout0_211) AT=425.025n

.meas tran vdout0_212ck840 FIND v(dout0_212) AT=425.025n

.meas tran vdout0_213ck840 FIND v(dout0_213) AT=425.025n

.meas tran vdout0_214ck840 FIND v(dout0_214) AT=425.025n

.meas tran vdout0_215ck840 FIND v(dout0_215) AT=425.025n

.meas tran vdout0_216ck840 FIND v(dout0_216) AT=425.025n

.meas tran vdout0_217ck840 FIND v(dout0_217) AT=425.025n

.meas tran vdout0_218ck840 FIND v(dout0_218) AT=425.025n

.meas tran vdout0_219ck840 FIND v(dout0_219) AT=425.025n

.meas tran vdout0_220ck840 FIND v(dout0_220) AT=425.025n

.meas tran vdout0_221ck840 FIND v(dout0_221) AT=425.025n

.meas tran vdout0_222ck840 FIND v(dout0_222) AT=425.025n

.meas tran vdout0_223ck840 FIND v(dout0_223) AT=425.025n

.meas tran vdout0_224ck840 FIND v(dout0_224) AT=425.025n

.meas tran vdout0_225ck840 FIND v(dout0_225) AT=425.025n

.meas tran vdout0_226ck840 FIND v(dout0_226) AT=425.025n

.meas tran vdout0_227ck840 FIND v(dout0_227) AT=425.025n

.meas tran vdout0_228ck840 FIND v(dout0_228) AT=425.025n

.meas tran vdout0_229ck840 FIND v(dout0_229) AT=425.025n

.meas tran vdout0_230ck840 FIND v(dout0_230) AT=425.025n

.meas tran vdout0_231ck840 FIND v(dout0_231) AT=425.025n

.meas tran vdout0_232ck840 FIND v(dout0_232) AT=425.025n

.meas tran vdout0_233ck840 FIND v(dout0_233) AT=425.025n

.meas tran vdout0_234ck840 FIND v(dout0_234) AT=425.025n

.meas tran vdout0_235ck840 FIND v(dout0_235) AT=425.025n

.meas tran vdout0_236ck840 FIND v(dout0_236) AT=425.025n

.meas tran vdout0_237ck840 FIND v(dout0_237) AT=425.025n

.meas tran vdout0_238ck840 FIND v(dout0_238) AT=425.025n

.meas tran vdout0_239ck840 FIND v(dout0_239) AT=425.025n

.meas tran vdout0_240ck840 FIND v(dout0_240) AT=425.025n

.meas tran vdout0_241ck840 FIND v(dout0_241) AT=425.025n

.meas tran vdout0_242ck840 FIND v(dout0_242) AT=425.025n

.meas tran vdout0_243ck840 FIND v(dout0_243) AT=425.025n

.meas tran vdout0_244ck840 FIND v(dout0_244) AT=425.025n

.meas tran vdout0_245ck840 FIND v(dout0_245) AT=425.025n

.meas tran vdout0_246ck840 FIND v(dout0_246) AT=425.025n

.meas tran vdout0_247ck840 FIND v(dout0_247) AT=425.025n

.meas tran vdout0_248ck840 FIND v(dout0_248) AT=425.025n

.meas tran vdout0_249ck840 FIND v(dout0_249) AT=425.025n

.meas tran vdout0_250ck840 FIND v(dout0_250) AT=425.025n

.meas tran vdout0_251ck840 FIND v(dout0_251) AT=425.025n

.meas tran vdout0_252ck840 FIND v(dout0_252) AT=425.025n

.meas tran vdout0_253ck840 FIND v(dout0_253) AT=425.025n

.meas tran vdout0_254ck840 FIND v(dout0_254) AT=425.025n

.meas tran vdout0_255ck840 FIND v(dout0_255) AT=425.025n

.meas tran vdout0_0ck860 FIND v(dout0_0) AT=435.025n

.meas tran vdout0_1ck860 FIND v(dout0_1) AT=435.025n

.meas tran vdout0_2ck860 FIND v(dout0_2) AT=435.025n

.meas tran vdout0_3ck860 FIND v(dout0_3) AT=435.025n

.meas tran vdout0_4ck860 FIND v(dout0_4) AT=435.025n

.meas tran vdout0_5ck860 FIND v(dout0_5) AT=435.025n

.meas tran vdout0_6ck860 FIND v(dout0_6) AT=435.025n

.meas tran vdout0_7ck860 FIND v(dout0_7) AT=435.025n

.meas tran vdout0_8ck860 FIND v(dout0_8) AT=435.025n

.meas tran vdout0_9ck860 FIND v(dout0_9) AT=435.025n

.meas tran vdout0_10ck860 FIND v(dout0_10) AT=435.025n

.meas tran vdout0_11ck860 FIND v(dout0_11) AT=435.025n

.meas tran vdout0_12ck860 FIND v(dout0_12) AT=435.025n

.meas tran vdout0_13ck860 FIND v(dout0_13) AT=435.025n

.meas tran vdout0_14ck860 FIND v(dout0_14) AT=435.025n

.meas tran vdout0_15ck860 FIND v(dout0_15) AT=435.025n

.meas tran vdout0_16ck860 FIND v(dout0_16) AT=435.025n

.meas tran vdout0_17ck860 FIND v(dout0_17) AT=435.025n

.meas tran vdout0_18ck860 FIND v(dout0_18) AT=435.025n

.meas tran vdout0_19ck860 FIND v(dout0_19) AT=435.025n

.meas tran vdout0_20ck860 FIND v(dout0_20) AT=435.025n

.meas tran vdout0_21ck860 FIND v(dout0_21) AT=435.025n

.meas tran vdout0_22ck860 FIND v(dout0_22) AT=435.025n

.meas tran vdout0_23ck860 FIND v(dout0_23) AT=435.025n

.meas tran vdout0_24ck860 FIND v(dout0_24) AT=435.025n

.meas tran vdout0_25ck860 FIND v(dout0_25) AT=435.025n

.meas tran vdout0_26ck860 FIND v(dout0_26) AT=435.025n

.meas tran vdout0_27ck860 FIND v(dout0_27) AT=435.025n

.meas tran vdout0_28ck860 FIND v(dout0_28) AT=435.025n

.meas tran vdout0_29ck860 FIND v(dout0_29) AT=435.025n

.meas tran vdout0_30ck860 FIND v(dout0_30) AT=435.025n

.meas tran vdout0_31ck860 FIND v(dout0_31) AT=435.025n

.meas tran vdout0_32ck860 FIND v(dout0_32) AT=435.025n

.meas tran vdout0_33ck860 FIND v(dout0_33) AT=435.025n

.meas tran vdout0_34ck860 FIND v(dout0_34) AT=435.025n

.meas tran vdout0_35ck860 FIND v(dout0_35) AT=435.025n

.meas tran vdout0_36ck860 FIND v(dout0_36) AT=435.025n

.meas tran vdout0_37ck860 FIND v(dout0_37) AT=435.025n

.meas tran vdout0_38ck860 FIND v(dout0_38) AT=435.025n

.meas tran vdout0_39ck860 FIND v(dout0_39) AT=435.025n

.meas tran vdout0_40ck860 FIND v(dout0_40) AT=435.025n

.meas tran vdout0_41ck860 FIND v(dout0_41) AT=435.025n

.meas tran vdout0_42ck860 FIND v(dout0_42) AT=435.025n

.meas tran vdout0_43ck860 FIND v(dout0_43) AT=435.025n

.meas tran vdout0_44ck860 FIND v(dout0_44) AT=435.025n

.meas tran vdout0_45ck860 FIND v(dout0_45) AT=435.025n

.meas tran vdout0_46ck860 FIND v(dout0_46) AT=435.025n

.meas tran vdout0_47ck860 FIND v(dout0_47) AT=435.025n

.meas tran vdout0_48ck860 FIND v(dout0_48) AT=435.025n

.meas tran vdout0_49ck860 FIND v(dout0_49) AT=435.025n

.meas tran vdout0_50ck860 FIND v(dout0_50) AT=435.025n

.meas tran vdout0_51ck860 FIND v(dout0_51) AT=435.025n

.meas tran vdout0_52ck860 FIND v(dout0_52) AT=435.025n

.meas tran vdout0_53ck860 FIND v(dout0_53) AT=435.025n

.meas tran vdout0_54ck860 FIND v(dout0_54) AT=435.025n

.meas tran vdout0_55ck860 FIND v(dout0_55) AT=435.025n

.meas tran vdout0_56ck860 FIND v(dout0_56) AT=435.025n

.meas tran vdout0_57ck860 FIND v(dout0_57) AT=435.025n

.meas tran vdout0_58ck860 FIND v(dout0_58) AT=435.025n

.meas tran vdout0_59ck860 FIND v(dout0_59) AT=435.025n

.meas tran vdout0_60ck860 FIND v(dout0_60) AT=435.025n

.meas tran vdout0_61ck860 FIND v(dout0_61) AT=435.025n

.meas tran vdout0_62ck860 FIND v(dout0_62) AT=435.025n

.meas tran vdout0_63ck860 FIND v(dout0_63) AT=435.025n

.meas tran vdout0_64ck860 FIND v(dout0_64) AT=435.025n

.meas tran vdout0_65ck860 FIND v(dout0_65) AT=435.025n

.meas tran vdout0_66ck860 FIND v(dout0_66) AT=435.025n

.meas tran vdout0_67ck860 FIND v(dout0_67) AT=435.025n

.meas tran vdout0_68ck860 FIND v(dout0_68) AT=435.025n

.meas tran vdout0_69ck860 FIND v(dout0_69) AT=435.025n

.meas tran vdout0_70ck860 FIND v(dout0_70) AT=435.025n

.meas tran vdout0_71ck860 FIND v(dout0_71) AT=435.025n

.meas tran vdout0_72ck860 FIND v(dout0_72) AT=435.025n

.meas tran vdout0_73ck860 FIND v(dout0_73) AT=435.025n

.meas tran vdout0_74ck860 FIND v(dout0_74) AT=435.025n

.meas tran vdout0_75ck860 FIND v(dout0_75) AT=435.025n

.meas tran vdout0_76ck860 FIND v(dout0_76) AT=435.025n

.meas tran vdout0_77ck860 FIND v(dout0_77) AT=435.025n

.meas tran vdout0_78ck860 FIND v(dout0_78) AT=435.025n

.meas tran vdout0_79ck860 FIND v(dout0_79) AT=435.025n

.meas tran vdout0_80ck860 FIND v(dout0_80) AT=435.025n

.meas tran vdout0_81ck860 FIND v(dout0_81) AT=435.025n

.meas tran vdout0_82ck860 FIND v(dout0_82) AT=435.025n

.meas tran vdout0_83ck860 FIND v(dout0_83) AT=435.025n

.meas tran vdout0_84ck860 FIND v(dout0_84) AT=435.025n

.meas tran vdout0_85ck860 FIND v(dout0_85) AT=435.025n

.meas tran vdout0_86ck860 FIND v(dout0_86) AT=435.025n

.meas tran vdout0_87ck860 FIND v(dout0_87) AT=435.025n

.meas tran vdout0_88ck860 FIND v(dout0_88) AT=435.025n

.meas tran vdout0_89ck860 FIND v(dout0_89) AT=435.025n

.meas tran vdout0_90ck860 FIND v(dout0_90) AT=435.025n

.meas tran vdout0_91ck860 FIND v(dout0_91) AT=435.025n

.meas tran vdout0_92ck860 FIND v(dout0_92) AT=435.025n

.meas tran vdout0_93ck860 FIND v(dout0_93) AT=435.025n

.meas tran vdout0_94ck860 FIND v(dout0_94) AT=435.025n

.meas tran vdout0_95ck860 FIND v(dout0_95) AT=435.025n

.meas tran vdout0_96ck860 FIND v(dout0_96) AT=435.025n

.meas tran vdout0_97ck860 FIND v(dout0_97) AT=435.025n

.meas tran vdout0_98ck860 FIND v(dout0_98) AT=435.025n

.meas tran vdout0_99ck860 FIND v(dout0_99) AT=435.025n

.meas tran vdout0_100ck860 FIND v(dout0_100) AT=435.025n

.meas tran vdout0_101ck860 FIND v(dout0_101) AT=435.025n

.meas tran vdout0_102ck860 FIND v(dout0_102) AT=435.025n

.meas tran vdout0_103ck860 FIND v(dout0_103) AT=435.025n

.meas tran vdout0_104ck860 FIND v(dout0_104) AT=435.025n

.meas tran vdout0_105ck860 FIND v(dout0_105) AT=435.025n

.meas tran vdout0_106ck860 FIND v(dout0_106) AT=435.025n

.meas tran vdout0_107ck860 FIND v(dout0_107) AT=435.025n

.meas tran vdout0_108ck860 FIND v(dout0_108) AT=435.025n

.meas tran vdout0_109ck860 FIND v(dout0_109) AT=435.025n

.meas tran vdout0_110ck860 FIND v(dout0_110) AT=435.025n

.meas tran vdout0_111ck860 FIND v(dout0_111) AT=435.025n

.meas tran vdout0_112ck860 FIND v(dout0_112) AT=435.025n

.meas tran vdout0_113ck860 FIND v(dout0_113) AT=435.025n

.meas tran vdout0_114ck860 FIND v(dout0_114) AT=435.025n

.meas tran vdout0_115ck860 FIND v(dout0_115) AT=435.025n

.meas tran vdout0_116ck860 FIND v(dout0_116) AT=435.025n

.meas tran vdout0_117ck860 FIND v(dout0_117) AT=435.025n

.meas tran vdout0_118ck860 FIND v(dout0_118) AT=435.025n

.meas tran vdout0_119ck860 FIND v(dout0_119) AT=435.025n

.meas tran vdout0_120ck860 FIND v(dout0_120) AT=435.025n

.meas tran vdout0_121ck860 FIND v(dout0_121) AT=435.025n

.meas tran vdout0_122ck860 FIND v(dout0_122) AT=435.025n

.meas tran vdout0_123ck860 FIND v(dout0_123) AT=435.025n

.meas tran vdout0_124ck860 FIND v(dout0_124) AT=435.025n

.meas tran vdout0_125ck860 FIND v(dout0_125) AT=435.025n

.meas tran vdout0_126ck860 FIND v(dout0_126) AT=435.025n

.meas tran vdout0_127ck860 FIND v(dout0_127) AT=435.025n

.meas tran vdout0_128ck860 FIND v(dout0_128) AT=435.025n

.meas tran vdout0_129ck860 FIND v(dout0_129) AT=435.025n

.meas tran vdout0_130ck860 FIND v(dout0_130) AT=435.025n

.meas tran vdout0_131ck860 FIND v(dout0_131) AT=435.025n

.meas tran vdout0_132ck860 FIND v(dout0_132) AT=435.025n

.meas tran vdout0_133ck860 FIND v(dout0_133) AT=435.025n

.meas tran vdout0_134ck860 FIND v(dout0_134) AT=435.025n

.meas tran vdout0_135ck860 FIND v(dout0_135) AT=435.025n

.meas tran vdout0_136ck860 FIND v(dout0_136) AT=435.025n

.meas tran vdout0_137ck860 FIND v(dout0_137) AT=435.025n

.meas tran vdout0_138ck860 FIND v(dout0_138) AT=435.025n

.meas tran vdout0_139ck860 FIND v(dout0_139) AT=435.025n

.meas tran vdout0_140ck860 FIND v(dout0_140) AT=435.025n

.meas tran vdout0_141ck860 FIND v(dout0_141) AT=435.025n

.meas tran vdout0_142ck860 FIND v(dout0_142) AT=435.025n

.meas tran vdout0_143ck860 FIND v(dout0_143) AT=435.025n

.meas tran vdout0_144ck860 FIND v(dout0_144) AT=435.025n

.meas tran vdout0_145ck860 FIND v(dout0_145) AT=435.025n

.meas tran vdout0_146ck860 FIND v(dout0_146) AT=435.025n

.meas tran vdout0_147ck860 FIND v(dout0_147) AT=435.025n

.meas tran vdout0_148ck860 FIND v(dout0_148) AT=435.025n

.meas tran vdout0_149ck860 FIND v(dout0_149) AT=435.025n

.meas tran vdout0_150ck860 FIND v(dout0_150) AT=435.025n

.meas tran vdout0_151ck860 FIND v(dout0_151) AT=435.025n

.meas tran vdout0_152ck860 FIND v(dout0_152) AT=435.025n

.meas tran vdout0_153ck860 FIND v(dout0_153) AT=435.025n

.meas tran vdout0_154ck860 FIND v(dout0_154) AT=435.025n

.meas tran vdout0_155ck860 FIND v(dout0_155) AT=435.025n

.meas tran vdout0_156ck860 FIND v(dout0_156) AT=435.025n

.meas tran vdout0_157ck860 FIND v(dout0_157) AT=435.025n

.meas tran vdout0_158ck860 FIND v(dout0_158) AT=435.025n

.meas tran vdout0_159ck860 FIND v(dout0_159) AT=435.025n

.meas tran vdout0_160ck860 FIND v(dout0_160) AT=435.025n

.meas tran vdout0_161ck860 FIND v(dout0_161) AT=435.025n

.meas tran vdout0_162ck860 FIND v(dout0_162) AT=435.025n

.meas tran vdout0_163ck860 FIND v(dout0_163) AT=435.025n

.meas tran vdout0_164ck860 FIND v(dout0_164) AT=435.025n

.meas tran vdout0_165ck860 FIND v(dout0_165) AT=435.025n

.meas tran vdout0_166ck860 FIND v(dout0_166) AT=435.025n

.meas tran vdout0_167ck860 FIND v(dout0_167) AT=435.025n

.meas tran vdout0_168ck860 FIND v(dout0_168) AT=435.025n

.meas tran vdout0_169ck860 FIND v(dout0_169) AT=435.025n

.meas tran vdout0_170ck860 FIND v(dout0_170) AT=435.025n

.meas tran vdout0_171ck860 FIND v(dout0_171) AT=435.025n

.meas tran vdout0_172ck860 FIND v(dout0_172) AT=435.025n

.meas tran vdout0_173ck860 FIND v(dout0_173) AT=435.025n

.meas tran vdout0_174ck860 FIND v(dout0_174) AT=435.025n

.meas tran vdout0_175ck860 FIND v(dout0_175) AT=435.025n

.meas tran vdout0_176ck860 FIND v(dout0_176) AT=435.025n

.meas tran vdout0_177ck860 FIND v(dout0_177) AT=435.025n

.meas tran vdout0_178ck860 FIND v(dout0_178) AT=435.025n

.meas tran vdout0_179ck860 FIND v(dout0_179) AT=435.025n

.meas tran vdout0_180ck860 FIND v(dout0_180) AT=435.025n

.meas tran vdout0_181ck860 FIND v(dout0_181) AT=435.025n

.meas tran vdout0_182ck860 FIND v(dout0_182) AT=435.025n

.meas tran vdout0_183ck860 FIND v(dout0_183) AT=435.025n

.meas tran vdout0_184ck860 FIND v(dout0_184) AT=435.025n

.meas tran vdout0_185ck860 FIND v(dout0_185) AT=435.025n

.meas tran vdout0_186ck860 FIND v(dout0_186) AT=435.025n

.meas tran vdout0_187ck860 FIND v(dout0_187) AT=435.025n

.meas tran vdout0_188ck860 FIND v(dout0_188) AT=435.025n

.meas tran vdout0_189ck860 FIND v(dout0_189) AT=435.025n

.meas tran vdout0_190ck860 FIND v(dout0_190) AT=435.025n

.meas tran vdout0_191ck860 FIND v(dout0_191) AT=435.025n

.meas tran vdout0_192ck860 FIND v(dout0_192) AT=435.025n

.meas tran vdout0_193ck860 FIND v(dout0_193) AT=435.025n

.meas tran vdout0_194ck860 FIND v(dout0_194) AT=435.025n

.meas tran vdout0_195ck860 FIND v(dout0_195) AT=435.025n

.meas tran vdout0_196ck860 FIND v(dout0_196) AT=435.025n

.meas tran vdout0_197ck860 FIND v(dout0_197) AT=435.025n

.meas tran vdout0_198ck860 FIND v(dout0_198) AT=435.025n

.meas tran vdout0_199ck860 FIND v(dout0_199) AT=435.025n

.meas tran vdout0_200ck860 FIND v(dout0_200) AT=435.025n

.meas tran vdout0_201ck860 FIND v(dout0_201) AT=435.025n

.meas tran vdout0_202ck860 FIND v(dout0_202) AT=435.025n

.meas tran vdout0_203ck860 FIND v(dout0_203) AT=435.025n

.meas tran vdout0_204ck860 FIND v(dout0_204) AT=435.025n

.meas tran vdout0_205ck860 FIND v(dout0_205) AT=435.025n

.meas tran vdout0_206ck860 FIND v(dout0_206) AT=435.025n

.meas tran vdout0_207ck860 FIND v(dout0_207) AT=435.025n

.meas tran vdout0_208ck860 FIND v(dout0_208) AT=435.025n

.meas tran vdout0_209ck860 FIND v(dout0_209) AT=435.025n

.meas tran vdout0_210ck860 FIND v(dout0_210) AT=435.025n

.meas tran vdout0_211ck860 FIND v(dout0_211) AT=435.025n

.meas tran vdout0_212ck860 FIND v(dout0_212) AT=435.025n

.meas tran vdout0_213ck860 FIND v(dout0_213) AT=435.025n

.meas tran vdout0_214ck860 FIND v(dout0_214) AT=435.025n

.meas tran vdout0_215ck860 FIND v(dout0_215) AT=435.025n

.meas tran vdout0_216ck860 FIND v(dout0_216) AT=435.025n

.meas tran vdout0_217ck860 FIND v(dout0_217) AT=435.025n

.meas tran vdout0_218ck860 FIND v(dout0_218) AT=435.025n

.meas tran vdout0_219ck860 FIND v(dout0_219) AT=435.025n

.meas tran vdout0_220ck860 FIND v(dout0_220) AT=435.025n

.meas tran vdout0_221ck860 FIND v(dout0_221) AT=435.025n

.meas tran vdout0_222ck860 FIND v(dout0_222) AT=435.025n

.meas tran vdout0_223ck860 FIND v(dout0_223) AT=435.025n

.meas tran vdout0_224ck860 FIND v(dout0_224) AT=435.025n

.meas tran vdout0_225ck860 FIND v(dout0_225) AT=435.025n

.meas tran vdout0_226ck860 FIND v(dout0_226) AT=435.025n

.meas tran vdout0_227ck860 FIND v(dout0_227) AT=435.025n

.meas tran vdout0_228ck860 FIND v(dout0_228) AT=435.025n

.meas tran vdout0_229ck860 FIND v(dout0_229) AT=435.025n

.meas tran vdout0_230ck860 FIND v(dout0_230) AT=435.025n

.meas tran vdout0_231ck860 FIND v(dout0_231) AT=435.025n

.meas tran vdout0_232ck860 FIND v(dout0_232) AT=435.025n

.meas tran vdout0_233ck860 FIND v(dout0_233) AT=435.025n

.meas tran vdout0_234ck860 FIND v(dout0_234) AT=435.025n

.meas tran vdout0_235ck860 FIND v(dout0_235) AT=435.025n

.meas tran vdout0_236ck860 FIND v(dout0_236) AT=435.025n

.meas tran vdout0_237ck860 FIND v(dout0_237) AT=435.025n

.meas tran vdout0_238ck860 FIND v(dout0_238) AT=435.025n

.meas tran vdout0_239ck860 FIND v(dout0_239) AT=435.025n

.meas tran vdout0_240ck860 FIND v(dout0_240) AT=435.025n

.meas tran vdout0_241ck860 FIND v(dout0_241) AT=435.025n

.meas tran vdout0_242ck860 FIND v(dout0_242) AT=435.025n

.meas tran vdout0_243ck860 FIND v(dout0_243) AT=435.025n

.meas tran vdout0_244ck860 FIND v(dout0_244) AT=435.025n

.meas tran vdout0_245ck860 FIND v(dout0_245) AT=435.025n

.meas tran vdout0_246ck860 FIND v(dout0_246) AT=435.025n

.meas tran vdout0_247ck860 FIND v(dout0_247) AT=435.025n

.meas tran vdout0_248ck860 FIND v(dout0_248) AT=435.025n

.meas tran vdout0_249ck860 FIND v(dout0_249) AT=435.025n

.meas tran vdout0_250ck860 FIND v(dout0_250) AT=435.025n

.meas tran vdout0_251ck860 FIND v(dout0_251) AT=435.025n

.meas tran vdout0_252ck860 FIND v(dout0_252) AT=435.025n

.meas tran vdout0_253ck860 FIND v(dout0_253) AT=435.025n

.meas tran vdout0_254ck860 FIND v(dout0_254) AT=435.025n

.meas tran vdout0_255ck860 FIND v(dout0_255) AT=435.025n

.meas tran vdout0_0ck870 FIND v(dout0_0) AT=440.025n

.meas tran vdout0_1ck870 FIND v(dout0_1) AT=440.025n

.meas tran vdout0_2ck870 FIND v(dout0_2) AT=440.025n

.meas tran vdout0_3ck870 FIND v(dout0_3) AT=440.025n

.meas tran vdout0_4ck870 FIND v(dout0_4) AT=440.025n

.meas tran vdout0_5ck870 FIND v(dout0_5) AT=440.025n

.meas tran vdout0_6ck870 FIND v(dout0_6) AT=440.025n

.meas tran vdout0_7ck870 FIND v(dout0_7) AT=440.025n

.meas tran vdout0_8ck870 FIND v(dout0_8) AT=440.025n

.meas tran vdout0_9ck870 FIND v(dout0_9) AT=440.025n

.meas tran vdout0_10ck870 FIND v(dout0_10) AT=440.025n

.meas tran vdout0_11ck870 FIND v(dout0_11) AT=440.025n

.meas tran vdout0_12ck870 FIND v(dout0_12) AT=440.025n

.meas tran vdout0_13ck870 FIND v(dout0_13) AT=440.025n

.meas tran vdout0_14ck870 FIND v(dout0_14) AT=440.025n

.meas tran vdout0_15ck870 FIND v(dout0_15) AT=440.025n

.meas tran vdout0_16ck870 FIND v(dout0_16) AT=440.025n

.meas tran vdout0_17ck870 FIND v(dout0_17) AT=440.025n

.meas tran vdout0_18ck870 FIND v(dout0_18) AT=440.025n

.meas tran vdout0_19ck870 FIND v(dout0_19) AT=440.025n

.meas tran vdout0_20ck870 FIND v(dout0_20) AT=440.025n

.meas tran vdout0_21ck870 FIND v(dout0_21) AT=440.025n

.meas tran vdout0_22ck870 FIND v(dout0_22) AT=440.025n

.meas tran vdout0_23ck870 FIND v(dout0_23) AT=440.025n

.meas tran vdout0_24ck870 FIND v(dout0_24) AT=440.025n

.meas tran vdout0_25ck870 FIND v(dout0_25) AT=440.025n

.meas tran vdout0_26ck870 FIND v(dout0_26) AT=440.025n

.meas tran vdout0_27ck870 FIND v(dout0_27) AT=440.025n

.meas tran vdout0_28ck870 FIND v(dout0_28) AT=440.025n

.meas tran vdout0_29ck870 FIND v(dout0_29) AT=440.025n

.meas tran vdout0_30ck870 FIND v(dout0_30) AT=440.025n

.meas tran vdout0_31ck870 FIND v(dout0_31) AT=440.025n

.meas tran vdout0_32ck870 FIND v(dout0_32) AT=440.025n

.meas tran vdout0_33ck870 FIND v(dout0_33) AT=440.025n

.meas tran vdout0_34ck870 FIND v(dout0_34) AT=440.025n

.meas tran vdout0_35ck870 FIND v(dout0_35) AT=440.025n

.meas tran vdout0_36ck870 FIND v(dout0_36) AT=440.025n

.meas tran vdout0_37ck870 FIND v(dout0_37) AT=440.025n

.meas tran vdout0_38ck870 FIND v(dout0_38) AT=440.025n

.meas tran vdout0_39ck870 FIND v(dout0_39) AT=440.025n

.meas tran vdout0_40ck870 FIND v(dout0_40) AT=440.025n

.meas tran vdout0_41ck870 FIND v(dout0_41) AT=440.025n

.meas tran vdout0_42ck870 FIND v(dout0_42) AT=440.025n

.meas tran vdout0_43ck870 FIND v(dout0_43) AT=440.025n

.meas tran vdout0_44ck870 FIND v(dout0_44) AT=440.025n

.meas tran vdout0_45ck870 FIND v(dout0_45) AT=440.025n

.meas tran vdout0_46ck870 FIND v(dout0_46) AT=440.025n

.meas tran vdout0_47ck870 FIND v(dout0_47) AT=440.025n

.meas tran vdout0_48ck870 FIND v(dout0_48) AT=440.025n

.meas tran vdout0_49ck870 FIND v(dout0_49) AT=440.025n

.meas tran vdout0_50ck870 FIND v(dout0_50) AT=440.025n

.meas tran vdout0_51ck870 FIND v(dout0_51) AT=440.025n

.meas tran vdout0_52ck870 FIND v(dout0_52) AT=440.025n

.meas tran vdout0_53ck870 FIND v(dout0_53) AT=440.025n

.meas tran vdout0_54ck870 FIND v(dout0_54) AT=440.025n

.meas tran vdout0_55ck870 FIND v(dout0_55) AT=440.025n

.meas tran vdout0_56ck870 FIND v(dout0_56) AT=440.025n

.meas tran vdout0_57ck870 FIND v(dout0_57) AT=440.025n

.meas tran vdout0_58ck870 FIND v(dout0_58) AT=440.025n

.meas tran vdout0_59ck870 FIND v(dout0_59) AT=440.025n

.meas tran vdout0_60ck870 FIND v(dout0_60) AT=440.025n

.meas tran vdout0_61ck870 FIND v(dout0_61) AT=440.025n

.meas tran vdout0_62ck870 FIND v(dout0_62) AT=440.025n

.meas tran vdout0_63ck870 FIND v(dout0_63) AT=440.025n

.meas tran vdout0_64ck870 FIND v(dout0_64) AT=440.025n

.meas tran vdout0_65ck870 FIND v(dout0_65) AT=440.025n

.meas tran vdout0_66ck870 FIND v(dout0_66) AT=440.025n

.meas tran vdout0_67ck870 FIND v(dout0_67) AT=440.025n

.meas tran vdout0_68ck870 FIND v(dout0_68) AT=440.025n

.meas tran vdout0_69ck870 FIND v(dout0_69) AT=440.025n

.meas tran vdout0_70ck870 FIND v(dout0_70) AT=440.025n

.meas tran vdout0_71ck870 FIND v(dout0_71) AT=440.025n

.meas tran vdout0_72ck870 FIND v(dout0_72) AT=440.025n

.meas tran vdout0_73ck870 FIND v(dout0_73) AT=440.025n

.meas tran vdout0_74ck870 FIND v(dout0_74) AT=440.025n

.meas tran vdout0_75ck870 FIND v(dout0_75) AT=440.025n

.meas tran vdout0_76ck870 FIND v(dout0_76) AT=440.025n

.meas tran vdout0_77ck870 FIND v(dout0_77) AT=440.025n

.meas tran vdout0_78ck870 FIND v(dout0_78) AT=440.025n

.meas tran vdout0_79ck870 FIND v(dout0_79) AT=440.025n

.meas tran vdout0_80ck870 FIND v(dout0_80) AT=440.025n

.meas tran vdout0_81ck870 FIND v(dout0_81) AT=440.025n

.meas tran vdout0_82ck870 FIND v(dout0_82) AT=440.025n

.meas tran vdout0_83ck870 FIND v(dout0_83) AT=440.025n

.meas tran vdout0_84ck870 FIND v(dout0_84) AT=440.025n

.meas tran vdout0_85ck870 FIND v(dout0_85) AT=440.025n

.meas tran vdout0_86ck870 FIND v(dout0_86) AT=440.025n

.meas tran vdout0_87ck870 FIND v(dout0_87) AT=440.025n

.meas tran vdout0_88ck870 FIND v(dout0_88) AT=440.025n

.meas tran vdout0_89ck870 FIND v(dout0_89) AT=440.025n

.meas tran vdout0_90ck870 FIND v(dout0_90) AT=440.025n

.meas tran vdout0_91ck870 FIND v(dout0_91) AT=440.025n

.meas tran vdout0_92ck870 FIND v(dout0_92) AT=440.025n

.meas tran vdout0_93ck870 FIND v(dout0_93) AT=440.025n

.meas tran vdout0_94ck870 FIND v(dout0_94) AT=440.025n

.meas tran vdout0_95ck870 FIND v(dout0_95) AT=440.025n

.meas tran vdout0_96ck870 FIND v(dout0_96) AT=440.025n

.meas tran vdout0_97ck870 FIND v(dout0_97) AT=440.025n

.meas tran vdout0_98ck870 FIND v(dout0_98) AT=440.025n

.meas tran vdout0_99ck870 FIND v(dout0_99) AT=440.025n

.meas tran vdout0_100ck870 FIND v(dout0_100) AT=440.025n

.meas tran vdout0_101ck870 FIND v(dout0_101) AT=440.025n

.meas tran vdout0_102ck870 FIND v(dout0_102) AT=440.025n

.meas tran vdout0_103ck870 FIND v(dout0_103) AT=440.025n

.meas tran vdout0_104ck870 FIND v(dout0_104) AT=440.025n

.meas tran vdout0_105ck870 FIND v(dout0_105) AT=440.025n

.meas tran vdout0_106ck870 FIND v(dout0_106) AT=440.025n

.meas tran vdout0_107ck870 FIND v(dout0_107) AT=440.025n

.meas tran vdout0_108ck870 FIND v(dout0_108) AT=440.025n

.meas tran vdout0_109ck870 FIND v(dout0_109) AT=440.025n

.meas tran vdout0_110ck870 FIND v(dout0_110) AT=440.025n

.meas tran vdout0_111ck870 FIND v(dout0_111) AT=440.025n

.meas tran vdout0_112ck870 FIND v(dout0_112) AT=440.025n

.meas tran vdout0_113ck870 FIND v(dout0_113) AT=440.025n

.meas tran vdout0_114ck870 FIND v(dout0_114) AT=440.025n

.meas tran vdout0_115ck870 FIND v(dout0_115) AT=440.025n

.meas tran vdout0_116ck870 FIND v(dout0_116) AT=440.025n

.meas tran vdout0_117ck870 FIND v(dout0_117) AT=440.025n

.meas tran vdout0_118ck870 FIND v(dout0_118) AT=440.025n

.meas tran vdout0_119ck870 FIND v(dout0_119) AT=440.025n

.meas tran vdout0_120ck870 FIND v(dout0_120) AT=440.025n

.meas tran vdout0_121ck870 FIND v(dout0_121) AT=440.025n

.meas tran vdout0_122ck870 FIND v(dout0_122) AT=440.025n

.meas tran vdout0_123ck870 FIND v(dout0_123) AT=440.025n

.meas tran vdout0_124ck870 FIND v(dout0_124) AT=440.025n

.meas tran vdout0_125ck870 FIND v(dout0_125) AT=440.025n

.meas tran vdout0_126ck870 FIND v(dout0_126) AT=440.025n

.meas tran vdout0_127ck870 FIND v(dout0_127) AT=440.025n

.meas tran vdout0_128ck870 FIND v(dout0_128) AT=440.025n

.meas tran vdout0_129ck870 FIND v(dout0_129) AT=440.025n

.meas tran vdout0_130ck870 FIND v(dout0_130) AT=440.025n

.meas tran vdout0_131ck870 FIND v(dout0_131) AT=440.025n

.meas tran vdout0_132ck870 FIND v(dout0_132) AT=440.025n

.meas tran vdout0_133ck870 FIND v(dout0_133) AT=440.025n

.meas tran vdout0_134ck870 FIND v(dout0_134) AT=440.025n

.meas tran vdout0_135ck870 FIND v(dout0_135) AT=440.025n

.meas tran vdout0_136ck870 FIND v(dout0_136) AT=440.025n

.meas tran vdout0_137ck870 FIND v(dout0_137) AT=440.025n

.meas tran vdout0_138ck870 FIND v(dout0_138) AT=440.025n

.meas tran vdout0_139ck870 FIND v(dout0_139) AT=440.025n

.meas tran vdout0_140ck870 FIND v(dout0_140) AT=440.025n

.meas tran vdout0_141ck870 FIND v(dout0_141) AT=440.025n

.meas tran vdout0_142ck870 FIND v(dout0_142) AT=440.025n

.meas tran vdout0_143ck870 FIND v(dout0_143) AT=440.025n

.meas tran vdout0_144ck870 FIND v(dout0_144) AT=440.025n

.meas tran vdout0_145ck870 FIND v(dout0_145) AT=440.025n

.meas tran vdout0_146ck870 FIND v(dout0_146) AT=440.025n

.meas tran vdout0_147ck870 FIND v(dout0_147) AT=440.025n

.meas tran vdout0_148ck870 FIND v(dout0_148) AT=440.025n

.meas tran vdout0_149ck870 FIND v(dout0_149) AT=440.025n

.meas tran vdout0_150ck870 FIND v(dout0_150) AT=440.025n

.meas tran vdout0_151ck870 FIND v(dout0_151) AT=440.025n

.meas tran vdout0_152ck870 FIND v(dout0_152) AT=440.025n

.meas tran vdout0_153ck870 FIND v(dout0_153) AT=440.025n

.meas tran vdout0_154ck870 FIND v(dout0_154) AT=440.025n

.meas tran vdout0_155ck870 FIND v(dout0_155) AT=440.025n

.meas tran vdout0_156ck870 FIND v(dout0_156) AT=440.025n

.meas tran vdout0_157ck870 FIND v(dout0_157) AT=440.025n

.meas tran vdout0_158ck870 FIND v(dout0_158) AT=440.025n

.meas tran vdout0_159ck870 FIND v(dout0_159) AT=440.025n

.meas tran vdout0_160ck870 FIND v(dout0_160) AT=440.025n

.meas tran vdout0_161ck870 FIND v(dout0_161) AT=440.025n

.meas tran vdout0_162ck870 FIND v(dout0_162) AT=440.025n

.meas tran vdout0_163ck870 FIND v(dout0_163) AT=440.025n

.meas tran vdout0_164ck870 FIND v(dout0_164) AT=440.025n

.meas tran vdout0_165ck870 FIND v(dout0_165) AT=440.025n

.meas tran vdout0_166ck870 FIND v(dout0_166) AT=440.025n

.meas tran vdout0_167ck870 FIND v(dout0_167) AT=440.025n

.meas tran vdout0_168ck870 FIND v(dout0_168) AT=440.025n

.meas tran vdout0_169ck870 FIND v(dout0_169) AT=440.025n

.meas tran vdout0_170ck870 FIND v(dout0_170) AT=440.025n

.meas tran vdout0_171ck870 FIND v(dout0_171) AT=440.025n

.meas tran vdout0_172ck870 FIND v(dout0_172) AT=440.025n

.meas tran vdout0_173ck870 FIND v(dout0_173) AT=440.025n

.meas tran vdout0_174ck870 FIND v(dout0_174) AT=440.025n

.meas tran vdout0_175ck870 FIND v(dout0_175) AT=440.025n

.meas tran vdout0_176ck870 FIND v(dout0_176) AT=440.025n

.meas tran vdout0_177ck870 FIND v(dout0_177) AT=440.025n

.meas tran vdout0_178ck870 FIND v(dout0_178) AT=440.025n

.meas tran vdout0_179ck870 FIND v(dout0_179) AT=440.025n

.meas tran vdout0_180ck870 FIND v(dout0_180) AT=440.025n

.meas tran vdout0_181ck870 FIND v(dout0_181) AT=440.025n

.meas tran vdout0_182ck870 FIND v(dout0_182) AT=440.025n

.meas tran vdout0_183ck870 FIND v(dout0_183) AT=440.025n

.meas tran vdout0_184ck870 FIND v(dout0_184) AT=440.025n

.meas tran vdout0_185ck870 FIND v(dout0_185) AT=440.025n

.meas tran vdout0_186ck870 FIND v(dout0_186) AT=440.025n

.meas tran vdout0_187ck870 FIND v(dout0_187) AT=440.025n

.meas tran vdout0_188ck870 FIND v(dout0_188) AT=440.025n

.meas tran vdout0_189ck870 FIND v(dout0_189) AT=440.025n

.meas tran vdout0_190ck870 FIND v(dout0_190) AT=440.025n

.meas tran vdout0_191ck870 FIND v(dout0_191) AT=440.025n

.meas tran vdout0_192ck870 FIND v(dout0_192) AT=440.025n

.meas tran vdout0_193ck870 FIND v(dout0_193) AT=440.025n

.meas tran vdout0_194ck870 FIND v(dout0_194) AT=440.025n

.meas tran vdout0_195ck870 FIND v(dout0_195) AT=440.025n

.meas tran vdout0_196ck870 FIND v(dout0_196) AT=440.025n

.meas tran vdout0_197ck870 FIND v(dout0_197) AT=440.025n

.meas tran vdout0_198ck870 FIND v(dout0_198) AT=440.025n

.meas tran vdout0_199ck870 FIND v(dout0_199) AT=440.025n

.meas tran vdout0_200ck870 FIND v(dout0_200) AT=440.025n

.meas tran vdout0_201ck870 FIND v(dout0_201) AT=440.025n

.meas tran vdout0_202ck870 FIND v(dout0_202) AT=440.025n

.meas tran vdout0_203ck870 FIND v(dout0_203) AT=440.025n

.meas tran vdout0_204ck870 FIND v(dout0_204) AT=440.025n

.meas tran vdout0_205ck870 FIND v(dout0_205) AT=440.025n

.meas tran vdout0_206ck870 FIND v(dout0_206) AT=440.025n

.meas tran vdout0_207ck870 FIND v(dout0_207) AT=440.025n

.meas tran vdout0_208ck870 FIND v(dout0_208) AT=440.025n

.meas tran vdout0_209ck870 FIND v(dout0_209) AT=440.025n

.meas tran vdout0_210ck870 FIND v(dout0_210) AT=440.025n

.meas tran vdout0_211ck870 FIND v(dout0_211) AT=440.025n

.meas tran vdout0_212ck870 FIND v(dout0_212) AT=440.025n

.meas tran vdout0_213ck870 FIND v(dout0_213) AT=440.025n

.meas tran vdout0_214ck870 FIND v(dout0_214) AT=440.025n

.meas tran vdout0_215ck870 FIND v(dout0_215) AT=440.025n

.meas tran vdout0_216ck870 FIND v(dout0_216) AT=440.025n

.meas tran vdout0_217ck870 FIND v(dout0_217) AT=440.025n

.meas tran vdout0_218ck870 FIND v(dout0_218) AT=440.025n

.meas tran vdout0_219ck870 FIND v(dout0_219) AT=440.025n

.meas tran vdout0_220ck870 FIND v(dout0_220) AT=440.025n

.meas tran vdout0_221ck870 FIND v(dout0_221) AT=440.025n

.meas tran vdout0_222ck870 FIND v(dout0_222) AT=440.025n

.meas tran vdout0_223ck870 FIND v(dout0_223) AT=440.025n

.meas tran vdout0_224ck870 FIND v(dout0_224) AT=440.025n

.meas tran vdout0_225ck870 FIND v(dout0_225) AT=440.025n

.meas tran vdout0_226ck870 FIND v(dout0_226) AT=440.025n

.meas tran vdout0_227ck870 FIND v(dout0_227) AT=440.025n

.meas tran vdout0_228ck870 FIND v(dout0_228) AT=440.025n

.meas tran vdout0_229ck870 FIND v(dout0_229) AT=440.025n

.meas tran vdout0_230ck870 FIND v(dout0_230) AT=440.025n

.meas tran vdout0_231ck870 FIND v(dout0_231) AT=440.025n

.meas tran vdout0_232ck870 FIND v(dout0_232) AT=440.025n

.meas tran vdout0_233ck870 FIND v(dout0_233) AT=440.025n

.meas tran vdout0_234ck870 FIND v(dout0_234) AT=440.025n

.meas tran vdout0_235ck870 FIND v(dout0_235) AT=440.025n

.meas tran vdout0_236ck870 FIND v(dout0_236) AT=440.025n

.meas tran vdout0_237ck870 FIND v(dout0_237) AT=440.025n

.meas tran vdout0_238ck870 FIND v(dout0_238) AT=440.025n

.meas tran vdout0_239ck870 FIND v(dout0_239) AT=440.025n

.meas tran vdout0_240ck870 FIND v(dout0_240) AT=440.025n

.meas tran vdout0_241ck870 FIND v(dout0_241) AT=440.025n

.meas tran vdout0_242ck870 FIND v(dout0_242) AT=440.025n

.meas tran vdout0_243ck870 FIND v(dout0_243) AT=440.025n

.meas tran vdout0_244ck870 FIND v(dout0_244) AT=440.025n

.meas tran vdout0_245ck870 FIND v(dout0_245) AT=440.025n

.meas tran vdout0_246ck870 FIND v(dout0_246) AT=440.025n

.meas tran vdout0_247ck870 FIND v(dout0_247) AT=440.025n

.meas tran vdout0_248ck870 FIND v(dout0_248) AT=440.025n

.meas tran vdout0_249ck870 FIND v(dout0_249) AT=440.025n

.meas tran vdout0_250ck870 FIND v(dout0_250) AT=440.025n

.meas tran vdout0_251ck870 FIND v(dout0_251) AT=440.025n

.meas tran vdout0_252ck870 FIND v(dout0_252) AT=440.025n

.meas tran vdout0_253ck870 FIND v(dout0_253) AT=440.025n

.meas tran vdout0_254ck870 FIND v(dout0_254) AT=440.025n

.meas tran vdout0_255ck870 FIND v(dout0_255) AT=440.025n

.meas tran vdout0_0ck910 FIND v(dout0_0) AT=460.025n

.meas tran vdout0_1ck910 FIND v(dout0_1) AT=460.025n

.meas tran vdout0_2ck910 FIND v(dout0_2) AT=460.025n

.meas tran vdout0_3ck910 FIND v(dout0_3) AT=460.025n

.meas tran vdout0_4ck910 FIND v(dout0_4) AT=460.025n

.meas tran vdout0_5ck910 FIND v(dout0_5) AT=460.025n

.meas tran vdout0_6ck910 FIND v(dout0_6) AT=460.025n

.meas tran vdout0_7ck910 FIND v(dout0_7) AT=460.025n

.meas tran vdout0_8ck910 FIND v(dout0_8) AT=460.025n

.meas tran vdout0_9ck910 FIND v(dout0_9) AT=460.025n

.meas tran vdout0_10ck910 FIND v(dout0_10) AT=460.025n

.meas tran vdout0_11ck910 FIND v(dout0_11) AT=460.025n

.meas tran vdout0_12ck910 FIND v(dout0_12) AT=460.025n

.meas tran vdout0_13ck910 FIND v(dout0_13) AT=460.025n

.meas tran vdout0_14ck910 FIND v(dout0_14) AT=460.025n

.meas tran vdout0_15ck910 FIND v(dout0_15) AT=460.025n

.meas tran vdout0_16ck910 FIND v(dout0_16) AT=460.025n

.meas tran vdout0_17ck910 FIND v(dout0_17) AT=460.025n

.meas tran vdout0_18ck910 FIND v(dout0_18) AT=460.025n

.meas tran vdout0_19ck910 FIND v(dout0_19) AT=460.025n

.meas tran vdout0_20ck910 FIND v(dout0_20) AT=460.025n

.meas tran vdout0_21ck910 FIND v(dout0_21) AT=460.025n

.meas tran vdout0_22ck910 FIND v(dout0_22) AT=460.025n

.meas tran vdout0_23ck910 FIND v(dout0_23) AT=460.025n

.meas tran vdout0_24ck910 FIND v(dout0_24) AT=460.025n

.meas tran vdout0_25ck910 FIND v(dout0_25) AT=460.025n

.meas tran vdout0_26ck910 FIND v(dout0_26) AT=460.025n

.meas tran vdout0_27ck910 FIND v(dout0_27) AT=460.025n

.meas tran vdout0_28ck910 FIND v(dout0_28) AT=460.025n

.meas tran vdout0_29ck910 FIND v(dout0_29) AT=460.025n

.meas tran vdout0_30ck910 FIND v(dout0_30) AT=460.025n

.meas tran vdout0_31ck910 FIND v(dout0_31) AT=460.025n

.meas tran vdout0_32ck910 FIND v(dout0_32) AT=460.025n

.meas tran vdout0_33ck910 FIND v(dout0_33) AT=460.025n

.meas tran vdout0_34ck910 FIND v(dout0_34) AT=460.025n

.meas tran vdout0_35ck910 FIND v(dout0_35) AT=460.025n

.meas tran vdout0_36ck910 FIND v(dout0_36) AT=460.025n

.meas tran vdout0_37ck910 FIND v(dout0_37) AT=460.025n

.meas tran vdout0_38ck910 FIND v(dout0_38) AT=460.025n

.meas tran vdout0_39ck910 FIND v(dout0_39) AT=460.025n

.meas tran vdout0_40ck910 FIND v(dout0_40) AT=460.025n

.meas tran vdout0_41ck910 FIND v(dout0_41) AT=460.025n

.meas tran vdout0_42ck910 FIND v(dout0_42) AT=460.025n

.meas tran vdout0_43ck910 FIND v(dout0_43) AT=460.025n

.meas tran vdout0_44ck910 FIND v(dout0_44) AT=460.025n

.meas tran vdout0_45ck910 FIND v(dout0_45) AT=460.025n

.meas tran vdout0_46ck910 FIND v(dout0_46) AT=460.025n

.meas tran vdout0_47ck910 FIND v(dout0_47) AT=460.025n

.meas tran vdout0_48ck910 FIND v(dout0_48) AT=460.025n

.meas tran vdout0_49ck910 FIND v(dout0_49) AT=460.025n

.meas tran vdout0_50ck910 FIND v(dout0_50) AT=460.025n

.meas tran vdout0_51ck910 FIND v(dout0_51) AT=460.025n

.meas tran vdout0_52ck910 FIND v(dout0_52) AT=460.025n

.meas tran vdout0_53ck910 FIND v(dout0_53) AT=460.025n

.meas tran vdout0_54ck910 FIND v(dout0_54) AT=460.025n

.meas tran vdout0_55ck910 FIND v(dout0_55) AT=460.025n

.meas tran vdout0_56ck910 FIND v(dout0_56) AT=460.025n

.meas tran vdout0_57ck910 FIND v(dout0_57) AT=460.025n

.meas tran vdout0_58ck910 FIND v(dout0_58) AT=460.025n

.meas tran vdout0_59ck910 FIND v(dout0_59) AT=460.025n

.meas tran vdout0_60ck910 FIND v(dout0_60) AT=460.025n

.meas tran vdout0_61ck910 FIND v(dout0_61) AT=460.025n

.meas tran vdout0_62ck910 FIND v(dout0_62) AT=460.025n

.meas tran vdout0_63ck910 FIND v(dout0_63) AT=460.025n

.meas tran vdout0_64ck910 FIND v(dout0_64) AT=460.025n

.meas tran vdout0_65ck910 FIND v(dout0_65) AT=460.025n

.meas tran vdout0_66ck910 FIND v(dout0_66) AT=460.025n

.meas tran vdout0_67ck910 FIND v(dout0_67) AT=460.025n

.meas tran vdout0_68ck910 FIND v(dout0_68) AT=460.025n

.meas tran vdout0_69ck910 FIND v(dout0_69) AT=460.025n

.meas tran vdout0_70ck910 FIND v(dout0_70) AT=460.025n

.meas tran vdout0_71ck910 FIND v(dout0_71) AT=460.025n

.meas tran vdout0_72ck910 FIND v(dout0_72) AT=460.025n

.meas tran vdout0_73ck910 FIND v(dout0_73) AT=460.025n

.meas tran vdout0_74ck910 FIND v(dout0_74) AT=460.025n

.meas tran vdout0_75ck910 FIND v(dout0_75) AT=460.025n

.meas tran vdout0_76ck910 FIND v(dout0_76) AT=460.025n

.meas tran vdout0_77ck910 FIND v(dout0_77) AT=460.025n

.meas tran vdout0_78ck910 FIND v(dout0_78) AT=460.025n

.meas tran vdout0_79ck910 FIND v(dout0_79) AT=460.025n

.meas tran vdout0_80ck910 FIND v(dout0_80) AT=460.025n

.meas tran vdout0_81ck910 FIND v(dout0_81) AT=460.025n

.meas tran vdout0_82ck910 FIND v(dout0_82) AT=460.025n

.meas tran vdout0_83ck910 FIND v(dout0_83) AT=460.025n

.meas tran vdout0_84ck910 FIND v(dout0_84) AT=460.025n

.meas tran vdout0_85ck910 FIND v(dout0_85) AT=460.025n

.meas tran vdout0_86ck910 FIND v(dout0_86) AT=460.025n

.meas tran vdout0_87ck910 FIND v(dout0_87) AT=460.025n

.meas tran vdout0_88ck910 FIND v(dout0_88) AT=460.025n

.meas tran vdout0_89ck910 FIND v(dout0_89) AT=460.025n

.meas tran vdout0_90ck910 FIND v(dout0_90) AT=460.025n

.meas tran vdout0_91ck910 FIND v(dout0_91) AT=460.025n

.meas tran vdout0_92ck910 FIND v(dout0_92) AT=460.025n

.meas tran vdout0_93ck910 FIND v(dout0_93) AT=460.025n

.meas tran vdout0_94ck910 FIND v(dout0_94) AT=460.025n

.meas tran vdout0_95ck910 FIND v(dout0_95) AT=460.025n

.meas tran vdout0_96ck910 FIND v(dout0_96) AT=460.025n

.meas tran vdout0_97ck910 FIND v(dout0_97) AT=460.025n

.meas tran vdout0_98ck910 FIND v(dout0_98) AT=460.025n

.meas tran vdout0_99ck910 FIND v(dout0_99) AT=460.025n

.meas tran vdout0_100ck910 FIND v(dout0_100) AT=460.025n

.meas tran vdout0_101ck910 FIND v(dout0_101) AT=460.025n

.meas tran vdout0_102ck910 FIND v(dout0_102) AT=460.025n

.meas tran vdout0_103ck910 FIND v(dout0_103) AT=460.025n

.meas tran vdout0_104ck910 FIND v(dout0_104) AT=460.025n

.meas tran vdout0_105ck910 FIND v(dout0_105) AT=460.025n

.meas tran vdout0_106ck910 FIND v(dout0_106) AT=460.025n

.meas tran vdout0_107ck910 FIND v(dout0_107) AT=460.025n

.meas tran vdout0_108ck910 FIND v(dout0_108) AT=460.025n

.meas tran vdout0_109ck910 FIND v(dout0_109) AT=460.025n

.meas tran vdout0_110ck910 FIND v(dout0_110) AT=460.025n

.meas tran vdout0_111ck910 FIND v(dout0_111) AT=460.025n

.meas tran vdout0_112ck910 FIND v(dout0_112) AT=460.025n

.meas tran vdout0_113ck910 FIND v(dout0_113) AT=460.025n

.meas tran vdout0_114ck910 FIND v(dout0_114) AT=460.025n

.meas tran vdout0_115ck910 FIND v(dout0_115) AT=460.025n

.meas tran vdout0_116ck910 FIND v(dout0_116) AT=460.025n

.meas tran vdout0_117ck910 FIND v(dout0_117) AT=460.025n

.meas tran vdout0_118ck910 FIND v(dout0_118) AT=460.025n

.meas tran vdout0_119ck910 FIND v(dout0_119) AT=460.025n

.meas tran vdout0_120ck910 FIND v(dout0_120) AT=460.025n

.meas tran vdout0_121ck910 FIND v(dout0_121) AT=460.025n

.meas tran vdout0_122ck910 FIND v(dout0_122) AT=460.025n

.meas tran vdout0_123ck910 FIND v(dout0_123) AT=460.025n

.meas tran vdout0_124ck910 FIND v(dout0_124) AT=460.025n

.meas tran vdout0_125ck910 FIND v(dout0_125) AT=460.025n

.meas tran vdout0_126ck910 FIND v(dout0_126) AT=460.025n

.meas tran vdout0_127ck910 FIND v(dout0_127) AT=460.025n

.meas tran vdout0_128ck910 FIND v(dout0_128) AT=460.025n

.meas tran vdout0_129ck910 FIND v(dout0_129) AT=460.025n

.meas tran vdout0_130ck910 FIND v(dout0_130) AT=460.025n

.meas tran vdout0_131ck910 FIND v(dout0_131) AT=460.025n

.meas tran vdout0_132ck910 FIND v(dout0_132) AT=460.025n

.meas tran vdout0_133ck910 FIND v(dout0_133) AT=460.025n

.meas tran vdout0_134ck910 FIND v(dout0_134) AT=460.025n

.meas tran vdout0_135ck910 FIND v(dout0_135) AT=460.025n

.meas tran vdout0_136ck910 FIND v(dout0_136) AT=460.025n

.meas tran vdout0_137ck910 FIND v(dout0_137) AT=460.025n

.meas tran vdout0_138ck910 FIND v(dout0_138) AT=460.025n

.meas tran vdout0_139ck910 FIND v(dout0_139) AT=460.025n

.meas tran vdout0_140ck910 FIND v(dout0_140) AT=460.025n

.meas tran vdout0_141ck910 FIND v(dout0_141) AT=460.025n

.meas tran vdout0_142ck910 FIND v(dout0_142) AT=460.025n

.meas tran vdout0_143ck910 FIND v(dout0_143) AT=460.025n

.meas tran vdout0_144ck910 FIND v(dout0_144) AT=460.025n

.meas tran vdout0_145ck910 FIND v(dout0_145) AT=460.025n

.meas tran vdout0_146ck910 FIND v(dout0_146) AT=460.025n

.meas tran vdout0_147ck910 FIND v(dout0_147) AT=460.025n

.meas tran vdout0_148ck910 FIND v(dout0_148) AT=460.025n

.meas tran vdout0_149ck910 FIND v(dout0_149) AT=460.025n

.meas tran vdout0_150ck910 FIND v(dout0_150) AT=460.025n

.meas tran vdout0_151ck910 FIND v(dout0_151) AT=460.025n

.meas tran vdout0_152ck910 FIND v(dout0_152) AT=460.025n

.meas tran vdout0_153ck910 FIND v(dout0_153) AT=460.025n

.meas tran vdout0_154ck910 FIND v(dout0_154) AT=460.025n

.meas tran vdout0_155ck910 FIND v(dout0_155) AT=460.025n

.meas tran vdout0_156ck910 FIND v(dout0_156) AT=460.025n

.meas tran vdout0_157ck910 FIND v(dout0_157) AT=460.025n

.meas tran vdout0_158ck910 FIND v(dout0_158) AT=460.025n

.meas tran vdout0_159ck910 FIND v(dout0_159) AT=460.025n

.meas tran vdout0_160ck910 FIND v(dout0_160) AT=460.025n

.meas tran vdout0_161ck910 FIND v(dout0_161) AT=460.025n

.meas tran vdout0_162ck910 FIND v(dout0_162) AT=460.025n

.meas tran vdout0_163ck910 FIND v(dout0_163) AT=460.025n

.meas tran vdout0_164ck910 FIND v(dout0_164) AT=460.025n

.meas tran vdout0_165ck910 FIND v(dout0_165) AT=460.025n

.meas tran vdout0_166ck910 FIND v(dout0_166) AT=460.025n

.meas tran vdout0_167ck910 FIND v(dout0_167) AT=460.025n

.meas tran vdout0_168ck910 FIND v(dout0_168) AT=460.025n

.meas tran vdout0_169ck910 FIND v(dout0_169) AT=460.025n

.meas tran vdout0_170ck910 FIND v(dout0_170) AT=460.025n

.meas tran vdout0_171ck910 FIND v(dout0_171) AT=460.025n

.meas tran vdout0_172ck910 FIND v(dout0_172) AT=460.025n

.meas tran vdout0_173ck910 FIND v(dout0_173) AT=460.025n

.meas tran vdout0_174ck910 FIND v(dout0_174) AT=460.025n

.meas tran vdout0_175ck910 FIND v(dout0_175) AT=460.025n

.meas tran vdout0_176ck910 FIND v(dout0_176) AT=460.025n

.meas tran vdout0_177ck910 FIND v(dout0_177) AT=460.025n

.meas tran vdout0_178ck910 FIND v(dout0_178) AT=460.025n

.meas tran vdout0_179ck910 FIND v(dout0_179) AT=460.025n

.meas tran vdout0_180ck910 FIND v(dout0_180) AT=460.025n

.meas tran vdout0_181ck910 FIND v(dout0_181) AT=460.025n

.meas tran vdout0_182ck910 FIND v(dout0_182) AT=460.025n

.meas tran vdout0_183ck910 FIND v(dout0_183) AT=460.025n

.meas tran vdout0_184ck910 FIND v(dout0_184) AT=460.025n

.meas tran vdout0_185ck910 FIND v(dout0_185) AT=460.025n

.meas tran vdout0_186ck910 FIND v(dout0_186) AT=460.025n

.meas tran vdout0_187ck910 FIND v(dout0_187) AT=460.025n

.meas tran vdout0_188ck910 FIND v(dout0_188) AT=460.025n

.meas tran vdout0_189ck910 FIND v(dout0_189) AT=460.025n

.meas tran vdout0_190ck910 FIND v(dout0_190) AT=460.025n

.meas tran vdout0_191ck910 FIND v(dout0_191) AT=460.025n

.meas tran vdout0_192ck910 FIND v(dout0_192) AT=460.025n

.meas tran vdout0_193ck910 FIND v(dout0_193) AT=460.025n

.meas tran vdout0_194ck910 FIND v(dout0_194) AT=460.025n

.meas tran vdout0_195ck910 FIND v(dout0_195) AT=460.025n

.meas tran vdout0_196ck910 FIND v(dout0_196) AT=460.025n

.meas tran vdout0_197ck910 FIND v(dout0_197) AT=460.025n

.meas tran vdout0_198ck910 FIND v(dout0_198) AT=460.025n

.meas tran vdout0_199ck910 FIND v(dout0_199) AT=460.025n

.meas tran vdout0_200ck910 FIND v(dout0_200) AT=460.025n

.meas tran vdout0_201ck910 FIND v(dout0_201) AT=460.025n

.meas tran vdout0_202ck910 FIND v(dout0_202) AT=460.025n

.meas tran vdout0_203ck910 FIND v(dout0_203) AT=460.025n

.meas tran vdout0_204ck910 FIND v(dout0_204) AT=460.025n

.meas tran vdout0_205ck910 FIND v(dout0_205) AT=460.025n

.meas tran vdout0_206ck910 FIND v(dout0_206) AT=460.025n

.meas tran vdout0_207ck910 FIND v(dout0_207) AT=460.025n

.meas tran vdout0_208ck910 FIND v(dout0_208) AT=460.025n

.meas tran vdout0_209ck910 FIND v(dout0_209) AT=460.025n

.meas tran vdout0_210ck910 FIND v(dout0_210) AT=460.025n

.meas tran vdout0_211ck910 FIND v(dout0_211) AT=460.025n

.meas tran vdout0_212ck910 FIND v(dout0_212) AT=460.025n

.meas tran vdout0_213ck910 FIND v(dout0_213) AT=460.025n

.meas tran vdout0_214ck910 FIND v(dout0_214) AT=460.025n

.meas tran vdout0_215ck910 FIND v(dout0_215) AT=460.025n

.meas tran vdout0_216ck910 FIND v(dout0_216) AT=460.025n

.meas tran vdout0_217ck910 FIND v(dout0_217) AT=460.025n

.meas tran vdout0_218ck910 FIND v(dout0_218) AT=460.025n

.meas tran vdout0_219ck910 FIND v(dout0_219) AT=460.025n

.meas tran vdout0_220ck910 FIND v(dout0_220) AT=460.025n

.meas tran vdout0_221ck910 FIND v(dout0_221) AT=460.025n

.meas tran vdout0_222ck910 FIND v(dout0_222) AT=460.025n

.meas tran vdout0_223ck910 FIND v(dout0_223) AT=460.025n

.meas tran vdout0_224ck910 FIND v(dout0_224) AT=460.025n

.meas tran vdout0_225ck910 FIND v(dout0_225) AT=460.025n

.meas tran vdout0_226ck910 FIND v(dout0_226) AT=460.025n

.meas tran vdout0_227ck910 FIND v(dout0_227) AT=460.025n

.meas tran vdout0_228ck910 FIND v(dout0_228) AT=460.025n

.meas tran vdout0_229ck910 FIND v(dout0_229) AT=460.025n

.meas tran vdout0_230ck910 FIND v(dout0_230) AT=460.025n

.meas tran vdout0_231ck910 FIND v(dout0_231) AT=460.025n

.meas tran vdout0_232ck910 FIND v(dout0_232) AT=460.025n

.meas tran vdout0_233ck910 FIND v(dout0_233) AT=460.025n

.meas tran vdout0_234ck910 FIND v(dout0_234) AT=460.025n

.meas tran vdout0_235ck910 FIND v(dout0_235) AT=460.025n

.meas tran vdout0_236ck910 FIND v(dout0_236) AT=460.025n

.meas tran vdout0_237ck910 FIND v(dout0_237) AT=460.025n

.meas tran vdout0_238ck910 FIND v(dout0_238) AT=460.025n

.meas tran vdout0_239ck910 FIND v(dout0_239) AT=460.025n

.meas tran vdout0_240ck910 FIND v(dout0_240) AT=460.025n

.meas tran vdout0_241ck910 FIND v(dout0_241) AT=460.025n

.meas tran vdout0_242ck910 FIND v(dout0_242) AT=460.025n

.meas tran vdout0_243ck910 FIND v(dout0_243) AT=460.025n

.meas tran vdout0_244ck910 FIND v(dout0_244) AT=460.025n

.meas tran vdout0_245ck910 FIND v(dout0_245) AT=460.025n

.meas tran vdout0_246ck910 FIND v(dout0_246) AT=460.025n

.meas tran vdout0_247ck910 FIND v(dout0_247) AT=460.025n

.meas tran vdout0_248ck910 FIND v(dout0_248) AT=460.025n

.meas tran vdout0_249ck910 FIND v(dout0_249) AT=460.025n

.meas tran vdout0_250ck910 FIND v(dout0_250) AT=460.025n

.meas tran vdout0_251ck910 FIND v(dout0_251) AT=460.025n

.meas tran vdout0_252ck910 FIND v(dout0_252) AT=460.025n

.meas tran vdout0_253ck910 FIND v(dout0_253) AT=460.025n

.meas tran vdout0_254ck910 FIND v(dout0_254) AT=460.025n

.meas tran vdout0_255ck910 FIND v(dout0_255) AT=460.025n

.meas tran vdout0_0ck940 FIND v(dout0_0) AT=475.025n

.meas tran vdout0_1ck940 FIND v(dout0_1) AT=475.025n

.meas tran vdout0_2ck940 FIND v(dout0_2) AT=475.025n

.meas tran vdout0_3ck940 FIND v(dout0_3) AT=475.025n

.meas tran vdout0_4ck940 FIND v(dout0_4) AT=475.025n

.meas tran vdout0_5ck940 FIND v(dout0_5) AT=475.025n

.meas tran vdout0_6ck940 FIND v(dout0_6) AT=475.025n

.meas tran vdout0_7ck940 FIND v(dout0_7) AT=475.025n

.meas tran vdout0_8ck940 FIND v(dout0_8) AT=475.025n

.meas tran vdout0_9ck940 FIND v(dout0_9) AT=475.025n

.meas tran vdout0_10ck940 FIND v(dout0_10) AT=475.025n

.meas tran vdout0_11ck940 FIND v(dout0_11) AT=475.025n

.meas tran vdout0_12ck940 FIND v(dout0_12) AT=475.025n

.meas tran vdout0_13ck940 FIND v(dout0_13) AT=475.025n

.meas tran vdout0_14ck940 FIND v(dout0_14) AT=475.025n

.meas tran vdout0_15ck940 FIND v(dout0_15) AT=475.025n

.meas tran vdout0_16ck940 FIND v(dout0_16) AT=475.025n

.meas tran vdout0_17ck940 FIND v(dout0_17) AT=475.025n

.meas tran vdout0_18ck940 FIND v(dout0_18) AT=475.025n

.meas tran vdout0_19ck940 FIND v(dout0_19) AT=475.025n

.meas tran vdout0_20ck940 FIND v(dout0_20) AT=475.025n

.meas tran vdout0_21ck940 FIND v(dout0_21) AT=475.025n

.meas tran vdout0_22ck940 FIND v(dout0_22) AT=475.025n

.meas tran vdout0_23ck940 FIND v(dout0_23) AT=475.025n

.meas tran vdout0_24ck940 FIND v(dout0_24) AT=475.025n

.meas tran vdout0_25ck940 FIND v(dout0_25) AT=475.025n

.meas tran vdout0_26ck940 FIND v(dout0_26) AT=475.025n

.meas tran vdout0_27ck940 FIND v(dout0_27) AT=475.025n

.meas tran vdout0_28ck940 FIND v(dout0_28) AT=475.025n

.meas tran vdout0_29ck940 FIND v(dout0_29) AT=475.025n

.meas tran vdout0_30ck940 FIND v(dout0_30) AT=475.025n

.meas tran vdout0_31ck940 FIND v(dout0_31) AT=475.025n

.meas tran vdout0_32ck940 FIND v(dout0_32) AT=475.025n

.meas tran vdout0_33ck940 FIND v(dout0_33) AT=475.025n

.meas tran vdout0_34ck940 FIND v(dout0_34) AT=475.025n

.meas tran vdout0_35ck940 FIND v(dout0_35) AT=475.025n

.meas tran vdout0_36ck940 FIND v(dout0_36) AT=475.025n

.meas tran vdout0_37ck940 FIND v(dout0_37) AT=475.025n

.meas tran vdout0_38ck940 FIND v(dout0_38) AT=475.025n

.meas tran vdout0_39ck940 FIND v(dout0_39) AT=475.025n

.meas tran vdout0_40ck940 FIND v(dout0_40) AT=475.025n

.meas tran vdout0_41ck940 FIND v(dout0_41) AT=475.025n

.meas tran vdout0_42ck940 FIND v(dout0_42) AT=475.025n

.meas tran vdout0_43ck940 FIND v(dout0_43) AT=475.025n

.meas tran vdout0_44ck940 FIND v(dout0_44) AT=475.025n

.meas tran vdout0_45ck940 FIND v(dout0_45) AT=475.025n

.meas tran vdout0_46ck940 FIND v(dout0_46) AT=475.025n

.meas tran vdout0_47ck940 FIND v(dout0_47) AT=475.025n

.meas tran vdout0_48ck940 FIND v(dout0_48) AT=475.025n

.meas tran vdout0_49ck940 FIND v(dout0_49) AT=475.025n

.meas tran vdout0_50ck940 FIND v(dout0_50) AT=475.025n

.meas tran vdout0_51ck940 FIND v(dout0_51) AT=475.025n

.meas tran vdout0_52ck940 FIND v(dout0_52) AT=475.025n

.meas tran vdout0_53ck940 FIND v(dout0_53) AT=475.025n

.meas tran vdout0_54ck940 FIND v(dout0_54) AT=475.025n

.meas tran vdout0_55ck940 FIND v(dout0_55) AT=475.025n

.meas tran vdout0_56ck940 FIND v(dout0_56) AT=475.025n

.meas tran vdout0_57ck940 FIND v(dout0_57) AT=475.025n

.meas tran vdout0_58ck940 FIND v(dout0_58) AT=475.025n

.meas tran vdout0_59ck940 FIND v(dout0_59) AT=475.025n

.meas tran vdout0_60ck940 FIND v(dout0_60) AT=475.025n

.meas tran vdout0_61ck940 FIND v(dout0_61) AT=475.025n

.meas tran vdout0_62ck940 FIND v(dout0_62) AT=475.025n

.meas tran vdout0_63ck940 FIND v(dout0_63) AT=475.025n

.meas tran vdout0_64ck940 FIND v(dout0_64) AT=475.025n

.meas tran vdout0_65ck940 FIND v(dout0_65) AT=475.025n

.meas tran vdout0_66ck940 FIND v(dout0_66) AT=475.025n

.meas tran vdout0_67ck940 FIND v(dout0_67) AT=475.025n

.meas tran vdout0_68ck940 FIND v(dout0_68) AT=475.025n

.meas tran vdout0_69ck940 FIND v(dout0_69) AT=475.025n

.meas tran vdout0_70ck940 FIND v(dout0_70) AT=475.025n

.meas tran vdout0_71ck940 FIND v(dout0_71) AT=475.025n

.meas tran vdout0_72ck940 FIND v(dout0_72) AT=475.025n

.meas tran vdout0_73ck940 FIND v(dout0_73) AT=475.025n

.meas tran vdout0_74ck940 FIND v(dout0_74) AT=475.025n

.meas tran vdout0_75ck940 FIND v(dout0_75) AT=475.025n

.meas tran vdout0_76ck940 FIND v(dout0_76) AT=475.025n

.meas tran vdout0_77ck940 FIND v(dout0_77) AT=475.025n

.meas tran vdout0_78ck940 FIND v(dout0_78) AT=475.025n

.meas tran vdout0_79ck940 FIND v(dout0_79) AT=475.025n

.meas tran vdout0_80ck940 FIND v(dout0_80) AT=475.025n

.meas tran vdout0_81ck940 FIND v(dout0_81) AT=475.025n

.meas tran vdout0_82ck940 FIND v(dout0_82) AT=475.025n

.meas tran vdout0_83ck940 FIND v(dout0_83) AT=475.025n

.meas tran vdout0_84ck940 FIND v(dout0_84) AT=475.025n

.meas tran vdout0_85ck940 FIND v(dout0_85) AT=475.025n

.meas tran vdout0_86ck940 FIND v(dout0_86) AT=475.025n

.meas tran vdout0_87ck940 FIND v(dout0_87) AT=475.025n

.meas tran vdout0_88ck940 FIND v(dout0_88) AT=475.025n

.meas tran vdout0_89ck940 FIND v(dout0_89) AT=475.025n

.meas tran vdout0_90ck940 FIND v(dout0_90) AT=475.025n

.meas tran vdout0_91ck940 FIND v(dout0_91) AT=475.025n

.meas tran vdout0_92ck940 FIND v(dout0_92) AT=475.025n

.meas tran vdout0_93ck940 FIND v(dout0_93) AT=475.025n

.meas tran vdout0_94ck940 FIND v(dout0_94) AT=475.025n

.meas tran vdout0_95ck940 FIND v(dout0_95) AT=475.025n

.meas tran vdout0_96ck940 FIND v(dout0_96) AT=475.025n

.meas tran vdout0_97ck940 FIND v(dout0_97) AT=475.025n

.meas tran vdout0_98ck940 FIND v(dout0_98) AT=475.025n

.meas tran vdout0_99ck940 FIND v(dout0_99) AT=475.025n

.meas tran vdout0_100ck940 FIND v(dout0_100) AT=475.025n

.meas tran vdout0_101ck940 FIND v(dout0_101) AT=475.025n

.meas tran vdout0_102ck940 FIND v(dout0_102) AT=475.025n

.meas tran vdout0_103ck940 FIND v(dout0_103) AT=475.025n

.meas tran vdout0_104ck940 FIND v(dout0_104) AT=475.025n

.meas tran vdout0_105ck940 FIND v(dout0_105) AT=475.025n

.meas tran vdout0_106ck940 FIND v(dout0_106) AT=475.025n

.meas tran vdout0_107ck940 FIND v(dout0_107) AT=475.025n

.meas tran vdout0_108ck940 FIND v(dout0_108) AT=475.025n

.meas tran vdout0_109ck940 FIND v(dout0_109) AT=475.025n

.meas tran vdout0_110ck940 FIND v(dout0_110) AT=475.025n

.meas tran vdout0_111ck940 FIND v(dout0_111) AT=475.025n

.meas tran vdout0_112ck940 FIND v(dout0_112) AT=475.025n

.meas tran vdout0_113ck940 FIND v(dout0_113) AT=475.025n

.meas tran vdout0_114ck940 FIND v(dout0_114) AT=475.025n

.meas tran vdout0_115ck940 FIND v(dout0_115) AT=475.025n

.meas tran vdout0_116ck940 FIND v(dout0_116) AT=475.025n

.meas tran vdout0_117ck940 FIND v(dout0_117) AT=475.025n

.meas tran vdout0_118ck940 FIND v(dout0_118) AT=475.025n

.meas tran vdout0_119ck940 FIND v(dout0_119) AT=475.025n

.meas tran vdout0_120ck940 FIND v(dout0_120) AT=475.025n

.meas tran vdout0_121ck940 FIND v(dout0_121) AT=475.025n

.meas tran vdout0_122ck940 FIND v(dout0_122) AT=475.025n

.meas tran vdout0_123ck940 FIND v(dout0_123) AT=475.025n

.meas tran vdout0_124ck940 FIND v(dout0_124) AT=475.025n

.meas tran vdout0_125ck940 FIND v(dout0_125) AT=475.025n

.meas tran vdout0_126ck940 FIND v(dout0_126) AT=475.025n

.meas tran vdout0_127ck940 FIND v(dout0_127) AT=475.025n

.meas tran vdout0_128ck940 FIND v(dout0_128) AT=475.025n

.meas tran vdout0_129ck940 FIND v(dout0_129) AT=475.025n

.meas tran vdout0_130ck940 FIND v(dout0_130) AT=475.025n

.meas tran vdout0_131ck940 FIND v(dout0_131) AT=475.025n

.meas tran vdout0_132ck940 FIND v(dout0_132) AT=475.025n

.meas tran vdout0_133ck940 FIND v(dout0_133) AT=475.025n

.meas tran vdout0_134ck940 FIND v(dout0_134) AT=475.025n

.meas tran vdout0_135ck940 FIND v(dout0_135) AT=475.025n

.meas tran vdout0_136ck940 FIND v(dout0_136) AT=475.025n

.meas tran vdout0_137ck940 FIND v(dout0_137) AT=475.025n

.meas tran vdout0_138ck940 FIND v(dout0_138) AT=475.025n

.meas tran vdout0_139ck940 FIND v(dout0_139) AT=475.025n

.meas tran vdout0_140ck940 FIND v(dout0_140) AT=475.025n

.meas tran vdout0_141ck940 FIND v(dout0_141) AT=475.025n

.meas tran vdout0_142ck940 FIND v(dout0_142) AT=475.025n

.meas tran vdout0_143ck940 FIND v(dout0_143) AT=475.025n

.meas tran vdout0_144ck940 FIND v(dout0_144) AT=475.025n

.meas tran vdout0_145ck940 FIND v(dout0_145) AT=475.025n

.meas tran vdout0_146ck940 FIND v(dout0_146) AT=475.025n

.meas tran vdout0_147ck940 FIND v(dout0_147) AT=475.025n

.meas tran vdout0_148ck940 FIND v(dout0_148) AT=475.025n

.meas tran vdout0_149ck940 FIND v(dout0_149) AT=475.025n

.meas tran vdout0_150ck940 FIND v(dout0_150) AT=475.025n

.meas tran vdout0_151ck940 FIND v(dout0_151) AT=475.025n

.meas tran vdout0_152ck940 FIND v(dout0_152) AT=475.025n

.meas tran vdout0_153ck940 FIND v(dout0_153) AT=475.025n

.meas tran vdout0_154ck940 FIND v(dout0_154) AT=475.025n

.meas tran vdout0_155ck940 FIND v(dout0_155) AT=475.025n

.meas tran vdout0_156ck940 FIND v(dout0_156) AT=475.025n

.meas tran vdout0_157ck940 FIND v(dout0_157) AT=475.025n

.meas tran vdout0_158ck940 FIND v(dout0_158) AT=475.025n

.meas tran vdout0_159ck940 FIND v(dout0_159) AT=475.025n

.meas tran vdout0_160ck940 FIND v(dout0_160) AT=475.025n

.meas tran vdout0_161ck940 FIND v(dout0_161) AT=475.025n

.meas tran vdout0_162ck940 FIND v(dout0_162) AT=475.025n

.meas tran vdout0_163ck940 FIND v(dout0_163) AT=475.025n

.meas tran vdout0_164ck940 FIND v(dout0_164) AT=475.025n

.meas tran vdout0_165ck940 FIND v(dout0_165) AT=475.025n

.meas tran vdout0_166ck940 FIND v(dout0_166) AT=475.025n

.meas tran vdout0_167ck940 FIND v(dout0_167) AT=475.025n

.meas tran vdout0_168ck940 FIND v(dout0_168) AT=475.025n

.meas tran vdout0_169ck940 FIND v(dout0_169) AT=475.025n

.meas tran vdout0_170ck940 FIND v(dout0_170) AT=475.025n

.meas tran vdout0_171ck940 FIND v(dout0_171) AT=475.025n

.meas tran vdout0_172ck940 FIND v(dout0_172) AT=475.025n

.meas tran vdout0_173ck940 FIND v(dout0_173) AT=475.025n

.meas tran vdout0_174ck940 FIND v(dout0_174) AT=475.025n

.meas tran vdout0_175ck940 FIND v(dout0_175) AT=475.025n

.meas tran vdout0_176ck940 FIND v(dout0_176) AT=475.025n

.meas tran vdout0_177ck940 FIND v(dout0_177) AT=475.025n

.meas tran vdout0_178ck940 FIND v(dout0_178) AT=475.025n

.meas tran vdout0_179ck940 FIND v(dout0_179) AT=475.025n

.meas tran vdout0_180ck940 FIND v(dout0_180) AT=475.025n

.meas tran vdout0_181ck940 FIND v(dout0_181) AT=475.025n

.meas tran vdout0_182ck940 FIND v(dout0_182) AT=475.025n

.meas tran vdout0_183ck940 FIND v(dout0_183) AT=475.025n

.meas tran vdout0_184ck940 FIND v(dout0_184) AT=475.025n

.meas tran vdout0_185ck940 FIND v(dout0_185) AT=475.025n

.meas tran vdout0_186ck940 FIND v(dout0_186) AT=475.025n

.meas tran vdout0_187ck940 FIND v(dout0_187) AT=475.025n

.meas tran vdout0_188ck940 FIND v(dout0_188) AT=475.025n

.meas tran vdout0_189ck940 FIND v(dout0_189) AT=475.025n

.meas tran vdout0_190ck940 FIND v(dout0_190) AT=475.025n

.meas tran vdout0_191ck940 FIND v(dout0_191) AT=475.025n

.meas tran vdout0_192ck940 FIND v(dout0_192) AT=475.025n

.meas tran vdout0_193ck940 FIND v(dout0_193) AT=475.025n

.meas tran vdout0_194ck940 FIND v(dout0_194) AT=475.025n

.meas tran vdout0_195ck940 FIND v(dout0_195) AT=475.025n

.meas tran vdout0_196ck940 FIND v(dout0_196) AT=475.025n

.meas tran vdout0_197ck940 FIND v(dout0_197) AT=475.025n

.meas tran vdout0_198ck940 FIND v(dout0_198) AT=475.025n

.meas tran vdout0_199ck940 FIND v(dout0_199) AT=475.025n

.meas tran vdout0_200ck940 FIND v(dout0_200) AT=475.025n

.meas tran vdout0_201ck940 FIND v(dout0_201) AT=475.025n

.meas tran vdout0_202ck940 FIND v(dout0_202) AT=475.025n

.meas tran vdout0_203ck940 FIND v(dout0_203) AT=475.025n

.meas tran vdout0_204ck940 FIND v(dout0_204) AT=475.025n

.meas tran vdout0_205ck940 FIND v(dout0_205) AT=475.025n

.meas tran vdout0_206ck940 FIND v(dout0_206) AT=475.025n

.meas tran vdout0_207ck940 FIND v(dout0_207) AT=475.025n

.meas tran vdout0_208ck940 FIND v(dout0_208) AT=475.025n

.meas tran vdout0_209ck940 FIND v(dout0_209) AT=475.025n

.meas tran vdout0_210ck940 FIND v(dout0_210) AT=475.025n

.meas tran vdout0_211ck940 FIND v(dout0_211) AT=475.025n

.meas tran vdout0_212ck940 FIND v(dout0_212) AT=475.025n

.meas tran vdout0_213ck940 FIND v(dout0_213) AT=475.025n

.meas tran vdout0_214ck940 FIND v(dout0_214) AT=475.025n

.meas tran vdout0_215ck940 FIND v(dout0_215) AT=475.025n

.meas tran vdout0_216ck940 FIND v(dout0_216) AT=475.025n

.meas tran vdout0_217ck940 FIND v(dout0_217) AT=475.025n

.meas tran vdout0_218ck940 FIND v(dout0_218) AT=475.025n

.meas tran vdout0_219ck940 FIND v(dout0_219) AT=475.025n

.meas tran vdout0_220ck940 FIND v(dout0_220) AT=475.025n

.meas tran vdout0_221ck940 FIND v(dout0_221) AT=475.025n

.meas tran vdout0_222ck940 FIND v(dout0_222) AT=475.025n

.meas tran vdout0_223ck940 FIND v(dout0_223) AT=475.025n

.meas tran vdout0_224ck940 FIND v(dout0_224) AT=475.025n

.meas tran vdout0_225ck940 FIND v(dout0_225) AT=475.025n

.meas tran vdout0_226ck940 FIND v(dout0_226) AT=475.025n

.meas tran vdout0_227ck940 FIND v(dout0_227) AT=475.025n

.meas tran vdout0_228ck940 FIND v(dout0_228) AT=475.025n

.meas tran vdout0_229ck940 FIND v(dout0_229) AT=475.025n

.meas tran vdout0_230ck940 FIND v(dout0_230) AT=475.025n

.meas tran vdout0_231ck940 FIND v(dout0_231) AT=475.025n

.meas tran vdout0_232ck940 FIND v(dout0_232) AT=475.025n

.meas tran vdout0_233ck940 FIND v(dout0_233) AT=475.025n

.meas tran vdout0_234ck940 FIND v(dout0_234) AT=475.025n

.meas tran vdout0_235ck940 FIND v(dout0_235) AT=475.025n

.meas tran vdout0_236ck940 FIND v(dout0_236) AT=475.025n

.meas tran vdout0_237ck940 FIND v(dout0_237) AT=475.025n

.meas tran vdout0_238ck940 FIND v(dout0_238) AT=475.025n

.meas tran vdout0_239ck940 FIND v(dout0_239) AT=475.025n

.meas tran vdout0_240ck940 FIND v(dout0_240) AT=475.025n

.meas tran vdout0_241ck940 FIND v(dout0_241) AT=475.025n

.meas tran vdout0_242ck940 FIND v(dout0_242) AT=475.025n

.meas tran vdout0_243ck940 FIND v(dout0_243) AT=475.025n

.meas tran vdout0_244ck940 FIND v(dout0_244) AT=475.025n

.meas tran vdout0_245ck940 FIND v(dout0_245) AT=475.025n

.meas tran vdout0_246ck940 FIND v(dout0_246) AT=475.025n

.meas tran vdout0_247ck940 FIND v(dout0_247) AT=475.025n

.meas tran vdout0_248ck940 FIND v(dout0_248) AT=475.025n

.meas tran vdout0_249ck940 FIND v(dout0_249) AT=475.025n

.meas tran vdout0_250ck940 FIND v(dout0_250) AT=475.025n

.meas tran vdout0_251ck940 FIND v(dout0_251) AT=475.025n

.meas tran vdout0_252ck940 FIND v(dout0_252) AT=475.025n

.meas tran vdout0_253ck940 FIND v(dout0_253) AT=475.025n

.meas tran vdout0_254ck940 FIND v(dout0_254) AT=475.025n

.meas tran vdout0_255ck940 FIND v(dout0_255) AT=475.025n

.meas tran vdout0_0ck970 FIND v(dout0_0) AT=490.025n

.meas tran vdout0_1ck970 FIND v(dout0_1) AT=490.025n

.meas tran vdout0_2ck970 FIND v(dout0_2) AT=490.025n

.meas tran vdout0_3ck970 FIND v(dout0_3) AT=490.025n

.meas tran vdout0_4ck970 FIND v(dout0_4) AT=490.025n

.meas tran vdout0_5ck970 FIND v(dout0_5) AT=490.025n

.meas tran vdout0_6ck970 FIND v(dout0_6) AT=490.025n

.meas tran vdout0_7ck970 FIND v(dout0_7) AT=490.025n

.meas tran vdout0_8ck970 FIND v(dout0_8) AT=490.025n

.meas tran vdout0_9ck970 FIND v(dout0_9) AT=490.025n

.meas tran vdout0_10ck970 FIND v(dout0_10) AT=490.025n

.meas tran vdout0_11ck970 FIND v(dout0_11) AT=490.025n

.meas tran vdout0_12ck970 FIND v(dout0_12) AT=490.025n

.meas tran vdout0_13ck970 FIND v(dout0_13) AT=490.025n

.meas tran vdout0_14ck970 FIND v(dout0_14) AT=490.025n

.meas tran vdout0_15ck970 FIND v(dout0_15) AT=490.025n

.meas tran vdout0_16ck970 FIND v(dout0_16) AT=490.025n

.meas tran vdout0_17ck970 FIND v(dout0_17) AT=490.025n

.meas tran vdout0_18ck970 FIND v(dout0_18) AT=490.025n

.meas tran vdout0_19ck970 FIND v(dout0_19) AT=490.025n

.meas tran vdout0_20ck970 FIND v(dout0_20) AT=490.025n

.meas tran vdout0_21ck970 FIND v(dout0_21) AT=490.025n

.meas tran vdout0_22ck970 FIND v(dout0_22) AT=490.025n

.meas tran vdout0_23ck970 FIND v(dout0_23) AT=490.025n

.meas tran vdout0_24ck970 FIND v(dout0_24) AT=490.025n

.meas tran vdout0_25ck970 FIND v(dout0_25) AT=490.025n

.meas tran vdout0_26ck970 FIND v(dout0_26) AT=490.025n

.meas tran vdout0_27ck970 FIND v(dout0_27) AT=490.025n

.meas tran vdout0_28ck970 FIND v(dout0_28) AT=490.025n

.meas tran vdout0_29ck970 FIND v(dout0_29) AT=490.025n

.meas tran vdout0_30ck970 FIND v(dout0_30) AT=490.025n

.meas tran vdout0_31ck970 FIND v(dout0_31) AT=490.025n

.meas tran vdout0_32ck970 FIND v(dout0_32) AT=490.025n

.meas tran vdout0_33ck970 FIND v(dout0_33) AT=490.025n

.meas tran vdout0_34ck970 FIND v(dout0_34) AT=490.025n

.meas tran vdout0_35ck970 FIND v(dout0_35) AT=490.025n

.meas tran vdout0_36ck970 FIND v(dout0_36) AT=490.025n

.meas tran vdout0_37ck970 FIND v(dout0_37) AT=490.025n

.meas tran vdout0_38ck970 FIND v(dout0_38) AT=490.025n

.meas tran vdout0_39ck970 FIND v(dout0_39) AT=490.025n

.meas tran vdout0_40ck970 FIND v(dout0_40) AT=490.025n

.meas tran vdout0_41ck970 FIND v(dout0_41) AT=490.025n

.meas tran vdout0_42ck970 FIND v(dout0_42) AT=490.025n

.meas tran vdout0_43ck970 FIND v(dout0_43) AT=490.025n

.meas tran vdout0_44ck970 FIND v(dout0_44) AT=490.025n

.meas tran vdout0_45ck970 FIND v(dout0_45) AT=490.025n

.meas tran vdout0_46ck970 FIND v(dout0_46) AT=490.025n

.meas tran vdout0_47ck970 FIND v(dout0_47) AT=490.025n

.meas tran vdout0_48ck970 FIND v(dout0_48) AT=490.025n

.meas tran vdout0_49ck970 FIND v(dout0_49) AT=490.025n

.meas tran vdout0_50ck970 FIND v(dout0_50) AT=490.025n

.meas tran vdout0_51ck970 FIND v(dout0_51) AT=490.025n

.meas tran vdout0_52ck970 FIND v(dout0_52) AT=490.025n

.meas tran vdout0_53ck970 FIND v(dout0_53) AT=490.025n

.meas tran vdout0_54ck970 FIND v(dout0_54) AT=490.025n

.meas tran vdout0_55ck970 FIND v(dout0_55) AT=490.025n

.meas tran vdout0_56ck970 FIND v(dout0_56) AT=490.025n

.meas tran vdout0_57ck970 FIND v(dout0_57) AT=490.025n

.meas tran vdout0_58ck970 FIND v(dout0_58) AT=490.025n

.meas tran vdout0_59ck970 FIND v(dout0_59) AT=490.025n

.meas tran vdout0_60ck970 FIND v(dout0_60) AT=490.025n

.meas tran vdout0_61ck970 FIND v(dout0_61) AT=490.025n

.meas tran vdout0_62ck970 FIND v(dout0_62) AT=490.025n

.meas tran vdout0_63ck970 FIND v(dout0_63) AT=490.025n

.meas tran vdout0_64ck970 FIND v(dout0_64) AT=490.025n

.meas tran vdout0_65ck970 FIND v(dout0_65) AT=490.025n

.meas tran vdout0_66ck970 FIND v(dout0_66) AT=490.025n

.meas tran vdout0_67ck970 FIND v(dout0_67) AT=490.025n

.meas tran vdout0_68ck970 FIND v(dout0_68) AT=490.025n

.meas tran vdout0_69ck970 FIND v(dout0_69) AT=490.025n

.meas tran vdout0_70ck970 FIND v(dout0_70) AT=490.025n

.meas tran vdout0_71ck970 FIND v(dout0_71) AT=490.025n

.meas tran vdout0_72ck970 FIND v(dout0_72) AT=490.025n

.meas tran vdout0_73ck970 FIND v(dout0_73) AT=490.025n

.meas tran vdout0_74ck970 FIND v(dout0_74) AT=490.025n

.meas tran vdout0_75ck970 FIND v(dout0_75) AT=490.025n

.meas tran vdout0_76ck970 FIND v(dout0_76) AT=490.025n

.meas tran vdout0_77ck970 FIND v(dout0_77) AT=490.025n

.meas tran vdout0_78ck970 FIND v(dout0_78) AT=490.025n

.meas tran vdout0_79ck970 FIND v(dout0_79) AT=490.025n

.meas tran vdout0_80ck970 FIND v(dout0_80) AT=490.025n

.meas tran vdout0_81ck970 FIND v(dout0_81) AT=490.025n

.meas tran vdout0_82ck970 FIND v(dout0_82) AT=490.025n

.meas tran vdout0_83ck970 FIND v(dout0_83) AT=490.025n

.meas tran vdout0_84ck970 FIND v(dout0_84) AT=490.025n

.meas tran vdout0_85ck970 FIND v(dout0_85) AT=490.025n

.meas tran vdout0_86ck970 FIND v(dout0_86) AT=490.025n

.meas tran vdout0_87ck970 FIND v(dout0_87) AT=490.025n

.meas tran vdout0_88ck970 FIND v(dout0_88) AT=490.025n

.meas tran vdout0_89ck970 FIND v(dout0_89) AT=490.025n

.meas tran vdout0_90ck970 FIND v(dout0_90) AT=490.025n

.meas tran vdout0_91ck970 FIND v(dout0_91) AT=490.025n

.meas tran vdout0_92ck970 FIND v(dout0_92) AT=490.025n

.meas tran vdout0_93ck970 FIND v(dout0_93) AT=490.025n

.meas tran vdout0_94ck970 FIND v(dout0_94) AT=490.025n

.meas tran vdout0_95ck970 FIND v(dout0_95) AT=490.025n

.meas tran vdout0_96ck970 FIND v(dout0_96) AT=490.025n

.meas tran vdout0_97ck970 FIND v(dout0_97) AT=490.025n

.meas tran vdout0_98ck970 FIND v(dout0_98) AT=490.025n

.meas tran vdout0_99ck970 FIND v(dout0_99) AT=490.025n

.meas tran vdout0_100ck970 FIND v(dout0_100) AT=490.025n

.meas tran vdout0_101ck970 FIND v(dout0_101) AT=490.025n

.meas tran vdout0_102ck970 FIND v(dout0_102) AT=490.025n

.meas tran vdout0_103ck970 FIND v(dout0_103) AT=490.025n

.meas tran vdout0_104ck970 FIND v(dout0_104) AT=490.025n

.meas tran vdout0_105ck970 FIND v(dout0_105) AT=490.025n

.meas tran vdout0_106ck970 FIND v(dout0_106) AT=490.025n

.meas tran vdout0_107ck970 FIND v(dout0_107) AT=490.025n

.meas tran vdout0_108ck970 FIND v(dout0_108) AT=490.025n

.meas tran vdout0_109ck970 FIND v(dout0_109) AT=490.025n

.meas tran vdout0_110ck970 FIND v(dout0_110) AT=490.025n

.meas tran vdout0_111ck970 FIND v(dout0_111) AT=490.025n

.meas tran vdout0_112ck970 FIND v(dout0_112) AT=490.025n

.meas tran vdout0_113ck970 FIND v(dout0_113) AT=490.025n

.meas tran vdout0_114ck970 FIND v(dout0_114) AT=490.025n

.meas tran vdout0_115ck970 FIND v(dout0_115) AT=490.025n

.meas tran vdout0_116ck970 FIND v(dout0_116) AT=490.025n

.meas tran vdout0_117ck970 FIND v(dout0_117) AT=490.025n

.meas tran vdout0_118ck970 FIND v(dout0_118) AT=490.025n

.meas tran vdout0_119ck970 FIND v(dout0_119) AT=490.025n

.meas tran vdout0_120ck970 FIND v(dout0_120) AT=490.025n

.meas tran vdout0_121ck970 FIND v(dout0_121) AT=490.025n

.meas tran vdout0_122ck970 FIND v(dout0_122) AT=490.025n

.meas tran vdout0_123ck970 FIND v(dout0_123) AT=490.025n

.meas tran vdout0_124ck970 FIND v(dout0_124) AT=490.025n

.meas tran vdout0_125ck970 FIND v(dout0_125) AT=490.025n

.meas tran vdout0_126ck970 FIND v(dout0_126) AT=490.025n

.meas tran vdout0_127ck970 FIND v(dout0_127) AT=490.025n

.meas tran vdout0_128ck970 FIND v(dout0_128) AT=490.025n

.meas tran vdout0_129ck970 FIND v(dout0_129) AT=490.025n

.meas tran vdout0_130ck970 FIND v(dout0_130) AT=490.025n

.meas tran vdout0_131ck970 FIND v(dout0_131) AT=490.025n

.meas tran vdout0_132ck970 FIND v(dout0_132) AT=490.025n

.meas tran vdout0_133ck970 FIND v(dout0_133) AT=490.025n

.meas tran vdout0_134ck970 FIND v(dout0_134) AT=490.025n

.meas tran vdout0_135ck970 FIND v(dout0_135) AT=490.025n

.meas tran vdout0_136ck970 FIND v(dout0_136) AT=490.025n

.meas tran vdout0_137ck970 FIND v(dout0_137) AT=490.025n

.meas tran vdout0_138ck970 FIND v(dout0_138) AT=490.025n

.meas tran vdout0_139ck970 FIND v(dout0_139) AT=490.025n

.meas tran vdout0_140ck970 FIND v(dout0_140) AT=490.025n

.meas tran vdout0_141ck970 FIND v(dout0_141) AT=490.025n

.meas tran vdout0_142ck970 FIND v(dout0_142) AT=490.025n

.meas tran vdout0_143ck970 FIND v(dout0_143) AT=490.025n

.meas tran vdout0_144ck970 FIND v(dout0_144) AT=490.025n

.meas tran vdout0_145ck970 FIND v(dout0_145) AT=490.025n

.meas tran vdout0_146ck970 FIND v(dout0_146) AT=490.025n

.meas tran vdout0_147ck970 FIND v(dout0_147) AT=490.025n

.meas tran vdout0_148ck970 FIND v(dout0_148) AT=490.025n

.meas tran vdout0_149ck970 FIND v(dout0_149) AT=490.025n

.meas tran vdout0_150ck970 FIND v(dout0_150) AT=490.025n

.meas tran vdout0_151ck970 FIND v(dout0_151) AT=490.025n

.meas tran vdout0_152ck970 FIND v(dout0_152) AT=490.025n

.meas tran vdout0_153ck970 FIND v(dout0_153) AT=490.025n

.meas tran vdout0_154ck970 FIND v(dout0_154) AT=490.025n

.meas tran vdout0_155ck970 FIND v(dout0_155) AT=490.025n

.meas tran vdout0_156ck970 FIND v(dout0_156) AT=490.025n

.meas tran vdout0_157ck970 FIND v(dout0_157) AT=490.025n

.meas tran vdout0_158ck970 FIND v(dout0_158) AT=490.025n

.meas tran vdout0_159ck970 FIND v(dout0_159) AT=490.025n

.meas tran vdout0_160ck970 FIND v(dout0_160) AT=490.025n

.meas tran vdout0_161ck970 FIND v(dout0_161) AT=490.025n

.meas tran vdout0_162ck970 FIND v(dout0_162) AT=490.025n

.meas tran vdout0_163ck970 FIND v(dout0_163) AT=490.025n

.meas tran vdout0_164ck970 FIND v(dout0_164) AT=490.025n

.meas tran vdout0_165ck970 FIND v(dout0_165) AT=490.025n

.meas tran vdout0_166ck970 FIND v(dout0_166) AT=490.025n

.meas tran vdout0_167ck970 FIND v(dout0_167) AT=490.025n

.meas tran vdout0_168ck970 FIND v(dout0_168) AT=490.025n

.meas tran vdout0_169ck970 FIND v(dout0_169) AT=490.025n

.meas tran vdout0_170ck970 FIND v(dout0_170) AT=490.025n

.meas tran vdout0_171ck970 FIND v(dout0_171) AT=490.025n

.meas tran vdout0_172ck970 FIND v(dout0_172) AT=490.025n

.meas tran vdout0_173ck970 FIND v(dout0_173) AT=490.025n

.meas tran vdout0_174ck970 FIND v(dout0_174) AT=490.025n

.meas tran vdout0_175ck970 FIND v(dout0_175) AT=490.025n

.meas tran vdout0_176ck970 FIND v(dout0_176) AT=490.025n

.meas tran vdout0_177ck970 FIND v(dout0_177) AT=490.025n

.meas tran vdout0_178ck970 FIND v(dout0_178) AT=490.025n

.meas tran vdout0_179ck970 FIND v(dout0_179) AT=490.025n

.meas tran vdout0_180ck970 FIND v(dout0_180) AT=490.025n

.meas tran vdout0_181ck970 FIND v(dout0_181) AT=490.025n

.meas tran vdout0_182ck970 FIND v(dout0_182) AT=490.025n

.meas tran vdout0_183ck970 FIND v(dout0_183) AT=490.025n

.meas tran vdout0_184ck970 FIND v(dout0_184) AT=490.025n

.meas tran vdout0_185ck970 FIND v(dout0_185) AT=490.025n

.meas tran vdout0_186ck970 FIND v(dout0_186) AT=490.025n

.meas tran vdout0_187ck970 FIND v(dout0_187) AT=490.025n

.meas tran vdout0_188ck970 FIND v(dout0_188) AT=490.025n

.meas tran vdout0_189ck970 FIND v(dout0_189) AT=490.025n

.meas tran vdout0_190ck970 FIND v(dout0_190) AT=490.025n

.meas tran vdout0_191ck970 FIND v(dout0_191) AT=490.025n

.meas tran vdout0_192ck970 FIND v(dout0_192) AT=490.025n

.meas tran vdout0_193ck970 FIND v(dout0_193) AT=490.025n

.meas tran vdout0_194ck970 FIND v(dout0_194) AT=490.025n

.meas tran vdout0_195ck970 FIND v(dout0_195) AT=490.025n

.meas tran vdout0_196ck970 FIND v(dout0_196) AT=490.025n

.meas tran vdout0_197ck970 FIND v(dout0_197) AT=490.025n

.meas tran vdout0_198ck970 FIND v(dout0_198) AT=490.025n

.meas tran vdout0_199ck970 FIND v(dout0_199) AT=490.025n

.meas tran vdout0_200ck970 FIND v(dout0_200) AT=490.025n

.meas tran vdout0_201ck970 FIND v(dout0_201) AT=490.025n

.meas tran vdout0_202ck970 FIND v(dout0_202) AT=490.025n

.meas tran vdout0_203ck970 FIND v(dout0_203) AT=490.025n

.meas tran vdout0_204ck970 FIND v(dout0_204) AT=490.025n

.meas tran vdout0_205ck970 FIND v(dout0_205) AT=490.025n

.meas tran vdout0_206ck970 FIND v(dout0_206) AT=490.025n

.meas tran vdout0_207ck970 FIND v(dout0_207) AT=490.025n

.meas tran vdout0_208ck970 FIND v(dout0_208) AT=490.025n

.meas tran vdout0_209ck970 FIND v(dout0_209) AT=490.025n

.meas tran vdout0_210ck970 FIND v(dout0_210) AT=490.025n

.meas tran vdout0_211ck970 FIND v(dout0_211) AT=490.025n

.meas tran vdout0_212ck970 FIND v(dout0_212) AT=490.025n

.meas tran vdout0_213ck970 FIND v(dout0_213) AT=490.025n

.meas tran vdout0_214ck970 FIND v(dout0_214) AT=490.025n

.meas tran vdout0_215ck970 FIND v(dout0_215) AT=490.025n

.meas tran vdout0_216ck970 FIND v(dout0_216) AT=490.025n

.meas tran vdout0_217ck970 FIND v(dout0_217) AT=490.025n

.meas tran vdout0_218ck970 FIND v(dout0_218) AT=490.025n

.meas tran vdout0_219ck970 FIND v(dout0_219) AT=490.025n

.meas tran vdout0_220ck970 FIND v(dout0_220) AT=490.025n

.meas tran vdout0_221ck970 FIND v(dout0_221) AT=490.025n

.meas tran vdout0_222ck970 FIND v(dout0_222) AT=490.025n

.meas tran vdout0_223ck970 FIND v(dout0_223) AT=490.025n

.meas tran vdout0_224ck970 FIND v(dout0_224) AT=490.025n

.meas tran vdout0_225ck970 FIND v(dout0_225) AT=490.025n

.meas tran vdout0_226ck970 FIND v(dout0_226) AT=490.025n

.meas tran vdout0_227ck970 FIND v(dout0_227) AT=490.025n

.meas tran vdout0_228ck970 FIND v(dout0_228) AT=490.025n

.meas tran vdout0_229ck970 FIND v(dout0_229) AT=490.025n

.meas tran vdout0_230ck970 FIND v(dout0_230) AT=490.025n

.meas tran vdout0_231ck970 FIND v(dout0_231) AT=490.025n

.meas tran vdout0_232ck970 FIND v(dout0_232) AT=490.025n

.meas tran vdout0_233ck970 FIND v(dout0_233) AT=490.025n

.meas tran vdout0_234ck970 FIND v(dout0_234) AT=490.025n

.meas tran vdout0_235ck970 FIND v(dout0_235) AT=490.025n

.meas tran vdout0_236ck970 FIND v(dout0_236) AT=490.025n

.meas tran vdout0_237ck970 FIND v(dout0_237) AT=490.025n

.meas tran vdout0_238ck970 FIND v(dout0_238) AT=490.025n

.meas tran vdout0_239ck970 FIND v(dout0_239) AT=490.025n

.meas tran vdout0_240ck970 FIND v(dout0_240) AT=490.025n

.meas tran vdout0_241ck970 FIND v(dout0_241) AT=490.025n

.meas tran vdout0_242ck970 FIND v(dout0_242) AT=490.025n

.meas tran vdout0_243ck970 FIND v(dout0_243) AT=490.025n

.meas tran vdout0_244ck970 FIND v(dout0_244) AT=490.025n

.meas tran vdout0_245ck970 FIND v(dout0_245) AT=490.025n

.meas tran vdout0_246ck970 FIND v(dout0_246) AT=490.025n

.meas tran vdout0_247ck970 FIND v(dout0_247) AT=490.025n

.meas tran vdout0_248ck970 FIND v(dout0_248) AT=490.025n

.meas tran vdout0_249ck970 FIND v(dout0_249) AT=490.025n

.meas tran vdout0_250ck970 FIND v(dout0_250) AT=490.025n

.meas tran vdout0_251ck970 FIND v(dout0_251) AT=490.025n

.meas tran vdout0_252ck970 FIND v(dout0_252) AT=490.025n

.meas tran vdout0_253ck970 FIND v(dout0_253) AT=490.025n

.meas tran vdout0_254ck970 FIND v(dout0_254) AT=490.025n

.meas tran vdout0_255ck970 FIND v(dout0_255) AT=490.025n

.meas tran vdout0_0ck980 FIND v(dout0_0) AT=495.025n

.meas tran vdout0_1ck980 FIND v(dout0_1) AT=495.025n

.meas tran vdout0_2ck980 FIND v(dout0_2) AT=495.025n

.meas tran vdout0_3ck980 FIND v(dout0_3) AT=495.025n

.meas tran vdout0_4ck980 FIND v(dout0_4) AT=495.025n

.meas tran vdout0_5ck980 FIND v(dout0_5) AT=495.025n

.meas tran vdout0_6ck980 FIND v(dout0_6) AT=495.025n

.meas tran vdout0_7ck980 FIND v(dout0_7) AT=495.025n

.meas tran vdout0_8ck980 FIND v(dout0_8) AT=495.025n

.meas tran vdout0_9ck980 FIND v(dout0_9) AT=495.025n

.meas tran vdout0_10ck980 FIND v(dout0_10) AT=495.025n

.meas tran vdout0_11ck980 FIND v(dout0_11) AT=495.025n

.meas tran vdout0_12ck980 FIND v(dout0_12) AT=495.025n

.meas tran vdout0_13ck980 FIND v(dout0_13) AT=495.025n

.meas tran vdout0_14ck980 FIND v(dout0_14) AT=495.025n

.meas tran vdout0_15ck980 FIND v(dout0_15) AT=495.025n

.meas tran vdout0_16ck980 FIND v(dout0_16) AT=495.025n

.meas tran vdout0_17ck980 FIND v(dout0_17) AT=495.025n

.meas tran vdout0_18ck980 FIND v(dout0_18) AT=495.025n

.meas tran vdout0_19ck980 FIND v(dout0_19) AT=495.025n

.meas tran vdout0_20ck980 FIND v(dout0_20) AT=495.025n

.meas tran vdout0_21ck980 FIND v(dout0_21) AT=495.025n

.meas tran vdout0_22ck980 FIND v(dout0_22) AT=495.025n

.meas tran vdout0_23ck980 FIND v(dout0_23) AT=495.025n

.meas tran vdout0_24ck980 FIND v(dout0_24) AT=495.025n

.meas tran vdout0_25ck980 FIND v(dout0_25) AT=495.025n

.meas tran vdout0_26ck980 FIND v(dout0_26) AT=495.025n

.meas tran vdout0_27ck980 FIND v(dout0_27) AT=495.025n

.meas tran vdout0_28ck980 FIND v(dout0_28) AT=495.025n

.meas tran vdout0_29ck980 FIND v(dout0_29) AT=495.025n

.meas tran vdout0_30ck980 FIND v(dout0_30) AT=495.025n

.meas tran vdout0_31ck980 FIND v(dout0_31) AT=495.025n

.meas tran vdout0_32ck980 FIND v(dout0_32) AT=495.025n

.meas tran vdout0_33ck980 FIND v(dout0_33) AT=495.025n

.meas tran vdout0_34ck980 FIND v(dout0_34) AT=495.025n

.meas tran vdout0_35ck980 FIND v(dout0_35) AT=495.025n

.meas tran vdout0_36ck980 FIND v(dout0_36) AT=495.025n

.meas tran vdout0_37ck980 FIND v(dout0_37) AT=495.025n

.meas tran vdout0_38ck980 FIND v(dout0_38) AT=495.025n

.meas tran vdout0_39ck980 FIND v(dout0_39) AT=495.025n

.meas tran vdout0_40ck980 FIND v(dout0_40) AT=495.025n

.meas tran vdout0_41ck980 FIND v(dout0_41) AT=495.025n

.meas tran vdout0_42ck980 FIND v(dout0_42) AT=495.025n

.meas tran vdout0_43ck980 FIND v(dout0_43) AT=495.025n

.meas tran vdout0_44ck980 FIND v(dout0_44) AT=495.025n

.meas tran vdout0_45ck980 FIND v(dout0_45) AT=495.025n

.meas tran vdout0_46ck980 FIND v(dout0_46) AT=495.025n

.meas tran vdout0_47ck980 FIND v(dout0_47) AT=495.025n

.meas tran vdout0_48ck980 FIND v(dout0_48) AT=495.025n

.meas tran vdout0_49ck980 FIND v(dout0_49) AT=495.025n

.meas tran vdout0_50ck980 FIND v(dout0_50) AT=495.025n

.meas tran vdout0_51ck980 FIND v(dout0_51) AT=495.025n

.meas tran vdout0_52ck980 FIND v(dout0_52) AT=495.025n

.meas tran vdout0_53ck980 FIND v(dout0_53) AT=495.025n

.meas tran vdout0_54ck980 FIND v(dout0_54) AT=495.025n

.meas tran vdout0_55ck980 FIND v(dout0_55) AT=495.025n

.meas tran vdout0_56ck980 FIND v(dout0_56) AT=495.025n

.meas tran vdout0_57ck980 FIND v(dout0_57) AT=495.025n

.meas tran vdout0_58ck980 FIND v(dout0_58) AT=495.025n

.meas tran vdout0_59ck980 FIND v(dout0_59) AT=495.025n

.meas tran vdout0_60ck980 FIND v(dout0_60) AT=495.025n

.meas tran vdout0_61ck980 FIND v(dout0_61) AT=495.025n

.meas tran vdout0_62ck980 FIND v(dout0_62) AT=495.025n

.meas tran vdout0_63ck980 FIND v(dout0_63) AT=495.025n

.meas tran vdout0_64ck980 FIND v(dout0_64) AT=495.025n

.meas tran vdout0_65ck980 FIND v(dout0_65) AT=495.025n

.meas tran vdout0_66ck980 FIND v(dout0_66) AT=495.025n

.meas tran vdout0_67ck980 FIND v(dout0_67) AT=495.025n

.meas tran vdout0_68ck980 FIND v(dout0_68) AT=495.025n

.meas tran vdout0_69ck980 FIND v(dout0_69) AT=495.025n

.meas tran vdout0_70ck980 FIND v(dout0_70) AT=495.025n

.meas tran vdout0_71ck980 FIND v(dout0_71) AT=495.025n

.meas tran vdout0_72ck980 FIND v(dout0_72) AT=495.025n

.meas tran vdout0_73ck980 FIND v(dout0_73) AT=495.025n

.meas tran vdout0_74ck980 FIND v(dout0_74) AT=495.025n

.meas tran vdout0_75ck980 FIND v(dout0_75) AT=495.025n

.meas tran vdout0_76ck980 FIND v(dout0_76) AT=495.025n

.meas tran vdout0_77ck980 FIND v(dout0_77) AT=495.025n

.meas tran vdout0_78ck980 FIND v(dout0_78) AT=495.025n

.meas tran vdout0_79ck980 FIND v(dout0_79) AT=495.025n

.meas tran vdout0_80ck980 FIND v(dout0_80) AT=495.025n

.meas tran vdout0_81ck980 FIND v(dout0_81) AT=495.025n

.meas tran vdout0_82ck980 FIND v(dout0_82) AT=495.025n

.meas tran vdout0_83ck980 FIND v(dout0_83) AT=495.025n

.meas tran vdout0_84ck980 FIND v(dout0_84) AT=495.025n

.meas tran vdout0_85ck980 FIND v(dout0_85) AT=495.025n

.meas tran vdout0_86ck980 FIND v(dout0_86) AT=495.025n

.meas tran vdout0_87ck980 FIND v(dout0_87) AT=495.025n

.meas tran vdout0_88ck980 FIND v(dout0_88) AT=495.025n

.meas tran vdout0_89ck980 FIND v(dout0_89) AT=495.025n

.meas tran vdout0_90ck980 FIND v(dout0_90) AT=495.025n

.meas tran vdout0_91ck980 FIND v(dout0_91) AT=495.025n

.meas tran vdout0_92ck980 FIND v(dout0_92) AT=495.025n

.meas tran vdout0_93ck980 FIND v(dout0_93) AT=495.025n

.meas tran vdout0_94ck980 FIND v(dout0_94) AT=495.025n

.meas tran vdout0_95ck980 FIND v(dout0_95) AT=495.025n

.meas tran vdout0_96ck980 FIND v(dout0_96) AT=495.025n

.meas tran vdout0_97ck980 FIND v(dout0_97) AT=495.025n

.meas tran vdout0_98ck980 FIND v(dout0_98) AT=495.025n

.meas tran vdout0_99ck980 FIND v(dout0_99) AT=495.025n

.meas tran vdout0_100ck980 FIND v(dout0_100) AT=495.025n

.meas tran vdout0_101ck980 FIND v(dout0_101) AT=495.025n

.meas tran vdout0_102ck980 FIND v(dout0_102) AT=495.025n

.meas tran vdout0_103ck980 FIND v(dout0_103) AT=495.025n

.meas tran vdout0_104ck980 FIND v(dout0_104) AT=495.025n

.meas tran vdout0_105ck980 FIND v(dout0_105) AT=495.025n

.meas tran vdout0_106ck980 FIND v(dout0_106) AT=495.025n

.meas tran vdout0_107ck980 FIND v(dout0_107) AT=495.025n

.meas tran vdout0_108ck980 FIND v(dout0_108) AT=495.025n

.meas tran vdout0_109ck980 FIND v(dout0_109) AT=495.025n

.meas tran vdout0_110ck980 FIND v(dout0_110) AT=495.025n

.meas tran vdout0_111ck980 FIND v(dout0_111) AT=495.025n

.meas tran vdout0_112ck980 FIND v(dout0_112) AT=495.025n

.meas tran vdout0_113ck980 FIND v(dout0_113) AT=495.025n

.meas tran vdout0_114ck980 FIND v(dout0_114) AT=495.025n

.meas tran vdout0_115ck980 FIND v(dout0_115) AT=495.025n

.meas tran vdout0_116ck980 FIND v(dout0_116) AT=495.025n

.meas tran vdout0_117ck980 FIND v(dout0_117) AT=495.025n

.meas tran vdout0_118ck980 FIND v(dout0_118) AT=495.025n

.meas tran vdout0_119ck980 FIND v(dout0_119) AT=495.025n

.meas tran vdout0_120ck980 FIND v(dout0_120) AT=495.025n

.meas tran vdout0_121ck980 FIND v(dout0_121) AT=495.025n

.meas tran vdout0_122ck980 FIND v(dout0_122) AT=495.025n

.meas tran vdout0_123ck980 FIND v(dout0_123) AT=495.025n

.meas tran vdout0_124ck980 FIND v(dout0_124) AT=495.025n

.meas tran vdout0_125ck980 FIND v(dout0_125) AT=495.025n

.meas tran vdout0_126ck980 FIND v(dout0_126) AT=495.025n

.meas tran vdout0_127ck980 FIND v(dout0_127) AT=495.025n

.meas tran vdout0_128ck980 FIND v(dout0_128) AT=495.025n

.meas tran vdout0_129ck980 FIND v(dout0_129) AT=495.025n

.meas tran vdout0_130ck980 FIND v(dout0_130) AT=495.025n

.meas tran vdout0_131ck980 FIND v(dout0_131) AT=495.025n

.meas tran vdout0_132ck980 FIND v(dout0_132) AT=495.025n

.meas tran vdout0_133ck980 FIND v(dout0_133) AT=495.025n

.meas tran vdout0_134ck980 FIND v(dout0_134) AT=495.025n

.meas tran vdout0_135ck980 FIND v(dout0_135) AT=495.025n

.meas tran vdout0_136ck980 FIND v(dout0_136) AT=495.025n

.meas tran vdout0_137ck980 FIND v(dout0_137) AT=495.025n

.meas tran vdout0_138ck980 FIND v(dout0_138) AT=495.025n

.meas tran vdout0_139ck980 FIND v(dout0_139) AT=495.025n

.meas tran vdout0_140ck980 FIND v(dout0_140) AT=495.025n

.meas tran vdout0_141ck980 FIND v(dout0_141) AT=495.025n

.meas tran vdout0_142ck980 FIND v(dout0_142) AT=495.025n

.meas tran vdout0_143ck980 FIND v(dout0_143) AT=495.025n

.meas tran vdout0_144ck980 FIND v(dout0_144) AT=495.025n

.meas tran vdout0_145ck980 FIND v(dout0_145) AT=495.025n

.meas tran vdout0_146ck980 FIND v(dout0_146) AT=495.025n

.meas tran vdout0_147ck980 FIND v(dout0_147) AT=495.025n

.meas tran vdout0_148ck980 FIND v(dout0_148) AT=495.025n

.meas tran vdout0_149ck980 FIND v(dout0_149) AT=495.025n

.meas tran vdout0_150ck980 FIND v(dout0_150) AT=495.025n

.meas tran vdout0_151ck980 FIND v(dout0_151) AT=495.025n

.meas tran vdout0_152ck980 FIND v(dout0_152) AT=495.025n

.meas tran vdout0_153ck980 FIND v(dout0_153) AT=495.025n

.meas tran vdout0_154ck980 FIND v(dout0_154) AT=495.025n

.meas tran vdout0_155ck980 FIND v(dout0_155) AT=495.025n

.meas tran vdout0_156ck980 FIND v(dout0_156) AT=495.025n

.meas tran vdout0_157ck980 FIND v(dout0_157) AT=495.025n

.meas tran vdout0_158ck980 FIND v(dout0_158) AT=495.025n

.meas tran vdout0_159ck980 FIND v(dout0_159) AT=495.025n

.meas tran vdout0_160ck980 FIND v(dout0_160) AT=495.025n

.meas tran vdout0_161ck980 FIND v(dout0_161) AT=495.025n

.meas tran vdout0_162ck980 FIND v(dout0_162) AT=495.025n

.meas tran vdout0_163ck980 FIND v(dout0_163) AT=495.025n

.meas tran vdout0_164ck980 FIND v(dout0_164) AT=495.025n

.meas tran vdout0_165ck980 FIND v(dout0_165) AT=495.025n

.meas tran vdout0_166ck980 FIND v(dout0_166) AT=495.025n

.meas tran vdout0_167ck980 FIND v(dout0_167) AT=495.025n

.meas tran vdout0_168ck980 FIND v(dout0_168) AT=495.025n

.meas tran vdout0_169ck980 FIND v(dout0_169) AT=495.025n

.meas tran vdout0_170ck980 FIND v(dout0_170) AT=495.025n

.meas tran vdout0_171ck980 FIND v(dout0_171) AT=495.025n

.meas tran vdout0_172ck980 FIND v(dout0_172) AT=495.025n

.meas tran vdout0_173ck980 FIND v(dout0_173) AT=495.025n

.meas tran vdout0_174ck980 FIND v(dout0_174) AT=495.025n

.meas tran vdout0_175ck980 FIND v(dout0_175) AT=495.025n

.meas tran vdout0_176ck980 FIND v(dout0_176) AT=495.025n

.meas tran vdout0_177ck980 FIND v(dout0_177) AT=495.025n

.meas tran vdout0_178ck980 FIND v(dout0_178) AT=495.025n

.meas tran vdout0_179ck980 FIND v(dout0_179) AT=495.025n

.meas tran vdout0_180ck980 FIND v(dout0_180) AT=495.025n

.meas tran vdout0_181ck980 FIND v(dout0_181) AT=495.025n

.meas tran vdout0_182ck980 FIND v(dout0_182) AT=495.025n

.meas tran vdout0_183ck980 FIND v(dout0_183) AT=495.025n

.meas tran vdout0_184ck980 FIND v(dout0_184) AT=495.025n

.meas tran vdout0_185ck980 FIND v(dout0_185) AT=495.025n

.meas tran vdout0_186ck980 FIND v(dout0_186) AT=495.025n

.meas tran vdout0_187ck980 FIND v(dout0_187) AT=495.025n

.meas tran vdout0_188ck980 FIND v(dout0_188) AT=495.025n

.meas tran vdout0_189ck980 FIND v(dout0_189) AT=495.025n

.meas tran vdout0_190ck980 FIND v(dout0_190) AT=495.025n

.meas tran vdout0_191ck980 FIND v(dout0_191) AT=495.025n

.meas tran vdout0_192ck980 FIND v(dout0_192) AT=495.025n

.meas tran vdout0_193ck980 FIND v(dout0_193) AT=495.025n

.meas tran vdout0_194ck980 FIND v(dout0_194) AT=495.025n

.meas tran vdout0_195ck980 FIND v(dout0_195) AT=495.025n

.meas tran vdout0_196ck980 FIND v(dout0_196) AT=495.025n

.meas tran vdout0_197ck980 FIND v(dout0_197) AT=495.025n

.meas tran vdout0_198ck980 FIND v(dout0_198) AT=495.025n

.meas tran vdout0_199ck980 FIND v(dout0_199) AT=495.025n

.meas tran vdout0_200ck980 FIND v(dout0_200) AT=495.025n

.meas tran vdout0_201ck980 FIND v(dout0_201) AT=495.025n

.meas tran vdout0_202ck980 FIND v(dout0_202) AT=495.025n

.meas tran vdout0_203ck980 FIND v(dout0_203) AT=495.025n

.meas tran vdout0_204ck980 FIND v(dout0_204) AT=495.025n

.meas tran vdout0_205ck980 FIND v(dout0_205) AT=495.025n

.meas tran vdout0_206ck980 FIND v(dout0_206) AT=495.025n

.meas tran vdout0_207ck980 FIND v(dout0_207) AT=495.025n

.meas tran vdout0_208ck980 FIND v(dout0_208) AT=495.025n

.meas tran vdout0_209ck980 FIND v(dout0_209) AT=495.025n

.meas tran vdout0_210ck980 FIND v(dout0_210) AT=495.025n

.meas tran vdout0_211ck980 FIND v(dout0_211) AT=495.025n

.meas tran vdout0_212ck980 FIND v(dout0_212) AT=495.025n

.meas tran vdout0_213ck980 FIND v(dout0_213) AT=495.025n

.meas tran vdout0_214ck980 FIND v(dout0_214) AT=495.025n

.meas tran vdout0_215ck980 FIND v(dout0_215) AT=495.025n

.meas tran vdout0_216ck980 FIND v(dout0_216) AT=495.025n

.meas tran vdout0_217ck980 FIND v(dout0_217) AT=495.025n

.meas tran vdout0_218ck980 FIND v(dout0_218) AT=495.025n

.meas tran vdout0_219ck980 FIND v(dout0_219) AT=495.025n

.meas tran vdout0_220ck980 FIND v(dout0_220) AT=495.025n

.meas tran vdout0_221ck980 FIND v(dout0_221) AT=495.025n

.meas tran vdout0_222ck980 FIND v(dout0_222) AT=495.025n

.meas tran vdout0_223ck980 FIND v(dout0_223) AT=495.025n

.meas tran vdout0_224ck980 FIND v(dout0_224) AT=495.025n

.meas tran vdout0_225ck980 FIND v(dout0_225) AT=495.025n

.meas tran vdout0_226ck980 FIND v(dout0_226) AT=495.025n

.meas tran vdout0_227ck980 FIND v(dout0_227) AT=495.025n

.meas tran vdout0_228ck980 FIND v(dout0_228) AT=495.025n

.meas tran vdout0_229ck980 FIND v(dout0_229) AT=495.025n

.meas tran vdout0_230ck980 FIND v(dout0_230) AT=495.025n

.meas tran vdout0_231ck980 FIND v(dout0_231) AT=495.025n

.meas tran vdout0_232ck980 FIND v(dout0_232) AT=495.025n

.meas tran vdout0_233ck980 FIND v(dout0_233) AT=495.025n

.meas tran vdout0_234ck980 FIND v(dout0_234) AT=495.025n

.meas tran vdout0_235ck980 FIND v(dout0_235) AT=495.025n

.meas tran vdout0_236ck980 FIND v(dout0_236) AT=495.025n

.meas tran vdout0_237ck980 FIND v(dout0_237) AT=495.025n

.meas tran vdout0_238ck980 FIND v(dout0_238) AT=495.025n

.meas tran vdout0_239ck980 FIND v(dout0_239) AT=495.025n

.meas tran vdout0_240ck980 FIND v(dout0_240) AT=495.025n

.meas tran vdout0_241ck980 FIND v(dout0_241) AT=495.025n

.meas tran vdout0_242ck980 FIND v(dout0_242) AT=495.025n

.meas tran vdout0_243ck980 FIND v(dout0_243) AT=495.025n

.meas tran vdout0_244ck980 FIND v(dout0_244) AT=495.025n

.meas tran vdout0_245ck980 FIND v(dout0_245) AT=495.025n

.meas tran vdout0_246ck980 FIND v(dout0_246) AT=495.025n

.meas tran vdout0_247ck980 FIND v(dout0_247) AT=495.025n

.meas tran vdout0_248ck980 FIND v(dout0_248) AT=495.025n

.meas tran vdout0_249ck980 FIND v(dout0_249) AT=495.025n

.meas tran vdout0_250ck980 FIND v(dout0_250) AT=495.025n

.meas tran vdout0_251ck980 FIND v(dout0_251) AT=495.025n

.meas tran vdout0_252ck980 FIND v(dout0_252) AT=495.025n

.meas tran vdout0_253ck980 FIND v(dout0_253) AT=495.025n

.meas tran vdout0_254ck980 FIND v(dout0_254) AT=495.025n

.meas tran vdout0_255ck980 FIND v(dout0_255) AT=495.025n

.meas tran vdout0_0ck1020 FIND v(dout0_0) AT=515.025n

.meas tran vdout0_1ck1020 FIND v(dout0_1) AT=515.025n

.meas tran vdout0_2ck1020 FIND v(dout0_2) AT=515.025n

.meas tran vdout0_3ck1020 FIND v(dout0_3) AT=515.025n

.meas tran vdout0_4ck1020 FIND v(dout0_4) AT=515.025n

.meas tran vdout0_5ck1020 FIND v(dout0_5) AT=515.025n

.meas tran vdout0_6ck1020 FIND v(dout0_6) AT=515.025n

.meas tran vdout0_7ck1020 FIND v(dout0_7) AT=515.025n

.meas tran vdout0_8ck1020 FIND v(dout0_8) AT=515.025n

.meas tran vdout0_9ck1020 FIND v(dout0_9) AT=515.025n

.meas tran vdout0_10ck1020 FIND v(dout0_10) AT=515.025n

.meas tran vdout0_11ck1020 FIND v(dout0_11) AT=515.025n

.meas tran vdout0_12ck1020 FIND v(dout0_12) AT=515.025n

.meas tran vdout0_13ck1020 FIND v(dout0_13) AT=515.025n

.meas tran vdout0_14ck1020 FIND v(dout0_14) AT=515.025n

.meas tran vdout0_15ck1020 FIND v(dout0_15) AT=515.025n

.meas tran vdout0_16ck1020 FIND v(dout0_16) AT=515.025n

.meas tran vdout0_17ck1020 FIND v(dout0_17) AT=515.025n

.meas tran vdout0_18ck1020 FIND v(dout0_18) AT=515.025n

.meas tran vdout0_19ck1020 FIND v(dout0_19) AT=515.025n

.meas tran vdout0_20ck1020 FIND v(dout0_20) AT=515.025n

.meas tran vdout0_21ck1020 FIND v(dout0_21) AT=515.025n

.meas tran vdout0_22ck1020 FIND v(dout0_22) AT=515.025n

.meas tran vdout0_23ck1020 FIND v(dout0_23) AT=515.025n

.meas tran vdout0_24ck1020 FIND v(dout0_24) AT=515.025n

.meas tran vdout0_25ck1020 FIND v(dout0_25) AT=515.025n

.meas tran vdout0_26ck1020 FIND v(dout0_26) AT=515.025n

.meas tran vdout0_27ck1020 FIND v(dout0_27) AT=515.025n

.meas tran vdout0_28ck1020 FIND v(dout0_28) AT=515.025n

.meas tran vdout0_29ck1020 FIND v(dout0_29) AT=515.025n

.meas tran vdout0_30ck1020 FIND v(dout0_30) AT=515.025n

.meas tran vdout0_31ck1020 FIND v(dout0_31) AT=515.025n

.meas tran vdout0_32ck1020 FIND v(dout0_32) AT=515.025n

.meas tran vdout0_33ck1020 FIND v(dout0_33) AT=515.025n

.meas tran vdout0_34ck1020 FIND v(dout0_34) AT=515.025n

.meas tran vdout0_35ck1020 FIND v(dout0_35) AT=515.025n

.meas tran vdout0_36ck1020 FIND v(dout0_36) AT=515.025n

.meas tran vdout0_37ck1020 FIND v(dout0_37) AT=515.025n

.meas tran vdout0_38ck1020 FIND v(dout0_38) AT=515.025n

.meas tran vdout0_39ck1020 FIND v(dout0_39) AT=515.025n

.meas tran vdout0_40ck1020 FIND v(dout0_40) AT=515.025n

.meas tran vdout0_41ck1020 FIND v(dout0_41) AT=515.025n

.meas tran vdout0_42ck1020 FIND v(dout0_42) AT=515.025n

.meas tran vdout0_43ck1020 FIND v(dout0_43) AT=515.025n

.meas tran vdout0_44ck1020 FIND v(dout0_44) AT=515.025n

.meas tran vdout0_45ck1020 FIND v(dout0_45) AT=515.025n

.meas tran vdout0_46ck1020 FIND v(dout0_46) AT=515.025n

.meas tran vdout0_47ck1020 FIND v(dout0_47) AT=515.025n

.meas tran vdout0_48ck1020 FIND v(dout0_48) AT=515.025n

.meas tran vdout0_49ck1020 FIND v(dout0_49) AT=515.025n

.meas tran vdout0_50ck1020 FIND v(dout0_50) AT=515.025n

.meas tran vdout0_51ck1020 FIND v(dout0_51) AT=515.025n

.meas tran vdout0_52ck1020 FIND v(dout0_52) AT=515.025n

.meas tran vdout0_53ck1020 FIND v(dout0_53) AT=515.025n

.meas tran vdout0_54ck1020 FIND v(dout0_54) AT=515.025n

.meas tran vdout0_55ck1020 FIND v(dout0_55) AT=515.025n

.meas tran vdout0_56ck1020 FIND v(dout0_56) AT=515.025n

.meas tran vdout0_57ck1020 FIND v(dout0_57) AT=515.025n

.meas tran vdout0_58ck1020 FIND v(dout0_58) AT=515.025n

.meas tran vdout0_59ck1020 FIND v(dout0_59) AT=515.025n

.meas tran vdout0_60ck1020 FIND v(dout0_60) AT=515.025n

.meas tran vdout0_61ck1020 FIND v(dout0_61) AT=515.025n

.meas tran vdout0_62ck1020 FIND v(dout0_62) AT=515.025n

.meas tran vdout0_63ck1020 FIND v(dout0_63) AT=515.025n

.meas tran vdout0_64ck1020 FIND v(dout0_64) AT=515.025n

.meas tran vdout0_65ck1020 FIND v(dout0_65) AT=515.025n

.meas tran vdout0_66ck1020 FIND v(dout0_66) AT=515.025n

.meas tran vdout0_67ck1020 FIND v(dout0_67) AT=515.025n

.meas tran vdout0_68ck1020 FIND v(dout0_68) AT=515.025n

.meas tran vdout0_69ck1020 FIND v(dout0_69) AT=515.025n

.meas tran vdout0_70ck1020 FIND v(dout0_70) AT=515.025n

.meas tran vdout0_71ck1020 FIND v(dout0_71) AT=515.025n

.meas tran vdout0_72ck1020 FIND v(dout0_72) AT=515.025n

.meas tran vdout0_73ck1020 FIND v(dout0_73) AT=515.025n

.meas tran vdout0_74ck1020 FIND v(dout0_74) AT=515.025n

.meas tran vdout0_75ck1020 FIND v(dout0_75) AT=515.025n

.meas tran vdout0_76ck1020 FIND v(dout0_76) AT=515.025n

.meas tran vdout0_77ck1020 FIND v(dout0_77) AT=515.025n

.meas tran vdout0_78ck1020 FIND v(dout0_78) AT=515.025n

.meas tran vdout0_79ck1020 FIND v(dout0_79) AT=515.025n

.meas tran vdout0_80ck1020 FIND v(dout0_80) AT=515.025n

.meas tran vdout0_81ck1020 FIND v(dout0_81) AT=515.025n

.meas tran vdout0_82ck1020 FIND v(dout0_82) AT=515.025n

.meas tran vdout0_83ck1020 FIND v(dout0_83) AT=515.025n

.meas tran vdout0_84ck1020 FIND v(dout0_84) AT=515.025n

.meas tran vdout0_85ck1020 FIND v(dout0_85) AT=515.025n

.meas tran vdout0_86ck1020 FIND v(dout0_86) AT=515.025n

.meas tran vdout0_87ck1020 FIND v(dout0_87) AT=515.025n

.meas tran vdout0_88ck1020 FIND v(dout0_88) AT=515.025n

.meas tran vdout0_89ck1020 FIND v(dout0_89) AT=515.025n

.meas tran vdout0_90ck1020 FIND v(dout0_90) AT=515.025n

.meas tran vdout0_91ck1020 FIND v(dout0_91) AT=515.025n

.meas tran vdout0_92ck1020 FIND v(dout0_92) AT=515.025n

.meas tran vdout0_93ck1020 FIND v(dout0_93) AT=515.025n

.meas tran vdout0_94ck1020 FIND v(dout0_94) AT=515.025n

.meas tran vdout0_95ck1020 FIND v(dout0_95) AT=515.025n

.meas tran vdout0_96ck1020 FIND v(dout0_96) AT=515.025n

.meas tran vdout0_97ck1020 FIND v(dout0_97) AT=515.025n

.meas tran vdout0_98ck1020 FIND v(dout0_98) AT=515.025n

.meas tran vdout0_99ck1020 FIND v(dout0_99) AT=515.025n

.meas tran vdout0_100ck1020 FIND v(dout0_100) AT=515.025n

.meas tran vdout0_101ck1020 FIND v(dout0_101) AT=515.025n

.meas tran vdout0_102ck1020 FIND v(dout0_102) AT=515.025n

.meas tran vdout0_103ck1020 FIND v(dout0_103) AT=515.025n

.meas tran vdout0_104ck1020 FIND v(dout0_104) AT=515.025n

.meas tran vdout0_105ck1020 FIND v(dout0_105) AT=515.025n

.meas tran vdout0_106ck1020 FIND v(dout0_106) AT=515.025n

.meas tran vdout0_107ck1020 FIND v(dout0_107) AT=515.025n

.meas tran vdout0_108ck1020 FIND v(dout0_108) AT=515.025n

.meas tran vdout0_109ck1020 FIND v(dout0_109) AT=515.025n

.meas tran vdout0_110ck1020 FIND v(dout0_110) AT=515.025n

.meas tran vdout0_111ck1020 FIND v(dout0_111) AT=515.025n

.meas tran vdout0_112ck1020 FIND v(dout0_112) AT=515.025n

.meas tran vdout0_113ck1020 FIND v(dout0_113) AT=515.025n

.meas tran vdout0_114ck1020 FIND v(dout0_114) AT=515.025n

.meas tran vdout0_115ck1020 FIND v(dout0_115) AT=515.025n

.meas tran vdout0_116ck1020 FIND v(dout0_116) AT=515.025n

.meas tran vdout0_117ck1020 FIND v(dout0_117) AT=515.025n

.meas tran vdout0_118ck1020 FIND v(dout0_118) AT=515.025n

.meas tran vdout0_119ck1020 FIND v(dout0_119) AT=515.025n

.meas tran vdout0_120ck1020 FIND v(dout0_120) AT=515.025n

.meas tran vdout0_121ck1020 FIND v(dout0_121) AT=515.025n

.meas tran vdout0_122ck1020 FIND v(dout0_122) AT=515.025n

.meas tran vdout0_123ck1020 FIND v(dout0_123) AT=515.025n

.meas tran vdout0_124ck1020 FIND v(dout0_124) AT=515.025n

.meas tran vdout0_125ck1020 FIND v(dout0_125) AT=515.025n

.meas tran vdout0_126ck1020 FIND v(dout0_126) AT=515.025n

.meas tran vdout0_127ck1020 FIND v(dout0_127) AT=515.025n

.meas tran vdout0_128ck1020 FIND v(dout0_128) AT=515.025n

.meas tran vdout0_129ck1020 FIND v(dout0_129) AT=515.025n

.meas tran vdout0_130ck1020 FIND v(dout0_130) AT=515.025n

.meas tran vdout0_131ck1020 FIND v(dout0_131) AT=515.025n

.meas tran vdout0_132ck1020 FIND v(dout0_132) AT=515.025n

.meas tran vdout0_133ck1020 FIND v(dout0_133) AT=515.025n

.meas tran vdout0_134ck1020 FIND v(dout0_134) AT=515.025n

.meas tran vdout0_135ck1020 FIND v(dout0_135) AT=515.025n

.meas tran vdout0_136ck1020 FIND v(dout0_136) AT=515.025n

.meas tran vdout0_137ck1020 FIND v(dout0_137) AT=515.025n

.meas tran vdout0_138ck1020 FIND v(dout0_138) AT=515.025n

.meas tran vdout0_139ck1020 FIND v(dout0_139) AT=515.025n

.meas tran vdout0_140ck1020 FIND v(dout0_140) AT=515.025n

.meas tran vdout0_141ck1020 FIND v(dout0_141) AT=515.025n

.meas tran vdout0_142ck1020 FIND v(dout0_142) AT=515.025n

.meas tran vdout0_143ck1020 FIND v(dout0_143) AT=515.025n

.meas tran vdout0_144ck1020 FIND v(dout0_144) AT=515.025n

.meas tran vdout0_145ck1020 FIND v(dout0_145) AT=515.025n

.meas tran vdout0_146ck1020 FIND v(dout0_146) AT=515.025n

.meas tran vdout0_147ck1020 FIND v(dout0_147) AT=515.025n

.meas tran vdout0_148ck1020 FIND v(dout0_148) AT=515.025n

.meas tran vdout0_149ck1020 FIND v(dout0_149) AT=515.025n

.meas tran vdout0_150ck1020 FIND v(dout0_150) AT=515.025n

.meas tran vdout0_151ck1020 FIND v(dout0_151) AT=515.025n

.meas tran vdout0_152ck1020 FIND v(dout0_152) AT=515.025n

.meas tran vdout0_153ck1020 FIND v(dout0_153) AT=515.025n

.meas tran vdout0_154ck1020 FIND v(dout0_154) AT=515.025n

.meas tran vdout0_155ck1020 FIND v(dout0_155) AT=515.025n

.meas tran vdout0_156ck1020 FIND v(dout0_156) AT=515.025n

.meas tran vdout0_157ck1020 FIND v(dout0_157) AT=515.025n

.meas tran vdout0_158ck1020 FIND v(dout0_158) AT=515.025n

.meas tran vdout0_159ck1020 FIND v(dout0_159) AT=515.025n

.meas tran vdout0_160ck1020 FIND v(dout0_160) AT=515.025n

.meas tran vdout0_161ck1020 FIND v(dout0_161) AT=515.025n

.meas tran vdout0_162ck1020 FIND v(dout0_162) AT=515.025n

.meas tran vdout0_163ck1020 FIND v(dout0_163) AT=515.025n

.meas tran vdout0_164ck1020 FIND v(dout0_164) AT=515.025n

.meas tran vdout0_165ck1020 FIND v(dout0_165) AT=515.025n

.meas tran vdout0_166ck1020 FIND v(dout0_166) AT=515.025n

.meas tran vdout0_167ck1020 FIND v(dout0_167) AT=515.025n

.meas tran vdout0_168ck1020 FIND v(dout0_168) AT=515.025n

.meas tran vdout0_169ck1020 FIND v(dout0_169) AT=515.025n

.meas tran vdout0_170ck1020 FIND v(dout0_170) AT=515.025n

.meas tran vdout0_171ck1020 FIND v(dout0_171) AT=515.025n

.meas tran vdout0_172ck1020 FIND v(dout0_172) AT=515.025n

.meas tran vdout0_173ck1020 FIND v(dout0_173) AT=515.025n

.meas tran vdout0_174ck1020 FIND v(dout0_174) AT=515.025n

.meas tran vdout0_175ck1020 FIND v(dout0_175) AT=515.025n

.meas tran vdout0_176ck1020 FIND v(dout0_176) AT=515.025n

.meas tran vdout0_177ck1020 FIND v(dout0_177) AT=515.025n

.meas tran vdout0_178ck1020 FIND v(dout0_178) AT=515.025n

.meas tran vdout0_179ck1020 FIND v(dout0_179) AT=515.025n

.meas tran vdout0_180ck1020 FIND v(dout0_180) AT=515.025n

.meas tran vdout0_181ck1020 FIND v(dout0_181) AT=515.025n

.meas tran vdout0_182ck1020 FIND v(dout0_182) AT=515.025n

.meas tran vdout0_183ck1020 FIND v(dout0_183) AT=515.025n

.meas tran vdout0_184ck1020 FIND v(dout0_184) AT=515.025n

.meas tran vdout0_185ck1020 FIND v(dout0_185) AT=515.025n

.meas tran vdout0_186ck1020 FIND v(dout0_186) AT=515.025n

.meas tran vdout0_187ck1020 FIND v(dout0_187) AT=515.025n

.meas tran vdout0_188ck1020 FIND v(dout0_188) AT=515.025n

.meas tran vdout0_189ck1020 FIND v(dout0_189) AT=515.025n

.meas tran vdout0_190ck1020 FIND v(dout0_190) AT=515.025n

.meas tran vdout0_191ck1020 FIND v(dout0_191) AT=515.025n

.meas tran vdout0_192ck1020 FIND v(dout0_192) AT=515.025n

.meas tran vdout0_193ck1020 FIND v(dout0_193) AT=515.025n

.meas tran vdout0_194ck1020 FIND v(dout0_194) AT=515.025n

.meas tran vdout0_195ck1020 FIND v(dout0_195) AT=515.025n

.meas tran vdout0_196ck1020 FIND v(dout0_196) AT=515.025n

.meas tran vdout0_197ck1020 FIND v(dout0_197) AT=515.025n

.meas tran vdout0_198ck1020 FIND v(dout0_198) AT=515.025n

.meas tran vdout0_199ck1020 FIND v(dout0_199) AT=515.025n

.meas tran vdout0_200ck1020 FIND v(dout0_200) AT=515.025n

.meas tran vdout0_201ck1020 FIND v(dout0_201) AT=515.025n

.meas tran vdout0_202ck1020 FIND v(dout0_202) AT=515.025n

.meas tran vdout0_203ck1020 FIND v(dout0_203) AT=515.025n

.meas tran vdout0_204ck1020 FIND v(dout0_204) AT=515.025n

.meas tran vdout0_205ck1020 FIND v(dout0_205) AT=515.025n

.meas tran vdout0_206ck1020 FIND v(dout0_206) AT=515.025n

.meas tran vdout0_207ck1020 FIND v(dout0_207) AT=515.025n

.meas tran vdout0_208ck1020 FIND v(dout0_208) AT=515.025n

.meas tran vdout0_209ck1020 FIND v(dout0_209) AT=515.025n

.meas tran vdout0_210ck1020 FIND v(dout0_210) AT=515.025n

.meas tran vdout0_211ck1020 FIND v(dout0_211) AT=515.025n

.meas tran vdout0_212ck1020 FIND v(dout0_212) AT=515.025n

.meas tran vdout0_213ck1020 FIND v(dout0_213) AT=515.025n

.meas tran vdout0_214ck1020 FIND v(dout0_214) AT=515.025n

.meas tran vdout0_215ck1020 FIND v(dout0_215) AT=515.025n

.meas tran vdout0_216ck1020 FIND v(dout0_216) AT=515.025n

.meas tran vdout0_217ck1020 FIND v(dout0_217) AT=515.025n

.meas tran vdout0_218ck1020 FIND v(dout0_218) AT=515.025n

.meas tran vdout0_219ck1020 FIND v(dout0_219) AT=515.025n

.meas tran vdout0_220ck1020 FIND v(dout0_220) AT=515.025n

.meas tran vdout0_221ck1020 FIND v(dout0_221) AT=515.025n

.meas tran vdout0_222ck1020 FIND v(dout0_222) AT=515.025n

.meas tran vdout0_223ck1020 FIND v(dout0_223) AT=515.025n

.meas tran vdout0_224ck1020 FIND v(dout0_224) AT=515.025n

.meas tran vdout0_225ck1020 FIND v(dout0_225) AT=515.025n

.meas tran vdout0_226ck1020 FIND v(dout0_226) AT=515.025n

.meas tran vdout0_227ck1020 FIND v(dout0_227) AT=515.025n

.meas tran vdout0_228ck1020 FIND v(dout0_228) AT=515.025n

.meas tran vdout0_229ck1020 FIND v(dout0_229) AT=515.025n

.meas tran vdout0_230ck1020 FIND v(dout0_230) AT=515.025n

.meas tran vdout0_231ck1020 FIND v(dout0_231) AT=515.025n

.meas tran vdout0_232ck1020 FIND v(dout0_232) AT=515.025n

.meas tran vdout0_233ck1020 FIND v(dout0_233) AT=515.025n

.meas tran vdout0_234ck1020 FIND v(dout0_234) AT=515.025n

.meas tran vdout0_235ck1020 FIND v(dout0_235) AT=515.025n

.meas tran vdout0_236ck1020 FIND v(dout0_236) AT=515.025n

.meas tran vdout0_237ck1020 FIND v(dout0_237) AT=515.025n

.meas tran vdout0_238ck1020 FIND v(dout0_238) AT=515.025n

.meas tran vdout0_239ck1020 FIND v(dout0_239) AT=515.025n

.meas tran vdout0_240ck1020 FIND v(dout0_240) AT=515.025n

.meas tran vdout0_241ck1020 FIND v(dout0_241) AT=515.025n

.meas tran vdout0_242ck1020 FIND v(dout0_242) AT=515.025n

.meas tran vdout0_243ck1020 FIND v(dout0_243) AT=515.025n

.meas tran vdout0_244ck1020 FIND v(dout0_244) AT=515.025n

.meas tran vdout0_245ck1020 FIND v(dout0_245) AT=515.025n

.meas tran vdout0_246ck1020 FIND v(dout0_246) AT=515.025n

.meas tran vdout0_247ck1020 FIND v(dout0_247) AT=515.025n

.meas tran vdout0_248ck1020 FIND v(dout0_248) AT=515.025n

.meas tran vdout0_249ck1020 FIND v(dout0_249) AT=515.025n

.meas tran vdout0_250ck1020 FIND v(dout0_250) AT=515.025n

.meas tran vdout0_251ck1020 FIND v(dout0_251) AT=515.025n

.meas tran vdout0_252ck1020 FIND v(dout0_252) AT=515.025n

.meas tran vdout0_253ck1020 FIND v(dout0_253) AT=515.025n

.meas tran vdout0_254ck1020 FIND v(dout0_254) AT=515.025n

.meas tran vdout0_255ck1020 FIND v(dout0_255) AT=515.025n

.meas tran vdout0_0ck1030 FIND v(dout0_0) AT=520.025n

.meas tran vdout0_1ck1030 FIND v(dout0_1) AT=520.025n

.meas tran vdout0_2ck1030 FIND v(dout0_2) AT=520.025n

.meas tran vdout0_3ck1030 FIND v(dout0_3) AT=520.025n

.meas tran vdout0_4ck1030 FIND v(dout0_4) AT=520.025n

.meas tran vdout0_5ck1030 FIND v(dout0_5) AT=520.025n

.meas tran vdout0_6ck1030 FIND v(dout0_6) AT=520.025n

.meas tran vdout0_7ck1030 FIND v(dout0_7) AT=520.025n

.meas tran vdout0_8ck1030 FIND v(dout0_8) AT=520.025n

.meas tran vdout0_9ck1030 FIND v(dout0_9) AT=520.025n

.meas tran vdout0_10ck1030 FIND v(dout0_10) AT=520.025n

.meas tran vdout0_11ck1030 FIND v(dout0_11) AT=520.025n

.meas tran vdout0_12ck1030 FIND v(dout0_12) AT=520.025n

.meas tran vdout0_13ck1030 FIND v(dout0_13) AT=520.025n

.meas tran vdout0_14ck1030 FIND v(dout0_14) AT=520.025n

.meas tran vdout0_15ck1030 FIND v(dout0_15) AT=520.025n

.meas tran vdout0_16ck1030 FIND v(dout0_16) AT=520.025n

.meas tran vdout0_17ck1030 FIND v(dout0_17) AT=520.025n

.meas tran vdout0_18ck1030 FIND v(dout0_18) AT=520.025n

.meas tran vdout0_19ck1030 FIND v(dout0_19) AT=520.025n

.meas tran vdout0_20ck1030 FIND v(dout0_20) AT=520.025n

.meas tran vdout0_21ck1030 FIND v(dout0_21) AT=520.025n

.meas tran vdout0_22ck1030 FIND v(dout0_22) AT=520.025n

.meas tran vdout0_23ck1030 FIND v(dout0_23) AT=520.025n

.meas tran vdout0_24ck1030 FIND v(dout0_24) AT=520.025n

.meas tran vdout0_25ck1030 FIND v(dout0_25) AT=520.025n

.meas tran vdout0_26ck1030 FIND v(dout0_26) AT=520.025n

.meas tran vdout0_27ck1030 FIND v(dout0_27) AT=520.025n

.meas tran vdout0_28ck1030 FIND v(dout0_28) AT=520.025n

.meas tran vdout0_29ck1030 FIND v(dout0_29) AT=520.025n

.meas tran vdout0_30ck1030 FIND v(dout0_30) AT=520.025n

.meas tran vdout0_31ck1030 FIND v(dout0_31) AT=520.025n

.meas tran vdout0_32ck1030 FIND v(dout0_32) AT=520.025n

.meas tran vdout0_33ck1030 FIND v(dout0_33) AT=520.025n

.meas tran vdout0_34ck1030 FIND v(dout0_34) AT=520.025n

.meas tran vdout0_35ck1030 FIND v(dout0_35) AT=520.025n

.meas tran vdout0_36ck1030 FIND v(dout0_36) AT=520.025n

.meas tran vdout0_37ck1030 FIND v(dout0_37) AT=520.025n

.meas tran vdout0_38ck1030 FIND v(dout0_38) AT=520.025n

.meas tran vdout0_39ck1030 FIND v(dout0_39) AT=520.025n

.meas tran vdout0_40ck1030 FIND v(dout0_40) AT=520.025n

.meas tran vdout0_41ck1030 FIND v(dout0_41) AT=520.025n

.meas tran vdout0_42ck1030 FIND v(dout0_42) AT=520.025n

.meas tran vdout0_43ck1030 FIND v(dout0_43) AT=520.025n

.meas tran vdout0_44ck1030 FIND v(dout0_44) AT=520.025n

.meas tran vdout0_45ck1030 FIND v(dout0_45) AT=520.025n

.meas tran vdout0_46ck1030 FIND v(dout0_46) AT=520.025n

.meas tran vdout0_47ck1030 FIND v(dout0_47) AT=520.025n

.meas tran vdout0_48ck1030 FIND v(dout0_48) AT=520.025n

.meas tran vdout0_49ck1030 FIND v(dout0_49) AT=520.025n

.meas tran vdout0_50ck1030 FIND v(dout0_50) AT=520.025n

.meas tran vdout0_51ck1030 FIND v(dout0_51) AT=520.025n

.meas tran vdout0_52ck1030 FIND v(dout0_52) AT=520.025n

.meas tran vdout0_53ck1030 FIND v(dout0_53) AT=520.025n

.meas tran vdout0_54ck1030 FIND v(dout0_54) AT=520.025n

.meas tran vdout0_55ck1030 FIND v(dout0_55) AT=520.025n

.meas tran vdout0_56ck1030 FIND v(dout0_56) AT=520.025n

.meas tran vdout0_57ck1030 FIND v(dout0_57) AT=520.025n

.meas tran vdout0_58ck1030 FIND v(dout0_58) AT=520.025n

.meas tran vdout0_59ck1030 FIND v(dout0_59) AT=520.025n

.meas tran vdout0_60ck1030 FIND v(dout0_60) AT=520.025n

.meas tran vdout0_61ck1030 FIND v(dout0_61) AT=520.025n

.meas tran vdout0_62ck1030 FIND v(dout0_62) AT=520.025n

.meas tran vdout0_63ck1030 FIND v(dout0_63) AT=520.025n

.meas tran vdout0_64ck1030 FIND v(dout0_64) AT=520.025n

.meas tran vdout0_65ck1030 FIND v(dout0_65) AT=520.025n

.meas tran vdout0_66ck1030 FIND v(dout0_66) AT=520.025n

.meas tran vdout0_67ck1030 FIND v(dout0_67) AT=520.025n

.meas tran vdout0_68ck1030 FIND v(dout0_68) AT=520.025n

.meas tran vdout0_69ck1030 FIND v(dout0_69) AT=520.025n

.meas tran vdout0_70ck1030 FIND v(dout0_70) AT=520.025n

.meas tran vdout0_71ck1030 FIND v(dout0_71) AT=520.025n

.meas tran vdout0_72ck1030 FIND v(dout0_72) AT=520.025n

.meas tran vdout0_73ck1030 FIND v(dout0_73) AT=520.025n

.meas tran vdout0_74ck1030 FIND v(dout0_74) AT=520.025n

.meas tran vdout0_75ck1030 FIND v(dout0_75) AT=520.025n

.meas tran vdout0_76ck1030 FIND v(dout0_76) AT=520.025n

.meas tran vdout0_77ck1030 FIND v(dout0_77) AT=520.025n

.meas tran vdout0_78ck1030 FIND v(dout0_78) AT=520.025n

.meas tran vdout0_79ck1030 FIND v(dout0_79) AT=520.025n

.meas tran vdout0_80ck1030 FIND v(dout0_80) AT=520.025n

.meas tran vdout0_81ck1030 FIND v(dout0_81) AT=520.025n

.meas tran vdout0_82ck1030 FIND v(dout0_82) AT=520.025n

.meas tran vdout0_83ck1030 FIND v(dout0_83) AT=520.025n

.meas tran vdout0_84ck1030 FIND v(dout0_84) AT=520.025n

.meas tran vdout0_85ck1030 FIND v(dout0_85) AT=520.025n

.meas tran vdout0_86ck1030 FIND v(dout0_86) AT=520.025n

.meas tran vdout0_87ck1030 FIND v(dout0_87) AT=520.025n

.meas tran vdout0_88ck1030 FIND v(dout0_88) AT=520.025n

.meas tran vdout0_89ck1030 FIND v(dout0_89) AT=520.025n

.meas tran vdout0_90ck1030 FIND v(dout0_90) AT=520.025n

.meas tran vdout0_91ck1030 FIND v(dout0_91) AT=520.025n

.meas tran vdout0_92ck1030 FIND v(dout0_92) AT=520.025n

.meas tran vdout0_93ck1030 FIND v(dout0_93) AT=520.025n

.meas tran vdout0_94ck1030 FIND v(dout0_94) AT=520.025n

.meas tran vdout0_95ck1030 FIND v(dout0_95) AT=520.025n

.meas tran vdout0_96ck1030 FIND v(dout0_96) AT=520.025n

.meas tran vdout0_97ck1030 FIND v(dout0_97) AT=520.025n

.meas tran vdout0_98ck1030 FIND v(dout0_98) AT=520.025n

.meas tran vdout0_99ck1030 FIND v(dout0_99) AT=520.025n

.meas tran vdout0_100ck1030 FIND v(dout0_100) AT=520.025n

.meas tran vdout0_101ck1030 FIND v(dout0_101) AT=520.025n

.meas tran vdout0_102ck1030 FIND v(dout0_102) AT=520.025n

.meas tran vdout0_103ck1030 FIND v(dout0_103) AT=520.025n

.meas tran vdout0_104ck1030 FIND v(dout0_104) AT=520.025n

.meas tran vdout0_105ck1030 FIND v(dout0_105) AT=520.025n

.meas tran vdout0_106ck1030 FIND v(dout0_106) AT=520.025n

.meas tran vdout0_107ck1030 FIND v(dout0_107) AT=520.025n

.meas tran vdout0_108ck1030 FIND v(dout0_108) AT=520.025n

.meas tran vdout0_109ck1030 FIND v(dout0_109) AT=520.025n

.meas tran vdout0_110ck1030 FIND v(dout0_110) AT=520.025n

.meas tran vdout0_111ck1030 FIND v(dout0_111) AT=520.025n

.meas tran vdout0_112ck1030 FIND v(dout0_112) AT=520.025n

.meas tran vdout0_113ck1030 FIND v(dout0_113) AT=520.025n

.meas tran vdout0_114ck1030 FIND v(dout0_114) AT=520.025n

.meas tran vdout0_115ck1030 FIND v(dout0_115) AT=520.025n

.meas tran vdout0_116ck1030 FIND v(dout0_116) AT=520.025n

.meas tran vdout0_117ck1030 FIND v(dout0_117) AT=520.025n

.meas tran vdout0_118ck1030 FIND v(dout0_118) AT=520.025n

.meas tran vdout0_119ck1030 FIND v(dout0_119) AT=520.025n

.meas tran vdout0_120ck1030 FIND v(dout0_120) AT=520.025n

.meas tran vdout0_121ck1030 FIND v(dout0_121) AT=520.025n

.meas tran vdout0_122ck1030 FIND v(dout0_122) AT=520.025n

.meas tran vdout0_123ck1030 FIND v(dout0_123) AT=520.025n

.meas tran vdout0_124ck1030 FIND v(dout0_124) AT=520.025n

.meas tran vdout0_125ck1030 FIND v(dout0_125) AT=520.025n

.meas tran vdout0_126ck1030 FIND v(dout0_126) AT=520.025n

.meas tran vdout0_127ck1030 FIND v(dout0_127) AT=520.025n

.meas tran vdout0_128ck1030 FIND v(dout0_128) AT=520.025n

.meas tran vdout0_129ck1030 FIND v(dout0_129) AT=520.025n

.meas tran vdout0_130ck1030 FIND v(dout0_130) AT=520.025n

.meas tran vdout0_131ck1030 FIND v(dout0_131) AT=520.025n

.meas tran vdout0_132ck1030 FIND v(dout0_132) AT=520.025n

.meas tran vdout0_133ck1030 FIND v(dout0_133) AT=520.025n

.meas tran vdout0_134ck1030 FIND v(dout0_134) AT=520.025n

.meas tran vdout0_135ck1030 FIND v(dout0_135) AT=520.025n

.meas tran vdout0_136ck1030 FIND v(dout0_136) AT=520.025n

.meas tran vdout0_137ck1030 FIND v(dout0_137) AT=520.025n

.meas tran vdout0_138ck1030 FIND v(dout0_138) AT=520.025n

.meas tran vdout0_139ck1030 FIND v(dout0_139) AT=520.025n

.meas tran vdout0_140ck1030 FIND v(dout0_140) AT=520.025n

.meas tran vdout0_141ck1030 FIND v(dout0_141) AT=520.025n

.meas tran vdout0_142ck1030 FIND v(dout0_142) AT=520.025n

.meas tran vdout0_143ck1030 FIND v(dout0_143) AT=520.025n

.meas tran vdout0_144ck1030 FIND v(dout0_144) AT=520.025n

.meas tran vdout0_145ck1030 FIND v(dout0_145) AT=520.025n

.meas tran vdout0_146ck1030 FIND v(dout0_146) AT=520.025n

.meas tran vdout0_147ck1030 FIND v(dout0_147) AT=520.025n

.meas tran vdout0_148ck1030 FIND v(dout0_148) AT=520.025n

.meas tran vdout0_149ck1030 FIND v(dout0_149) AT=520.025n

.meas tran vdout0_150ck1030 FIND v(dout0_150) AT=520.025n

.meas tran vdout0_151ck1030 FIND v(dout0_151) AT=520.025n

.meas tran vdout0_152ck1030 FIND v(dout0_152) AT=520.025n

.meas tran vdout0_153ck1030 FIND v(dout0_153) AT=520.025n

.meas tran vdout0_154ck1030 FIND v(dout0_154) AT=520.025n

.meas tran vdout0_155ck1030 FIND v(dout0_155) AT=520.025n

.meas tran vdout0_156ck1030 FIND v(dout0_156) AT=520.025n

.meas tran vdout0_157ck1030 FIND v(dout0_157) AT=520.025n

.meas tran vdout0_158ck1030 FIND v(dout0_158) AT=520.025n

.meas tran vdout0_159ck1030 FIND v(dout0_159) AT=520.025n

.meas tran vdout0_160ck1030 FIND v(dout0_160) AT=520.025n

.meas tran vdout0_161ck1030 FIND v(dout0_161) AT=520.025n

.meas tran vdout0_162ck1030 FIND v(dout0_162) AT=520.025n

.meas tran vdout0_163ck1030 FIND v(dout0_163) AT=520.025n

.meas tran vdout0_164ck1030 FIND v(dout0_164) AT=520.025n

.meas tran vdout0_165ck1030 FIND v(dout0_165) AT=520.025n

.meas tran vdout0_166ck1030 FIND v(dout0_166) AT=520.025n

.meas tran vdout0_167ck1030 FIND v(dout0_167) AT=520.025n

.meas tran vdout0_168ck1030 FIND v(dout0_168) AT=520.025n

.meas tran vdout0_169ck1030 FIND v(dout0_169) AT=520.025n

.meas tran vdout0_170ck1030 FIND v(dout0_170) AT=520.025n

.meas tran vdout0_171ck1030 FIND v(dout0_171) AT=520.025n

.meas tran vdout0_172ck1030 FIND v(dout0_172) AT=520.025n

.meas tran vdout0_173ck1030 FIND v(dout0_173) AT=520.025n

.meas tran vdout0_174ck1030 FIND v(dout0_174) AT=520.025n

.meas tran vdout0_175ck1030 FIND v(dout0_175) AT=520.025n

.meas tran vdout0_176ck1030 FIND v(dout0_176) AT=520.025n

.meas tran vdout0_177ck1030 FIND v(dout0_177) AT=520.025n

.meas tran vdout0_178ck1030 FIND v(dout0_178) AT=520.025n

.meas tran vdout0_179ck1030 FIND v(dout0_179) AT=520.025n

.meas tran vdout0_180ck1030 FIND v(dout0_180) AT=520.025n

.meas tran vdout0_181ck1030 FIND v(dout0_181) AT=520.025n

.meas tran vdout0_182ck1030 FIND v(dout0_182) AT=520.025n

.meas tran vdout0_183ck1030 FIND v(dout0_183) AT=520.025n

.meas tran vdout0_184ck1030 FIND v(dout0_184) AT=520.025n

.meas tran vdout0_185ck1030 FIND v(dout0_185) AT=520.025n

.meas tran vdout0_186ck1030 FIND v(dout0_186) AT=520.025n

.meas tran vdout0_187ck1030 FIND v(dout0_187) AT=520.025n

.meas tran vdout0_188ck1030 FIND v(dout0_188) AT=520.025n

.meas tran vdout0_189ck1030 FIND v(dout0_189) AT=520.025n

.meas tran vdout0_190ck1030 FIND v(dout0_190) AT=520.025n

.meas tran vdout0_191ck1030 FIND v(dout0_191) AT=520.025n

.meas tran vdout0_192ck1030 FIND v(dout0_192) AT=520.025n

.meas tran vdout0_193ck1030 FIND v(dout0_193) AT=520.025n

.meas tran vdout0_194ck1030 FIND v(dout0_194) AT=520.025n

.meas tran vdout0_195ck1030 FIND v(dout0_195) AT=520.025n

.meas tran vdout0_196ck1030 FIND v(dout0_196) AT=520.025n

.meas tran vdout0_197ck1030 FIND v(dout0_197) AT=520.025n

.meas tran vdout0_198ck1030 FIND v(dout0_198) AT=520.025n

.meas tran vdout0_199ck1030 FIND v(dout0_199) AT=520.025n

.meas tran vdout0_200ck1030 FIND v(dout0_200) AT=520.025n

.meas tran vdout0_201ck1030 FIND v(dout0_201) AT=520.025n

.meas tran vdout0_202ck1030 FIND v(dout0_202) AT=520.025n

.meas tran vdout0_203ck1030 FIND v(dout0_203) AT=520.025n

.meas tran vdout0_204ck1030 FIND v(dout0_204) AT=520.025n

.meas tran vdout0_205ck1030 FIND v(dout0_205) AT=520.025n

.meas tran vdout0_206ck1030 FIND v(dout0_206) AT=520.025n

.meas tran vdout0_207ck1030 FIND v(dout0_207) AT=520.025n

.meas tran vdout0_208ck1030 FIND v(dout0_208) AT=520.025n

.meas tran vdout0_209ck1030 FIND v(dout0_209) AT=520.025n

.meas tran vdout0_210ck1030 FIND v(dout0_210) AT=520.025n

.meas tran vdout0_211ck1030 FIND v(dout0_211) AT=520.025n

.meas tran vdout0_212ck1030 FIND v(dout0_212) AT=520.025n

.meas tran vdout0_213ck1030 FIND v(dout0_213) AT=520.025n

.meas tran vdout0_214ck1030 FIND v(dout0_214) AT=520.025n

.meas tran vdout0_215ck1030 FIND v(dout0_215) AT=520.025n

.meas tran vdout0_216ck1030 FIND v(dout0_216) AT=520.025n

.meas tran vdout0_217ck1030 FIND v(dout0_217) AT=520.025n

.meas tran vdout0_218ck1030 FIND v(dout0_218) AT=520.025n

.meas tran vdout0_219ck1030 FIND v(dout0_219) AT=520.025n

.meas tran vdout0_220ck1030 FIND v(dout0_220) AT=520.025n

.meas tran vdout0_221ck1030 FIND v(dout0_221) AT=520.025n

.meas tran vdout0_222ck1030 FIND v(dout0_222) AT=520.025n

.meas tran vdout0_223ck1030 FIND v(dout0_223) AT=520.025n

.meas tran vdout0_224ck1030 FIND v(dout0_224) AT=520.025n

.meas tran vdout0_225ck1030 FIND v(dout0_225) AT=520.025n

.meas tran vdout0_226ck1030 FIND v(dout0_226) AT=520.025n

.meas tran vdout0_227ck1030 FIND v(dout0_227) AT=520.025n

.meas tran vdout0_228ck1030 FIND v(dout0_228) AT=520.025n

.meas tran vdout0_229ck1030 FIND v(dout0_229) AT=520.025n

.meas tran vdout0_230ck1030 FIND v(dout0_230) AT=520.025n

.meas tran vdout0_231ck1030 FIND v(dout0_231) AT=520.025n

.meas tran vdout0_232ck1030 FIND v(dout0_232) AT=520.025n

.meas tran vdout0_233ck1030 FIND v(dout0_233) AT=520.025n

.meas tran vdout0_234ck1030 FIND v(dout0_234) AT=520.025n

.meas tran vdout0_235ck1030 FIND v(dout0_235) AT=520.025n

.meas tran vdout0_236ck1030 FIND v(dout0_236) AT=520.025n

.meas tran vdout0_237ck1030 FIND v(dout0_237) AT=520.025n

.meas tran vdout0_238ck1030 FIND v(dout0_238) AT=520.025n

.meas tran vdout0_239ck1030 FIND v(dout0_239) AT=520.025n

.meas tran vdout0_240ck1030 FIND v(dout0_240) AT=520.025n

.meas tran vdout0_241ck1030 FIND v(dout0_241) AT=520.025n

.meas tran vdout0_242ck1030 FIND v(dout0_242) AT=520.025n

.meas tran vdout0_243ck1030 FIND v(dout0_243) AT=520.025n

.meas tran vdout0_244ck1030 FIND v(dout0_244) AT=520.025n

.meas tran vdout0_245ck1030 FIND v(dout0_245) AT=520.025n

.meas tran vdout0_246ck1030 FIND v(dout0_246) AT=520.025n

.meas tran vdout0_247ck1030 FIND v(dout0_247) AT=520.025n

.meas tran vdout0_248ck1030 FIND v(dout0_248) AT=520.025n

.meas tran vdout0_249ck1030 FIND v(dout0_249) AT=520.025n

.meas tran vdout0_250ck1030 FIND v(dout0_250) AT=520.025n

.meas tran vdout0_251ck1030 FIND v(dout0_251) AT=520.025n

.meas tran vdout0_252ck1030 FIND v(dout0_252) AT=520.025n

.meas tran vdout0_253ck1030 FIND v(dout0_253) AT=520.025n

.meas tran vdout0_254ck1030 FIND v(dout0_254) AT=520.025n

.meas tran vdout0_255ck1030 FIND v(dout0_255) AT=520.025n

.meas tran vdout0_0ck1060 FIND v(dout0_0) AT=535.025n

.meas tran vdout0_1ck1060 FIND v(dout0_1) AT=535.025n

.meas tran vdout0_2ck1060 FIND v(dout0_2) AT=535.025n

.meas tran vdout0_3ck1060 FIND v(dout0_3) AT=535.025n

.meas tran vdout0_4ck1060 FIND v(dout0_4) AT=535.025n

.meas tran vdout0_5ck1060 FIND v(dout0_5) AT=535.025n

.meas tran vdout0_6ck1060 FIND v(dout0_6) AT=535.025n

.meas tran vdout0_7ck1060 FIND v(dout0_7) AT=535.025n

.meas tran vdout0_8ck1060 FIND v(dout0_8) AT=535.025n

.meas tran vdout0_9ck1060 FIND v(dout0_9) AT=535.025n

.meas tran vdout0_10ck1060 FIND v(dout0_10) AT=535.025n

.meas tran vdout0_11ck1060 FIND v(dout0_11) AT=535.025n

.meas tran vdout0_12ck1060 FIND v(dout0_12) AT=535.025n

.meas tran vdout0_13ck1060 FIND v(dout0_13) AT=535.025n

.meas tran vdout0_14ck1060 FIND v(dout0_14) AT=535.025n

.meas tran vdout0_15ck1060 FIND v(dout0_15) AT=535.025n

.meas tran vdout0_16ck1060 FIND v(dout0_16) AT=535.025n

.meas tran vdout0_17ck1060 FIND v(dout0_17) AT=535.025n

.meas tran vdout0_18ck1060 FIND v(dout0_18) AT=535.025n

.meas tran vdout0_19ck1060 FIND v(dout0_19) AT=535.025n

.meas tran vdout0_20ck1060 FIND v(dout0_20) AT=535.025n

.meas tran vdout0_21ck1060 FIND v(dout0_21) AT=535.025n

.meas tran vdout0_22ck1060 FIND v(dout0_22) AT=535.025n

.meas tran vdout0_23ck1060 FIND v(dout0_23) AT=535.025n

.meas tran vdout0_24ck1060 FIND v(dout0_24) AT=535.025n

.meas tran vdout0_25ck1060 FIND v(dout0_25) AT=535.025n

.meas tran vdout0_26ck1060 FIND v(dout0_26) AT=535.025n

.meas tran vdout0_27ck1060 FIND v(dout0_27) AT=535.025n

.meas tran vdout0_28ck1060 FIND v(dout0_28) AT=535.025n

.meas tran vdout0_29ck1060 FIND v(dout0_29) AT=535.025n

.meas tran vdout0_30ck1060 FIND v(dout0_30) AT=535.025n

.meas tran vdout0_31ck1060 FIND v(dout0_31) AT=535.025n

.meas tran vdout0_32ck1060 FIND v(dout0_32) AT=535.025n

.meas tran vdout0_33ck1060 FIND v(dout0_33) AT=535.025n

.meas tran vdout0_34ck1060 FIND v(dout0_34) AT=535.025n

.meas tran vdout0_35ck1060 FIND v(dout0_35) AT=535.025n

.meas tran vdout0_36ck1060 FIND v(dout0_36) AT=535.025n

.meas tran vdout0_37ck1060 FIND v(dout0_37) AT=535.025n

.meas tran vdout0_38ck1060 FIND v(dout0_38) AT=535.025n

.meas tran vdout0_39ck1060 FIND v(dout0_39) AT=535.025n

.meas tran vdout0_40ck1060 FIND v(dout0_40) AT=535.025n

.meas tran vdout0_41ck1060 FIND v(dout0_41) AT=535.025n

.meas tran vdout0_42ck1060 FIND v(dout0_42) AT=535.025n

.meas tran vdout0_43ck1060 FIND v(dout0_43) AT=535.025n

.meas tran vdout0_44ck1060 FIND v(dout0_44) AT=535.025n

.meas tran vdout0_45ck1060 FIND v(dout0_45) AT=535.025n

.meas tran vdout0_46ck1060 FIND v(dout0_46) AT=535.025n

.meas tran vdout0_47ck1060 FIND v(dout0_47) AT=535.025n

.meas tran vdout0_48ck1060 FIND v(dout0_48) AT=535.025n

.meas tran vdout0_49ck1060 FIND v(dout0_49) AT=535.025n

.meas tran vdout0_50ck1060 FIND v(dout0_50) AT=535.025n

.meas tran vdout0_51ck1060 FIND v(dout0_51) AT=535.025n

.meas tran vdout0_52ck1060 FIND v(dout0_52) AT=535.025n

.meas tran vdout0_53ck1060 FIND v(dout0_53) AT=535.025n

.meas tran vdout0_54ck1060 FIND v(dout0_54) AT=535.025n

.meas tran vdout0_55ck1060 FIND v(dout0_55) AT=535.025n

.meas tran vdout0_56ck1060 FIND v(dout0_56) AT=535.025n

.meas tran vdout0_57ck1060 FIND v(dout0_57) AT=535.025n

.meas tran vdout0_58ck1060 FIND v(dout0_58) AT=535.025n

.meas tran vdout0_59ck1060 FIND v(dout0_59) AT=535.025n

.meas tran vdout0_60ck1060 FIND v(dout0_60) AT=535.025n

.meas tran vdout0_61ck1060 FIND v(dout0_61) AT=535.025n

.meas tran vdout0_62ck1060 FIND v(dout0_62) AT=535.025n

.meas tran vdout0_63ck1060 FIND v(dout0_63) AT=535.025n

.meas tran vdout0_64ck1060 FIND v(dout0_64) AT=535.025n

.meas tran vdout0_65ck1060 FIND v(dout0_65) AT=535.025n

.meas tran vdout0_66ck1060 FIND v(dout0_66) AT=535.025n

.meas tran vdout0_67ck1060 FIND v(dout0_67) AT=535.025n

.meas tran vdout0_68ck1060 FIND v(dout0_68) AT=535.025n

.meas tran vdout0_69ck1060 FIND v(dout0_69) AT=535.025n

.meas tran vdout0_70ck1060 FIND v(dout0_70) AT=535.025n

.meas tran vdout0_71ck1060 FIND v(dout0_71) AT=535.025n

.meas tran vdout0_72ck1060 FIND v(dout0_72) AT=535.025n

.meas tran vdout0_73ck1060 FIND v(dout0_73) AT=535.025n

.meas tran vdout0_74ck1060 FIND v(dout0_74) AT=535.025n

.meas tran vdout0_75ck1060 FIND v(dout0_75) AT=535.025n

.meas tran vdout0_76ck1060 FIND v(dout0_76) AT=535.025n

.meas tran vdout0_77ck1060 FIND v(dout0_77) AT=535.025n

.meas tran vdout0_78ck1060 FIND v(dout0_78) AT=535.025n

.meas tran vdout0_79ck1060 FIND v(dout0_79) AT=535.025n

.meas tran vdout0_80ck1060 FIND v(dout0_80) AT=535.025n

.meas tran vdout0_81ck1060 FIND v(dout0_81) AT=535.025n

.meas tran vdout0_82ck1060 FIND v(dout0_82) AT=535.025n

.meas tran vdout0_83ck1060 FIND v(dout0_83) AT=535.025n

.meas tran vdout0_84ck1060 FIND v(dout0_84) AT=535.025n

.meas tran vdout0_85ck1060 FIND v(dout0_85) AT=535.025n

.meas tran vdout0_86ck1060 FIND v(dout0_86) AT=535.025n

.meas tran vdout0_87ck1060 FIND v(dout0_87) AT=535.025n

.meas tran vdout0_88ck1060 FIND v(dout0_88) AT=535.025n

.meas tran vdout0_89ck1060 FIND v(dout0_89) AT=535.025n

.meas tran vdout0_90ck1060 FIND v(dout0_90) AT=535.025n

.meas tran vdout0_91ck1060 FIND v(dout0_91) AT=535.025n

.meas tran vdout0_92ck1060 FIND v(dout0_92) AT=535.025n

.meas tran vdout0_93ck1060 FIND v(dout0_93) AT=535.025n

.meas tran vdout0_94ck1060 FIND v(dout0_94) AT=535.025n

.meas tran vdout0_95ck1060 FIND v(dout0_95) AT=535.025n

.meas tran vdout0_96ck1060 FIND v(dout0_96) AT=535.025n

.meas tran vdout0_97ck1060 FIND v(dout0_97) AT=535.025n

.meas tran vdout0_98ck1060 FIND v(dout0_98) AT=535.025n

.meas tran vdout0_99ck1060 FIND v(dout0_99) AT=535.025n

.meas tran vdout0_100ck1060 FIND v(dout0_100) AT=535.025n

.meas tran vdout0_101ck1060 FIND v(dout0_101) AT=535.025n

.meas tran vdout0_102ck1060 FIND v(dout0_102) AT=535.025n

.meas tran vdout0_103ck1060 FIND v(dout0_103) AT=535.025n

.meas tran vdout0_104ck1060 FIND v(dout0_104) AT=535.025n

.meas tran vdout0_105ck1060 FIND v(dout0_105) AT=535.025n

.meas tran vdout0_106ck1060 FIND v(dout0_106) AT=535.025n

.meas tran vdout0_107ck1060 FIND v(dout0_107) AT=535.025n

.meas tran vdout0_108ck1060 FIND v(dout0_108) AT=535.025n

.meas tran vdout0_109ck1060 FIND v(dout0_109) AT=535.025n

.meas tran vdout0_110ck1060 FIND v(dout0_110) AT=535.025n

.meas tran vdout0_111ck1060 FIND v(dout0_111) AT=535.025n

.meas tran vdout0_112ck1060 FIND v(dout0_112) AT=535.025n

.meas tran vdout0_113ck1060 FIND v(dout0_113) AT=535.025n

.meas tran vdout0_114ck1060 FIND v(dout0_114) AT=535.025n

.meas tran vdout0_115ck1060 FIND v(dout0_115) AT=535.025n

.meas tran vdout0_116ck1060 FIND v(dout0_116) AT=535.025n

.meas tran vdout0_117ck1060 FIND v(dout0_117) AT=535.025n

.meas tran vdout0_118ck1060 FIND v(dout0_118) AT=535.025n

.meas tran vdout0_119ck1060 FIND v(dout0_119) AT=535.025n

.meas tran vdout0_120ck1060 FIND v(dout0_120) AT=535.025n

.meas tran vdout0_121ck1060 FIND v(dout0_121) AT=535.025n

.meas tran vdout0_122ck1060 FIND v(dout0_122) AT=535.025n

.meas tran vdout0_123ck1060 FIND v(dout0_123) AT=535.025n

.meas tran vdout0_124ck1060 FIND v(dout0_124) AT=535.025n

.meas tran vdout0_125ck1060 FIND v(dout0_125) AT=535.025n

.meas tran vdout0_126ck1060 FIND v(dout0_126) AT=535.025n

.meas tran vdout0_127ck1060 FIND v(dout0_127) AT=535.025n

.meas tran vdout0_128ck1060 FIND v(dout0_128) AT=535.025n

.meas tran vdout0_129ck1060 FIND v(dout0_129) AT=535.025n

.meas tran vdout0_130ck1060 FIND v(dout0_130) AT=535.025n

.meas tran vdout0_131ck1060 FIND v(dout0_131) AT=535.025n

.meas tran vdout0_132ck1060 FIND v(dout0_132) AT=535.025n

.meas tran vdout0_133ck1060 FIND v(dout0_133) AT=535.025n

.meas tran vdout0_134ck1060 FIND v(dout0_134) AT=535.025n

.meas tran vdout0_135ck1060 FIND v(dout0_135) AT=535.025n

.meas tran vdout0_136ck1060 FIND v(dout0_136) AT=535.025n

.meas tran vdout0_137ck1060 FIND v(dout0_137) AT=535.025n

.meas tran vdout0_138ck1060 FIND v(dout0_138) AT=535.025n

.meas tran vdout0_139ck1060 FIND v(dout0_139) AT=535.025n

.meas tran vdout0_140ck1060 FIND v(dout0_140) AT=535.025n

.meas tran vdout0_141ck1060 FIND v(dout0_141) AT=535.025n

.meas tran vdout0_142ck1060 FIND v(dout0_142) AT=535.025n

.meas tran vdout0_143ck1060 FIND v(dout0_143) AT=535.025n

.meas tran vdout0_144ck1060 FIND v(dout0_144) AT=535.025n

.meas tran vdout0_145ck1060 FIND v(dout0_145) AT=535.025n

.meas tran vdout0_146ck1060 FIND v(dout0_146) AT=535.025n

.meas tran vdout0_147ck1060 FIND v(dout0_147) AT=535.025n

.meas tran vdout0_148ck1060 FIND v(dout0_148) AT=535.025n

.meas tran vdout0_149ck1060 FIND v(dout0_149) AT=535.025n

.meas tran vdout0_150ck1060 FIND v(dout0_150) AT=535.025n

.meas tran vdout0_151ck1060 FIND v(dout0_151) AT=535.025n

.meas tran vdout0_152ck1060 FIND v(dout0_152) AT=535.025n

.meas tran vdout0_153ck1060 FIND v(dout0_153) AT=535.025n

.meas tran vdout0_154ck1060 FIND v(dout0_154) AT=535.025n

.meas tran vdout0_155ck1060 FIND v(dout0_155) AT=535.025n

.meas tran vdout0_156ck1060 FIND v(dout0_156) AT=535.025n

.meas tran vdout0_157ck1060 FIND v(dout0_157) AT=535.025n

.meas tran vdout0_158ck1060 FIND v(dout0_158) AT=535.025n

.meas tran vdout0_159ck1060 FIND v(dout0_159) AT=535.025n

.meas tran vdout0_160ck1060 FIND v(dout0_160) AT=535.025n

.meas tran vdout0_161ck1060 FIND v(dout0_161) AT=535.025n

.meas tran vdout0_162ck1060 FIND v(dout0_162) AT=535.025n

.meas tran vdout0_163ck1060 FIND v(dout0_163) AT=535.025n

.meas tran vdout0_164ck1060 FIND v(dout0_164) AT=535.025n

.meas tran vdout0_165ck1060 FIND v(dout0_165) AT=535.025n

.meas tran vdout0_166ck1060 FIND v(dout0_166) AT=535.025n

.meas tran vdout0_167ck1060 FIND v(dout0_167) AT=535.025n

.meas tran vdout0_168ck1060 FIND v(dout0_168) AT=535.025n

.meas tran vdout0_169ck1060 FIND v(dout0_169) AT=535.025n

.meas tran vdout0_170ck1060 FIND v(dout0_170) AT=535.025n

.meas tran vdout0_171ck1060 FIND v(dout0_171) AT=535.025n

.meas tran vdout0_172ck1060 FIND v(dout0_172) AT=535.025n

.meas tran vdout0_173ck1060 FIND v(dout0_173) AT=535.025n

.meas tran vdout0_174ck1060 FIND v(dout0_174) AT=535.025n

.meas tran vdout0_175ck1060 FIND v(dout0_175) AT=535.025n

.meas tran vdout0_176ck1060 FIND v(dout0_176) AT=535.025n

.meas tran vdout0_177ck1060 FIND v(dout0_177) AT=535.025n

.meas tran vdout0_178ck1060 FIND v(dout0_178) AT=535.025n

.meas tran vdout0_179ck1060 FIND v(dout0_179) AT=535.025n

.meas tran vdout0_180ck1060 FIND v(dout0_180) AT=535.025n

.meas tran vdout0_181ck1060 FIND v(dout0_181) AT=535.025n

.meas tran vdout0_182ck1060 FIND v(dout0_182) AT=535.025n

.meas tran vdout0_183ck1060 FIND v(dout0_183) AT=535.025n

.meas tran vdout0_184ck1060 FIND v(dout0_184) AT=535.025n

.meas tran vdout0_185ck1060 FIND v(dout0_185) AT=535.025n

.meas tran vdout0_186ck1060 FIND v(dout0_186) AT=535.025n

.meas tran vdout0_187ck1060 FIND v(dout0_187) AT=535.025n

.meas tran vdout0_188ck1060 FIND v(dout0_188) AT=535.025n

.meas tran vdout0_189ck1060 FIND v(dout0_189) AT=535.025n

.meas tran vdout0_190ck1060 FIND v(dout0_190) AT=535.025n

.meas tran vdout0_191ck1060 FIND v(dout0_191) AT=535.025n

.meas tran vdout0_192ck1060 FIND v(dout0_192) AT=535.025n

.meas tran vdout0_193ck1060 FIND v(dout0_193) AT=535.025n

.meas tran vdout0_194ck1060 FIND v(dout0_194) AT=535.025n

.meas tran vdout0_195ck1060 FIND v(dout0_195) AT=535.025n

.meas tran vdout0_196ck1060 FIND v(dout0_196) AT=535.025n

.meas tran vdout0_197ck1060 FIND v(dout0_197) AT=535.025n

.meas tran vdout0_198ck1060 FIND v(dout0_198) AT=535.025n

.meas tran vdout0_199ck1060 FIND v(dout0_199) AT=535.025n

.meas tran vdout0_200ck1060 FIND v(dout0_200) AT=535.025n

.meas tran vdout0_201ck1060 FIND v(dout0_201) AT=535.025n

.meas tran vdout0_202ck1060 FIND v(dout0_202) AT=535.025n

.meas tran vdout0_203ck1060 FIND v(dout0_203) AT=535.025n

.meas tran vdout0_204ck1060 FIND v(dout0_204) AT=535.025n

.meas tran vdout0_205ck1060 FIND v(dout0_205) AT=535.025n

.meas tran vdout0_206ck1060 FIND v(dout0_206) AT=535.025n

.meas tran vdout0_207ck1060 FIND v(dout0_207) AT=535.025n

.meas tran vdout0_208ck1060 FIND v(dout0_208) AT=535.025n

.meas tran vdout0_209ck1060 FIND v(dout0_209) AT=535.025n

.meas tran vdout0_210ck1060 FIND v(dout0_210) AT=535.025n

.meas tran vdout0_211ck1060 FIND v(dout0_211) AT=535.025n

.meas tran vdout0_212ck1060 FIND v(dout0_212) AT=535.025n

.meas tran vdout0_213ck1060 FIND v(dout0_213) AT=535.025n

.meas tran vdout0_214ck1060 FIND v(dout0_214) AT=535.025n

.meas tran vdout0_215ck1060 FIND v(dout0_215) AT=535.025n

.meas tran vdout0_216ck1060 FIND v(dout0_216) AT=535.025n

.meas tran vdout0_217ck1060 FIND v(dout0_217) AT=535.025n

.meas tran vdout0_218ck1060 FIND v(dout0_218) AT=535.025n

.meas tran vdout0_219ck1060 FIND v(dout0_219) AT=535.025n

.meas tran vdout0_220ck1060 FIND v(dout0_220) AT=535.025n

.meas tran vdout0_221ck1060 FIND v(dout0_221) AT=535.025n

.meas tran vdout0_222ck1060 FIND v(dout0_222) AT=535.025n

.meas tran vdout0_223ck1060 FIND v(dout0_223) AT=535.025n

.meas tran vdout0_224ck1060 FIND v(dout0_224) AT=535.025n

.meas tran vdout0_225ck1060 FIND v(dout0_225) AT=535.025n

.meas tran vdout0_226ck1060 FIND v(dout0_226) AT=535.025n

.meas tran vdout0_227ck1060 FIND v(dout0_227) AT=535.025n

.meas tran vdout0_228ck1060 FIND v(dout0_228) AT=535.025n

.meas tran vdout0_229ck1060 FIND v(dout0_229) AT=535.025n

.meas tran vdout0_230ck1060 FIND v(dout0_230) AT=535.025n

.meas tran vdout0_231ck1060 FIND v(dout0_231) AT=535.025n

.meas tran vdout0_232ck1060 FIND v(dout0_232) AT=535.025n

.meas tran vdout0_233ck1060 FIND v(dout0_233) AT=535.025n

.meas tran vdout0_234ck1060 FIND v(dout0_234) AT=535.025n

.meas tran vdout0_235ck1060 FIND v(dout0_235) AT=535.025n

.meas tran vdout0_236ck1060 FIND v(dout0_236) AT=535.025n

.meas tran vdout0_237ck1060 FIND v(dout0_237) AT=535.025n

.meas tran vdout0_238ck1060 FIND v(dout0_238) AT=535.025n

.meas tran vdout0_239ck1060 FIND v(dout0_239) AT=535.025n

.meas tran vdout0_240ck1060 FIND v(dout0_240) AT=535.025n

.meas tran vdout0_241ck1060 FIND v(dout0_241) AT=535.025n

.meas tran vdout0_242ck1060 FIND v(dout0_242) AT=535.025n

.meas tran vdout0_243ck1060 FIND v(dout0_243) AT=535.025n

.meas tran vdout0_244ck1060 FIND v(dout0_244) AT=535.025n

.meas tran vdout0_245ck1060 FIND v(dout0_245) AT=535.025n

.meas tran vdout0_246ck1060 FIND v(dout0_246) AT=535.025n

.meas tran vdout0_247ck1060 FIND v(dout0_247) AT=535.025n

.meas tran vdout0_248ck1060 FIND v(dout0_248) AT=535.025n

.meas tran vdout0_249ck1060 FIND v(dout0_249) AT=535.025n

.meas tran vdout0_250ck1060 FIND v(dout0_250) AT=535.025n

.meas tran vdout0_251ck1060 FIND v(dout0_251) AT=535.025n

.meas tran vdout0_252ck1060 FIND v(dout0_252) AT=535.025n

.meas tran vdout0_253ck1060 FIND v(dout0_253) AT=535.025n

.meas tran vdout0_254ck1060 FIND v(dout0_254) AT=535.025n

.meas tran vdout0_255ck1060 FIND v(dout0_255) AT=535.025n

.meas tran vdout0_0ck1090 FIND v(dout0_0) AT=550.025n

.meas tran vdout0_1ck1090 FIND v(dout0_1) AT=550.025n

.meas tran vdout0_2ck1090 FIND v(dout0_2) AT=550.025n

.meas tran vdout0_3ck1090 FIND v(dout0_3) AT=550.025n

.meas tran vdout0_4ck1090 FIND v(dout0_4) AT=550.025n

.meas tran vdout0_5ck1090 FIND v(dout0_5) AT=550.025n

.meas tran vdout0_6ck1090 FIND v(dout0_6) AT=550.025n

.meas tran vdout0_7ck1090 FIND v(dout0_7) AT=550.025n

.meas tran vdout0_8ck1090 FIND v(dout0_8) AT=550.025n

.meas tran vdout0_9ck1090 FIND v(dout0_9) AT=550.025n

.meas tran vdout0_10ck1090 FIND v(dout0_10) AT=550.025n

.meas tran vdout0_11ck1090 FIND v(dout0_11) AT=550.025n

.meas tran vdout0_12ck1090 FIND v(dout0_12) AT=550.025n

.meas tran vdout0_13ck1090 FIND v(dout0_13) AT=550.025n

.meas tran vdout0_14ck1090 FIND v(dout0_14) AT=550.025n

.meas tran vdout0_15ck1090 FIND v(dout0_15) AT=550.025n

.meas tran vdout0_16ck1090 FIND v(dout0_16) AT=550.025n

.meas tran vdout0_17ck1090 FIND v(dout0_17) AT=550.025n

.meas tran vdout0_18ck1090 FIND v(dout0_18) AT=550.025n

.meas tran vdout0_19ck1090 FIND v(dout0_19) AT=550.025n

.meas tran vdout0_20ck1090 FIND v(dout0_20) AT=550.025n

.meas tran vdout0_21ck1090 FIND v(dout0_21) AT=550.025n

.meas tran vdout0_22ck1090 FIND v(dout0_22) AT=550.025n

.meas tran vdout0_23ck1090 FIND v(dout0_23) AT=550.025n

.meas tran vdout0_24ck1090 FIND v(dout0_24) AT=550.025n

.meas tran vdout0_25ck1090 FIND v(dout0_25) AT=550.025n

.meas tran vdout0_26ck1090 FIND v(dout0_26) AT=550.025n

.meas tran vdout0_27ck1090 FIND v(dout0_27) AT=550.025n

.meas tran vdout0_28ck1090 FIND v(dout0_28) AT=550.025n

.meas tran vdout0_29ck1090 FIND v(dout0_29) AT=550.025n

.meas tran vdout0_30ck1090 FIND v(dout0_30) AT=550.025n

.meas tran vdout0_31ck1090 FIND v(dout0_31) AT=550.025n

.meas tran vdout0_32ck1090 FIND v(dout0_32) AT=550.025n

.meas tran vdout0_33ck1090 FIND v(dout0_33) AT=550.025n

.meas tran vdout0_34ck1090 FIND v(dout0_34) AT=550.025n

.meas tran vdout0_35ck1090 FIND v(dout0_35) AT=550.025n

.meas tran vdout0_36ck1090 FIND v(dout0_36) AT=550.025n

.meas tran vdout0_37ck1090 FIND v(dout0_37) AT=550.025n

.meas tran vdout0_38ck1090 FIND v(dout0_38) AT=550.025n

.meas tran vdout0_39ck1090 FIND v(dout0_39) AT=550.025n

.meas tran vdout0_40ck1090 FIND v(dout0_40) AT=550.025n

.meas tran vdout0_41ck1090 FIND v(dout0_41) AT=550.025n

.meas tran vdout0_42ck1090 FIND v(dout0_42) AT=550.025n

.meas tran vdout0_43ck1090 FIND v(dout0_43) AT=550.025n

.meas tran vdout0_44ck1090 FIND v(dout0_44) AT=550.025n

.meas tran vdout0_45ck1090 FIND v(dout0_45) AT=550.025n

.meas tran vdout0_46ck1090 FIND v(dout0_46) AT=550.025n

.meas tran vdout0_47ck1090 FIND v(dout0_47) AT=550.025n

.meas tran vdout0_48ck1090 FIND v(dout0_48) AT=550.025n

.meas tran vdout0_49ck1090 FIND v(dout0_49) AT=550.025n

.meas tran vdout0_50ck1090 FIND v(dout0_50) AT=550.025n

.meas tran vdout0_51ck1090 FIND v(dout0_51) AT=550.025n

.meas tran vdout0_52ck1090 FIND v(dout0_52) AT=550.025n

.meas tran vdout0_53ck1090 FIND v(dout0_53) AT=550.025n

.meas tran vdout0_54ck1090 FIND v(dout0_54) AT=550.025n

.meas tran vdout0_55ck1090 FIND v(dout0_55) AT=550.025n

.meas tran vdout0_56ck1090 FIND v(dout0_56) AT=550.025n

.meas tran vdout0_57ck1090 FIND v(dout0_57) AT=550.025n

.meas tran vdout0_58ck1090 FIND v(dout0_58) AT=550.025n

.meas tran vdout0_59ck1090 FIND v(dout0_59) AT=550.025n

.meas tran vdout0_60ck1090 FIND v(dout0_60) AT=550.025n

.meas tran vdout0_61ck1090 FIND v(dout0_61) AT=550.025n

.meas tran vdout0_62ck1090 FIND v(dout0_62) AT=550.025n

.meas tran vdout0_63ck1090 FIND v(dout0_63) AT=550.025n

.meas tran vdout0_64ck1090 FIND v(dout0_64) AT=550.025n

.meas tran vdout0_65ck1090 FIND v(dout0_65) AT=550.025n

.meas tran vdout0_66ck1090 FIND v(dout0_66) AT=550.025n

.meas tran vdout0_67ck1090 FIND v(dout0_67) AT=550.025n

.meas tran vdout0_68ck1090 FIND v(dout0_68) AT=550.025n

.meas tran vdout0_69ck1090 FIND v(dout0_69) AT=550.025n

.meas tran vdout0_70ck1090 FIND v(dout0_70) AT=550.025n

.meas tran vdout0_71ck1090 FIND v(dout0_71) AT=550.025n

.meas tran vdout0_72ck1090 FIND v(dout0_72) AT=550.025n

.meas tran vdout0_73ck1090 FIND v(dout0_73) AT=550.025n

.meas tran vdout0_74ck1090 FIND v(dout0_74) AT=550.025n

.meas tran vdout0_75ck1090 FIND v(dout0_75) AT=550.025n

.meas tran vdout0_76ck1090 FIND v(dout0_76) AT=550.025n

.meas tran vdout0_77ck1090 FIND v(dout0_77) AT=550.025n

.meas tran vdout0_78ck1090 FIND v(dout0_78) AT=550.025n

.meas tran vdout0_79ck1090 FIND v(dout0_79) AT=550.025n

.meas tran vdout0_80ck1090 FIND v(dout0_80) AT=550.025n

.meas tran vdout0_81ck1090 FIND v(dout0_81) AT=550.025n

.meas tran vdout0_82ck1090 FIND v(dout0_82) AT=550.025n

.meas tran vdout0_83ck1090 FIND v(dout0_83) AT=550.025n

.meas tran vdout0_84ck1090 FIND v(dout0_84) AT=550.025n

.meas tran vdout0_85ck1090 FIND v(dout0_85) AT=550.025n

.meas tran vdout0_86ck1090 FIND v(dout0_86) AT=550.025n

.meas tran vdout0_87ck1090 FIND v(dout0_87) AT=550.025n

.meas tran vdout0_88ck1090 FIND v(dout0_88) AT=550.025n

.meas tran vdout0_89ck1090 FIND v(dout0_89) AT=550.025n

.meas tran vdout0_90ck1090 FIND v(dout0_90) AT=550.025n

.meas tran vdout0_91ck1090 FIND v(dout0_91) AT=550.025n

.meas tran vdout0_92ck1090 FIND v(dout0_92) AT=550.025n

.meas tran vdout0_93ck1090 FIND v(dout0_93) AT=550.025n

.meas tran vdout0_94ck1090 FIND v(dout0_94) AT=550.025n

.meas tran vdout0_95ck1090 FIND v(dout0_95) AT=550.025n

.meas tran vdout0_96ck1090 FIND v(dout0_96) AT=550.025n

.meas tran vdout0_97ck1090 FIND v(dout0_97) AT=550.025n

.meas tran vdout0_98ck1090 FIND v(dout0_98) AT=550.025n

.meas tran vdout0_99ck1090 FIND v(dout0_99) AT=550.025n

.meas tran vdout0_100ck1090 FIND v(dout0_100) AT=550.025n

.meas tran vdout0_101ck1090 FIND v(dout0_101) AT=550.025n

.meas tran vdout0_102ck1090 FIND v(dout0_102) AT=550.025n

.meas tran vdout0_103ck1090 FIND v(dout0_103) AT=550.025n

.meas tran vdout0_104ck1090 FIND v(dout0_104) AT=550.025n

.meas tran vdout0_105ck1090 FIND v(dout0_105) AT=550.025n

.meas tran vdout0_106ck1090 FIND v(dout0_106) AT=550.025n

.meas tran vdout0_107ck1090 FIND v(dout0_107) AT=550.025n

.meas tran vdout0_108ck1090 FIND v(dout0_108) AT=550.025n

.meas tran vdout0_109ck1090 FIND v(dout0_109) AT=550.025n

.meas tran vdout0_110ck1090 FIND v(dout0_110) AT=550.025n

.meas tran vdout0_111ck1090 FIND v(dout0_111) AT=550.025n

.meas tran vdout0_112ck1090 FIND v(dout0_112) AT=550.025n

.meas tran vdout0_113ck1090 FIND v(dout0_113) AT=550.025n

.meas tran vdout0_114ck1090 FIND v(dout0_114) AT=550.025n

.meas tran vdout0_115ck1090 FIND v(dout0_115) AT=550.025n

.meas tran vdout0_116ck1090 FIND v(dout0_116) AT=550.025n

.meas tran vdout0_117ck1090 FIND v(dout0_117) AT=550.025n

.meas tran vdout0_118ck1090 FIND v(dout0_118) AT=550.025n

.meas tran vdout0_119ck1090 FIND v(dout0_119) AT=550.025n

.meas tran vdout0_120ck1090 FIND v(dout0_120) AT=550.025n

.meas tran vdout0_121ck1090 FIND v(dout0_121) AT=550.025n

.meas tran vdout0_122ck1090 FIND v(dout0_122) AT=550.025n

.meas tran vdout0_123ck1090 FIND v(dout0_123) AT=550.025n

.meas tran vdout0_124ck1090 FIND v(dout0_124) AT=550.025n

.meas tran vdout0_125ck1090 FIND v(dout0_125) AT=550.025n

.meas tran vdout0_126ck1090 FIND v(dout0_126) AT=550.025n

.meas tran vdout0_127ck1090 FIND v(dout0_127) AT=550.025n

.meas tran vdout0_128ck1090 FIND v(dout0_128) AT=550.025n

.meas tran vdout0_129ck1090 FIND v(dout0_129) AT=550.025n

.meas tran vdout0_130ck1090 FIND v(dout0_130) AT=550.025n

.meas tran vdout0_131ck1090 FIND v(dout0_131) AT=550.025n

.meas tran vdout0_132ck1090 FIND v(dout0_132) AT=550.025n

.meas tran vdout0_133ck1090 FIND v(dout0_133) AT=550.025n

.meas tran vdout0_134ck1090 FIND v(dout0_134) AT=550.025n

.meas tran vdout0_135ck1090 FIND v(dout0_135) AT=550.025n

.meas tran vdout0_136ck1090 FIND v(dout0_136) AT=550.025n

.meas tran vdout0_137ck1090 FIND v(dout0_137) AT=550.025n

.meas tran vdout0_138ck1090 FIND v(dout0_138) AT=550.025n

.meas tran vdout0_139ck1090 FIND v(dout0_139) AT=550.025n

.meas tran vdout0_140ck1090 FIND v(dout0_140) AT=550.025n

.meas tran vdout0_141ck1090 FIND v(dout0_141) AT=550.025n

.meas tran vdout0_142ck1090 FIND v(dout0_142) AT=550.025n

.meas tran vdout0_143ck1090 FIND v(dout0_143) AT=550.025n

.meas tran vdout0_144ck1090 FIND v(dout0_144) AT=550.025n

.meas tran vdout0_145ck1090 FIND v(dout0_145) AT=550.025n

.meas tran vdout0_146ck1090 FIND v(dout0_146) AT=550.025n

.meas tran vdout0_147ck1090 FIND v(dout0_147) AT=550.025n

.meas tran vdout0_148ck1090 FIND v(dout0_148) AT=550.025n

.meas tran vdout0_149ck1090 FIND v(dout0_149) AT=550.025n

.meas tran vdout0_150ck1090 FIND v(dout0_150) AT=550.025n

.meas tran vdout0_151ck1090 FIND v(dout0_151) AT=550.025n

.meas tran vdout0_152ck1090 FIND v(dout0_152) AT=550.025n

.meas tran vdout0_153ck1090 FIND v(dout0_153) AT=550.025n

.meas tran vdout0_154ck1090 FIND v(dout0_154) AT=550.025n

.meas tran vdout0_155ck1090 FIND v(dout0_155) AT=550.025n

.meas tran vdout0_156ck1090 FIND v(dout0_156) AT=550.025n

.meas tran vdout0_157ck1090 FIND v(dout0_157) AT=550.025n

.meas tran vdout0_158ck1090 FIND v(dout0_158) AT=550.025n

.meas tran vdout0_159ck1090 FIND v(dout0_159) AT=550.025n

.meas tran vdout0_160ck1090 FIND v(dout0_160) AT=550.025n

.meas tran vdout0_161ck1090 FIND v(dout0_161) AT=550.025n

.meas tran vdout0_162ck1090 FIND v(dout0_162) AT=550.025n

.meas tran vdout0_163ck1090 FIND v(dout0_163) AT=550.025n

.meas tran vdout0_164ck1090 FIND v(dout0_164) AT=550.025n

.meas tran vdout0_165ck1090 FIND v(dout0_165) AT=550.025n

.meas tran vdout0_166ck1090 FIND v(dout0_166) AT=550.025n

.meas tran vdout0_167ck1090 FIND v(dout0_167) AT=550.025n

.meas tran vdout0_168ck1090 FIND v(dout0_168) AT=550.025n

.meas tran vdout0_169ck1090 FIND v(dout0_169) AT=550.025n

.meas tran vdout0_170ck1090 FIND v(dout0_170) AT=550.025n

.meas tran vdout0_171ck1090 FIND v(dout0_171) AT=550.025n

.meas tran vdout0_172ck1090 FIND v(dout0_172) AT=550.025n

.meas tran vdout0_173ck1090 FIND v(dout0_173) AT=550.025n

.meas tran vdout0_174ck1090 FIND v(dout0_174) AT=550.025n

.meas tran vdout0_175ck1090 FIND v(dout0_175) AT=550.025n

.meas tran vdout0_176ck1090 FIND v(dout0_176) AT=550.025n

.meas tran vdout0_177ck1090 FIND v(dout0_177) AT=550.025n

.meas tran vdout0_178ck1090 FIND v(dout0_178) AT=550.025n

.meas tran vdout0_179ck1090 FIND v(dout0_179) AT=550.025n

.meas tran vdout0_180ck1090 FIND v(dout0_180) AT=550.025n

.meas tran vdout0_181ck1090 FIND v(dout0_181) AT=550.025n

.meas tran vdout0_182ck1090 FIND v(dout0_182) AT=550.025n

.meas tran vdout0_183ck1090 FIND v(dout0_183) AT=550.025n

.meas tran vdout0_184ck1090 FIND v(dout0_184) AT=550.025n

.meas tran vdout0_185ck1090 FIND v(dout0_185) AT=550.025n

.meas tran vdout0_186ck1090 FIND v(dout0_186) AT=550.025n

.meas tran vdout0_187ck1090 FIND v(dout0_187) AT=550.025n

.meas tran vdout0_188ck1090 FIND v(dout0_188) AT=550.025n

.meas tran vdout0_189ck1090 FIND v(dout0_189) AT=550.025n

.meas tran vdout0_190ck1090 FIND v(dout0_190) AT=550.025n

.meas tran vdout0_191ck1090 FIND v(dout0_191) AT=550.025n

.meas tran vdout0_192ck1090 FIND v(dout0_192) AT=550.025n

.meas tran vdout0_193ck1090 FIND v(dout0_193) AT=550.025n

.meas tran vdout0_194ck1090 FIND v(dout0_194) AT=550.025n

.meas tran vdout0_195ck1090 FIND v(dout0_195) AT=550.025n

.meas tran vdout0_196ck1090 FIND v(dout0_196) AT=550.025n

.meas tran vdout0_197ck1090 FIND v(dout0_197) AT=550.025n

.meas tran vdout0_198ck1090 FIND v(dout0_198) AT=550.025n

.meas tran vdout0_199ck1090 FIND v(dout0_199) AT=550.025n

.meas tran vdout0_200ck1090 FIND v(dout0_200) AT=550.025n

.meas tran vdout0_201ck1090 FIND v(dout0_201) AT=550.025n

.meas tran vdout0_202ck1090 FIND v(dout0_202) AT=550.025n

.meas tran vdout0_203ck1090 FIND v(dout0_203) AT=550.025n

.meas tran vdout0_204ck1090 FIND v(dout0_204) AT=550.025n

.meas tran vdout0_205ck1090 FIND v(dout0_205) AT=550.025n

.meas tran vdout0_206ck1090 FIND v(dout0_206) AT=550.025n

.meas tran vdout0_207ck1090 FIND v(dout0_207) AT=550.025n

.meas tran vdout0_208ck1090 FIND v(dout0_208) AT=550.025n

.meas tran vdout0_209ck1090 FIND v(dout0_209) AT=550.025n

.meas tran vdout0_210ck1090 FIND v(dout0_210) AT=550.025n

.meas tran vdout0_211ck1090 FIND v(dout0_211) AT=550.025n

.meas tran vdout0_212ck1090 FIND v(dout0_212) AT=550.025n

.meas tran vdout0_213ck1090 FIND v(dout0_213) AT=550.025n

.meas tran vdout0_214ck1090 FIND v(dout0_214) AT=550.025n

.meas tran vdout0_215ck1090 FIND v(dout0_215) AT=550.025n

.meas tran vdout0_216ck1090 FIND v(dout0_216) AT=550.025n

.meas tran vdout0_217ck1090 FIND v(dout0_217) AT=550.025n

.meas tran vdout0_218ck1090 FIND v(dout0_218) AT=550.025n

.meas tran vdout0_219ck1090 FIND v(dout0_219) AT=550.025n

.meas tran vdout0_220ck1090 FIND v(dout0_220) AT=550.025n

.meas tran vdout0_221ck1090 FIND v(dout0_221) AT=550.025n

.meas tran vdout0_222ck1090 FIND v(dout0_222) AT=550.025n

.meas tran vdout0_223ck1090 FIND v(dout0_223) AT=550.025n

.meas tran vdout0_224ck1090 FIND v(dout0_224) AT=550.025n

.meas tran vdout0_225ck1090 FIND v(dout0_225) AT=550.025n

.meas tran vdout0_226ck1090 FIND v(dout0_226) AT=550.025n

.meas tran vdout0_227ck1090 FIND v(dout0_227) AT=550.025n

.meas tran vdout0_228ck1090 FIND v(dout0_228) AT=550.025n

.meas tran vdout0_229ck1090 FIND v(dout0_229) AT=550.025n

.meas tran vdout0_230ck1090 FIND v(dout0_230) AT=550.025n

.meas tran vdout0_231ck1090 FIND v(dout0_231) AT=550.025n

.meas tran vdout0_232ck1090 FIND v(dout0_232) AT=550.025n

.meas tran vdout0_233ck1090 FIND v(dout0_233) AT=550.025n

.meas tran vdout0_234ck1090 FIND v(dout0_234) AT=550.025n

.meas tran vdout0_235ck1090 FIND v(dout0_235) AT=550.025n

.meas tran vdout0_236ck1090 FIND v(dout0_236) AT=550.025n

.meas tran vdout0_237ck1090 FIND v(dout0_237) AT=550.025n

.meas tran vdout0_238ck1090 FIND v(dout0_238) AT=550.025n

.meas tran vdout0_239ck1090 FIND v(dout0_239) AT=550.025n

.meas tran vdout0_240ck1090 FIND v(dout0_240) AT=550.025n

.meas tran vdout0_241ck1090 FIND v(dout0_241) AT=550.025n

.meas tran vdout0_242ck1090 FIND v(dout0_242) AT=550.025n

.meas tran vdout0_243ck1090 FIND v(dout0_243) AT=550.025n

.meas tran vdout0_244ck1090 FIND v(dout0_244) AT=550.025n

.meas tran vdout0_245ck1090 FIND v(dout0_245) AT=550.025n

.meas tran vdout0_246ck1090 FIND v(dout0_246) AT=550.025n

.meas tran vdout0_247ck1090 FIND v(dout0_247) AT=550.025n

.meas tran vdout0_248ck1090 FIND v(dout0_248) AT=550.025n

.meas tran vdout0_249ck1090 FIND v(dout0_249) AT=550.025n

.meas tran vdout0_250ck1090 FIND v(dout0_250) AT=550.025n

.meas tran vdout0_251ck1090 FIND v(dout0_251) AT=550.025n

.meas tran vdout0_252ck1090 FIND v(dout0_252) AT=550.025n

.meas tran vdout0_253ck1090 FIND v(dout0_253) AT=550.025n

.meas tran vdout0_254ck1090 FIND v(dout0_254) AT=550.025n

.meas tran vdout0_255ck1090 FIND v(dout0_255) AT=550.025n

.meas tran vdout0_0ck1110 FIND v(dout0_0) AT=560.025n

.meas tran vdout0_1ck1110 FIND v(dout0_1) AT=560.025n

.meas tran vdout0_2ck1110 FIND v(dout0_2) AT=560.025n

.meas tran vdout0_3ck1110 FIND v(dout0_3) AT=560.025n

.meas tran vdout0_4ck1110 FIND v(dout0_4) AT=560.025n

.meas tran vdout0_5ck1110 FIND v(dout0_5) AT=560.025n

.meas tran vdout0_6ck1110 FIND v(dout0_6) AT=560.025n

.meas tran vdout0_7ck1110 FIND v(dout0_7) AT=560.025n

.meas tran vdout0_8ck1110 FIND v(dout0_8) AT=560.025n

.meas tran vdout0_9ck1110 FIND v(dout0_9) AT=560.025n

.meas tran vdout0_10ck1110 FIND v(dout0_10) AT=560.025n

.meas tran vdout0_11ck1110 FIND v(dout0_11) AT=560.025n

.meas tran vdout0_12ck1110 FIND v(dout0_12) AT=560.025n

.meas tran vdout0_13ck1110 FIND v(dout0_13) AT=560.025n

.meas tran vdout0_14ck1110 FIND v(dout0_14) AT=560.025n

.meas tran vdout0_15ck1110 FIND v(dout0_15) AT=560.025n

.meas tran vdout0_16ck1110 FIND v(dout0_16) AT=560.025n

.meas tran vdout0_17ck1110 FIND v(dout0_17) AT=560.025n

.meas tran vdout0_18ck1110 FIND v(dout0_18) AT=560.025n

.meas tran vdout0_19ck1110 FIND v(dout0_19) AT=560.025n

.meas tran vdout0_20ck1110 FIND v(dout0_20) AT=560.025n

.meas tran vdout0_21ck1110 FIND v(dout0_21) AT=560.025n

.meas tran vdout0_22ck1110 FIND v(dout0_22) AT=560.025n

.meas tran vdout0_23ck1110 FIND v(dout0_23) AT=560.025n

.meas tran vdout0_24ck1110 FIND v(dout0_24) AT=560.025n

.meas tran vdout0_25ck1110 FIND v(dout0_25) AT=560.025n

.meas tran vdout0_26ck1110 FIND v(dout0_26) AT=560.025n

.meas tran vdout0_27ck1110 FIND v(dout0_27) AT=560.025n

.meas tran vdout0_28ck1110 FIND v(dout0_28) AT=560.025n

.meas tran vdout0_29ck1110 FIND v(dout0_29) AT=560.025n

.meas tran vdout0_30ck1110 FIND v(dout0_30) AT=560.025n

.meas tran vdout0_31ck1110 FIND v(dout0_31) AT=560.025n

.meas tran vdout0_32ck1110 FIND v(dout0_32) AT=560.025n

.meas tran vdout0_33ck1110 FIND v(dout0_33) AT=560.025n

.meas tran vdout0_34ck1110 FIND v(dout0_34) AT=560.025n

.meas tran vdout0_35ck1110 FIND v(dout0_35) AT=560.025n

.meas tran vdout0_36ck1110 FIND v(dout0_36) AT=560.025n

.meas tran vdout0_37ck1110 FIND v(dout0_37) AT=560.025n

.meas tran vdout0_38ck1110 FIND v(dout0_38) AT=560.025n

.meas tran vdout0_39ck1110 FIND v(dout0_39) AT=560.025n

.meas tran vdout0_40ck1110 FIND v(dout0_40) AT=560.025n

.meas tran vdout0_41ck1110 FIND v(dout0_41) AT=560.025n

.meas tran vdout0_42ck1110 FIND v(dout0_42) AT=560.025n

.meas tran vdout0_43ck1110 FIND v(dout0_43) AT=560.025n

.meas tran vdout0_44ck1110 FIND v(dout0_44) AT=560.025n

.meas tran vdout0_45ck1110 FIND v(dout0_45) AT=560.025n

.meas tran vdout0_46ck1110 FIND v(dout0_46) AT=560.025n

.meas tran vdout0_47ck1110 FIND v(dout0_47) AT=560.025n

.meas tran vdout0_48ck1110 FIND v(dout0_48) AT=560.025n

.meas tran vdout0_49ck1110 FIND v(dout0_49) AT=560.025n

.meas tran vdout0_50ck1110 FIND v(dout0_50) AT=560.025n

.meas tran vdout0_51ck1110 FIND v(dout0_51) AT=560.025n

.meas tran vdout0_52ck1110 FIND v(dout0_52) AT=560.025n

.meas tran vdout0_53ck1110 FIND v(dout0_53) AT=560.025n

.meas tran vdout0_54ck1110 FIND v(dout0_54) AT=560.025n

.meas tran vdout0_55ck1110 FIND v(dout0_55) AT=560.025n

.meas tran vdout0_56ck1110 FIND v(dout0_56) AT=560.025n

.meas tran vdout0_57ck1110 FIND v(dout0_57) AT=560.025n

.meas tran vdout0_58ck1110 FIND v(dout0_58) AT=560.025n

.meas tran vdout0_59ck1110 FIND v(dout0_59) AT=560.025n

.meas tran vdout0_60ck1110 FIND v(dout0_60) AT=560.025n

.meas tran vdout0_61ck1110 FIND v(dout0_61) AT=560.025n

.meas tran vdout0_62ck1110 FIND v(dout0_62) AT=560.025n

.meas tran vdout0_63ck1110 FIND v(dout0_63) AT=560.025n

.meas tran vdout0_64ck1110 FIND v(dout0_64) AT=560.025n

.meas tran vdout0_65ck1110 FIND v(dout0_65) AT=560.025n

.meas tran vdout0_66ck1110 FIND v(dout0_66) AT=560.025n

.meas tran vdout0_67ck1110 FIND v(dout0_67) AT=560.025n

.meas tran vdout0_68ck1110 FIND v(dout0_68) AT=560.025n

.meas tran vdout0_69ck1110 FIND v(dout0_69) AT=560.025n

.meas tran vdout0_70ck1110 FIND v(dout0_70) AT=560.025n

.meas tran vdout0_71ck1110 FIND v(dout0_71) AT=560.025n

.meas tran vdout0_72ck1110 FIND v(dout0_72) AT=560.025n

.meas tran vdout0_73ck1110 FIND v(dout0_73) AT=560.025n

.meas tran vdout0_74ck1110 FIND v(dout0_74) AT=560.025n

.meas tran vdout0_75ck1110 FIND v(dout0_75) AT=560.025n

.meas tran vdout0_76ck1110 FIND v(dout0_76) AT=560.025n

.meas tran vdout0_77ck1110 FIND v(dout0_77) AT=560.025n

.meas tran vdout0_78ck1110 FIND v(dout0_78) AT=560.025n

.meas tran vdout0_79ck1110 FIND v(dout0_79) AT=560.025n

.meas tran vdout0_80ck1110 FIND v(dout0_80) AT=560.025n

.meas tran vdout0_81ck1110 FIND v(dout0_81) AT=560.025n

.meas tran vdout0_82ck1110 FIND v(dout0_82) AT=560.025n

.meas tran vdout0_83ck1110 FIND v(dout0_83) AT=560.025n

.meas tran vdout0_84ck1110 FIND v(dout0_84) AT=560.025n

.meas tran vdout0_85ck1110 FIND v(dout0_85) AT=560.025n

.meas tran vdout0_86ck1110 FIND v(dout0_86) AT=560.025n

.meas tran vdout0_87ck1110 FIND v(dout0_87) AT=560.025n

.meas tran vdout0_88ck1110 FIND v(dout0_88) AT=560.025n

.meas tran vdout0_89ck1110 FIND v(dout0_89) AT=560.025n

.meas tran vdout0_90ck1110 FIND v(dout0_90) AT=560.025n

.meas tran vdout0_91ck1110 FIND v(dout0_91) AT=560.025n

.meas tran vdout0_92ck1110 FIND v(dout0_92) AT=560.025n

.meas tran vdout0_93ck1110 FIND v(dout0_93) AT=560.025n

.meas tran vdout0_94ck1110 FIND v(dout0_94) AT=560.025n

.meas tran vdout0_95ck1110 FIND v(dout0_95) AT=560.025n

.meas tran vdout0_96ck1110 FIND v(dout0_96) AT=560.025n

.meas tran vdout0_97ck1110 FIND v(dout0_97) AT=560.025n

.meas tran vdout0_98ck1110 FIND v(dout0_98) AT=560.025n

.meas tran vdout0_99ck1110 FIND v(dout0_99) AT=560.025n

.meas tran vdout0_100ck1110 FIND v(dout0_100) AT=560.025n

.meas tran vdout0_101ck1110 FIND v(dout0_101) AT=560.025n

.meas tran vdout0_102ck1110 FIND v(dout0_102) AT=560.025n

.meas tran vdout0_103ck1110 FIND v(dout0_103) AT=560.025n

.meas tran vdout0_104ck1110 FIND v(dout0_104) AT=560.025n

.meas tran vdout0_105ck1110 FIND v(dout0_105) AT=560.025n

.meas tran vdout0_106ck1110 FIND v(dout0_106) AT=560.025n

.meas tran vdout0_107ck1110 FIND v(dout0_107) AT=560.025n

.meas tran vdout0_108ck1110 FIND v(dout0_108) AT=560.025n

.meas tran vdout0_109ck1110 FIND v(dout0_109) AT=560.025n

.meas tran vdout0_110ck1110 FIND v(dout0_110) AT=560.025n

.meas tran vdout0_111ck1110 FIND v(dout0_111) AT=560.025n

.meas tran vdout0_112ck1110 FIND v(dout0_112) AT=560.025n

.meas tran vdout0_113ck1110 FIND v(dout0_113) AT=560.025n

.meas tran vdout0_114ck1110 FIND v(dout0_114) AT=560.025n

.meas tran vdout0_115ck1110 FIND v(dout0_115) AT=560.025n

.meas tran vdout0_116ck1110 FIND v(dout0_116) AT=560.025n

.meas tran vdout0_117ck1110 FIND v(dout0_117) AT=560.025n

.meas tran vdout0_118ck1110 FIND v(dout0_118) AT=560.025n

.meas tran vdout0_119ck1110 FIND v(dout0_119) AT=560.025n

.meas tran vdout0_120ck1110 FIND v(dout0_120) AT=560.025n

.meas tran vdout0_121ck1110 FIND v(dout0_121) AT=560.025n

.meas tran vdout0_122ck1110 FIND v(dout0_122) AT=560.025n

.meas tran vdout0_123ck1110 FIND v(dout0_123) AT=560.025n

.meas tran vdout0_124ck1110 FIND v(dout0_124) AT=560.025n

.meas tran vdout0_125ck1110 FIND v(dout0_125) AT=560.025n

.meas tran vdout0_126ck1110 FIND v(dout0_126) AT=560.025n

.meas tran vdout0_127ck1110 FIND v(dout0_127) AT=560.025n

.meas tran vdout0_128ck1110 FIND v(dout0_128) AT=560.025n

.meas tran vdout0_129ck1110 FIND v(dout0_129) AT=560.025n

.meas tran vdout0_130ck1110 FIND v(dout0_130) AT=560.025n

.meas tran vdout0_131ck1110 FIND v(dout0_131) AT=560.025n

.meas tran vdout0_132ck1110 FIND v(dout0_132) AT=560.025n

.meas tran vdout0_133ck1110 FIND v(dout0_133) AT=560.025n

.meas tran vdout0_134ck1110 FIND v(dout0_134) AT=560.025n

.meas tran vdout0_135ck1110 FIND v(dout0_135) AT=560.025n

.meas tran vdout0_136ck1110 FIND v(dout0_136) AT=560.025n

.meas tran vdout0_137ck1110 FIND v(dout0_137) AT=560.025n

.meas tran vdout0_138ck1110 FIND v(dout0_138) AT=560.025n

.meas tran vdout0_139ck1110 FIND v(dout0_139) AT=560.025n

.meas tran vdout0_140ck1110 FIND v(dout0_140) AT=560.025n

.meas tran vdout0_141ck1110 FIND v(dout0_141) AT=560.025n

.meas tran vdout0_142ck1110 FIND v(dout0_142) AT=560.025n

.meas tran vdout0_143ck1110 FIND v(dout0_143) AT=560.025n

.meas tran vdout0_144ck1110 FIND v(dout0_144) AT=560.025n

.meas tran vdout0_145ck1110 FIND v(dout0_145) AT=560.025n

.meas tran vdout0_146ck1110 FIND v(dout0_146) AT=560.025n

.meas tran vdout0_147ck1110 FIND v(dout0_147) AT=560.025n

.meas tran vdout0_148ck1110 FIND v(dout0_148) AT=560.025n

.meas tran vdout0_149ck1110 FIND v(dout0_149) AT=560.025n

.meas tran vdout0_150ck1110 FIND v(dout0_150) AT=560.025n

.meas tran vdout0_151ck1110 FIND v(dout0_151) AT=560.025n

.meas tran vdout0_152ck1110 FIND v(dout0_152) AT=560.025n

.meas tran vdout0_153ck1110 FIND v(dout0_153) AT=560.025n

.meas tran vdout0_154ck1110 FIND v(dout0_154) AT=560.025n

.meas tran vdout0_155ck1110 FIND v(dout0_155) AT=560.025n

.meas tran vdout0_156ck1110 FIND v(dout0_156) AT=560.025n

.meas tran vdout0_157ck1110 FIND v(dout0_157) AT=560.025n

.meas tran vdout0_158ck1110 FIND v(dout0_158) AT=560.025n

.meas tran vdout0_159ck1110 FIND v(dout0_159) AT=560.025n

.meas tran vdout0_160ck1110 FIND v(dout0_160) AT=560.025n

.meas tran vdout0_161ck1110 FIND v(dout0_161) AT=560.025n

.meas tran vdout0_162ck1110 FIND v(dout0_162) AT=560.025n

.meas tran vdout0_163ck1110 FIND v(dout0_163) AT=560.025n

.meas tran vdout0_164ck1110 FIND v(dout0_164) AT=560.025n

.meas tran vdout0_165ck1110 FIND v(dout0_165) AT=560.025n

.meas tran vdout0_166ck1110 FIND v(dout0_166) AT=560.025n

.meas tran vdout0_167ck1110 FIND v(dout0_167) AT=560.025n

.meas tran vdout0_168ck1110 FIND v(dout0_168) AT=560.025n

.meas tran vdout0_169ck1110 FIND v(dout0_169) AT=560.025n

.meas tran vdout0_170ck1110 FIND v(dout0_170) AT=560.025n

.meas tran vdout0_171ck1110 FIND v(dout0_171) AT=560.025n

.meas tran vdout0_172ck1110 FIND v(dout0_172) AT=560.025n

.meas tran vdout0_173ck1110 FIND v(dout0_173) AT=560.025n

.meas tran vdout0_174ck1110 FIND v(dout0_174) AT=560.025n

.meas tran vdout0_175ck1110 FIND v(dout0_175) AT=560.025n

.meas tran vdout0_176ck1110 FIND v(dout0_176) AT=560.025n

.meas tran vdout0_177ck1110 FIND v(dout0_177) AT=560.025n

.meas tran vdout0_178ck1110 FIND v(dout0_178) AT=560.025n

.meas tran vdout0_179ck1110 FIND v(dout0_179) AT=560.025n

.meas tran vdout0_180ck1110 FIND v(dout0_180) AT=560.025n

.meas tran vdout0_181ck1110 FIND v(dout0_181) AT=560.025n

.meas tran vdout0_182ck1110 FIND v(dout0_182) AT=560.025n

.meas tran vdout0_183ck1110 FIND v(dout0_183) AT=560.025n

.meas tran vdout0_184ck1110 FIND v(dout0_184) AT=560.025n

.meas tran vdout0_185ck1110 FIND v(dout0_185) AT=560.025n

.meas tran vdout0_186ck1110 FIND v(dout0_186) AT=560.025n

.meas tran vdout0_187ck1110 FIND v(dout0_187) AT=560.025n

.meas tran vdout0_188ck1110 FIND v(dout0_188) AT=560.025n

.meas tran vdout0_189ck1110 FIND v(dout0_189) AT=560.025n

.meas tran vdout0_190ck1110 FIND v(dout0_190) AT=560.025n

.meas tran vdout0_191ck1110 FIND v(dout0_191) AT=560.025n

.meas tran vdout0_192ck1110 FIND v(dout0_192) AT=560.025n

.meas tran vdout0_193ck1110 FIND v(dout0_193) AT=560.025n

.meas tran vdout0_194ck1110 FIND v(dout0_194) AT=560.025n

.meas tran vdout0_195ck1110 FIND v(dout0_195) AT=560.025n

.meas tran vdout0_196ck1110 FIND v(dout0_196) AT=560.025n

.meas tran vdout0_197ck1110 FIND v(dout0_197) AT=560.025n

.meas tran vdout0_198ck1110 FIND v(dout0_198) AT=560.025n

.meas tran vdout0_199ck1110 FIND v(dout0_199) AT=560.025n

.meas tran vdout0_200ck1110 FIND v(dout0_200) AT=560.025n

.meas tran vdout0_201ck1110 FIND v(dout0_201) AT=560.025n

.meas tran vdout0_202ck1110 FIND v(dout0_202) AT=560.025n

.meas tran vdout0_203ck1110 FIND v(dout0_203) AT=560.025n

.meas tran vdout0_204ck1110 FIND v(dout0_204) AT=560.025n

.meas tran vdout0_205ck1110 FIND v(dout0_205) AT=560.025n

.meas tran vdout0_206ck1110 FIND v(dout0_206) AT=560.025n

.meas tran vdout0_207ck1110 FIND v(dout0_207) AT=560.025n

.meas tran vdout0_208ck1110 FIND v(dout0_208) AT=560.025n

.meas tran vdout0_209ck1110 FIND v(dout0_209) AT=560.025n

.meas tran vdout0_210ck1110 FIND v(dout0_210) AT=560.025n

.meas tran vdout0_211ck1110 FIND v(dout0_211) AT=560.025n

.meas tran vdout0_212ck1110 FIND v(dout0_212) AT=560.025n

.meas tran vdout0_213ck1110 FIND v(dout0_213) AT=560.025n

.meas tran vdout0_214ck1110 FIND v(dout0_214) AT=560.025n

.meas tran vdout0_215ck1110 FIND v(dout0_215) AT=560.025n

.meas tran vdout0_216ck1110 FIND v(dout0_216) AT=560.025n

.meas tran vdout0_217ck1110 FIND v(dout0_217) AT=560.025n

.meas tran vdout0_218ck1110 FIND v(dout0_218) AT=560.025n

.meas tran vdout0_219ck1110 FIND v(dout0_219) AT=560.025n

.meas tran vdout0_220ck1110 FIND v(dout0_220) AT=560.025n

.meas tran vdout0_221ck1110 FIND v(dout0_221) AT=560.025n

.meas tran vdout0_222ck1110 FIND v(dout0_222) AT=560.025n

.meas tran vdout0_223ck1110 FIND v(dout0_223) AT=560.025n

.meas tran vdout0_224ck1110 FIND v(dout0_224) AT=560.025n

.meas tran vdout0_225ck1110 FIND v(dout0_225) AT=560.025n

.meas tran vdout0_226ck1110 FIND v(dout0_226) AT=560.025n

.meas tran vdout0_227ck1110 FIND v(dout0_227) AT=560.025n

.meas tran vdout0_228ck1110 FIND v(dout0_228) AT=560.025n

.meas tran vdout0_229ck1110 FIND v(dout0_229) AT=560.025n

.meas tran vdout0_230ck1110 FIND v(dout0_230) AT=560.025n

.meas tran vdout0_231ck1110 FIND v(dout0_231) AT=560.025n

.meas tran vdout0_232ck1110 FIND v(dout0_232) AT=560.025n

.meas tran vdout0_233ck1110 FIND v(dout0_233) AT=560.025n

.meas tran vdout0_234ck1110 FIND v(dout0_234) AT=560.025n

.meas tran vdout0_235ck1110 FIND v(dout0_235) AT=560.025n

.meas tran vdout0_236ck1110 FIND v(dout0_236) AT=560.025n

.meas tran vdout0_237ck1110 FIND v(dout0_237) AT=560.025n

.meas tran vdout0_238ck1110 FIND v(dout0_238) AT=560.025n

.meas tran vdout0_239ck1110 FIND v(dout0_239) AT=560.025n

.meas tran vdout0_240ck1110 FIND v(dout0_240) AT=560.025n

.meas tran vdout0_241ck1110 FIND v(dout0_241) AT=560.025n

.meas tran vdout0_242ck1110 FIND v(dout0_242) AT=560.025n

.meas tran vdout0_243ck1110 FIND v(dout0_243) AT=560.025n

.meas tran vdout0_244ck1110 FIND v(dout0_244) AT=560.025n

.meas tran vdout0_245ck1110 FIND v(dout0_245) AT=560.025n

.meas tran vdout0_246ck1110 FIND v(dout0_246) AT=560.025n

.meas tran vdout0_247ck1110 FIND v(dout0_247) AT=560.025n

.meas tran vdout0_248ck1110 FIND v(dout0_248) AT=560.025n

.meas tran vdout0_249ck1110 FIND v(dout0_249) AT=560.025n

.meas tran vdout0_250ck1110 FIND v(dout0_250) AT=560.025n

.meas tran vdout0_251ck1110 FIND v(dout0_251) AT=560.025n

.meas tran vdout0_252ck1110 FIND v(dout0_252) AT=560.025n

.meas tran vdout0_253ck1110 FIND v(dout0_253) AT=560.025n

.meas tran vdout0_254ck1110 FIND v(dout0_254) AT=560.025n

.meas tran vdout0_255ck1110 FIND v(dout0_255) AT=560.025n

.meas tran vdout0_0ck1130 FIND v(dout0_0) AT=570.025n

.meas tran vdout0_1ck1130 FIND v(dout0_1) AT=570.025n

.meas tran vdout0_2ck1130 FIND v(dout0_2) AT=570.025n

.meas tran vdout0_3ck1130 FIND v(dout0_3) AT=570.025n

.meas tran vdout0_4ck1130 FIND v(dout0_4) AT=570.025n

.meas tran vdout0_5ck1130 FIND v(dout0_5) AT=570.025n

.meas tran vdout0_6ck1130 FIND v(dout0_6) AT=570.025n

.meas tran vdout0_7ck1130 FIND v(dout0_7) AT=570.025n

.meas tran vdout0_8ck1130 FIND v(dout0_8) AT=570.025n

.meas tran vdout0_9ck1130 FIND v(dout0_9) AT=570.025n

.meas tran vdout0_10ck1130 FIND v(dout0_10) AT=570.025n

.meas tran vdout0_11ck1130 FIND v(dout0_11) AT=570.025n

.meas tran vdout0_12ck1130 FIND v(dout0_12) AT=570.025n

.meas tran vdout0_13ck1130 FIND v(dout0_13) AT=570.025n

.meas tran vdout0_14ck1130 FIND v(dout0_14) AT=570.025n

.meas tran vdout0_15ck1130 FIND v(dout0_15) AT=570.025n

.meas tran vdout0_16ck1130 FIND v(dout0_16) AT=570.025n

.meas tran vdout0_17ck1130 FIND v(dout0_17) AT=570.025n

.meas tran vdout0_18ck1130 FIND v(dout0_18) AT=570.025n

.meas tran vdout0_19ck1130 FIND v(dout0_19) AT=570.025n

.meas tran vdout0_20ck1130 FIND v(dout0_20) AT=570.025n

.meas tran vdout0_21ck1130 FIND v(dout0_21) AT=570.025n

.meas tran vdout0_22ck1130 FIND v(dout0_22) AT=570.025n

.meas tran vdout0_23ck1130 FIND v(dout0_23) AT=570.025n

.meas tran vdout0_24ck1130 FIND v(dout0_24) AT=570.025n

.meas tran vdout0_25ck1130 FIND v(dout0_25) AT=570.025n

.meas tran vdout0_26ck1130 FIND v(dout0_26) AT=570.025n

.meas tran vdout0_27ck1130 FIND v(dout0_27) AT=570.025n

.meas tran vdout0_28ck1130 FIND v(dout0_28) AT=570.025n

.meas tran vdout0_29ck1130 FIND v(dout0_29) AT=570.025n

.meas tran vdout0_30ck1130 FIND v(dout0_30) AT=570.025n

.meas tran vdout0_31ck1130 FIND v(dout0_31) AT=570.025n

.meas tran vdout0_32ck1130 FIND v(dout0_32) AT=570.025n

.meas tran vdout0_33ck1130 FIND v(dout0_33) AT=570.025n

.meas tran vdout0_34ck1130 FIND v(dout0_34) AT=570.025n

.meas tran vdout0_35ck1130 FIND v(dout0_35) AT=570.025n

.meas tran vdout0_36ck1130 FIND v(dout0_36) AT=570.025n

.meas tran vdout0_37ck1130 FIND v(dout0_37) AT=570.025n

.meas tran vdout0_38ck1130 FIND v(dout0_38) AT=570.025n

.meas tran vdout0_39ck1130 FIND v(dout0_39) AT=570.025n

.meas tran vdout0_40ck1130 FIND v(dout0_40) AT=570.025n

.meas tran vdout0_41ck1130 FIND v(dout0_41) AT=570.025n

.meas tran vdout0_42ck1130 FIND v(dout0_42) AT=570.025n

.meas tran vdout0_43ck1130 FIND v(dout0_43) AT=570.025n

.meas tran vdout0_44ck1130 FIND v(dout0_44) AT=570.025n

.meas tran vdout0_45ck1130 FIND v(dout0_45) AT=570.025n

.meas tran vdout0_46ck1130 FIND v(dout0_46) AT=570.025n

.meas tran vdout0_47ck1130 FIND v(dout0_47) AT=570.025n

.meas tran vdout0_48ck1130 FIND v(dout0_48) AT=570.025n

.meas tran vdout0_49ck1130 FIND v(dout0_49) AT=570.025n

.meas tran vdout0_50ck1130 FIND v(dout0_50) AT=570.025n

.meas tran vdout0_51ck1130 FIND v(dout0_51) AT=570.025n

.meas tran vdout0_52ck1130 FIND v(dout0_52) AT=570.025n

.meas tran vdout0_53ck1130 FIND v(dout0_53) AT=570.025n

.meas tran vdout0_54ck1130 FIND v(dout0_54) AT=570.025n

.meas tran vdout0_55ck1130 FIND v(dout0_55) AT=570.025n

.meas tran vdout0_56ck1130 FIND v(dout0_56) AT=570.025n

.meas tran vdout0_57ck1130 FIND v(dout0_57) AT=570.025n

.meas tran vdout0_58ck1130 FIND v(dout0_58) AT=570.025n

.meas tran vdout0_59ck1130 FIND v(dout0_59) AT=570.025n

.meas tran vdout0_60ck1130 FIND v(dout0_60) AT=570.025n

.meas tran vdout0_61ck1130 FIND v(dout0_61) AT=570.025n

.meas tran vdout0_62ck1130 FIND v(dout0_62) AT=570.025n

.meas tran vdout0_63ck1130 FIND v(dout0_63) AT=570.025n

.meas tran vdout0_64ck1130 FIND v(dout0_64) AT=570.025n

.meas tran vdout0_65ck1130 FIND v(dout0_65) AT=570.025n

.meas tran vdout0_66ck1130 FIND v(dout0_66) AT=570.025n

.meas tran vdout0_67ck1130 FIND v(dout0_67) AT=570.025n

.meas tran vdout0_68ck1130 FIND v(dout0_68) AT=570.025n

.meas tran vdout0_69ck1130 FIND v(dout0_69) AT=570.025n

.meas tran vdout0_70ck1130 FIND v(dout0_70) AT=570.025n

.meas tran vdout0_71ck1130 FIND v(dout0_71) AT=570.025n

.meas tran vdout0_72ck1130 FIND v(dout0_72) AT=570.025n

.meas tran vdout0_73ck1130 FIND v(dout0_73) AT=570.025n

.meas tran vdout0_74ck1130 FIND v(dout0_74) AT=570.025n

.meas tran vdout0_75ck1130 FIND v(dout0_75) AT=570.025n

.meas tran vdout0_76ck1130 FIND v(dout0_76) AT=570.025n

.meas tran vdout0_77ck1130 FIND v(dout0_77) AT=570.025n

.meas tran vdout0_78ck1130 FIND v(dout0_78) AT=570.025n

.meas tran vdout0_79ck1130 FIND v(dout0_79) AT=570.025n

.meas tran vdout0_80ck1130 FIND v(dout0_80) AT=570.025n

.meas tran vdout0_81ck1130 FIND v(dout0_81) AT=570.025n

.meas tran vdout0_82ck1130 FIND v(dout0_82) AT=570.025n

.meas tran vdout0_83ck1130 FIND v(dout0_83) AT=570.025n

.meas tran vdout0_84ck1130 FIND v(dout0_84) AT=570.025n

.meas tran vdout0_85ck1130 FIND v(dout0_85) AT=570.025n

.meas tran vdout0_86ck1130 FIND v(dout0_86) AT=570.025n

.meas tran vdout0_87ck1130 FIND v(dout0_87) AT=570.025n

.meas tran vdout0_88ck1130 FIND v(dout0_88) AT=570.025n

.meas tran vdout0_89ck1130 FIND v(dout0_89) AT=570.025n

.meas tran vdout0_90ck1130 FIND v(dout0_90) AT=570.025n

.meas tran vdout0_91ck1130 FIND v(dout0_91) AT=570.025n

.meas tran vdout0_92ck1130 FIND v(dout0_92) AT=570.025n

.meas tran vdout0_93ck1130 FIND v(dout0_93) AT=570.025n

.meas tran vdout0_94ck1130 FIND v(dout0_94) AT=570.025n

.meas tran vdout0_95ck1130 FIND v(dout0_95) AT=570.025n

.meas tran vdout0_96ck1130 FIND v(dout0_96) AT=570.025n

.meas tran vdout0_97ck1130 FIND v(dout0_97) AT=570.025n

.meas tran vdout0_98ck1130 FIND v(dout0_98) AT=570.025n

.meas tran vdout0_99ck1130 FIND v(dout0_99) AT=570.025n

.meas tran vdout0_100ck1130 FIND v(dout0_100) AT=570.025n

.meas tran vdout0_101ck1130 FIND v(dout0_101) AT=570.025n

.meas tran vdout0_102ck1130 FIND v(dout0_102) AT=570.025n

.meas tran vdout0_103ck1130 FIND v(dout0_103) AT=570.025n

.meas tran vdout0_104ck1130 FIND v(dout0_104) AT=570.025n

.meas tran vdout0_105ck1130 FIND v(dout0_105) AT=570.025n

.meas tran vdout0_106ck1130 FIND v(dout0_106) AT=570.025n

.meas tran vdout0_107ck1130 FIND v(dout0_107) AT=570.025n

.meas tran vdout0_108ck1130 FIND v(dout0_108) AT=570.025n

.meas tran vdout0_109ck1130 FIND v(dout0_109) AT=570.025n

.meas tran vdout0_110ck1130 FIND v(dout0_110) AT=570.025n

.meas tran vdout0_111ck1130 FIND v(dout0_111) AT=570.025n

.meas tran vdout0_112ck1130 FIND v(dout0_112) AT=570.025n

.meas tran vdout0_113ck1130 FIND v(dout0_113) AT=570.025n

.meas tran vdout0_114ck1130 FIND v(dout0_114) AT=570.025n

.meas tran vdout0_115ck1130 FIND v(dout0_115) AT=570.025n

.meas tran vdout0_116ck1130 FIND v(dout0_116) AT=570.025n

.meas tran vdout0_117ck1130 FIND v(dout0_117) AT=570.025n

.meas tran vdout0_118ck1130 FIND v(dout0_118) AT=570.025n

.meas tran vdout0_119ck1130 FIND v(dout0_119) AT=570.025n

.meas tran vdout0_120ck1130 FIND v(dout0_120) AT=570.025n

.meas tran vdout0_121ck1130 FIND v(dout0_121) AT=570.025n

.meas tran vdout0_122ck1130 FIND v(dout0_122) AT=570.025n

.meas tran vdout0_123ck1130 FIND v(dout0_123) AT=570.025n

.meas tran vdout0_124ck1130 FIND v(dout0_124) AT=570.025n

.meas tran vdout0_125ck1130 FIND v(dout0_125) AT=570.025n

.meas tran vdout0_126ck1130 FIND v(dout0_126) AT=570.025n

.meas tran vdout0_127ck1130 FIND v(dout0_127) AT=570.025n

.meas tran vdout0_128ck1130 FIND v(dout0_128) AT=570.025n

.meas tran vdout0_129ck1130 FIND v(dout0_129) AT=570.025n

.meas tran vdout0_130ck1130 FIND v(dout0_130) AT=570.025n

.meas tran vdout0_131ck1130 FIND v(dout0_131) AT=570.025n

.meas tran vdout0_132ck1130 FIND v(dout0_132) AT=570.025n

.meas tran vdout0_133ck1130 FIND v(dout0_133) AT=570.025n

.meas tran vdout0_134ck1130 FIND v(dout0_134) AT=570.025n

.meas tran vdout0_135ck1130 FIND v(dout0_135) AT=570.025n

.meas tran vdout0_136ck1130 FIND v(dout0_136) AT=570.025n

.meas tran vdout0_137ck1130 FIND v(dout0_137) AT=570.025n

.meas tran vdout0_138ck1130 FIND v(dout0_138) AT=570.025n

.meas tran vdout0_139ck1130 FIND v(dout0_139) AT=570.025n

.meas tran vdout0_140ck1130 FIND v(dout0_140) AT=570.025n

.meas tran vdout0_141ck1130 FIND v(dout0_141) AT=570.025n

.meas tran vdout0_142ck1130 FIND v(dout0_142) AT=570.025n

.meas tran vdout0_143ck1130 FIND v(dout0_143) AT=570.025n

.meas tran vdout0_144ck1130 FIND v(dout0_144) AT=570.025n

.meas tran vdout0_145ck1130 FIND v(dout0_145) AT=570.025n

.meas tran vdout0_146ck1130 FIND v(dout0_146) AT=570.025n

.meas tran vdout0_147ck1130 FIND v(dout0_147) AT=570.025n

.meas tran vdout0_148ck1130 FIND v(dout0_148) AT=570.025n

.meas tran vdout0_149ck1130 FIND v(dout0_149) AT=570.025n

.meas tran vdout0_150ck1130 FIND v(dout0_150) AT=570.025n

.meas tran vdout0_151ck1130 FIND v(dout0_151) AT=570.025n

.meas tran vdout0_152ck1130 FIND v(dout0_152) AT=570.025n

.meas tran vdout0_153ck1130 FIND v(dout0_153) AT=570.025n

.meas tran vdout0_154ck1130 FIND v(dout0_154) AT=570.025n

.meas tran vdout0_155ck1130 FIND v(dout0_155) AT=570.025n

.meas tran vdout0_156ck1130 FIND v(dout0_156) AT=570.025n

.meas tran vdout0_157ck1130 FIND v(dout0_157) AT=570.025n

.meas tran vdout0_158ck1130 FIND v(dout0_158) AT=570.025n

.meas tran vdout0_159ck1130 FIND v(dout0_159) AT=570.025n

.meas tran vdout0_160ck1130 FIND v(dout0_160) AT=570.025n

.meas tran vdout0_161ck1130 FIND v(dout0_161) AT=570.025n

.meas tran vdout0_162ck1130 FIND v(dout0_162) AT=570.025n

.meas tran vdout0_163ck1130 FIND v(dout0_163) AT=570.025n

.meas tran vdout0_164ck1130 FIND v(dout0_164) AT=570.025n

.meas tran vdout0_165ck1130 FIND v(dout0_165) AT=570.025n

.meas tran vdout0_166ck1130 FIND v(dout0_166) AT=570.025n

.meas tran vdout0_167ck1130 FIND v(dout0_167) AT=570.025n

.meas tran vdout0_168ck1130 FIND v(dout0_168) AT=570.025n

.meas tran vdout0_169ck1130 FIND v(dout0_169) AT=570.025n

.meas tran vdout0_170ck1130 FIND v(dout0_170) AT=570.025n

.meas tran vdout0_171ck1130 FIND v(dout0_171) AT=570.025n

.meas tran vdout0_172ck1130 FIND v(dout0_172) AT=570.025n

.meas tran vdout0_173ck1130 FIND v(dout0_173) AT=570.025n

.meas tran vdout0_174ck1130 FIND v(dout0_174) AT=570.025n

.meas tran vdout0_175ck1130 FIND v(dout0_175) AT=570.025n

.meas tran vdout0_176ck1130 FIND v(dout0_176) AT=570.025n

.meas tran vdout0_177ck1130 FIND v(dout0_177) AT=570.025n

.meas tran vdout0_178ck1130 FIND v(dout0_178) AT=570.025n

.meas tran vdout0_179ck1130 FIND v(dout0_179) AT=570.025n

.meas tran vdout0_180ck1130 FIND v(dout0_180) AT=570.025n

.meas tran vdout0_181ck1130 FIND v(dout0_181) AT=570.025n

.meas tran vdout0_182ck1130 FIND v(dout0_182) AT=570.025n

.meas tran vdout0_183ck1130 FIND v(dout0_183) AT=570.025n

.meas tran vdout0_184ck1130 FIND v(dout0_184) AT=570.025n

.meas tran vdout0_185ck1130 FIND v(dout0_185) AT=570.025n

.meas tran vdout0_186ck1130 FIND v(dout0_186) AT=570.025n

.meas tran vdout0_187ck1130 FIND v(dout0_187) AT=570.025n

.meas tran vdout0_188ck1130 FIND v(dout0_188) AT=570.025n

.meas tran vdout0_189ck1130 FIND v(dout0_189) AT=570.025n

.meas tran vdout0_190ck1130 FIND v(dout0_190) AT=570.025n

.meas tran vdout0_191ck1130 FIND v(dout0_191) AT=570.025n

.meas tran vdout0_192ck1130 FIND v(dout0_192) AT=570.025n

.meas tran vdout0_193ck1130 FIND v(dout0_193) AT=570.025n

.meas tran vdout0_194ck1130 FIND v(dout0_194) AT=570.025n

.meas tran vdout0_195ck1130 FIND v(dout0_195) AT=570.025n

.meas tran vdout0_196ck1130 FIND v(dout0_196) AT=570.025n

.meas tran vdout0_197ck1130 FIND v(dout0_197) AT=570.025n

.meas tran vdout0_198ck1130 FIND v(dout0_198) AT=570.025n

.meas tran vdout0_199ck1130 FIND v(dout0_199) AT=570.025n

.meas tran vdout0_200ck1130 FIND v(dout0_200) AT=570.025n

.meas tran vdout0_201ck1130 FIND v(dout0_201) AT=570.025n

.meas tran vdout0_202ck1130 FIND v(dout0_202) AT=570.025n

.meas tran vdout0_203ck1130 FIND v(dout0_203) AT=570.025n

.meas tran vdout0_204ck1130 FIND v(dout0_204) AT=570.025n

.meas tran vdout0_205ck1130 FIND v(dout0_205) AT=570.025n

.meas tran vdout0_206ck1130 FIND v(dout0_206) AT=570.025n

.meas tran vdout0_207ck1130 FIND v(dout0_207) AT=570.025n

.meas tran vdout0_208ck1130 FIND v(dout0_208) AT=570.025n

.meas tran vdout0_209ck1130 FIND v(dout0_209) AT=570.025n

.meas tran vdout0_210ck1130 FIND v(dout0_210) AT=570.025n

.meas tran vdout0_211ck1130 FIND v(dout0_211) AT=570.025n

.meas tran vdout0_212ck1130 FIND v(dout0_212) AT=570.025n

.meas tran vdout0_213ck1130 FIND v(dout0_213) AT=570.025n

.meas tran vdout0_214ck1130 FIND v(dout0_214) AT=570.025n

.meas tran vdout0_215ck1130 FIND v(dout0_215) AT=570.025n

.meas tran vdout0_216ck1130 FIND v(dout0_216) AT=570.025n

.meas tran vdout0_217ck1130 FIND v(dout0_217) AT=570.025n

.meas tran vdout0_218ck1130 FIND v(dout0_218) AT=570.025n

.meas tran vdout0_219ck1130 FIND v(dout0_219) AT=570.025n

.meas tran vdout0_220ck1130 FIND v(dout0_220) AT=570.025n

.meas tran vdout0_221ck1130 FIND v(dout0_221) AT=570.025n

.meas tran vdout0_222ck1130 FIND v(dout0_222) AT=570.025n

.meas tran vdout0_223ck1130 FIND v(dout0_223) AT=570.025n

.meas tran vdout0_224ck1130 FIND v(dout0_224) AT=570.025n

.meas tran vdout0_225ck1130 FIND v(dout0_225) AT=570.025n

.meas tran vdout0_226ck1130 FIND v(dout0_226) AT=570.025n

.meas tran vdout0_227ck1130 FIND v(dout0_227) AT=570.025n

.meas tran vdout0_228ck1130 FIND v(dout0_228) AT=570.025n

.meas tran vdout0_229ck1130 FIND v(dout0_229) AT=570.025n

.meas tran vdout0_230ck1130 FIND v(dout0_230) AT=570.025n

.meas tran vdout0_231ck1130 FIND v(dout0_231) AT=570.025n

.meas tran vdout0_232ck1130 FIND v(dout0_232) AT=570.025n

.meas tran vdout0_233ck1130 FIND v(dout0_233) AT=570.025n

.meas tran vdout0_234ck1130 FIND v(dout0_234) AT=570.025n

.meas tran vdout0_235ck1130 FIND v(dout0_235) AT=570.025n

.meas tran vdout0_236ck1130 FIND v(dout0_236) AT=570.025n

.meas tran vdout0_237ck1130 FIND v(dout0_237) AT=570.025n

.meas tran vdout0_238ck1130 FIND v(dout0_238) AT=570.025n

.meas tran vdout0_239ck1130 FIND v(dout0_239) AT=570.025n

.meas tran vdout0_240ck1130 FIND v(dout0_240) AT=570.025n

.meas tran vdout0_241ck1130 FIND v(dout0_241) AT=570.025n

.meas tran vdout0_242ck1130 FIND v(dout0_242) AT=570.025n

.meas tran vdout0_243ck1130 FIND v(dout0_243) AT=570.025n

.meas tran vdout0_244ck1130 FIND v(dout0_244) AT=570.025n

.meas tran vdout0_245ck1130 FIND v(dout0_245) AT=570.025n

.meas tran vdout0_246ck1130 FIND v(dout0_246) AT=570.025n

.meas tran vdout0_247ck1130 FIND v(dout0_247) AT=570.025n

.meas tran vdout0_248ck1130 FIND v(dout0_248) AT=570.025n

.meas tran vdout0_249ck1130 FIND v(dout0_249) AT=570.025n

.meas tran vdout0_250ck1130 FIND v(dout0_250) AT=570.025n

.meas tran vdout0_251ck1130 FIND v(dout0_251) AT=570.025n

.meas tran vdout0_252ck1130 FIND v(dout0_252) AT=570.025n

.meas tran vdout0_253ck1130 FIND v(dout0_253) AT=570.025n

.meas tran vdout0_254ck1130 FIND v(dout0_254) AT=570.025n

.meas tran vdout0_255ck1130 FIND v(dout0_255) AT=570.025n

.meas tran vdout0_0ck1180 FIND v(dout0_0) AT=595.025n

.meas tran vdout0_1ck1180 FIND v(dout0_1) AT=595.025n

.meas tran vdout0_2ck1180 FIND v(dout0_2) AT=595.025n

.meas tran vdout0_3ck1180 FIND v(dout0_3) AT=595.025n

.meas tran vdout0_4ck1180 FIND v(dout0_4) AT=595.025n

.meas tran vdout0_5ck1180 FIND v(dout0_5) AT=595.025n

.meas tran vdout0_6ck1180 FIND v(dout0_6) AT=595.025n

.meas tran vdout0_7ck1180 FIND v(dout0_7) AT=595.025n

.meas tran vdout0_8ck1180 FIND v(dout0_8) AT=595.025n

.meas tran vdout0_9ck1180 FIND v(dout0_9) AT=595.025n

.meas tran vdout0_10ck1180 FIND v(dout0_10) AT=595.025n

.meas tran vdout0_11ck1180 FIND v(dout0_11) AT=595.025n

.meas tran vdout0_12ck1180 FIND v(dout0_12) AT=595.025n

.meas tran vdout0_13ck1180 FIND v(dout0_13) AT=595.025n

.meas tran vdout0_14ck1180 FIND v(dout0_14) AT=595.025n

.meas tran vdout0_15ck1180 FIND v(dout0_15) AT=595.025n

.meas tran vdout0_16ck1180 FIND v(dout0_16) AT=595.025n

.meas tran vdout0_17ck1180 FIND v(dout0_17) AT=595.025n

.meas tran vdout0_18ck1180 FIND v(dout0_18) AT=595.025n

.meas tran vdout0_19ck1180 FIND v(dout0_19) AT=595.025n

.meas tran vdout0_20ck1180 FIND v(dout0_20) AT=595.025n

.meas tran vdout0_21ck1180 FIND v(dout0_21) AT=595.025n

.meas tran vdout0_22ck1180 FIND v(dout0_22) AT=595.025n

.meas tran vdout0_23ck1180 FIND v(dout0_23) AT=595.025n

.meas tran vdout0_24ck1180 FIND v(dout0_24) AT=595.025n

.meas tran vdout0_25ck1180 FIND v(dout0_25) AT=595.025n

.meas tran vdout0_26ck1180 FIND v(dout0_26) AT=595.025n

.meas tran vdout0_27ck1180 FIND v(dout0_27) AT=595.025n

.meas tran vdout0_28ck1180 FIND v(dout0_28) AT=595.025n

.meas tran vdout0_29ck1180 FIND v(dout0_29) AT=595.025n

.meas tran vdout0_30ck1180 FIND v(dout0_30) AT=595.025n

.meas tran vdout0_31ck1180 FIND v(dout0_31) AT=595.025n

.meas tran vdout0_32ck1180 FIND v(dout0_32) AT=595.025n

.meas tran vdout0_33ck1180 FIND v(dout0_33) AT=595.025n

.meas tran vdout0_34ck1180 FIND v(dout0_34) AT=595.025n

.meas tran vdout0_35ck1180 FIND v(dout0_35) AT=595.025n

.meas tran vdout0_36ck1180 FIND v(dout0_36) AT=595.025n

.meas tran vdout0_37ck1180 FIND v(dout0_37) AT=595.025n

.meas tran vdout0_38ck1180 FIND v(dout0_38) AT=595.025n

.meas tran vdout0_39ck1180 FIND v(dout0_39) AT=595.025n

.meas tran vdout0_40ck1180 FIND v(dout0_40) AT=595.025n

.meas tran vdout0_41ck1180 FIND v(dout0_41) AT=595.025n

.meas tran vdout0_42ck1180 FIND v(dout0_42) AT=595.025n

.meas tran vdout0_43ck1180 FIND v(dout0_43) AT=595.025n

.meas tran vdout0_44ck1180 FIND v(dout0_44) AT=595.025n

.meas tran vdout0_45ck1180 FIND v(dout0_45) AT=595.025n

.meas tran vdout0_46ck1180 FIND v(dout0_46) AT=595.025n

.meas tran vdout0_47ck1180 FIND v(dout0_47) AT=595.025n

.meas tran vdout0_48ck1180 FIND v(dout0_48) AT=595.025n

.meas tran vdout0_49ck1180 FIND v(dout0_49) AT=595.025n

.meas tran vdout0_50ck1180 FIND v(dout0_50) AT=595.025n

.meas tran vdout0_51ck1180 FIND v(dout0_51) AT=595.025n

.meas tran vdout0_52ck1180 FIND v(dout0_52) AT=595.025n

.meas tran vdout0_53ck1180 FIND v(dout0_53) AT=595.025n

.meas tran vdout0_54ck1180 FIND v(dout0_54) AT=595.025n

.meas tran vdout0_55ck1180 FIND v(dout0_55) AT=595.025n

.meas tran vdout0_56ck1180 FIND v(dout0_56) AT=595.025n

.meas tran vdout0_57ck1180 FIND v(dout0_57) AT=595.025n

.meas tran vdout0_58ck1180 FIND v(dout0_58) AT=595.025n

.meas tran vdout0_59ck1180 FIND v(dout0_59) AT=595.025n

.meas tran vdout0_60ck1180 FIND v(dout0_60) AT=595.025n

.meas tran vdout0_61ck1180 FIND v(dout0_61) AT=595.025n

.meas tran vdout0_62ck1180 FIND v(dout0_62) AT=595.025n

.meas tran vdout0_63ck1180 FIND v(dout0_63) AT=595.025n

.meas tran vdout0_64ck1180 FIND v(dout0_64) AT=595.025n

.meas tran vdout0_65ck1180 FIND v(dout0_65) AT=595.025n

.meas tran vdout0_66ck1180 FIND v(dout0_66) AT=595.025n

.meas tran vdout0_67ck1180 FIND v(dout0_67) AT=595.025n

.meas tran vdout0_68ck1180 FIND v(dout0_68) AT=595.025n

.meas tran vdout0_69ck1180 FIND v(dout0_69) AT=595.025n

.meas tran vdout0_70ck1180 FIND v(dout0_70) AT=595.025n

.meas tran vdout0_71ck1180 FIND v(dout0_71) AT=595.025n

.meas tran vdout0_72ck1180 FIND v(dout0_72) AT=595.025n

.meas tran vdout0_73ck1180 FIND v(dout0_73) AT=595.025n

.meas tran vdout0_74ck1180 FIND v(dout0_74) AT=595.025n

.meas tran vdout0_75ck1180 FIND v(dout0_75) AT=595.025n

.meas tran vdout0_76ck1180 FIND v(dout0_76) AT=595.025n

.meas tran vdout0_77ck1180 FIND v(dout0_77) AT=595.025n

.meas tran vdout0_78ck1180 FIND v(dout0_78) AT=595.025n

.meas tran vdout0_79ck1180 FIND v(dout0_79) AT=595.025n

.meas tran vdout0_80ck1180 FIND v(dout0_80) AT=595.025n

.meas tran vdout0_81ck1180 FIND v(dout0_81) AT=595.025n

.meas tran vdout0_82ck1180 FIND v(dout0_82) AT=595.025n

.meas tran vdout0_83ck1180 FIND v(dout0_83) AT=595.025n

.meas tran vdout0_84ck1180 FIND v(dout0_84) AT=595.025n

.meas tran vdout0_85ck1180 FIND v(dout0_85) AT=595.025n

.meas tran vdout0_86ck1180 FIND v(dout0_86) AT=595.025n

.meas tran vdout0_87ck1180 FIND v(dout0_87) AT=595.025n

.meas tran vdout0_88ck1180 FIND v(dout0_88) AT=595.025n

.meas tran vdout0_89ck1180 FIND v(dout0_89) AT=595.025n

.meas tran vdout0_90ck1180 FIND v(dout0_90) AT=595.025n

.meas tran vdout0_91ck1180 FIND v(dout0_91) AT=595.025n

.meas tran vdout0_92ck1180 FIND v(dout0_92) AT=595.025n

.meas tran vdout0_93ck1180 FIND v(dout0_93) AT=595.025n

.meas tran vdout0_94ck1180 FIND v(dout0_94) AT=595.025n

.meas tran vdout0_95ck1180 FIND v(dout0_95) AT=595.025n

.meas tran vdout0_96ck1180 FIND v(dout0_96) AT=595.025n

.meas tran vdout0_97ck1180 FIND v(dout0_97) AT=595.025n

.meas tran vdout0_98ck1180 FIND v(dout0_98) AT=595.025n

.meas tran vdout0_99ck1180 FIND v(dout0_99) AT=595.025n

.meas tran vdout0_100ck1180 FIND v(dout0_100) AT=595.025n

.meas tran vdout0_101ck1180 FIND v(dout0_101) AT=595.025n

.meas tran vdout0_102ck1180 FIND v(dout0_102) AT=595.025n

.meas tran vdout0_103ck1180 FIND v(dout0_103) AT=595.025n

.meas tran vdout0_104ck1180 FIND v(dout0_104) AT=595.025n

.meas tran vdout0_105ck1180 FIND v(dout0_105) AT=595.025n

.meas tran vdout0_106ck1180 FIND v(dout0_106) AT=595.025n

.meas tran vdout0_107ck1180 FIND v(dout0_107) AT=595.025n

.meas tran vdout0_108ck1180 FIND v(dout0_108) AT=595.025n

.meas tran vdout0_109ck1180 FIND v(dout0_109) AT=595.025n

.meas tran vdout0_110ck1180 FIND v(dout0_110) AT=595.025n

.meas tran vdout0_111ck1180 FIND v(dout0_111) AT=595.025n

.meas tran vdout0_112ck1180 FIND v(dout0_112) AT=595.025n

.meas tran vdout0_113ck1180 FIND v(dout0_113) AT=595.025n

.meas tran vdout0_114ck1180 FIND v(dout0_114) AT=595.025n

.meas tran vdout0_115ck1180 FIND v(dout0_115) AT=595.025n

.meas tran vdout0_116ck1180 FIND v(dout0_116) AT=595.025n

.meas tran vdout0_117ck1180 FIND v(dout0_117) AT=595.025n

.meas tran vdout0_118ck1180 FIND v(dout0_118) AT=595.025n

.meas tran vdout0_119ck1180 FIND v(dout0_119) AT=595.025n

.meas tran vdout0_120ck1180 FIND v(dout0_120) AT=595.025n

.meas tran vdout0_121ck1180 FIND v(dout0_121) AT=595.025n

.meas tran vdout0_122ck1180 FIND v(dout0_122) AT=595.025n

.meas tran vdout0_123ck1180 FIND v(dout0_123) AT=595.025n

.meas tran vdout0_124ck1180 FIND v(dout0_124) AT=595.025n

.meas tran vdout0_125ck1180 FIND v(dout0_125) AT=595.025n

.meas tran vdout0_126ck1180 FIND v(dout0_126) AT=595.025n

.meas tran vdout0_127ck1180 FIND v(dout0_127) AT=595.025n

.meas tran vdout0_128ck1180 FIND v(dout0_128) AT=595.025n

.meas tran vdout0_129ck1180 FIND v(dout0_129) AT=595.025n

.meas tran vdout0_130ck1180 FIND v(dout0_130) AT=595.025n

.meas tran vdout0_131ck1180 FIND v(dout0_131) AT=595.025n

.meas tran vdout0_132ck1180 FIND v(dout0_132) AT=595.025n

.meas tran vdout0_133ck1180 FIND v(dout0_133) AT=595.025n

.meas tran vdout0_134ck1180 FIND v(dout0_134) AT=595.025n

.meas tran vdout0_135ck1180 FIND v(dout0_135) AT=595.025n

.meas tran vdout0_136ck1180 FIND v(dout0_136) AT=595.025n

.meas tran vdout0_137ck1180 FIND v(dout0_137) AT=595.025n

.meas tran vdout0_138ck1180 FIND v(dout0_138) AT=595.025n

.meas tran vdout0_139ck1180 FIND v(dout0_139) AT=595.025n

.meas tran vdout0_140ck1180 FIND v(dout0_140) AT=595.025n

.meas tran vdout0_141ck1180 FIND v(dout0_141) AT=595.025n

.meas tran vdout0_142ck1180 FIND v(dout0_142) AT=595.025n

.meas tran vdout0_143ck1180 FIND v(dout0_143) AT=595.025n

.meas tran vdout0_144ck1180 FIND v(dout0_144) AT=595.025n

.meas tran vdout0_145ck1180 FIND v(dout0_145) AT=595.025n

.meas tran vdout0_146ck1180 FIND v(dout0_146) AT=595.025n

.meas tran vdout0_147ck1180 FIND v(dout0_147) AT=595.025n

.meas tran vdout0_148ck1180 FIND v(dout0_148) AT=595.025n

.meas tran vdout0_149ck1180 FIND v(dout0_149) AT=595.025n

.meas tran vdout0_150ck1180 FIND v(dout0_150) AT=595.025n

.meas tran vdout0_151ck1180 FIND v(dout0_151) AT=595.025n

.meas tran vdout0_152ck1180 FIND v(dout0_152) AT=595.025n

.meas tran vdout0_153ck1180 FIND v(dout0_153) AT=595.025n

.meas tran vdout0_154ck1180 FIND v(dout0_154) AT=595.025n

.meas tran vdout0_155ck1180 FIND v(dout0_155) AT=595.025n

.meas tran vdout0_156ck1180 FIND v(dout0_156) AT=595.025n

.meas tran vdout0_157ck1180 FIND v(dout0_157) AT=595.025n

.meas tran vdout0_158ck1180 FIND v(dout0_158) AT=595.025n

.meas tran vdout0_159ck1180 FIND v(dout0_159) AT=595.025n

.meas tran vdout0_160ck1180 FIND v(dout0_160) AT=595.025n

.meas tran vdout0_161ck1180 FIND v(dout0_161) AT=595.025n

.meas tran vdout0_162ck1180 FIND v(dout0_162) AT=595.025n

.meas tran vdout0_163ck1180 FIND v(dout0_163) AT=595.025n

.meas tran vdout0_164ck1180 FIND v(dout0_164) AT=595.025n

.meas tran vdout0_165ck1180 FIND v(dout0_165) AT=595.025n

.meas tran vdout0_166ck1180 FIND v(dout0_166) AT=595.025n

.meas tran vdout0_167ck1180 FIND v(dout0_167) AT=595.025n

.meas tran vdout0_168ck1180 FIND v(dout0_168) AT=595.025n

.meas tran vdout0_169ck1180 FIND v(dout0_169) AT=595.025n

.meas tran vdout0_170ck1180 FIND v(dout0_170) AT=595.025n

.meas tran vdout0_171ck1180 FIND v(dout0_171) AT=595.025n

.meas tran vdout0_172ck1180 FIND v(dout0_172) AT=595.025n

.meas tran vdout0_173ck1180 FIND v(dout0_173) AT=595.025n

.meas tran vdout0_174ck1180 FIND v(dout0_174) AT=595.025n

.meas tran vdout0_175ck1180 FIND v(dout0_175) AT=595.025n

.meas tran vdout0_176ck1180 FIND v(dout0_176) AT=595.025n

.meas tran vdout0_177ck1180 FIND v(dout0_177) AT=595.025n

.meas tran vdout0_178ck1180 FIND v(dout0_178) AT=595.025n

.meas tran vdout0_179ck1180 FIND v(dout0_179) AT=595.025n

.meas tran vdout0_180ck1180 FIND v(dout0_180) AT=595.025n

.meas tran vdout0_181ck1180 FIND v(dout0_181) AT=595.025n

.meas tran vdout0_182ck1180 FIND v(dout0_182) AT=595.025n

.meas tran vdout0_183ck1180 FIND v(dout0_183) AT=595.025n

.meas tran vdout0_184ck1180 FIND v(dout0_184) AT=595.025n

.meas tran vdout0_185ck1180 FIND v(dout0_185) AT=595.025n

.meas tran vdout0_186ck1180 FIND v(dout0_186) AT=595.025n

.meas tran vdout0_187ck1180 FIND v(dout0_187) AT=595.025n

.meas tran vdout0_188ck1180 FIND v(dout0_188) AT=595.025n

.meas tran vdout0_189ck1180 FIND v(dout0_189) AT=595.025n

.meas tran vdout0_190ck1180 FIND v(dout0_190) AT=595.025n

.meas tran vdout0_191ck1180 FIND v(dout0_191) AT=595.025n

.meas tran vdout0_192ck1180 FIND v(dout0_192) AT=595.025n

.meas tran vdout0_193ck1180 FIND v(dout0_193) AT=595.025n

.meas tran vdout0_194ck1180 FIND v(dout0_194) AT=595.025n

.meas tran vdout0_195ck1180 FIND v(dout0_195) AT=595.025n

.meas tran vdout0_196ck1180 FIND v(dout0_196) AT=595.025n

.meas tran vdout0_197ck1180 FIND v(dout0_197) AT=595.025n

.meas tran vdout0_198ck1180 FIND v(dout0_198) AT=595.025n

.meas tran vdout0_199ck1180 FIND v(dout0_199) AT=595.025n

.meas tran vdout0_200ck1180 FIND v(dout0_200) AT=595.025n

.meas tran vdout0_201ck1180 FIND v(dout0_201) AT=595.025n

.meas tran vdout0_202ck1180 FIND v(dout0_202) AT=595.025n

.meas tran vdout0_203ck1180 FIND v(dout0_203) AT=595.025n

.meas tran vdout0_204ck1180 FIND v(dout0_204) AT=595.025n

.meas tran vdout0_205ck1180 FIND v(dout0_205) AT=595.025n

.meas tran vdout0_206ck1180 FIND v(dout0_206) AT=595.025n

.meas tran vdout0_207ck1180 FIND v(dout0_207) AT=595.025n

.meas tran vdout0_208ck1180 FIND v(dout0_208) AT=595.025n

.meas tran vdout0_209ck1180 FIND v(dout0_209) AT=595.025n

.meas tran vdout0_210ck1180 FIND v(dout0_210) AT=595.025n

.meas tran vdout0_211ck1180 FIND v(dout0_211) AT=595.025n

.meas tran vdout0_212ck1180 FIND v(dout0_212) AT=595.025n

.meas tran vdout0_213ck1180 FIND v(dout0_213) AT=595.025n

.meas tran vdout0_214ck1180 FIND v(dout0_214) AT=595.025n

.meas tran vdout0_215ck1180 FIND v(dout0_215) AT=595.025n

.meas tran vdout0_216ck1180 FIND v(dout0_216) AT=595.025n

.meas tran vdout0_217ck1180 FIND v(dout0_217) AT=595.025n

.meas tran vdout0_218ck1180 FIND v(dout0_218) AT=595.025n

.meas tran vdout0_219ck1180 FIND v(dout0_219) AT=595.025n

.meas tran vdout0_220ck1180 FIND v(dout0_220) AT=595.025n

.meas tran vdout0_221ck1180 FIND v(dout0_221) AT=595.025n

.meas tran vdout0_222ck1180 FIND v(dout0_222) AT=595.025n

.meas tran vdout0_223ck1180 FIND v(dout0_223) AT=595.025n

.meas tran vdout0_224ck1180 FIND v(dout0_224) AT=595.025n

.meas tran vdout0_225ck1180 FIND v(dout0_225) AT=595.025n

.meas tran vdout0_226ck1180 FIND v(dout0_226) AT=595.025n

.meas tran vdout0_227ck1180 FIND v(dout0_227) AT=595.025n

.meas tran vdout0_228ck1180 FIND v(dout0_228) AT=595.025n

.meas tran vdout0_229ck1180 FIND v(dout0_229) AT=595.025n

.meas tran vdout0_230ck1180 FIND v(dout0_230) AT=595.025n

.meas tran vdout0_231ck1180 FIND v(dout0_231) AT=595.025n

.meas tran vdout0_232ck1180 FIND v(dout0_232) AT=595.025n

.meas tran vdout0_233ck1180 FIND v(dout0_233) AT=595.025n

.meas tran vdout0_234ck1180 FIND v(dout0_234) AT=595.025n

.meas tran vdout0_235ck1180 FIND v(dout0_235) AT=595.025n

.meas tran vdout0_236ck1180 FIND v(dout0_236) AT=595.025n

.meas tran vdout0_237ck1180 FIND v(dout0_237) AT=595.025n

.meas tran vdout0_238ck1180 FIND v(dout0_238) AT=595.025n

.meas tran vdout0_239ck1180 FIND v(dout0_239) AT=595.025n

.meas tran vdout0_240ck1180 FIND v(dout0_240) AT=595.025n

.meas tran vdout0_241ck1180 FIND v(dout0_241) AT=595.025n

.meas tran vdout0_242ck1180 FIND v(dout0_242) AT=595.025n

.meas tran vdout0_243ck1180 FIND v(dout0_243) AT=595.025n

.meas tran vdout0_244ck1180 FIND v(dout0_244) AT=595.025n

.meas tran vdout0_245ck1180 FIND v(dout0_245) AT=595.025n

.meas tran vdout0_246ck1180 FIND v(dout0_246) AT=595.025n

.meas tran vdout0_247ck1180 FIND v(dout0_247) AT=595.025n

.meas tran vdout0_248ck1180 FIND v(dout0_248) AT=595.025n

.meas tran vdout0_249ck1180 FIND v(dout0_249) AT=595.025n

.meas tran vdout0_250ck1180 FIND v(dout0_250) AT=595.025n

.meas tran vdout0_251ck1180 FIND v(dout0_251) AT=595.025n

.meas tran vdout0_252ck1180 FIND v(dout0_252) AT=595.025n

.meas tran vdout0_253ck1180 FIND v(dout0_253) AT=595.025n

.meas tran vdout0_254ck1180 FIND v(dout0_254) AT=595.025n

.meas tran vdout0_255ck1180 FIND v(dout0_255) AT=595.025n

.meas tran vdout0_0ck1200 FIND v(dout0_0) AT=605.025n

.meas tran vdout0_1ck1200 FIND v(dout0_1) AT=605.025n

.meas tran vdout0_2ck1200 FIND v(dout0_2) AT=605.025n

.meas tran vdout0_3ck1200 FIND v(dout0_3) AT=605.025n

.meas tran vdout0_4ck1200 FIND v(dout0_4) AT=605.025n

.meas tran vdout0_5ck1200 FIND v(dout0_5) AT=605.025n

.meas tran vdout0_6ck1200 FIND v(dout0_6) AT=605.025n

.meas tran vdout0_7ck1200 FIND v(dout0_7) AT=605.025n

.meas tran vdout0_8ck1200 FIND v(dout0_8) AT=605.025n

.meas tran vdout0_9ck1200 FIND v(dout0_9) AT=605.025n

.meas tran vdout0_10ck1200 FIND v(dout0_10) AT=605.025n

.meas tran vdout0_11ck1200 FIND v(dout0_11) AT=605.025n

.meas tran vdout0_12ck1200 FIND v(dout0_12) AT=605.025n

.meas tran vdout0_13ck1200 FIND v(dout0_13) AT=605.025n

.meas tran vdout0_14ck1200 FIND v(dout0_14) AT=605.025n

.meas tran vdout0_15ck1200 FIND v(dout0_15) AT=605.025n

.meas tran vdout0_16ck1200 FIND v(dout0_16) AT=605.025n

.meas tran vdout0_17ck1200 FIND v(dout0_17) AT=605.025n

.meas tran vdout0_18ck1200 FIND v(dout0_18) AT=605.025n

.meas tran vdout0_19ck1200 FIND v(dout0_19) AT=605.025n

.meas tran vdout0_20ck1200 FIND v(dout0_20) AT=605.025n

.meas tran vdout0_21ck1200 FIND v(dout0_21) AT=605.025n

.meas tran vdout0_22ck1200 FIND v(dout0_22) AT=605.025n

.meas tran vdout0_23ck1200 FIND v(dout0_23) AT=605.025n

.meas tran vdout0_24ck1200 FIND v(dout0_24) AT=605.025n

.meas tran vdout0_25ck1200 FIND v(dout0_25) AT=605.025n

.meas tran vdout0_26ck1200 FIND v(dout0_26) AT=605.025n

.meas tran vdout0_27ck1200 FIND v(dout0_27) AT=605.025n

.meas tran vdout0_28ck1200 FIND v(dout0_28) AT=605.025n

.meas tran vdout0_29ck1200 FIND v(dout0_29) AT=605.025n

.meas tran vdout0_30ck1200 FIND v(dout0_30) AT=605.025n

.meas tran vdout0_31ck1200 FIND v(dout0_31) AT=605.025n

.meas tran vdout0_32ck1200 FIND v(dout0_32) AT=605.025n

.meas tran vdout0_33ck1200 FIND v(dout0_33) AT=605.025n

.meas tran vdout0_34ck1200 FIND v(dout0_34) AT=605.025n

.meas tran vdout0_35ck1200 FIND v(dout0_35) AT=605.025n

.meas tran vdout0_36ck1200 FIND v(dout0_36) AT=605.025n

.meas tran vdout0_37ck1200 FIND v(dout0_37) AT=605.025n

.meas tran vdout0_38ck1200 FIND v(dout0_38) AT=605.025n

.meas tran vdout0_39ck1200 FIND v(dout0_39) AT=605.025n

.meas tran vdout0_40ck1200 FIND v(dout0_40) AT=605.025n

.meas tran vdout0_41ck1200 FIND v(dout0_41) AT=605.025n

.meas tran vdout0_42ck1200 FIND v(dout0_42) AT=605.025n

.meas tran vdout0_43ck1200 FIND v(dout0_43) AT=605.025n

.meas tran vdout0_44ck1200 FIND v(dout0_44) AT=605.025n

.meas tran vdout0_45ck1200 FIND v(dout0_45) AT=605.025n

.meas tran vdout0_46ck1200 FIND v(dout0_46) AT=605.025n

.meas tran vdout0_47ck1200 FIND v(dout0_47) AT=605.025n

.meas tran vdout0_48ck1200 FIND v(dout0_48) AT=605.025n

.meas tran vdout0_49ck1200 FIND v(dout0_49) AT=605.025n

.meas tran vdout0_50ck1200 FIND v(dout0_50) AT=605.025n

.meas tran vdout0_51ck1200 FIND v(dout0_51) AT=605.025n

.meas tran vdout0_52ck1200 FIND v(dout0_52) AT=605.025n

.meas tran vdout0_53ck1200 FIND v(dout0_53) AT=605.025n

.meas tran vdout0_54ck1200 FIND v(dout0_54) AT=605.025n

.meas tran vdout0_55ck1200 FIND v(dout0_55) AT=605.025n

.meas tran vdout0_56ck1200 FIND v(dout0_56) AT=605.025n

.meas tran vdout0_57ck1200 FIND v(dout0_57) AT=605.025n

.meas tran vdout0_58ck1200 FIND v(dout0_58) AT=605.025n

.meas tran vdout0_59ck1200 FIND v(dout0_59) AT=605.025n

.meas tran vdout0_60ck1200 FIND v(dout0_60) AT=605.025n

.meas tran vdout0_61ck1200 FIND v(dout0_61) AT=605.025n

.meas tran vdout0_62ck1200 FIND v(dout0_62) AT=605.025n

.meas tran vdout0_63ck1200 FIND v(dout0_63) AT=605.025n

.meas tran vdout0_64ck1200 FIND v(dout0_64) AT=605.025n

.meas tran vdout0_65ck1200 FIND v(dout0_65) AT=605.025n

.meas tran vdout0_66ck1200 FIND v(dout0_66) AT=605.025n

.meas tran vdout0_67ck1200 FIND v(dout0_67) AT=605.025n

.meas tran vdout0_68ck1200 FIND v(dout0_68) AT=605.025n

.meas tran vdout0_69ck1200 FIND v(dout0_69) AT=605.025n

.meas tran vdout0_70ck1200 FIND v(dout0_70) AT=605.025n

.meas tran vdout0_71ck1200 FIND v(dout0_71) AT=605.025n

.meas tran vdout0_72ck1200 FIND v(dout0_72) AT=605.025n

.meas tran vdout0_73ck1200 FIND v(dout0_73) AT=605.025n

.meas tran vdout0_74ck1200 FIND v(dout0_74) AT=605.025n

.meas tran vdout0_75ck1200 FIND v(dout0_75) AT=605.025n

.meas tran vdout0_76ck1200 FIND v(dout0_76) AT=605.025n

.meas tran vdout0_77ck1200 FIND v(dout0_77) AT=605.025n

.meas tran vdout0_78ck1200 FIND v(dout0_78) AT=605.025n

.meas tran vdout0_79ck1200 FIND v(dout0_79) AT=605.025n

.meas tran vdout0_80ck1200 FIND v(dout0_80) AT=605.025n

.meas tran vdout0_81ck1200 FIND v(dout0_81) AT=605.025n

.meas tran vdout0_82ck1200 FIND v(dout0_82) AT=605.025n

.meas tran vdout0_83ck1200 FIND v(dout0_83) AT=605.025n

.meas tran vdout0_84ck1200 FIND v(dout0_84) AT=605.025n

.meas tran vdout0_85ck1200 FIND v(dout0_85) AT=605.025n

.meas tran vdout0_86ck1200 FIND v(dout0_86) AT=605.025n

.meas tran vdout0_87ck1200 FIND v(dout0_87) AT=605.025n

.meas tran vdout0_88ck1200 FIND v(dout0_88) AT=605.025n

.meas tran vdout0_89ck1200 FIND v(dout0_89) AT=605.025n

.meas tran vdout0_90ck1200 FIND v(dout0_90) AT=605.025n

.meas tran vdout0_91ck1200 FIND v(dout0_91) AT=605.025n

.meas tran vdout0_92ck1200 FIND v(dout0_92) AT=605.025n

.meas tran vdout0_93ck1200 FIND v(dout0_93) AT=605.025n

.meas tran vdout0_94ck1200 FIND v(dout0_94) AT=605.025n

.meas tran vdout0_95ck1200 FIND v(dout0_95) AT=605.025n

.meas tran vdout0_96ck1200 FIND v(dout0_96) AT=605.025n

.meas tran vdout0_97ck1200 FIND v(dout0_97) AT=605.025n

.meas tran vdout0_98ck1200 FIND v(dout0_98) AT=605.025n

.meas tran vdout0_99ck1200 FIND v(dout0_99) AT=605.025n

.meas tran vdout0_100ck1200 FIND v(dout0_100) AT=605.025n

.meas tran vdout0_101ck1200 FIND v(dout0_101) AT=605.025n

.meas tran vdout0_102ck1200 FIND v(dout0_102) AT=605.025n

.meas tran vdout0_103ck1200 FIND v(dout0_103) AT=605.025n

.meas tran vdout0_104ck1200 FIND v(dout0_104) AT=605.025n

.meas tran vdout0_105ck1200 FIND v(dout0_105) AT=605.025n

.meas tran vdout0_106ck1200 FIND v(dout0_106) AT=605.025n

.meas tran vdout0_107ck1200 FIND v(dout0_107) AT=605.025n

.meas tran vdout0_108ck1200 FIND v(dout0_108) AT=605.025n

.meas tran vdout0_109ck1200 FIND v(dout0_109) AT=605.025n

.meas tran vdout0_110ck1200 FIND v(dout0_110) AT=605.025n

.meas tran vdout0_111ck1200 FIND v(dout0_111) AT=605.025n

.meas tran vdout0_112ck1200 FIND v(dout0_112) AT=605.025n

.meas tran vdout0_113ck1200 FIND v(dout0_113) AT=605.025n

.meas tran vdout0_114ck1200 FIND v(dout0_114) AT=605.025n

.meas tran vdout0_115ck1200 FIND v(dout0_115) AT=605.025n

.meas tran vdout0_116ck1200 FIND v(dout0_116) AT=605.025n

.meas tran vdout0_117ck1200 FIND v(dout0_117) AT=605.025n

.meas tran vdout0_118ck1200 FIND v(dout0_118) AT=605.025n

.meas tran vdout0_119ck1200 FIND v(dout0_119) AT=605.025n

.meas tran vdout0_120ck1200 FIND v(dout0_120) AT=605.025n

.meas tran vdout0_121ck1200 FIND v(dout0_121) AT=605.025n

.meas tran vdout0_122ck1200 FIND v(dout0_122) AT=605.025n

.meas tran vdout0_123ck1200 FIND v(dout0_123) AT=605.025n

.meas tran vdout0_124ck1200 FIND v(dout0_124) AT=605.025n

.meas tran vdout0_125ck1200 FIND v(dout0_125) AT=605.025n

.meas tran vdout0_126ck1200 FIND v(dout0_126) AT=605.025n

.meas tran vdout0_127ck1200 FIND v(dout0_127) AT=605.025n

.meas tran vdout0_128ck1200 FIND v(dout0_128) AT=605.025n

.meas tran vdout0_129ck1200 FIND v(dout0_129) AT=605.025n

.meas tran vdout0_130ck1200 FIND v(dout0_130) AT=605.025n

.meas tran vdout0_131ck1200 FIND v(dout0_131) AT=605.025n

.meas tran vdout0_132ck1200 FIND v(dout0_132) AT=605.025n

.meas tran vdout0_133ck1200 FIND v(dout0_133) AT=605.025n

.meas tran vdout0_134ck1200 FIND v(dout0_134) AT=605.025n

.meas tran vdout0_135ck1200 FIND v(dout0_135) AT=605.025n

.meas tran vdout0_136ck1200 FIND v(dout0_136) AT=605.025n

.meas tran vdout0_137ck1200 FIND v(dout0_137) AT=605.025n

.meas tran vdout0_138ck1200 FIND v(dout0_138) AT=605.025n

.meas tran vdout0_139ck1200 FIND v(dout0_139) AT=605.025n

.meas tran vdout0_140ck1200 FIND v(dout0_140) AT=605.025n

.meas tran vdout0_141ck1200 FIND v(dout0_141) AT=605.025n

.meas tran vdout0_142ck1200 FIND v(dout0_142) AT=605.025n

.meas tran vdout0_143ck1200 FIND v(dout0_143) AT=605.025n

.meas tran vdout0_144ck1200 FIND v(dout0_144) AT=605.025n

.meas tran vdout0_145ck1200 FIND v(dout0_145) AT=605.025n

.meas tran vdout0_146ck1200 FIND v(dout0_146) AT=605.025n

.meas tran vdout0_147ck1200 FIND v(dout0_147) AT=605.025n

.meas tran vdout0_148ck1200 FIND v(dout0_148) AT=605.025n

.meas tran vdout0_149ck1200 FIND v(dout0_149) AT=605.025n

.meas tran vdout0_150ck1200 FIND v(dout0_150) AT=605.025n

.meas tran vdout0_151ck1200 FIND v(dout0_151) AT=605.025n

.meas tran vdout0_152ck1200 FIND v(dout0_152) AT=605.025n

.meas tran vdout0_153ck1200 FIND v(dout0_153) AT=605.025n

.meas tran vdout0_154ck1200 FIND v(dout0_154) AT=605.025n

.meas tran vdout0_155ck1200 FIND v(dout0_155) AT=605.025n

.meas tran vdout0_156ck1200 FIND v(dout0_156) AT=605.025n

.meas tran vdout0_157ck1200 FIND v(dout0_157) AT=605.025n

.meas tran vdout0_158ck1200 FIND v(dout0_158) AT=605.025n

.meas tran vdout0_159ck1200 FIND v(dout0_159) AT=605.025n

.meas tran vdout0_160ck1200 FIND v(dout0_160) AT=605.025n

.meas tran vdout0_161ck1200 FIND v(dout0_161) AT=605.025n

.meas tran vdout0_162ck1200 FIND v(dout0_162) AT=605.025n

.meas tran vdout0_163ck1200 FIND v(dout0_163) AT=605.025n

.meas tran vdout0_164ck1200 FIND v(dout0_164) AT=605.025n

.meas tran vdout0_165ck1200 FIND v(dout0_165) AT=605.025n

.meas tran vdout0_166ck1200 FIND v(dout0_166) AT=605.025n

.meas tran vdout0_167ck1200 FIND v(dout0_167) AT=605.025n

.meas tran vdout0_168ck1200 FIND v(dout0_168) AT=605.025n

.meas tran vdout0_169ck1200 FIND v(dout0_169) AT=605.025n

.meas tran vdout0_170ck1200 FIND v(dout0_170) AT=605.025n

.meas tran vdout0_171ck1200 FIND v(dout0_171) AT=605.025n

.meas tran vdout0_172ck1200 FIND v(dout0_172) AT=605.025n

.meas tran vdout0_173ck1200 FIND v(dout0_173) AT=605.025n

.meas tran vdout0_174ck1200 FIND v(dout0_174) AT=605.025n

.meas tran vdout0_175ck1200 FIND v(dout0_175) AT=605.025n

.meas tran vdout0_176ck1200 FIND v(dout0_176) AT=605.025n

.meas tran vdout0_177ck1200 FIND v(dout0_177) AT=605.025n

.meas tran vdout0_178ck1200 FIND v(dout0_178) AT=605.025n

.meas tran vdout0_179ck1200 FIND v(dout0_179) AT=605.025n

.meas tran vdout0_180ck1200 FIND v(dout0_180) AT=605.025n

.meas tran vdout0_181ck1200 FIND v(dout0_181) AT=605.025n

.meas tran vdout0_182ck1200 FIND v(dout0_182) AT=605.025n

.meas tran vdout0_183ck1200 FIND v(dout0_183) AT=605.025n

.meas tran vdout0_184ck1200 FIND v(dout0_184) AT=605.025n

.meas tran vdout0_185ck1200 FIND v(dout0_185) AT=605.025n

.meas tran vdout0_186ck1200 FIND v(dout0_186) AT=605.025n

.meas tran vdout0_187ck1200 FIND v(dout0_187) AT=605.025n

.meas tran vdout0_188ck1200 FIND v(dout0_188) AT=605.025n

.meas tran vdout0_189ck1200 FIND v(dout0_189) AT=605.025n

.meas tran vdout0_190ck1200 FIND v(dout0_190) AT=605.025n

.meas tran vdout0_191ck1200 FIND v(dout0_191) AT=605.025n

.meas tran vdout0_192ck1200 FIND v(dout0_192) AT=605.025n

.meas tran vdout0_193ck1200 FIND v(dout0_193) AT=605.025n

.meas tran vdout0_194ck1200 FIND v(dout0_194) AT=605.025n

.meas tran vdout0_195ck1200 FIND v(dout0_195) AT=605.025n

.meas tran vdout0_196ck1200 FIND v(dout0_196) AT=605.025n

.meas tran vdout0_197ck1200 FIND v(dout0_197) AT=605.025n

.meas tran vdout0_198ck1200 FIND v(dout0_198) AT=605.025n

.meas tran vdout0_199ck1200 FIND v(dout0_199) AT=605.025n

.meas tran vdout0_200ck1200 FIND v(dout0_200) AT=605.025n

.meas tran vdout0_201ck1200 FIND v(dout0_201) AT=605.025n

.meas tran vdout0_202ck1200 FIND v(dout0_202) AT=605.025n

.meas tran vdout0_203ck1200 FIND v(dout0_203) AT=605.025n

.meas tran vdout0_204ck1200 FIND v(dout0_204) AT=605.025n

.meas tran vdout0_205ck1200 FIND v(dout0_205) AT=605.025n

.meas tran vdout0_206ck1200 FIND v(dout0_206) AT=605.025n

.meas tran vdout0_207ck1200 FIND v(dout0_207) AT=605.025n

.meas tran vdout0_208ck1200 FIND v(dout0_208) AT=605.025n

.meas tran vdout0_209ck1200 FIND v(dout0_209) AT=605.025n

.meas tran vdout0_210ck1200 FIND v(dout0_210) AT=605.025n

.meas tran vdout0_211ck1200 FIND v(dout0_211) AT=605.025n

.meas tran vdout0_212ck1200 FIND v(dout0_212) AT=605.025n

.meas tran vdout0_213ck1200 FIND v(dout0_213) AT=605.025n

.meas tran vdout0_214ck1200 FIND v(dout0_214) AT=605.025n

.meas tran vdout0_215ck1200 FIND v(dout0_215) AT=605.025n

.meas tran vdout0_216ck1200 FIND v(dout0_216) AT=605.025n

.meas tran vdout0_217ck1200 FIND v(dout0_217) AT=605.025n

.meas tran vdout0_218ck1200 FIND v(dout0_218) AT=605.025n

.meas tran vdout0_219ck1200 FIND v(dout0_219) AT=605.025n

.meas tran vdout0_220ck1200 FIND v(dout0_220) AT=605.025n

.meas tran vdout0_221ck1200 FIND v(dout0_221) AT=605.025n

.meas tran vdout0_222ck1200 FIND v(dout0_222) AT=605.025n

.meas tran vdout0_223ck1200 FIND v(dout0_223) AT=605.025n

.meas tran vdout0_224ck1200 FIND v(dout0_224) AT=605.025n

.meas tran vdout0_225ck1200 FIND v(dout0_225) AT=605.025n

.meas tran vdout0_226ck1200 FIND v(dout0_226) AT=605.025n

.meas tran vdout0_227ck1200 FIND v(dout0_227) AT=605.025n

.meas tran vdout0_228ck1200 FIND v(dout0_228) AT=605.025n

.meas tran vdout0_229ck1200 FIND v(dout0_229) AT=605.025n

.meas tran vdout0_230ck1200 FIND v(dout0_230) AT=605.025n

.meas tran vdout0_231ck1200 FIND v(dout0_231) AT=605.025n

.meas tran vdout0_232ck1200 FIND v(dout0_232) AT=605.025n

.meas tran vdout0_233ck1200 FIND v(dout0_233) AT=605.025n

.meas tran vdout0_234ck1200 FIND v(dout0_234) AT=605.025n

.meas tran vdout0_235ck1200 FIND v(dout0_235) AT=605.025n

.meas tran vdout0_236ck1200 FIND v(dout0_236) AT=605.025n

.meas tran vdout0_237ck1200 FIND v(dout0_237) AT=605.025n

.meas tran vdout0_238ck1200 FIND v(dout0_238) AT=605.025n

.meas tran vdout0_239ck1200 FIND v(dout0_239) AT=605.025n

.meas tran vdout0_240ck1200 FIND v(dout0_240) AT=605.025n

.meas tran vdout0_241ck1200 FIND v(dout0_241) AT=605.025n

.meas tran vdout0_242ck1200 FIND v(dout0_242) AT=605.025n

.meas tran vdout0_243ck1200 FIND v(dout0_243) AT=605.025n

.meas tran vdout0_244ck1200 FIND v(dout0_244) AT=605.025n

.meas tran vdout0_245ck1200 FIND v(dout0_245) AT=605.025n

.meas tran vdout0_246ck1200 FIND v(dout0_246) AT=605.025n

.meas tran vdout0_247ck1200 FIND v(dout0_247) AT=605.025n

.meas tran vdout0_248ck1200 FIND v(dout0_248) AT=605.025n

.meas tran vdout0_249ck1200 FIND v(dout0_249) AT=605.025n

.meas tran vdout0_250ck1200 FIND v(dout0_250) AT=605.025n

.meas tran vdout0_251ck1200 FIND v(dout0_251) AT=605.025n

.meas tran vdout0_252ck1200 FIND v(dout0_252) AT=605.025n

.meas tran vdout0_253ck1200 FIND v(dout0_253) AT=605.025n

.meas tran vdout0_254ck1200 FIND v(dout0_254) AT=605.025n

.meas tran vdout0_255ck1200 FIND v(dout0_255) AT=605.025n

.meas tran vdout0_0ck1210 FIND v(dout0_0) AT=610.025n

.meas tran vdout0_1ck1210 FIND v(dout0_1) AT=610.025n

.meas tran vdout0_2ck1210 FIND v(dout0_2) AT=610.025n

.meas tran vdout0_3ck1210 FIND v(dout0_3) AT=610.025n

.meas tran vdout0_4ck1210 FIND v(dout0_4) AT=610.025n

.meas tran vdout0_5ck1210 FIND v(dout0_5) AT=610.025n

.meas tran vdout0_6ck1210 FIND v(dout0_6) AT=610.025n

.meas tran vdout0_7ck1210 FIND v(dout0_7) AT=610.025n

.meas tran vdout0_8ck1210 FIND v(dout0_8) AT=610.025n

.meas tran vdout0_9ck1210 FIND v(dout0_9) AT=610.025n

.meas tran vdout0_10ck1210 FIND v(dout0_10) AT=610.025n

.meas tran vdout0_11ck1210 FIND v(dout0_11) AT=610.025n

.meas tran vdout0_12ck1210 FIND v(dout0_12) AT=610.025n

.meas tran vdout0_13ck1210 FIND v(dout0_13) AT=610.025n

.meas tran vdout0_14ck1210 FIND v(dout0_14) AT=610.025n

.meas tran vdout0_15ck1210 FIND v(dout0_15) AT=610.025n

.meas tran vdout0_16ck1210 FIND v(dout0_16) AT=610.025n

.meas tran vdout0_17ck1210 FIND v(dout0_17) AT=610.025n

.meas tran vdout0_18ck1210 FIND v(dout0_18) AT=610.025n

.meas tran vdout0_19ck1210 FIND v(dout0_19) AT=610.025n

.meas tran vdout0_20ck1210 FIND v(dout0_20) AT=610.025n

.meas tran vdout0_21ck1210 FIND v(dout0_21) AT=610.025n

.meas tran vdout0_22ck1210 FIND v(dout0_22) AT=610.025n

.meas tran vdout0_23ck1210 FIND v(dout0_23) AT=610.025n

.meas tran vdout0_24ck1210 FIND v(dout0_24) AT=610.025n

.meas tran vdout0_25ck1210 FIND v(dout0_25) AT=610.025n

.meas tran vdout0_26ck1210 FIND v(dout0_26) AT=610.025n

.meas tran vdout0_27ck1210 FIND v(dout0_27) AT=610.025n

.meas tran vdout0_28ck1210 FIND v(dout0_28) AT=610.025n

.meas tran vdout0_29ck1210 FIND v(dout0_29) AT=610.025n

.meas tran vdout0_30ck1210 FIND v(dout0_30) AT=610.025n

.meas tran vdout0_31ck1210 FIND v(dout0_31) AT=610.025n

.meas tran vdout0_32ck1210 FIND v(dout0_32) AT=610.025n

.meas tran vdout0_33ck1210 FIND v(dout0_33) AT=610.025n

.meas tran vdout0_34ck1210 FIND v(dout0_34) AT=610.025n

.meas tran vdout0_35ck1210 FIND v(dout0_35) AT=610.025n

.meas tran vdout0_36ck1210 FIND v(dout0_36) AT=610.025n

.meas tran vdout0_37ck1210 FIND v(dout0_37) AT=610.025n

.meas tran vdout0_38ck1210 FIND v(dout0_38) AT=610.025n

.meas tran vdout0_39ck1210 FIND v(dout0_39) AT=610.025n

.meas tran vdout0_40ck1210 FIND v(dout0_40) AT=610.025n

.meas tran vdout0_41ck1210 FIND v(dout0_41) AT=610.025n

.meas tran vdout0_42ck1210 FIND v(dout0_42) AT=610.025n

.meas tran vdout0_43ck1210 FIND v(dout0_43) AT=610.025n

.meas tran vdout0_44ck1210 FIND v(dout0_44) AT=610.025n

.meas tran vdout0_45ck1210 FIND v(dout0_45) AT=610.025n

.meas tran vdout0_46ck1210 FIND v(dout0_46) AT=610.025n

.meas tran vdout0_47ck1210 FIND v(dout0_47) AT=610.025n

.meas tran vdout0_48ck1210 FIND v(dout0_48) AT=610.025n

.meas tran vdout0_49ck1210 FIND v(dout0_49) AT=610.025n

.meas tran vdout0_50ck1210 FIND v(dout0_50) AT=610.025n

.meas tran vdout0_51ck1210 FIND v(dout0_51) AT=610.025n

.meas tran vdout0_52ck1210 FIND v(dout0_52) AT=610.025n

.meas tran vdout0_53ck1210 FIND v(dout0_53) AT=610.025n

.meas tran vdout0_54ck1210 FIND v(dout0_54) AT=610.025n

.meas tran vdout0_55ck1210 FIND v(dout0_55) AT=610.025n

.meas tran vdout0_56ck1210 FIND v(dout0_56) AT=610.025n

.meas tran vdout0_57ck1210 FIND v(dout0_57) AT=610.025n

.meas tran vdout0_58ck1210 FIND v(dout0_58) AT=610.025n

.meas tran vdout0_59ck1210 FIND v(dout0_59) AT=610.025n

.meas tran vdout0_60ck1210 FIND v(dout0_60) AT=610.025n

.meas tran vdout0_61ck1210 FIND v(dout0_61) AT=610.025n

.meas tran vdout0_62ck1210 FIND v(dout0_62) AT=610.025n

.meas tran vdout0_63ck1210 FIND v(dout0_63) AT=610.025n

.meas tran vdout0_64ck1210 FIND v(dout0_64) AT=610.025n

.meas tran vdout0_65ck1210 FIND v(dout0_65) AT=610.025n

.meas tran vdout0_66ck1210 FIND v(dout0_66) AT=610.025n

.meas tran vdout0_67ck1210 FIND v(dout0_67) AT=610.025n

.meas tran vdout0_68ck1210 FIND v(dout0_68) AT=610.025n

.meas tran vdout0_69ck1210 FIND v(dout0_69) AT=610.025n

.meas tran vdout0_70ck1210 FIND v(dout0_70) AT=610.025n

.meas tran vdout0_71ck1210 FIND v(dout0_71) AT=610.025n

.meas tran vdout0_72ck1210 FIND v(dout0_72) AT=610.025n

.meas tran vdout0_73ck1210 FIND v(dout0_73) AT=610.025n

.meas tran vdout0_74ck1210 FIND v(dout0_74) AT=610.025n

.meas tran vdout0_75ck1210 FIND v(dout0_75) AT=610.025n

.meas tran vdout0_76ck1210 FIND v(dout0_76) AT=610.025n

.meas tran vdout0_77ck1210 FIND v(dout0_77) AT=610.025n

.meas tran vdout0_78ck1210 FIND v(dout0_78) AT=610.025n

.meas tran vdout0_79ck1210 FIND v(dout0_79) AT=610.025n

.meas tran vdout0_80ck1210 FIND v(dout0_80) AT=610.025n

.meas tran vdout0_81ck1210 FIND v(dout0_81) AT=610.025n

.meas tran vdout0_82ck1210 FIND v(dout0_82) AT=610.025n

.meas tran vdout0_83ck1210 FIND v(dout0_83) AT=610.025n

.meas tran vdout0_84ck1210 FIND v(dout0_84) AT=610.025n

.meas tran vdout0_85ck1210 FIND v(dout0_85) AT=610.025n

.meas tran vdout0_86ck1210 FIND v(dout0_86) AT=610.025n

.meas tran vdout0_87ck1210 FIND v(dout0_87) AT=610.025n

.meas tran vdout0_88ck1210 FIND v(dout0_88) AT=610.025n

.meas tran vdout0_89ck1210 FIND v(dout0_89) AT=610.025n

.meas tran vdout0_90ck1210 FIND v(dout0_90) AT=610.025n

.meas tran vdout0_91ck1210 FIND v(dout0_91) AT=610.025n

.meas tran vdout0_92ck1210 FIND v(dout0_92) AT=610.025n

.meas tran vdout0_93ck1210 FIND v(dout0_93) AT=610.025n

.meas tran vdout0_94ck1210 FIND v(dout0_94) AT=610.025n

.meas tran vdout0_95ck1210 FIND v(dout0_95) AT=610.025n

.meas tran vdout0_96ck1210 FIND v(dout0_96) AT=610.025n

.meas tran vdout0_97ck1210 FIND v(dout0_97) AT=610.025n

.meas tran vdout0_98ck1210 FIND v(dout0_98) AT=610.025n

.meas tran vdout0_99ck1210 FIND v(dout0_99) AT=610.025n

.meas tran vdout0_100ck1210 FIND v(dout0_100) AT=610.025n

.meas tran vdout0_101ck1210 FIND v(dout0_101) AT=610.025n

.meas tran vdout0_102ck1210 FIND v(dout0_102) AT=610.025n

.meas tran vdout0_103ck1210 FIND v(dout0_103) AT=610.025n

.meas tran vdout0_104ck1210 FIND v(dout0_104) AT=610.025n

.meas tran vdout0_105ck1210 FIND v(dout0_105) AT=610.025n

.meas tran vdout0_106ck1210 FIND v(dout0_106) AT=610.025n

.meas tran vdout0_107ck1210 FIND v(dout0_107) AT=610.025n

.meas tran vdout0_108ck1210 FIND v(dout0_108) AT=610.025n

.meas tran vdout0_109ck1210 FIND v(dout0_109) AT=610.025n

.meas tran vdout0_110ck1210 FIND v(dout0_110) AT=610.025n

.meas tran vdout0_111ck1210 FIND v(dout0_111) AT=610.025n

.meas tran vdout0_112ck1210 FIND v(dout0_112) AT=610.025n

.meas tran vdout0_113ck1210 FIND v(dout0_113) AT=610.025n

.meas tran vdout0_114ck1210 FIND v(dout0_114) AT=610.025n

.meas tran vdout0_115ck1210 FIND v(dout0_115) AT=610.025n

.meas tran vdout0_116ck1210 FIND v(dout0_116) AT=610.025n

.meas tran vdout0_117ck1210 FIND v(dout0_117) AT=610.025n

.meas tran vdout0_118ck1210 FIND v(dout0_118) AT=610.025n

.meas tran vdout0_119ck1210 FIND v(dout0_119) AT=610.025n

.meas tran vdout0_120ck1210 FIND v(dout0_120) AT=610.025n

.meas tran vdout0_121ck1210 FIND v(dout0_121) AT=610.025n

.meas tran vdout0_122ck1210 FIND v(dout0_122) AT=610.025n

.meas tran vdout0_123ck1210 FIND v(dout0_123) AT=610.025n

.meas tran vdout0_124ck1210 FIND v(dout0_124) AT=610.025n

.meas tran vdout0_125ck1210 FIND v(dout0_125) AT=610.025n

.meas tran vdout0_126ck1210 FIND v(dout0_126) AT=610.025n

.meas tran vdout0_127ck1210 FIND v(dout0_127) AT=610.025n

.meas tran vdout0_128ck1210 FIND v(dout0_128) AT=610.025n

.meas tran vdout0_129ck1210 FIND v(dout0_129) AT=610.025n

.meas tran vdout0_130ck1210 FIND v(dout0_130) AT=610.025n

.meas tran vdout0_131ck1210 FIND v(dout0_131) AT=610.025n

.meas tran vdout0_132ck1210 FIND v(dout0_132) AT=610.025n

.meas tran vdout0_133ck1210 FIND v(dout0_133) AT=610.025n

.meas tran vdout0_134ck1210 FIND v(dout0_134) AT=610.025n

.meas tran vdout0_135ck1210 FIND v(dout0_135) AT=610.025n

.meas tran vdout0_136ck1210 FIND v(dout0_136) AT=610.025n

.meas tran vdout0_137ck1210 FIND v(dout0_137) AT=610.025n

.meas tran vdout0_138ck1210 FIND v(dout0_138) AT=610.025n

.meas tran vdout0_139ck1210 FIND v(dout0_139) AT=610.025n

.meas tran vdout0_140ck1210 FIND v(dout0_140) AT=610.025n

.meas tran vdout0_141ck1210 FIND v(dout0_141) AT=610.025n

.meas tran vdout0_142ck1210 FIND v(dout0_142) AT=610.025n

.meas tran vdout0_143ck1210 FIND v(dout0_143) AT=610.025n

.meas tran vdout0_144ck1210 FIND v(dout0_144) AT=610.025n

.meas tran vdout0_145ck1210 FIND v(dout0_145) AT=610.025n

.meas tran vdout0_146ck1210 FIND v(dout0_146) AT=610.025n

.meas tran vdout0_147ck1210 FIND v(dout0_147) AT=610.025n

.meas tran vdout0_148ck1210 FIND v(dout0_148) AT=610.025n

.meas tran vdout0_149ck1210 FIND v(dout0_149) AT=610.025n

.meas tran vdout0_150ck1210 FIND v(dout0_150) AT=610.025n

.meas tran vdout0_151ck1210 FIND v(dout0_151) AT=610.025n

.meas tran vdout0_152ck1210 FIND v(dout0_152) AT=610.025n

.meas tran vdout0_153ck1210 FIND v(dout0_153) AT=610.025n

.meas tran vdout0_154ck1210 FIND v(dout0_154) AT=610.025n

.meas tran vdout0_155ck1210 FIND v(dout0_155) AT=610.025n

.meas tran vdout0_156ck1210 FIND v(dout0_156) AT=610.025n

.meas tran vdout0_157ck1210 FIND v(dout0_157) AT=610.025n

.meas tran vdout0_158ck1210 FIND v(dout0_158) AT=610.025n

.meas tran vdout0_159ck1210 FIND v(dout0_159) AT=610.025n

.meas tran vdout0_160ck1210 FIND v(dout0_160) AT=610.025n

.meas tran vdout0_161ck1210 FIND v(dout0_161) AT=610.025n

.meas tran vdout0_162ck1210 FIND v(dout0_162) AT=610.025n

.meas tran vdout0_163ck1210 FIND v(dout0_163) AT=610.025n

.meas tran vdout0_164ck1210 FIND v(dout0_164) AT=610.025n

.meas tran vdout0_165ck1210 FIND v(dout0_165) AT=610.025n

.meas tran vdout0_166ck1210 FIND v(dout0_166) AT=610.025n

.meas tran vdout0_167ck1210 FIND v(dout0_167) AT=610.025n

.meas tran vdout0_168ck1210 FIND v(dout0_168) AT=610.025n

.meas tran vdout0_169ck1210 FIND v(dout0_169) AT=610.025n

.meas tran vdout0_170ck1210 FIND v(dout0_170) AT=610.025n

.meas tran vdout0_171ck1210 FIND v(dout0_171) AT=610.025n

.meas tran vdout0_172ck1210 FIND v(dout0_172) AT=610.025n

.meas tran vdout0_173ck1210 FIND v(dout0_173) AT=610.025n

.meas tran vdout0_174ck1210 FIND v(dout0_174) AT=610.025n

.meas tran vdout0_175ck1210 FIND v(dout0_175) AT=610.025n

.meas tran vdout0_176ck1210 FIND v(dout0_176) AT=610.025n

.meas tran vdout0_177ck1210 FIND v(dout0_177) AT=610.025n

.meas tran vdout0_178ck1210 FIND v(dout0_178) AT=610.025n

.meas tran vdout0_179ck1210 FIND v(dout0_179) AT=610.025n

.meas tran vdout0_180ck1210 FIND v(dout0_180) AT=610.025n

.meas tran vdout0_181ck1210 FIND v(dout0_181) AT=610.025n

.meas tran vdout0_182ck1210 FIND v(dout0_182) AT=610.025n

.meas tran vdout0_183ck1210 FIND v(dout0_183) AT=610.025n

.meas tran vdout0_184ck1210 FIND v(dout0_184) AT=610.025n

.meas tran vdout0_185ck1210 FIND v(dout0_185) AT=610.025n

.meas tran vdout0_186ck1210 FIND v(dout0_186) AT=610.025n

.meas tran vdout0_187ck1210 FIND v(dout0_187) AT=610.025n

.meas tran vdout0_188ck1210 FIND v(dout0_188) AT=610.025n

.meas tran vdout0_189ck1210 FIND v(dout0_189) AT=610.025n

.meas tran vdout0_190ck1210 FIND v(dout0_190) AT=610.025n

.meas tran vdout0_191ck1210 FIND v(dout0_191) AT=610.025n

.meas tran vdout0_192ck1210 FIND v(dout0_192) AT=610.025n

.meas tran vdout0_193ck1210 FIND v(dout0_193) AT=610.025n

.meas tran vdout0_194ck1210 FIND v(dout0_194) AT=610.025n

.meas tran vdout0_195ck1210 FIND v(dout0_195) AT=610.025n

.meas tran vdout0_196ck1210 FIND v(dout0_196) AT=610.025n

.meas tran vdout0_197ck1210 FIND v(dout0_197) AT=610.025n

.meas tran vdout0_198ck1210 FIND v(dout0_198) AT=610.025n

.meas tran vdout0_199ck1210 FIND v(dout0_199) AT=610.025n

.meas tran vdout0_200ck1210 FIND v(dout0_200) AT=610.025n

.meas tran vdout0_201ck1210 FIND v(dout0_201) AT=610.025n

.meas tran vdout0_202ck1210 FIND v(dout0_202) AT=610.025n

.meas tran vdout0_203ck1210 FIND v(dout0_203) AT=610.025n

.meas tran vdout0_204ck1210 FIND v(dout0_204) AT=610.025n

.meas tran vdout0_205ck1210 FIND v(dout0_205) AT=610.025n

.meas tran vdout0_206ck1210 FIND v(dout0_206) AT=610.025n

.meas tran vdout0_207ck1210 FIND v(dout0_207) AT=610.025n

.meas tran vdout0_208ck1210 FIND v(dout0_208) AT=610.025n

.meas tran vdout0_209ck1210 FIND v(dout0_209) AT=610.025n

.meas tran vdout0_210ck1210 FIND v(dout0_210) AT=610.025n

.meas tran vdout0_211ck1210 FIND v(dout0_211) AT=610.025n

.meas tran vdout0_212ck1210 FIND v(dout0_212) AT=610.025n

.meas tran vdout0_213ck1210 FIND v(dout0_213) AT=610.025n

.meas tran vdout0_214ck1210 FIND v(dout0_214) AT=610.025n

.meas tran vdout0_215ck1210 FIND v(dout0_215) AT=610.025n

.meas tran vdout0_216ck1210 FIND v(dout0_216) AT=610.025n

.meas tran vdout0_217ck1210 FIND v(dout0_217) AT=610.025n

.meas tran vdout0_218ck1210 FIND v(dout0_218) AT=610.025n

.meas tran vdout0_219ck1210 FIND v(dout0_219) AT=610.025n

.meas tran vdout0_220ck1210 FIND v(dout0_220) AT=610.025n

.meas tran vdout0_221ck1210 FIND v(dout0_221) AT=610.025n

.meas tran vdout0_222ck1210 FIND v(dout0_222) AT=610.025n

.meas tran vdout0_223ck1210 FIND v(dout0_223) AT=610.025n

.meas tran vdout0_224ck1210 FIND v(dout0_224) AT=610.025n

.meas tran vdout0_225ck1210 FIND v(dout0_225) AT=610.025n

.meas tran vdout0_226ck1210 FIND v(dout0_226) AT=610.025n

.meas tran vdout0_227ck1210 FIND v(dout0_227) AT=610.025n

.meas tran vdout0_228ck1210 FIND v(dout0_228) AT=610.025n

.meas tran vdout0_229ck1210 FIND v(dout0_229) AT=610.025n

.meas tran vdout0_230ck1210 FIND v(dout0_230) AT=610.025n

.meas tran vdout0_231ck1210 FIND v(dout0_231) AT=610.025n

.meas tran vdout0_232ck1210 FIND v(dout0_232) AT=610.025n

.meas tran vdout0_233ck1210 FIND v(dout0_233) AT=610.025n

.meas tran vdout0_234ck1210 FIND v(dout0_234) AT=610.025n

.meas tran vdout0_235ck1210 FIND v(dout0_235) AT=610.025n

.meas tran vdout0_236ck1210 FIND v(dout0_236) AT=610.025n

.meas tran vdout0_237ck1210 FIND v(dout0_237) AT=610.025n

.meas tran vdout0_238ck1210 FIND v(dout0_238) AT=610.025n

.meas tran vdout0_239ck1210 FIND v(dout0_239) AT=610.025n

.meas tran vdout0_240ck1210 FIND v(dout0_240) AT=610.025n

.meas tran vdout0_241ck1210 FIND v(dout0_241) AT=610.025n

.meas tran vdout0_242ck1210 FIND v(dout0_242) AT=610.025n

.meas tran vdout0_243ck1210 FIND v(dout0_243) AT=610.025n

.meas tran vdout0_244ck1210 FIND v(dout0_244) AT=610.025n

.meas tran vdout0_245ck1210 FIND v(dout0_245) AT=610.025n

.meas tran vdout0_246ck1210 FIND v(dout0_246) AT=610.025n

.meas tran vdout0_247ck1210 FIND v(dout0_247) AT=610.025n

.meas tran vdout0_248ck1210 FIND v(dout0_248) AT=610.025n

.meas tran vdout0_249ck1210 FIND v(dout0_249) AT=610.025n

.meas tran vdout0_250ck1210 FIND v(dout0_250) AT=610.025n

.meas tran vdout0_251ck1210 FIND v(dout0_251) AT=610.025n

.meas tran vdout0_252ck1210 FIND v(dout0_252) AT=610.025n

.meas tran vdout0_253ck1210 FIND v(dout0_253) AT=610.025n

.meas tran vdout0_254ck1210 FIND v(dout0_254) AT=610.025n

.meas tran vdout0_255ck1210 FIND v(dout0_255) AT=610.025n

.meas tran vdout0_0ck1220 FIND v(dout0_0) AT=615.025n

.meas tran vdout0_1ck1220 FIND v(dout0_1) AT=615.025n

.meas tran vdout0_2ck1220 FIND v(dout0_2) AT=615.025n

.meas tran vdout0_3ck1220 FIND v(dout0_3) AT=615.025n

.meas tran vdout0_4ck1220 FIND v(dout0_4) AT=615.025n

.meas tran vdout0_5ck1220 FIND v(dout0_5) AT=615.025n

.meas tran vdout0_6ck1220 FIND v(dout0_6) AT=615.025n

.meas tran vdout0_7ck1220 FIND v(dout0_7) AT=615.025n

.meas tran vdout0_8ck1220 FIND v(dout0_8) AT=615.025n

.meas tran vdout0_9ck1220 FIND v(dout0_9) AT=615.025n

.meas tran vdout0_10ck1220 FIND v(dout0_10) AT=615.025n

.meas tran vdout0_11ck1220 FIND v(dout0_11) AT=615.025n

.meas tran vdout0_12ck1220 FIND v(dout0_12) AT=615.025n

.meas tran vdout0_13ck1220 FIND v(dout0_13) AT=615.025n

.meas tran vdout0_14ck1220 FIND v(dout0_14) AT=615.025n

.meas tran vdout0_15ck1220 FIND v(dout0_15) AT=615.025n

.meas tran vdout0_16ck1220 FIND v(dout0_16) AT=615.025n

.meas tran vdout0_17ck1220 FIND v(dout0_17) AT=615.025n

.meas tran vdout0_18ck1220 FIND v(dout0_18) AT=615.025n

.meas tran vdout0_19ck1220 FIND v(dout0_19) AT=615.025n

.meas tran vdout0_20ck1220 FIND v(dout0_20) AT=615.025n

.meas tran vdout0_21ck1220 FIND v(dout0_21) AT=615.025n

.meas tran vdout0_22ck1220 FIND v(dout0_22) AT=615.025n

.meas tran vdout0_23ck1220 FIND v(dout0_23) AT=615.025n

.meas tran vdout0_24ck1220 FIND v(dout0_24) AT=615.025n

.meas tran vdout0_25ck1220 FIND v(dout0_25) AT=615.025n

.meas tran vdout0_26ck1220 FIND v(dout0_26) AT=615.025n

.meas tran vdout0_27ck1220 FIND v(dout0_27) AT=615.025n

.meas tran vdout0_28ck1220 FIND v(dout0_28) AT=615.025n

.meas tran vdout0_29ck1220 FIND v(dout0_29) AT=615.025n

.meas tran vdout0_30ck1220 FIND v(dout0_30) AT=615.025n

.meas tran vdout0_31ck1220 FIND v(dout0_31) AT=615.025n

.meas tran vdout0_32ck1220 FIND v(dout0_32) AT=615.025n

.meas tran vdout0_33ck1220 FIND v(dout0_33) AT=615.025n

.meas tran vdout0_34ck1220 FIND v(dout0_34) AT=615.025n

.meas tran vdout0_35ck1220 FIND v(dout0_35) AT=615.025n

.meas tran vdout0_36ck1220 FIND v(dout0_36) AT=615.025n

.meas tran vdout0_37ck1220 FIND v(dout0_37) AT=615.025n

.meas tran vdout0_38ck1220 FIND v(dout0_38) AT=615.025n

.meas tran vdout0_39ck1220 FIND v(dout0_39) AT=615.025n

.meas tran vdout0_40ck1220 FIND v(dout0_40) AT=615.025n

.meas tran vdout0_41ck1220 FIND v(dout0_41) AT=615.025n

.meas tran vdout0_42ck1220 FIND v(dout0_42) AT=615.025n

.meas tran vdout0_43ck1220 FIND v(dout0_43) AT=615.025n

.meas tran vdout0_44ck1220 FIND v(dout0_44) AT=615.025n

.meas tran vdout0_45ck1220 FIND v(dout0_45) AT=615.025n

.meas tran vdout0_46ck1220 FIND v(dout0_46) AT=615.025n

.meas tran vdout0_47ck1220 FIND v(dout0_47) AT=615.025n

.meas tran vdout0_48ck1220 FIND v(dout0_48) AT=615.025n

.meas tran vdout0_49ck1220 FIND v(dout0_49) AT=615.025n

.meas tran vdout0_50ck1220 FIND v(dout0_50) AT=615.025n

.meas tran vdout0_51ck1220 FIND v(dout0_51) AT=615.025n

.meas tran vdout0_52ck1220 FIND v(dout0_52) AT=615.025n

.meas tran vdout0_53ck1220 FIND v(dout0_53) AT=615.025n

.meas tran vdout0_54ck1220 FIND v(dout0_54) AT=615.025n

.meas tran vdout0_55ck1220 FIND v(dout0_55) AT=615.025n

.meas tran vdout0_56ck1220 FIND v(dout0_56) AT=615.025n

.meas tran vdout0_57ck1220 FIND v(dout0_57) AT=615.025n

.meas tran vdout0_58ck1220 FIND v(dout0_58) AT=615.025n

.meas tran vdout0_59ck1220 FIND v(dout0_59) AT=615.025n

.meas tran vdout0_60ck1220 FIND v(dout0_60) AT=615.025n

.meas tran vdout0_61ck1220 FIND v(dout0_61) AT=615.025n

.meas tran vdout0_62ck1220 FIND v(dout0_62) AT=615.025n

.meas tran vdout0_63ck1220 FIND v(dout0_63) AT=615.025n

.meas tran vdout0_64ck1220 FIND v(dout0_64) AT=615.025n

.meas tran vdout0_65ck1220 FIND v(dout0_65) AT=615.025n

.meas tran vdout0_66ck1220 FIND v(dout0_66) AT=615.025n

.meas tran vdout0_67ck1220 FIND v(dout0_67) AT=615.025n

.meas tran vdout0_68ck1220 FIND v(dout0_68) AT=615.025n

.meas tran vdout0_69ck1220 FIND v(dout0_69) AT=615.025n

.meas tran vdout0_70ck1220 FIND v(dout0_70) AT=615.025n

.meas tran vdout0_71ck1220 FIND v(dout0_71) AT=615.025n

.meas tran vdout0_72ck1220 FIND v(dout0_72) AT=615.025n

.meas tran vdout0_73ck1220 FIND v(dout0_73) AT=615.025n

.meas tran vdout0_74ck1220 FIND v(dout0_74) AT=615.025n

.meas tran vdout0_75ck1220 FIND v(dout0_75) AT=615.025n

.meas tran vdout0_76ck1220 FIND v(dout0_76) AT=615.025n

.meas tran vdout0_77ck1220 FIND v(dout0_77) AT=615.025n

.meas tran vdout0_78ck1220 FIND v(dout0_78) AT=615.025n

.meas tran vdout0_79ck1220 FIND v(dout0_79) AT=615.025n

.meas tran vdout0_80ck1220 FIND v(dout0_80) AT=615.025n

.meas tran vdout0_81ck1220 FIND v(dout0_81) AT=615.025n

.meas tran vdout0_82ck1220 FIND v(dout0_82) AT=615.025n

.meas tran vdout0_83ck1220 FIND v(dout0_83) AT=615.025n

.meas tran vdout0_84ck1220 FIND v(dout0_84) AT=615.025n

.meas tran vdout0_85ck1220 FIND v(dout0_85) AT=615.025n

.meas tran vdout0_86ck1220 FIND v(dout0_86) AT=615.025n

.meas tran vdout0_87ck1220 FIND v(dout0_87) AT=615.025n

.meas tran vdout0_88ck1220 FIND v(dout0_88) AT=615.025n

.meas tran vdout0_89ck1220 FIND v(dout0_89) AT=615.025n

.meas tran vdout0_90ck1220 FIND v(dout0_90) AT=615.025n

.meas tran vdout0_91ck1220 FIND v(dout0_91) AT=615.025n

.meas tran vdout0_92ck1220 FIND v(dout0_92) AT=615.025n

.meas tran vdout0_93ck1220 FIND v(dout0_93) AT=615.025n

.meas tran vdout0_94ck1220 FIND v(dout0_94) AT=615.025n

.meas tran vdout0_95ck1220 FIND v(dout0_95) AT=615.025n

.meas tran vdout0_96ck1220 FIND v(dout0_96) AT=615.025n

.meas tran vdout0_97ck1220 FIND v(dout0_97) AT=615.025n

.meas tran vdout0_98ck1220 FIND v(dout0_98) AT=615.025n

.meas tran vdout0_99ck1220 FIND v(dout0_99) AT=615.025n

.meas tran vdout0_100ck1220 FIND v(dout0_100) AT=615.025n

.meas tran vdout0_101ck1220 FIND v(dout0_101) AT=615.025n

.meas tran vdout0_102ck1220 FIND v(dout0_102) AT=615.025n

.meas tran vdout0_103ck1220 FIND v(dout0_103) AT=615.025n

.meas tran vdout0_104ck1220 FIND v(dout0_104) AT=615.025n

.meas tran vdout0_105ck1220 FIND v(dout0_105) AT=615.025n

.meas tran vdout0_106ck1220 FIND v(dout0_106) AT=615.025n

.meas tran vdout0_107ck1220 FIND v(dout0_107) AT=615.025n

.meas tran vdout0_108ck1220 FIND v(dout0_108) AT=615.025n

.meas tran vdout0_109ck1220 FIND v(dout0_109) AT=615.025n

.meas tran vdout0_110ck1220 FIND v(dout0_110) AT=615.025n

.meas tran vdout0_111ck1220 FIND v(dout0_111) AT=615.025n

.meas tran vdout0_112ck1220 FIND v(dout0_112) AT=615.025n

.meas tran vdout0_113ck1220 FIND v(dout0_113) AT=615.025n

.meas tran vdout0_114ck1220 FIND v(dout0_114) AT=615.025n

.meas tran vdout0_115ck1220 FIND v(dout0_115) AT=615.025n

.meas tran vdout0_116ck1220 FIND v(dout0_116) AT=615.025n

.meas tran vdout0_117ck1220 FIND v(dout0_117) AT=615.025n

.meas tran vdout0_118ck1220 FIND v(dout0_118) AT=615.025n

.meas tran vdout0_119ck1220 FIND v(dout0_119) AT=615.025n

.meas tran vdout0_120ck1220 FIND v(dout0_120) AT=615.025n

.meas tran vdout0_121ck1220 FIND v(dout0_121) AT=615.025n

.meas tran vdout0_122ck1220 FIND v(dout0_122) AT=615.025n

.meas tran vdout0_123ck1220 FIND v(dout0_123) AT=615.025n

.meas tran vdout0_124ck1220 FIND v(dout0_124) AT=615.025n

.meas tran vdout0_125ck1220 FIND v(dout0_125) AT=615.025n

.meas tran vdout0_126ck1220 FIND v(dout0_126) AT=615.025n

.meas tran vdout0_127ck1220 FIND v(dout0_127) AT=615.025n

.meas tran vdout0_128ck1220 FIND v(dout0_128) AT=615.025n

.meas tran vdout0_129ck1220 FIND v(dout0_129) AT=615.025n

.meas tran vdout0_130ck1220 FIND v(dout0_130) AT=615.025n

.meas tran vdout0_131ck1220 FIND v(dout0_131) AT=615.025n

.meas tran vdout0_132ck1220 FIND v(dout0_132) AT=615.025n

.meas tran vdout0_133ck1220 FIND v(dout0_133) AT=615.025n

.meas tran vdout0_134ck1220 FIND v(dout0_134) AT=615.025n

.meas tran vdout0_135ck1220 FIND v(dout0_135) AT=615.025n

.meas tran vdout0_136ck1220 FIND v(dout0_136) AT=615.025n

.meas tran vdout0_137ck1220 FIND v(dout0_137) AT=615.025n

.meas tran vdout0_138ck1220 FIND v(dout0_138) AT=615.025n

.meas tran vdout0_139ck1220 FIND v(dout0_139) AT=615.025n

.meas tran vdout0_140ck1220 FIND v(dout0_140) AT=615.025n

.meas tran vdout0_141ck1220 FIND v(dout0_141) AT=615.025n

.meas tran vdout0_142ck1220 FIND v(dout0_142) AT=615.025n

.meas tran vdout0_143ck1220 FIND v(dout0_143) AT=615.025n

.meas tran vdout0_144ck1220 FIND v(dout0_144) AT=615.025n

.meas tran vdout0_145ck1220 FIND v(dout0_145) AT=615.025n

.meas tran vdout0_146ck1220 FIND v(dout0_146) AT=615.025n

.meas tran vdout0_147ck1220 FIND v(dout0_147) AT=615.025n

.meas tran vdout0_148ck1220 FIND v(dout0_148) AT=615.025n

.meas tran vdout0_149ck1220 FIND v(dout0_149) AT=615.025n

.meas tran vdout0_150ck1220 FIND v(dout0_150) AT=615.025n

.meas tran vdout0_151ck1220 FIND v(dout0_151) AT=615.025n

.meas tran vdout0_152ck1220 FIND v(dout0_152) AT=615.025n

.meas tran vdout0_153ck1220 FIND v(dout0_153) AT=615.025n

.meas tran vdout0_154ck1220 FIND v(dout0_154) AT=615.025n

.meas tran vdout0_155ck1220 FIND v(dout0_155) AT=615.025n

.meas tran vdout0_156ck1220 FIND v(dout0_156) AT=615.025n

.meas tran vdout0_157ck1220 FIND v(dout0_157) AT=615.025n

.meas tran vdout0_158ck1220 FIND v(dout0_158) AT=615.025n

.meas tran vdout0_159ck1220 FIND v(dout0_159) AT=615.025n

.meas tran vdout0_160ck1220 FIND v(dout0_160) AT=615.025n

.meas tran vdout0_161ck1220 FIND v(dout0_161) AT=615.025n

.meas tran vdout0_162ck1220 FIND v(dout0_162) AT=615.025n

.meas tran vdout0_163ck1220 FIND v(dout0_163) AT=615.025n

.meas tran vdout0_164ck1220 FIND v(dout0_164) AT=615.025n

.meas tran vdout0_165ck1220 FIND v(dout0_165) AT=615.025n

.meas tran vdout0_166ck1220 FIND v(dout0_166) AT=615.025n

.meas tran vdout0_167ck1220 FIND v(dout0_167) AT=615.025n

.meas tran vdout0_168ck1220 FIND v(dout0_168) AT=615.025n

.meas tran vdout0_169ck1220 FIND v(dout0_169) AT=615.025n

.meas tran vdout0_170ck1220 FIND v(dout0_170) AT=615.025n

.meas tran vdout0_171ck1220 FIND v(dout0_171) AT=615.025n

.meas tran vdout0_172ck1220 FIND v(dout0_172) AT=615.025n

.meas tran vdout0_173ck1220 FIND v(dout0_173) AT=615.025n

.meas tran vdout0_174ck1220 FIND v(dout0_174) AT=615.025n

.meas tran vdout0_175ck1220 FIND v(dout0_175) AT=615.025n

.meas tran vdout0_176ck1220 FIND v(dout0_176) AT=615.025n

.meas tran vdout0_177ck1220 FIND v(dout0_177) AT=615.025n

.meas tran vdout0_178ck1220 FIND v(dout0_178) AT=615.025n

.meas tran vdout0_179ck1220 FIND v(dout0_179) AT=615.025n

.meas tran vdout0_180ck1220 FIND v(dout0_180) AT=615.025n

.meas tran vdout0_181ck1220 FIND v(dout0_181) AT=615.025n

.meas tran vdout0_182ck1220 FIND v(dout0_182) AT=615.025n

.meas tran vdout0_183ck1220 FIND v(dout0_183) AT=615.025n

.meas tran vdout0_184ck1220 FIND v(dout0_184) AT=615.025n

.meas tran vdout0_185ck1220 FIND v(dout0_185) AT=615.025n

.meas tran vdout0_186ck1220 FIND v(dout0_186) AT=615.025n

.meas tran vdout0_187ck1220 FIND v(dout0_187) AT=615.025n

.meas tran vdout0_188ck1220 FIND v(dout0_188) AT=615.025n

.meas tran vdout0_189ck1220 FIND v(dout0_189) AT=615.025n

.meas tran vdout0_190ck1220 FIND v(dout0_190) AT=615.025n

.meas tran vdout0_191ck1220 FIND v(dout0_191) AT=615.025n

.meas tran vdout0_192ck1220 FIND v(dout0_192) AT=615.025n

.meas tran vdout0_193ck1220 FIND v(dout0_193) AT=615.025n

.meas tran vdout0_194ck1220 FIND v(dout0_194) AT=615.025n

.meas tran vdout0_195ck1220 FIND v(dout0_195) AT=615.025n

.meas tran vdout0_196ck1220 FIND v(dout0_196) AT=615.025n

.meas tran vdout0_197ck1220 FIND v(dout0_197) AT=615.025n

.meas tran vdout0_198ck1220 FIND v(dout0_198) AT=615.025n

.meas tran vdout0_199ck1220 FIND v(dout0_199) AT=615.025n

.meas tran vdout0_200ck1220 FIND v(dout0_200) AT=615.025n

.meas tran vdout0_201ck1220 FIND v(dout0_201) AT=615.025n

.meas tran vdout0_202ck1220 FIND v(dout0_202) AT=615.025n

.meas tran vdout0_203ck1220 FIND v(dout0_203) AT=615.025n

.meas tran vdout0_204ck1220 FIND v(dout0_204) AT=615.025n

.meas tran vdout0_205ck1220 FIND v(dout0_205) AT=615.025n

.meas tran vdout0_206ck1220 FIND v(dout0_206) AT=615.025n

.meas tran vdout0_207ck1220 FIND v(dout0_207) AT=615.025n

.meas tran vdout0_208ck1220 FIND v(dout0_208) AT=615.025n

.meas tran vdout0_209ck1220 FIND v(dout0_209) AT=615.025n

.meas tran vdout0_210ck1220 FIND v(dout0_210) AT=615.025n

.meas tran vdout0_211ck1220 FIND v(dout0_211) AT=615.025n

.meas tran vdout0_212ck1220 FIND v(dout0_212) AT=615.025n

.meas tran vdout0_213ck1220 FIND v(dout0_213) AT=615.025n

.meas tran vdout0_214ck1220 FIND v(dout0_214) AT=615.025n

.meas tran vdout0_215ck1220 FIND v(dout0_215) AT=615.025n

.meas tran vdout0_216ck1220 FIND v(dout0_216) AT=615.025n

.meas tran vdout0_217ck1220 FIND v(dout0_217) AT=615.025n

.meas tran vdout0_218ck1220 FIND v(dout0_218) AT=615.025n

.meas tran vdout0_219ck1220 FIND v(dout0_219) AT=615.025n

.meas tran vdout0_220ck1220 FIND v(dout0_220) AT=615.025n

.meas tran vdout0_221ck1220 FIND v(dout0_221) AT=615.025n

.meas tran vdout0_222ck1220 FIND v(dout0_222) AT=615.025n

.meas tran vdout0_223ck1220 FIND v(dout0_223) AT=615.025n

.meas tran vdout0_224ck1220 FIND v(dout0_224) AT=615.025n

.meas tran vdout0_225ck1220 FIND v(dout0_225) AT=615.025n

.meas tran vdout0_226ck1220 FIND v(dout0_226) AT=615.025n

.meas tran vdout0_227ck1220 FIND v(dout0_227) AT=615.025n

.meas tran vdout0_228ck1220 FIND v(dout0_228) AT=615.025n

.meas tran vdout0_229ck1220 FIND v(dout0_229) AT=615.025n

.meas tran vdout0_230ck1220 FIND v(dout0_230) AT=615.025n

.meas tran vdout0_231ck1220 FIND v(dout0_231) AT=615.025n

.meas tran vdout0_232ck1220 FIND v(dout0_232) AT=615.025n

.meas tran vdout0_233ck1220 FIND v(dout0_233) AT=615.025n

.meas tran vdout0_234ck1220 FIND v(dout0_234) AT=615.025n

.meas tran vdout0_235ck1220 FIND v(dout0_235) AT=615.025n

.meas tran vdout0_236ck1220 FIND v(dout0_236) AT=615.025n

.meas tran vdout0_237ck1220 FIND v(dout0_237) AT=615.025n

.meas tran vdout0_238ck1220 FIND v(dout0_238) AT=615.025n

.meas tran vdout0_239ck1220 FIND v(dout0_239) AT=615.025n

.meas tran vdout0_240ck1220 FIND v(dout0_240) AT=615.025n

.meas tran vdout0_241ck1220 FIND v(dout0_241) AT=615.025n

.meas tran vdout0_242ck1220 FIND v(dout0_242) AT=615.025n

.meas tran vdout0_243ck1220 FIND v(dout0_243) AT=615.025n

.meas tran vdout0_244ck1220 FIND v(dout0_244) AT=615.025n

.meas tran vdout0_245ck1220 FIND v(dout0_245) AT=615.025n

.meas tran vdout0_246ck1220 FIND v(dout0_246) AT=615.025n

.meas tran vdout0_247ck1220 FIND v(dout0_247) AT=615.025n

.meas tran vdout0_248ck1220 FIND v(dout0_248) AT=615.025n

.meas tran vdout0_249ck1220 FIND v(dout0_249) AT=615.025n

.meas tran vdout0_250ck1220 FIND v(dout0_250) AT=615.025n

.meas tran vdout0_251ck1220 FIND v(dout0_251) AT=615.025n

.meas tran vdout0_252ck1220 FIND v(dout0_252) AT=615.025n

.meas tran vdout0_253ck1220 FIND v(dout0_253) AT=615.025n

.meas tran vdout0_254ck1220 FIND v(dout0_254) AT=615.025n

.meas tran vdout0_255ck1220 FIND v(dout0_255) AT=615.025n

.meas tran vdout0_0ck1260 FIND v(dout0_0) AT=635.025n

.meas tran vdout0_1ck1260 FIND v(dout0_1) AT=635.025n

.meas tran vdout0_2ck1260 FIND v(dout0_2) AT=635.025n

.meas tran vdout0_3ck1260 FIND v(dout0_3) AT=635.025n

.meas tran vdout0_4ck1260 FIND v(dout0_4) AT=635.025n

.meas tran vdout0_5ck1260 FIND v(dout0_5) AT=635.025n

.meas tran vdout0_6ck1260 FIND v(dout0_6) AT=635.025n

.meas tran vdout0_7ck1260 FIND v(dout0_7) AT=635.025n

.meas tran vdout0_8ck1260 FIND v(dout0_8) AT=635.025n

.meas tran vdout0_9ck1260 FIND v(dout0_9) AT=635.025n

.meas tran vdout0_10ck1260 FIND v(dout0_10) AT=635.025n

.meas tran vdout0_11ck1260 FIND v(dout0_11) AT=635.025n

.meas tran vdout0_12ck1260 FIND v(dout0_12) AT=635.025n

.meas tran vdout0_13ck1260 FIND v(dout0_13) AT=635.025n

.meas tran vdout0_14ck1260 FIND v(dout0_14) AT=635.025n

.meas tran vdout0_15ck1260 FIND v(dout0_15) AT=635.025n

.meas tran vdout0_16ck1260 FIND v(dout0_16) AT=635.025n

.meas tran vdout0_17ck1260 FIND v(dout0_17) AT=635.025n

.meas tran vdout0_18ck1260 FIND v(dout0_18) AT=635.025n

.meas tran vdout0_19ck1260 FIND v(dout0_19) AT=635.025n

.meas tran vdout0_20ck1260 FIND v(dout0_20) AT=635.025n

.meas tran vdout0_21ck1260 FIND v(dout0_21) AT=635.025n

.meas tran vdout0_22ck1260 FIND v(dout0_22) AT=635.025n

.meas tran vdout0_23ck1260 FIND v(dout0_23) AT=635.025n

.meas tran vdout0_24ck1260 FIND v(dout0_24) AT=635.025n

.meas tran vdout0_25ck1260 FIND v(dout0_25) AT=635.025n

.meas tran vdout0_26ck1260 FIND v(dout0_26) AT=635.025n

.meas tran vdout0_27ck1260 FIND v(dout0_27) AT=635.025n

.meas tran vdout0_28ck1260 FIND v(dout0_28) AT=635.025n

.meas tran vdout0_29ck1260 FIND v(dout0_29) AT=635.025n

.meas tran vdout0_30ck1260 FIND v(dout0_30) AT=635.025n

.meas tran vdout0_31ck1260 FIND v(dout0_31) AT=635.025n

.meas tran vdout0_32ck1260 FIND v(dout0_32) AT=635.025n

.meas tran vdout0_33ck1260 FIND v(dout0_33) AT=635.025n

.meas tran vdout0_34ck1260 FIND v(dout0_34) AT=635.025n

.meas tran vdout0_35ck1260 FIND v(dout0_35) AT=635.025n

.meas tran vdout0_36ck1260 FIND v(dout0_36) AT=635.025n

.meas tran vdout0_37ck1260 FIND v(dout0_37) AT=635.025n

.meas tran vdout0_38ck1260 FIND v(dout0_38) AT=635.025n

.meas tran vdout0_39ck1260 FIND v(dout0_39) AT=635.025n

.meas tran vdout0_40ck1260 FIND v(dout0_40) AT=635.025n

.meas tran vdout0_41ck1260 FIND v(dout0_41) AT=635.025n

.meas tran vdout0_42ck1260 FIND v(dout0_42) AT=635.025n

.meas tran vdout0_43ck1260 FIND v(dout0_43) AT=635.025n

.meas tran vdout0_44ck1260 FIND v(dout0_44) AT=635.025n

.meas tran vdout0_45ck1260 FIND v(dout0_45) AT=635.025n

.meas tran vdout0_46ck1260 FIND v(dout0_46) AT=635.025n

.meas tran vdout0_47ck1260 FIND v(dout0_47) AT=635.025n

.meas tran vdout0_48ck1260 FIND v(dout0_48) AT=635.025n

.meas tran vdout0_49ck1260 FIND v(dout0_49) AT=635.025n

.meas tran vdout0_50ck1260 FIND v(dout0_50) AT=635.025n

.meas tran vdout0_51ck1260 FIND v(dout0_51) AT=635.025n

.meas tran vdout0_52ck1260 FIND v(dout0_52) AT=635.025n

.meas tran vdout0_53ck1260 FIND v(dout0_53) AT=635.025n

.meas tran vdout0_54ck1260 FIND v(dout0_54) AT=635.025n

.meas tran vdout0_55ck1260 FIND v(dout0_55) AT=635.025n

.meas tran vdout0_56ck1260 FIND v(dout0_56) AT=635.025n

.meas tran vdout0_57ck1260 FIND v(dout0_57) AT=635.025n

.meas tran vdout0_58ck1260 FIND v(dout0_58) AT=635.025n

.meas tran vdout0_59ck1260 FIND v(dout0_59) AT=635.025n

.meas tran vdout0_60ck1260 FIND v(dout0_60) AT=635.025n

.meas tran vdout0_61ck1260 FIND v(dout0_61) AT=635.025n

.meas tran vdout0_62ck1260 FIND v(dout0_62) AT=635.025n

.meas tran vdout0_63ck1260 FIND v(dout0_63) AT=635.025n

.meas tran vdout0_64ck1260 FIND v(dout0_64) AT=635.025n

.meas tran vdout0_65ck1260 FIND v(dout0_65) AT=635.025n

.meas tran vdout0_66ck1260 FIND v(dout0_66) AT=635.025n

.meas tran vdout0_67ck1260 FIND v(dout0_67) AT=635.025n

.meas tran vdout0_68ck1260 FIND v(dout0_68) AT=635.025n

.meas tran vdout0_69ck1260 FIND v(dout0_69) AT=635.025n

.meas tran vdout0_70ck1260 FIND v(dout0_70) AT=635.025n

.meas tran vdout0_71ck1260 FIND v(dout0_71) AT=635.025n

.meas tran vdout0_72ck1260 FIND v(dout0_72) AT=635.025n

.meas tran vdout0_73ck1260 FIND v(dout0_73) AT=635.025n

.meas tran vdout0_74ck1260 FIND v(dout0_74) AT=635.025n

.meas tran vdout0_75ck1260 FIND v(dout0_75) AT=635.025n

.meas tran vdout0_76ck1260 FIND v(dout0_76) AT=635.025n

.meas tran vdout0_77ck1260 FIND v(dout0_77) AT=635.025n

.meas tran vdout0_78ck1260 FIND v(dout0_78) AT=635.025n

.meas tran vdout0_79ck1260 FIND v(dout0_79) AT=635.025n

.meas tran vdout0_80ck1260 FIND v(dout0_80) AT=635.025n

.meas tran vdout0_81ck1260 FIND v(dout0_81) AT=635.025n

.meas tran vdout0_82ck1260 FIND v(dout0_82) AT=635.025n

.meas tran vdout0_83ck1260 FIND v(dout0_83) AT=635.025n

.meas tran vdout0_84ck1260 FIND v(dout0_84) AT=635.025n

.meas tran vdout0_85ck1260 FIND v(dout0_85) AT=635.025n

.meas tran vdout0_86ck1260 FIND v(dout0_86) AT=635.025n

.meas tran vdout0_87ck1260 FIND v(dout0_87) AT=635.025n

.meas tran vdout0_88ck1260 FIND v(dout0_88) AT=635.025n

.meas tran vdout0_89ck1260 FIND v(dout0_89) AT=635.025n

.meas tran vdout0_90ck1260 FIND v(dout0_90) AT=635.025n

.meas tran vdout0_91ck1260 FIND v(dout0_91) AT=635.025n

.meas tran vdout0_92ck1260 FIND v(dout0_92) AT=635.025n

.meas tran vdout0_93ck1260 FIND v(dout0_93) AT=635.025n

.meas tran vdout0_94ck1260 FIND v(dout0_94) AT=635.025n

.meas tran vdout0_95ck1260 FIND v(dout0_95) AT=635.025n

.meas tran vdout0_96ck1260 FIND v(dout0_96) AT=635.025n

.meas tran vdout0_97ck1260 FIND v(dout0_97) AT=635.025n

.meas tran vdout0_98ck1260 FIND v(dout0_98) AT=635.025n

.meas tran vdout0_99ck1260 FIND v(dout0_99) AT=635.025n

.meas tran vdout0_100ck1260 FIND v(dout0_100) AT=635.025n

.meas tran vdout0_101ck1260 FIND v(dout0_101) AT=635.025n

.meas tran vdout0_102ck1260 FIND v(dout0_102) AT=635.025n

.meas tran vdout0_103ck1260 FIND v(dout0_103) AT=635.025n

.meas tran vdout0_104ck1260 FIND v(dout0_104) AT=635.025n

.meas tran vdout0_105ck1260 FIND v(dout0_105) AT=635.025n

.meas tran vdout0_106ck1260 FIND v(dout0_106) AT=635.025n

.meas tran vdout0_107ck1260 FIND v(dout0_107) AT=635.025n

.meas tran vdout0_108ck1260 FIND v(dout0_108) AT=635.025n

.meas tran vdout0_109ck1260 FIND v(dout0_109) AT=635.025n

.meas tran vdout0_110ck1260 FIND v(dout0_110) AT=635.025n

.meas tran vdout0_111ck1260 FIND v(dout0_111) AT=635.025n

.meas tran vdout0_112ck1260 FIND v(dout0_112) AT=635.025n

.meas tran vdout0_113ck1260 FIND v(dout0_113) AT=635.025n

.meas tran vdout0_114ck1260 FIND v(dout0_114) AT=635.025n

.meas tran vdout0_115ck1260 FIND v(dout0_115) AT=635.025n

.meas tran vdout0_116ck1260 FIND v(dout0_116) AT=635.025n

.meas tran vdout0_117ck1260 FIND v(dout0_117) AT=635.025n

.meas tran vdout0_118ck1260 FIND v(dout0_118) AT=635.025n

.meas tran vdout0_119ck1260 FIND v(dout0_119) AT=635.025n

.meas tran vdout0_120ck1260 FIND v(dout0_120) AT=635.025n

.meas tran vdout0_121ck1260 FIND v(dout0_121) AT=635.025n

.meas tran vdout0_122ck1260 FIND v(dout0_122) AT=635.025n

.meas tran vdout0_123ck1260 FIND v(dout0_123) AT=635.025n

.meas tran vdout0_124ck1260 FIND v(dout0_124) AT=635.025n

.meas tran vdout0_125ck1260 FIND v(dout0_125) AT=635.025n

.meas tran vdout0_126ck1260 FIND v(dout0_126) AT=635.025n

.meas tran vdout0_127ck1260 FIND v(dout0_127) AT=635.025n

.meas tran vdout0_128ck1260 FIND v(dout0_128) AT=635.025n

.meas tran vdout0_129ck1260 FIND v(dout0_129) AT=635.025n

.meas tran vdout0_130ck1260 FIND v(dout0_130) AT=635.025n

.meas tran vdout0_131ck1260 FIND v(dout0_131) AT=635.025n

.meas tran vdout0_132ck1260 FIND v(dout0_132) AT=635.025n

.meas tran vdout0_133ck1260 FIND v(dout0_133) AT=635.025n

.meas tran vdout0_134ck1260 FIND v(dout0_134) AT=635.025n

.meas tran vdout0_135ck1260 FIND v(dout0_135) AT=635.025n

.meas tran vdout0_136ck1260 FIND v(dout0_136) AT=635.025n

.meas tran vdout0_137ck1260 FIND v(dout0_137) AT=635.025n

.meas tran vdout0_138ck1260 FIND v(dout0_138) AT=635.025n

.meas tran vdout0_139ck1260 FIND v(dout0_139) AT=635.025n

.meas tran vdout0_140ck1260 FIND v(dout0_140) AT=635.025n

.meas tran vdout0_141ck1260 FIND v(dout0_141) AT=635.025n

.meas tran vdout0_142ck1260 FIND v(dout0_142) AT=635.025n

.meas tran vdout0_143ck1260 FIND v(dout0_143) AT=635.025n

.meas tran vdout0_144ck1260 FIND v(dout0_144) AT=635.025n

.meas tran vdout0_145ck1260 FIND v(dout0_145) AT=635.025n

.meas tran vdout0_146ck1260 FIND v(dout0_146) AT=635.025n

.meas tran vdout0_147ck1260 FIND v(dout0_147) AT=635.025n

.meas tran vdout0_148ck1260 FIND v(dout0_148) AT=635.025n

.meas tran vdout0_149ck1260 FIND v(dout0_149) AT=635.025n

.meas tran vdout0_150ck1260 FIND v(dout0_150) AT=635.025n

.meas tran vdout0_151ck1260 FIND v(dout0_151) AT=635.025n

.meas tran vdout0_152ck1260 FIND v(dout0_152) AT=635.025n

.meas tran vdout0_153ck1260 FIND v(dout0_153) AT=635.025n

.meas tran vdout0_154ck1260 FIND v(dout0_154) AT=635.025n

.meas tran vdout0_155ck1260 FIND v(dout0_155) AT=635.025n

.meas tran vdout0_156ck1260 FIND v(dout0_156) AT=635.025n

.meas tran vdout0_157ck1260 FIND v(dout0_157) AT=635.025n

.meas tran vdout0_158ck1260 FIND v(dout0_158) AT=635.025n

.meas tran vdout0_159ck1260 FIND v(dout0_159) AT=635.025n

.meas tran vdout0_160ck1260 FIND v(dout0_160) AT=635.025n

.meas tran vdout0_161ck1260 FIND v(dout0_161) AT=635.025n

.meas tran vdout0_162ck1260 FIND v(dout0_162) AT=635.025n

.meas tran vdout0_163ck1260 FIND v(dout0_163) AT=635.025n

.meas tran vdout0_164ck1260 FIND v(dout0_164) AT=635.025n

.meas tran vdout0_165ck1260 FIND v(dout0_165) AT=635.025n

.meas tran vdout0_166ck1260 FIND v(dout0_166) AT=635.025n

.meas tran vdout0_167ck1260 FIND v(dout0_167) AT=635.025n

.meas tran vdout0_168ck1260 FIND v(dout0_168) AT=635.025n

.meas tran vdout0_169ck1260 FIND v(dout0_169) AT=635.025n

.meas tran vdout0_170ck1260 FIND v(dout0_170) AT=635.025n

.meas tran vdout0_171ck1260 FIND v(dout0_171) AT=635.025n

.meas tran vdout0_172ck1260 FIND v(dout0_172) AT=635.025n

.meas tran vdout0_173ck1260 FIND v(dout0_173) AT=635.025n

.meas tran vdout0_174ck1260 FIND v(dout0_174) AT=635.025n

.meas tran vdout0_175ck1260 FIND v(dout0_175) AT=635.025n

.meas tran vdout0_176ck1260 FIND v(dout0_176) AT=635.025n

.meas tran vdout0_177ck1260 FIND v(dout0_177) AT=635.025n

.meas tran vdout0_178ck1260 FIND v(dout0_178) AT=635.025n

.meas tran vdout0_179ck1260 FIND v(dout0_179) AT=635.025n

.meas tran vdout0_180ck1260 FIND v(dout0_180) AT=635.025n

.meas tran vdout0_181ck1260 FIND v(dout0_181) AT=635.025n

.meas tran vdout0_182ck1260 FIND v(dout0_182) AT=635.025n

.meas tran vdout0_183ck1260 FIND v(dout0_183) AT=635.025n

.meas tran vdout0_184ck1260 FIND v(dout0_184) AT=635.025n

.meas tran vdout0_185ck1260 FIND v(dout0_185) AT=635.025n

.meas tran vdout0_186ck1260 FIND v(dout0_186) AT=635.025n

.meas tran vdout0_187ck1260 FIND v(dout0_187) AT=635.025n

.meas tran vdout0_188ck1260 FIND v(dout0_188) AT=635.025n

.meas tran vdout0_189ck1260 FIND v(dout0_189) AT=635.025n

.meas tran vdout0_190ck1260 FIND v(dout0_190) AT=635.025n

.meas tran vdout0_191ck1260 FIND v(dout0_191) AT=635.025n

.meas tran vdout0_192ck1260 FIND v(dout0_192) AT=635.025n

.meas tran vdout0_193ck1260 FIND v(dout0_193) AT=635.025n

.meas tran vdout0_194ck1260 FIND v(dout0_194) AT=635.025n

.meas tran vdout0_195ck1260 FIND v(dout0_195) AT=635.025n

.meas tran vdout0_196ck1260 FIND v(dout0_196) AT=635.025n

.meas tran vdout0_197ck1260 FIND v(dout0_197) AT=635.025n

.meas tran vdout0_198ck1260 FIND v(dout0_198) AT=635.025n

.meas tran vdout0_199ck1260 FIND v(dout0_199) AT=635.025n

.meas tran vdout0_200ck1260 FIND v(dout0_200) AT=635.025n

.meas tran vdout0_201ck1260 FIND v(dout0_201) AT=635.025n

.meas tran vdout0_202ck1260 FIND v(dout0_202) AT=635.025n

.meas tran vdout0_203ck1260 FIND v(dout0_203) AT=635.025n

.meas tran vdout0_204ck1260 FIND v(dout0_204) AT=635.025n

.meas tran vdout0_205ck1260 FIND v(dout0_205) AT=635.025n

.meas tran vdout0_206ck1260 FIND v(dout0_206) AT=635.025n

.meas tran vdout0_207ck1260 FIND v(dout0_207) AT=635.025n

.meas tran vdout0_208ck1260 FIND v(dout0_208) AT=635.025n

.meas tran vdout0_209ck1260 FIND v(dout0_209) AT=635.025n

.meas tran vdout0_210ck1260 FIND v(dout0_210) AT=635.025n

.meas tran vdout0_211ck1260 FIND v(dout0_211) AT=635.025n

.meas tran vdout0_212ck1260 FIND v(dout0_212) AT=635.025n

.meas tran vdout0_213ck1260 FIND v(dout0_213) AT=635.025n

.meas tran vdout0_214ck1260 FIND v(dout0_214) AT=635.025n

.meas tran vdout0_215ck1260 FIND v(dout0_215) AT=635.025n

.meas tran vdout0_216ck1260 FIND v(dout0_216) AT=635.025n

.meas tran vdout0_217ck1260 FIND v(dout0_217) AT=635.025n

.meas tran vdout0_218ck1260 FIND v(dout0_218) AT=635.025n

.meas tran vdout0_219ck1260 FIND v(dout0_219) AT=635.025n

.meas tran vdout0_220ck1260 FIND v(dout0_220) AT=635.025n

.meas tran vdout0_221ck1260 FIND v(dout0_221) AT=635.025n

.meas tran vdout0_222ck1260 FIND v(dout0_222) AT=635.025n

.meas tran vdout0_223ck1260 FIND v(dout0_223) AT=635.025n

.meas tran vdout0_224ck1260 FIND v(dout0_224) AT=635.025n

.meas tran vdout0_225ck1260 FIND v(dout0_225) AT=635.025n

.meas tran vdout0_226ck1260 FIND v(dout0_226) AT=635.025n

.meas tran vdout0_227ck1260 FIND v(dout0_227) AT=635.025n

.meas tran vdout0_228ck1260 FIND v(dout0_228) AT=635.025n

.meas tran vdout0_229ck1260 FIND v(dout0_229) AT=635.025n

.meas tran vdout0_230ck1260 FIND v(dout0_230) AT=635.025n

.meas tran vdout0_231ck1260 FIND v(dout0_231) AT=635.025n

.meas tran vdout0_232ck1260 FIND v(dout0_232) AT=635.025n

.meas tran vdout0_233ck1260 FIND v(dout0_233) AT=635.025n

.meas tran vdout0_234ck1260 FIND v(dout0_234) AT=635.025n

.meas tran vdout0_235ck1260 FIND v(dout0_235) AT=635.025n

.meas tran vdout0_236ck1260 FIND v(dout0_236) AT=635.025n

.meas tran vdout0_237ck1260 FIND v(dout0_237) AT=635.025n

.meas tran vdout0_238ck1260 FIND v(dout0_238) AT=635.025n

.meas tran vdout0_239ck1260 FIND v(dout0_239) AT=635.025n

.meas tran vdout0_240ck1260 FIND v(dout0_240) AT=635.025n

.meas tran vdout0_241ck1260 FIND v(dout0_241) AT=635.025n

.meas tran vdout0_242ck1260 FIND v(dout0_242) AT=635.025n

.meas tran vdout0_243ck1260 FIND v(dout0_243) AT=635.025n

.meas tran vdout0_244ck1260 FIND v(dout0_244) AT=635.025n

.meas tran vdout0_245ck1260 FIND v(dout0_245) AT=635.025n

.meas tran vdout0_246ck1260 FIND v(dout0_246) AT=635.025n

.meas tran vdout0_247ck1260 FIND v(dout0_247) AT=635.025n

.meas tran vdout0_248ck1260 FIND v(dout0_248) AT=635.025n

.meas tran vdout0_249ck1260 FIND v(dout0_249) AT=635.025n

.meas tran vdout0_250ck1260 FIND v(dout0_250) AT=635.025n

.meas tran vdout0_251ck1260 FIND v(dout0_251) AT=635.025n

.meas tran vdout0_252ck1260 FIND v(dout0_252) AT=635.025n

.meas tran vdout0_253ck1260 FIND v(dout0_253) AT=635.025n

.meas tran vdout0_254ck1260 FIND v(dout0_254) AT=635.025n

.meas tran vdout0_255ck1260 FIND v(dout0_255) AT=635.025n

.meas tran vdout0_0ck1280 FIND v(dout0_0) AT=645.025n

.meas tran vdout0_1ck1280 FIND v(dout0_1) AT=645.025n

.meas tran vdout0_2ck1280 FIND v(dout0_2) AT=645.025n

.meas tran vdout0_3ck1280 FIND v(dout0_3) AT=645.025n

.meas tran vdout0_4ck1280 FIND v(dout0_4) AT=645.025n

.meas tran vdout0_5ck1280 FIND v(dout0_5) AT=645.025n

.meas tran vdout0_6ck1280 FIND v(dout0_6) AT=645.025n

.meas tran vdout0_7ck1280 FIND v(dout0_7) AT=645.025n

.meas tran vdout0_8ck1280 FIND v(dout0_8) AT=645.025n

.meas tran vdout0_9ck1280 FIND v(dout0_9) AT=645.025n

.meas tran vdout0_10ck1280 FIND v(dout0_10) AT=645.025n

.meas tran vdout0_11ck1280 FIND v(dout0_11) AT=645.025n

.meas tran vdout0_12ck1280 FIND v(dout0_12) AT=645.025n

.meas tran vdout0_13ck1280 FIND v(dout0_13) AT=645.025n

.meas tran vdout0_14ck1280 FIND v(dout0_14) AT=645.025n

.meas tran vdout0_15ck1280 FIND v(dout0_15) AT=645.025n

.meas tran vdout0_16ck1280 FIND v(dout0_16) AT=645.025n

.meas tran vdout0_17ck1280 FIND v(dout0_17) AT=645.025n

.meas tran vdout0_18ck1280 FIND v(dout0_18) AT=645.025n

.meas tran vdout0_19ck1280 FIND v(dout0_19) AT=645.025n

.meas tran vdout0_20ck1280 FIND v(dout0_20) AT=645.025n

.meas tran vdout0_21ck1280 FIND v(dout0_21) AT=645.025n

.meas tran vdout0_22ck1280 FIND v(dout0_22) AT=645.025n

.meas tran vdout0_23ck1280 FIND v(dout0_23) AT=645.025n

.meas tran vdout0_24ck1280 FIND v(dout0_24) AT=645.025n

.meas tran vdout0_25ck1280 FIND v(dout0_25) AT=645.025n

.meas tran vdout0_26ck1280 FIND v(dout0_26) AT=645.025n

.meas tran vdout0_27ck1280 FIND v(dout0_27) AT=645.025n

.meas tran vdout0_28ck1280 FIND v(dout0_28) AT=645.025n

.meas tran vdout0_29ck1280 FIND v(dout0_29) AT=645.025n

.meas tran vdout0_30ck1280 FIND v(dout0_30) AT=645.025n

.meas tran vdout0_31ck1280 FIND v(dout0_31) AT=645.025n

.meas tran vdout0_32ck1280 FIND v(dout0_32) AT=645.025n

.meas tran vdout0_33ck1280 FIND v(dout0_33) AT=645.025n

.meas tran vdout0_34ck1280 FIND v(dout0_34) AT=645.025n

.meas tran vdout0_35ck1280 FIND v(dout0_35) AT=645.025n

.meas tran vdout0_36ck1280 FIND v(dout0_36) AT=645.025n

.meas tran vdout0_37ck1280 FIND v(dout0_37) AT=645.025n

.meas tran vdout0_38ck1280 FIND v(dout0_38) AT=645.025n

.meas tran vdout0_39ck1280 FIND v(dout0_39) AT=645.025n

.meas tran vdout0_40ck1280 FIND v(dout0_40) AT=645.025n

.meas tran vdout0_41ck1280 FIND v(dout0_41) AT=645.025n

.meas tran vdout0_42ck1280 FIND v(dout0_42) AT=645.025n

.meas tran vdout0_43ck1280 FIND v(dout0_43) AT=645.025n

.meas tran vdout0_44ck1280 FIND v(dout0_44) AT=645.025n

.meas tran vdout0_45ck1280 FIND v(dout0_45) AT=645.025n

.meas tran vdout0_46ck1280 FIND v(dout0_46) AT=645.025n

.meas tran vdout0_47ck1280 FIND v(dout0_47) AT=645.025n

.meas tran vdout0_48ck1280 FIND v(dout0_48) AT=645.025n

.meas tran vdout0_49ck1280 FIND v(dout0_49) AT=645.025n

.meas tran vdout0_50ck1280 FIND v(dout0_50) AT=645.025n

.meas tran vdout0_51ck1280 FIND v(dout0_51) AT=645.025n

.meas tran vdout0_52ck1280 FIND v(dout0_52) AT=645.025n

.meas tran vdout0_53ck1280 FIND v(dout0_53) AT=645.025n

.meas tran vdout0_54ck1280 FIND v(dout0_54) AT=645.025n

.meas tran vdout0_55ck1280 FIND v(dout0_55) AT=645.025n

.meas tran vdout0_56ck1280 FIND v(dout0_56) AT=645.025n

.meas tran vdout0_57ck1280 FIND v(dout0_57) AT=645.025n

.meas tran vdout0_58ck1280 FIND v(dout0_58) AT=645.025n

.meas tran vdout0_59ck1280 FIND v(dout0_59) AT=645.025n

.meas tran vdout0_60ck1280 FIND v(dout0_60) AT=645.025n

.meas tran vdout0_61ck1280 FIND v(dout0_61) AT=645.025n

.meas tran vdout0_62ck1280 FIND v(dout0_62) AT=645.025n

.meas tran vdout0_63ck1280 FIND v(dout0_63) AT=645.025n

.meas tran vdout0_64ck1280 FIND v(dout0_64) AT=645.025n

.meas tran vdout0_65ck1280 FIND v(dout0_65) AT=645.025n

.meas tran vdout0_66ck1280 FIND v(dout0_66) AT=645.025n

.meas tran vdout0_67ck1280 FIND v(dout0_67) AT=645.025n

.meas tran vdout0_68ck1280 FIND v(dout0_68) AT=645.025n

.meas tran vdout0_69ck1280 FIND v(dout0_69) AT=645.025n

.meas tran vdout0_70ck1280 FIND v(dout0_70) AT=645.025n

.meas tran vdout0_71ck1280 FIND v(dout0_71) AT=645.025n

.meas tran vdout0_72ck1280 FIND v(dout0_72) AT=645.025n

.meas tran vdout0_73ck1280 FIND v(dout0_73) AT=645.025n

.meas tran vdout0_74ck1280 FIND v(dout0_74) AT=645.025n

.meas tran vdout0_75ck1280 FIND v(dout0_75) AT=645.025n

.meas tran vdout0_76ck1280 FIND v(dout0_76) AT=645.025n

.meas tran vdout0_77ck1280 FIND v(dout0_77) AT=645.025n

.meas tran vdout0_78ck1280 FIND v(dout0_78) AT=645.025n

.meas tran vdout0_79ck1280 FIND v(dout0_79) AT=645.025n

.meas tran vdout0_80ck1280 FIND v(dout0_80) AT=645.025n

.meas tran vdout0_81ck1280 FIND v(dout0_81) AT=645.025n

.meas tran vdout0_82ck1280 FIND v(dout0_82) AT=645.025n

.meas tran vdout0_83ck1280 FIND v(dout0_83) AT=645.025n

.meas tran vdout0_84ck1280 FIND v(dout0_84) AT=645.025n

.meas tran vdout0_85ck1280 FIND v(dout0_85) AT=645.025n

.meas tran vdout0_86ck1280 FIND v(dout0_86) AT=645.025n

.meas tran vdout0_87ck1280 FIND v(dout0_87) AT=645.025n

.meas tran vdout0_88ck1280 FIND v(dout0_88) AT=645.025n

.meas tran vdout0_89ck1280 FIND v(dout0_89) AT=645.025n

.meas tran vdout0_90ck1280 FIND v(dout0_90) AT=645.025n

.meas tran vdout0_91ck1280 FIND v(dout0_91) AT=645.025n

.meas tran vdout0_92ck1280 FIND v(dout0_92) AT=645.025n

.meas tran vdout0_93ck1280 FIND v(dout0_93) AT=645.025n

.meas tran vdout0_94ck1280 FIND v(dout0_94) AT=645.025n

.meas tran vdout0_95ck1280 FIND v(dout0_95) AT=645.025n

.meas tran vdout0_96ck1280 FIND v(dout0_96) AT=645.025n

.meas tran vdout0_97ck1280 FIND v(dout0_97) AT=645.025n

.meas tran vdout0_98ck1280 FIND v(dout0_98) AT=645.025n

.meas tran vdout0_99ck1280 FIND v(dout0_99) AT=645.025n

.meas tran vdout0_100ck1280 FIND v(dout0_100) AT=645.025n

.meas tran vdout0_101ck1280 FIND v(dout0_101) AT=645.025n

.meas tran vdout0_102ck1280 FIND v(dout0_102) AT=645.025n

.meas tran vdout0_103ck1280 FIND v(dout0_103) AT=645.025n

.meas tran vdout0_104ck1280 FIND v(dout0_104) AT=645.025n

.meas tran vdout0_105ck1280 FIND v(dout0_105) AT=645.025n

.meas tran vdout0_106ck1280 FIND v(dout0_106) AT=645.025n

.meas tran vdout0_107ck1280 FIND v(dout0_107) AT=645.025n

.meas tran vdout0_108ck1280 FIND v(dout0_108) AT=645.025n

.meas tran vdout0_109ck1280 FIND v(dout0_109) AT=645.025n

.meas tran vdout0_110ck1280 FIND v(dout0_110) AT=645.025n

.meas tran vdout0_111ck1280 FIND v(dout0_111) AT=645.025n

.meas tran vdout0_112ck1280 FIND v(dout0_112) AT=645.025n

.meas tran vdout0_113ck1280 FIND v(dout0_113) AT=645.025n

.meas tran vdout0_114ck1280 FIND v(dout0_114) AT=645.025n

.meas tran vdout0_115ck1280 FIND v(dout0_115) AT=645.025n

.meas tran vdout0_116ck1280 FIND v(dout0_116) AT=645.025n

.meas tran vdout0_117ck1280 FIND v(dout0_117) AT=645.025n

.meas tran vdout0_118ck1280 FIND v(dout0_118) AT=645.025n

.meas tran vdout0_119ck1280 FIND v(dout0_119) AT=645.025n

.meas tran vdout0_120ck1280 FIND v(dout0_120) AT=645.025n

.meas tran vdout0_121ck1280 FIND v(dout0_121) AT=645.025n

.meas tran vdout0_122ck1280 FIND v(dout0_122) AT=645.025n

.meas tran vdout0_123ck1280 FIND v(dout0_123) AT=645.025n

.meas tran vdout0_124ck1280 FIND v(dout0_124) AT=645.025n

.meas tran vdout0_125ck1280 FIND v(dout0_125) AT=645.025n

.meas tran vdout0_126ck1280 FIND v(dout0_126) AT=645.025n

.meas tran vdout0_127ck1280 FIND v(dout0_127) AT=645.025n

.meas tran vdout0_128ck1280 FIND v(dout0_128) AT=645.025n

.meas tran vdout0_129ck1280 FIND v(dout0_129) AT=645.025n

.meas tran vdout0_130ck1280 FIND v(dout0_130) AT=645.025n

.meas tran vdout0_131ck1280 FIND v(dout0_131) AT=645.025n

.meas tran vdout0_132ck1280 FIND v(dout0_132) AT=645.025n

.meas tran vdout0_133ck1280 FIND v(dout0_133) AT=645.025n

.meas tran vdout0_134ck1280 FIND v(dout0_134) AT=645.025n

.meas tran vdout0_135ck1280 FIND v(dout0_135) AT=645.025n

.meas tran vdout0_136ck1280 FIND v(dout0_136) AT=645.025n

.meas tran vdout0_137ck1280 FIND v(dout0_137) AT=645.025n

.meas tran vdout0_138ck1280 FIND v(dout0_138) AT=645.025n

.meas tran vdout0_139ck1280 FIND v(dout0_139) AT=645.025n

.meas tran vdout0_140ck1280 FIND v(dout0_140) AT=645.025n

.meas tran vdout0_141ck1280 FIND v(dout0_141) AT=645.025n

.meas tran vdout0_142ck1280 FIND v(dout0_142) AT=645.025n

.meas tran vdout0_143ck1280 FIND v(dout0_143) AT=645.025n

.meas tran vdout0_144ck1280 FIND v(dout0_144) AT=645.025n

.meas tran vdout0_145ck1280 FIND v(dout0_145) AT=645.025n

.meas tran vdout0_146ck1280 FIND v(dout0_146) AT=645.025n

.meas tran vdout0_147ck1280 FIND v(dout0_147) AT=645.025n

.meas tran vdout0_148ck1280 FIND v(dout0_148) AT=645.025n

.meas tran vdout0_149ck1280 FIND v(dout0_149) AT=645.025n

.meas tran vdout0_150ck1280 FIND v(dout0_150) AT=645.025n

.meas tran vdout0_151ck1280 FIND v(dout0_151) AT=645.025n

.meas tran vdout0_152ck1280 FIND v(dout0_152) AT=645.025n

.meas tran vdout0_153ck1280 FIND v(dout0_153) AT=645.025n

.meas tran vdout0_154ck1280 FIND v(dout0_154) AT=645.025n

.meas tran vdout0_155ck1280 FIND v(dout0_155) AT=645.025n

.meas tran vdout0_156ck1280 FIND v(dout0_156) AT=645.025n

.meas tran vdout0_157ck1280 FIND v(dout0_157) AT=645.025n

.meas tran vdout0_158ck1280 FIND v(dout0_158) AT=645.025n

.meas tran vdout0_159ck1280 FIND v(dout0_159) AT=645.025n

.meas tran vdout0_160ck1280 FIND v(dout0_160) AT=645.025n

.meas tran vdout0_161ck1280 FIND v(dout0_161) AT=645.025n

.meas tran vdout0_162ck1280 FIND v(dout0_162) AT=645.025n

.meas tran vdout0_163ck1280 FIND v(dout0_163) AT=645.025n

.meas tran vdout0_164ck1280 FIND v(dout0_164) AT=645.025n

.meas tran vdout0_165ck1280 FIND v(dout0_165) AT=645.025n

.meas tran vdout0_166ck1280 FIND v(dout0_166) AT=645.025n

.meas tran vdout0_167ck1280 FIND v(dout0_167) AT=645.025n

.meas tran vdout0_168ck1280 FIND v(dout0_168) AT=645.025n

.meas tran vdout0_169ck1280 FIND v(dout0_169) AT=645.025n

.meas tran vdout0_170ck1280 FIND v(dout0_170) AT=645.025n

.meas tran vdout0_171ck1280 FIND v(dout0_171) AT=645.025n

.meas tran vdout0_172ck1280 FIND v(dout0_172) AT=645.025n

.meas tran vdout0_173ck1280 FIND v(dout0_173) AT=645.025n

.meas tran vdout0_174ck1280 FIND v(dout0_174) AT=645.025n

.meas tran vdout0_175ck1280 FIND v(dout0_175) AT=645.025n

.meas tran vdout0_176ck1280 FIND v(dout0_176) AT=645.025n

.meas tran vdout0_177ck1280 FIND v(dout0_177) AT=645.025n

.meas tran vdout0_178ck1280 FIND v(dout0_178) AT=645.025n

.meas tran vdout0_179ck1280 FIND v(dout0_179) AT=645.025n

.meas tran vdout0_180ck1280 FIND v(dout0_180) AT=645.025n

.meas tran vdout0_181ck1280 FIND v(dout0_181) AT=645.025n

.meas tran vdout0_182ck1280 FIND v(dout0_182) AT=645.025n

.meas tran vdout0_183ck1280 FIND v(dout0_183) AT=645.025n

.meas tran vdout0_184ck1280 FIND v(dout0_184) AT=645.025n

.meas tran vdout0_185ck1280 FIND v(dout0_185) AT=645.025n

.meas tran vdout0_186ck1280 FIND v(dout0_186) AT=645.025n

.meas tran vdout0_187ck1280 FIND v(dout0_187) AT=645.025n

.meas tran vdout0_188ck1280 FIND v(dout0_188) AT=645.025n

.meas tran vdout0_189ck1280 FIND v(dout0_189) AT=645.025n

.meas tran vdout0_190ck1280 FIND v(dout0_190) AT=645.025n

.meas tran vdout0_191ck1280 FIND v(dout0_191) AT=645.025n

.meas tran vdout0_192ck1280 FIND v(dout0_192) AT=645.025n

.meas tran vdout0_193ck1280 FIND v(dout0_193) AT=645.025n

.meas tran vdout0_194ck1280 FIND v(dout0_194) AT=645.025n

.meas tran vdout0_195ck1280 FIND v(dout0_195) AT=645.025n

.meas tran vdout0_196ck1280 FIND v(dout0_196) AT=645.025n

.meas tran vdout0_197ck1280 FIND v(dout0_197) AT=645.025n

.meas tran vdout0_198ck1280 FIND v(dout0_198) AT=645.025n

.meas tran vdout0_199ck1280 FIND v(dout0_199) AT=645.025n

.meas tran vdout0_200ck1280 FIND v(dout0_200) AT=645.025n

.meas tran vdout0_201ck1280 FIND v(dout0_201) AT=645.025n

.meas tran vdout0_202ck1280 FIND v(dout0_202) AT=645.025n

.meas tran vdout0_203ck1280 FIND v(dout0_203) AT=645.025n

.meas tran vdout0_204ck1280 FIND v(dout0_204) AT=645.025n

.meas tran vdout0_205ck1280 FIND v(dout0_205) AT=645.025n

.meas tran vdout0_206ck1280 FIND v(dout0_206) AT=645.025n

.meas tran vdout0_207ck1280 FIND v(dout0_207) AT=645.025n

.meas tran vdout0_208ck1280 FIND v(dout0_208) AT=645.025n

.meas tran vdout0_209ck1280 FIND v(dout0_209) AT=645.025n

.meas tran vdout0_210ck1280 FIND v(dout0_210) AT=645.025n

.meas tran vdout0_211ck1280 FIND v(dout0_211) AT=645.025n

.meas tran vdout0_212ck1280 FIND v(dout0_212) AT=645.025n

.meas tran vdout0_213ck1280 FIND v(dout0_213) AT=645.025n

.meas tran vdout0_214ck1280 FIND v(dout0_214) AT=645.025n

.meas tran vdout0_215ck1280 FIND v(dout0_215) AT=645.025n

.meas tran vdout0_216ck1280 FIND v(dout0_216) AT=645.025n

.meas tran vdout0_217ck1280 FIND v(dout0_217) AT=645.025n

.meas tran vdout0_218ck1280 FIND v(dout0_218) AT=645.025n

.meas tran vdout0_219ck1280 FIND v(dout0_219) AT=645.025n

.meas tran vdout0_220ck1280 FIND v(dout0_220) AT=645.025n

.meas tran vdout0_221ck1280 FIND v(dout0_221) AT=645.025n

.meas tran vdout0_222ck1280 FIND v(dout0_222) AT=645.025n

.meas tran vdout0_223ck1280 FIND v(dout0_223) AT=645.025n

.meas tran vdout0_224ck1280 FIND v(dout0_224) AT=645.025n

.meas tran vdout0_225ck1280 FIND v(dout0_225) AT=645.025n

.meas tran vdout0_226ck1280 FIND v(dout0_226) AT=645.025n

.meas tran vdout0_227ck1280 FIND v(dout0_227) AT=645.025n

.meas tran vdout0_228ck1280 FIND v(dout0_228) AT=645.025n

.meas tran vdout0_229ck1280 FIND v(dout0_229) AT=645.025n

.meas tran vdout0_230ck1280 FIND v(dout0_230) AT=645.025n

.meas tran vdout0_231ck1280 FIND v(dout0_231) AT=645.025n

.meas tran vdout0_232ck1280 FIND v(dout0_232) AT=645.025n

.meas tran vdout0_233ck1280 FIND v(dout0_233) AT=645.025n

.meas tran vdout0_234ck1280 FIND v(dout0_234) AT=645.025n

.meas tran vdout0_235ck1280 FIND v(dout0_235) AT=645.025n

.meas tran vdout0_236ck1280 FIND v(dout0_236) AT=645.025n

.meas tran vdout0_237ck1280 FIND v(dout0_237) AT=645.025n

.meas tran vdout0_238ck1280 FIND v(dout0_238) AT=645.025n

.meas tran vdout0_239ck1280 FIND v(dout0_239) AT=645.025n

.meas tran vdout0_240ck1280 FIND v(dout0_240) AT=645.025n

.meas tran vdout0_241ck1280 FIND v(dout0_241) AT=645.025n

.meas tran vdout0_242ck1280 FIND v(dout0_242) AT=645.025n

.meas tran vdout0_243ck1280 FIND v(dout0_243) AT=645.025n

.meas tran vdout0_244ck1280 FIND v(dout0_244) AT=645.025n

.meas tran vdout0_245ck1280 FIND v(dout0_245) AT=645.025n

.meas tran vdout0_246ck1280 FIND v(dout0_246) AT=645.025n

.meas tran vdout0_247ck1280 FIND v(dout0_247) AT=645.025n

.meas tran vdout0_248ck1280 FIND v(dout0_248) AT=645.025n

.meas tran vdout0_249ck1280 FIND v(dout0_249) AT=645.025n

.meas tran vdout0_250ck1280 FIND v(dout0_250) AT=645.025n

.meas tran vdout0_251ck1280 FIND v(dout0_251) AT=645.025n

.meas tran vdout0_252ck1280 FIND v(dout0_252) AT=645.025n

.meas tran vdout0_253ck1280 FIND v(dout0_253) AT=645.025n

.meas tran vdout0_254ck1280 FIND v(dout0_254) AT=645.025n

.meas tran vdout0_255ck1280 FIND v(dout0_255) AT=645.025n

.meas tran vdout0_0ck1290 FIND v(dout0_0) AT=650.025n

.meas tran vdout0_1ck1290 FIND v(dout0_1) AT=650.025n

.meas tran vdout0_2ck1290 FIND v(dout0_2) AT=650.025n

.meas tran vdout0_3ck1290 FIND v(dout0_3) AT=650.025n

.meas tran vdout0_4ck1290 FIND v(dout0_4) AT=650.025n

.meas tran vdout0_5ck1290 FIND v(dout0_5) AT=650.025n

.meas tran vdout0_6ck1290 FIND v(dout0_6) AT=650.025n

.meas tran vdout0_7ck1290 FIND v(dout0_7) AT=650.025n

.meas tran vdout0_8ck1290 FIND v(dout0_8) AT=650.025n

.meas tran vdout0_9ck1290 FIND v(dout0_9) AT=650.025n

.meas tran vdout0_10ck1290 FIND v(dout0_10) AT=650.025n

.meas tran vdout0_11ck1290 FIND v(dout0_11) AT=650.025n

.meas tran vdout0_12ck1290 FIND v(dout0_12) AT=650.025n

.meas tran vdout0_13ck1290 FIND v(dout0_13) AT=650.025n

.meas tran vdout0_14ck1290 FIND v(dout0_14) AT=650.025n

.meas tran vdout0_15ck1290 FIND v(dout0_15) AT=650.025n

.meas tran vdout0_16ck1290 FIND v(dout0_16) AT=650.025n

.meas tran vdout0_17ck1290 FIND v(dout0_17) AT=650.025n

.meas tran vdout0_18ck1290 FIND v(dout0_18) AT=650.025n

.meas tran vdout0_19ck1290 FIND v(dout0_19) AT=650.025n

.meas tran vdout0_20ck1290 FIND v(dout0_20) AT=650.025n

.meas tran vdout0_21ck1290 FIND v(dout0_21) AT=650.025n

.meas tran vdout0_22ck1290 FIND v(dout0_22) AT=650.025n

.meas tran vdout0_23ck1290 FIND v(dout0_23) AT=650.025n

.meas tran vdout0_24ck1290 FIND v(dout0_24) AT=650.025n

.meas tran vdout0_25ck1290 FIND v(dout0_25) AT=650.025n

.meas tran vdout0_26ck1290 FIND v(dout0_26) AT=650.025n

.meas tran vdout0_27ck1290 FIND v(dout0_27) AT=650.025n

.meas tran vdout0_28ck1290 FIND v(dout0_28) AT=650.025n

.meas tran vdout0_29ck1290 FIND v(dout0_29) AT=650.025n

.meas tran vdout0_30ck1290 FIND v(dout0_30) AT=650.025n

.meas tran vdout0_31ck1290 FIND v(dout0_31) AT=650.025n

.meas tran vdout0_32ck1290 FIND v(dout0_32) AT=650.025n

.meas tran vdout0_33ck1290 FIND v(dout0_33) AT=650.025n

.meas tran vdout0_34ck1290 FIND v(dout0_34) AT=650.025n

.meas tran vdout0_35ck1290 FIND v(dout0_35) AT=650.025n

.meas tran vdout0_36ck1290 FIND v(dout0_36) AT=650.025n

.meas tran vdout0_37ck1290 FIND v(dout0_37) AT=650.025n

.meas tran vdout0_38ck1290 FIND v(dout0_38) AT=650.025n

.meas tran vdout0_39ck1290 FIND v(dout0_39) AT=650.025n

.meas tran vdout0_40ck1290 FIND v(dout0_40) AT=650.025n

.meas tran vdout0_41ck1290 FIND v(dout0_41) AT=650.025n

.meas tran vdout0_42ck1290 FIND v(dout0_42) AT=650.025n

.meas tran vdout0_43ck1290 FIND v(dout0_43) AT=650.025n

.meas tran vdout0_44ck1290 FIND v(dout0_44) AT=650.025n

.meas tran vdout0_45ck1290 FIND v(dout0_45) AT=650.025n

.meas tran vdout0_46ck1290 FIND v(dout0_46) AT=650.025n

.meas tran vdout0_47ck1290 FIND v(dout0_47) AT=650.025n

.meas tran vdout0_48ck1290 FIND v(dout0_48) AT=650.025n

.meas tran vdout0_49ck1290 FIND v(dout0_49) AT=650.025n

.meas tran vdout0_50ck1290 FIND v(dout0_50) AT=650.025n

.meas tran vdout0_51ck1290 FIND v(dout0_51) AT=650.025n

.meas tran vdout0_52ck1290 FIND v(dout0_52) AT=650.025n

.meas tran vdout0_53ck1290 FIND v(dout0_53) AT=650.025n

.meas tran vdout0_54ck1290 FIND v(dout0_54) AT=650.025n

.meas tran vdout0_55ck1290 FIND v(dout0_55) AT=650.025n

.meas tran vdout0_56ck1290 FIND v(dout0_56) AT=650.025n

.meas tran vdout0_57ck1290 FIND v(dout0_57) AT=650.025n

.meas tran vdout0_58ck1290 FIND v(dout0_58) AT=650.025n

.meas tran vdout0_59ck1290 FIND v(dout0_59) AT=650.025n

.meas tran vdout0_60ck1290 FIND v(dout0_60) AT=650.025n

.meas tran vdout0_61ck1290 FIND v(dout0_61) AT=650.025n

.meas tran vdout0_62ck1290 FIND v(dout0_62) AT=650.025n

.meas tran vdout0_63ck1290 FIND v(dout0_63) AT=650.025n

.meas tran vdout0_64ck1290 FIND v(dout0_64) AT=650.025n

.meas tran vdout0_65ck1290 FIND v(dout0_65) AT=650.025n

.meas tran vdout0_66ck1290 FIND v(dout0_66) AT=650.025n

.meas tran vdout0_67ck1290 FIND v(dout0_67) AT=650.025n

.meas tran vdout0_68ck1290 FIND v(dout0_68) AT=650.025n

.meas tran vdout0_69ck1290 FIND v(dout0_69) AT=650.025n

.meas tran vdout0_70ck1290 FIND v(dout0_70) AT=650.025n

.meas tran vdout0_71ck1290 FIND v(dout0_71) AT=650.025n

.meas tran vdout0_72ck1290 FIND v(dout0_72) AT=650.025n

.meas tran vdout0_73ck1290 FIND v(dout0_73) AT=650.025n

.meas tran vdout0_74ck1290 FIND v(dout0_74) AT=650.025n

.meas tran vdout0_75ck1290 FIND v(dout0_75) AT=650.025n

.meas tran vdout0_76ck1290 FIND v(dout0_76) AT=650.025n

.meas tran vdout0_77ck1290 FIND v(dout0_77) AT=650.025n

.meas tran vdout0_78ck1290 FIND v(dout0_78) AT=650.025n

.meas tran vdout0_79ck1290 FIND v(dout0_79) AT=650.025n

.meas tran vdout0_80ck1290 FIND v(dout0_80) AT=650.025n

.meas tran vdout0_81ck1290 FIND v(dout0_81) AT=650.025n

.meas tran vdout0_82ck1290 FIND v(dout0_82) AT=650.025n

.meas tran vdout0_83ck1290 FIND v(dout0_83) AT=650.025n

.meas tran vdout0_84ck1290 FIND v(dout0_84) AT=650.025n

.meas tran vdout0_85ck1290 FIND v(dout0_85) AT=650.025n

.meas tran vdout0_86ck1290 FIND v(dout0_86) AT=650.025n

.meas tran vdout0_87ck1290 FIND v(dout0_87) AT=650.025n

.meas tran vdout0_88ck1290 FIND v(dout0_88) AT=650.025n

.meas tran vdout0_89ck1290 FIND v(dout0_89) AT=650.025n

.meas tran vdout0_90ck1290 FIND v(dout0_90) AT=650.025n

.meas tran vdout0_91ck1290 FIND v(dout0_91) AT=650.025n

.meas tran vdout0_92ck1290 FIND v(dout0_92) AT=650.025n

.meas tran vdout0_93ck1290 FIND v(dout0_93) AT=650.025n

.meas tran vdout0_94ck1290 FIND v(dout0_94) AT=650.025n

.meas tran vdout0_95ck1290 FIND v(dout0_95) AT=650.025n

.meas tran vdout0_96ck1290 FIND v(dout0_96) AT=650.025n

.meas tran vdout0_97ck1290 FIND v(dout0_97) AT=650.025n

.meas tran vdout0_98ck1290 FIND v(dout0_98) AT=650.025n

.meas tran vdout0_99ck1290 FIND v(dout0_99) AT=650.025n

.meas tran vdout0_100ck1290 FIND v(dout0_100) AT=650.025n

.meas tran vdout0_101ck1290 FIND v(dout0_101) AT=650.025n

.meas tran vdout0_102ck1290 FIND v(dout0_102) AT=650.025n

.meas tran vdout0_103ck1290 FIND v(dout0_103) AT=650.025n

.meas tran vdout0_104ck1290 FIND v(dout0_104) AT=650.025n

.meas tran vdout0_105ck1290 FIND v(dout0_105) AT=650.025n

.meas tran vdout0_106ck1290 FIND v(dout0_106) AT=650.025n

.meas tran vdout0_107ck1290 FIND v(dout0_107) AT=650.025n

.meas tran vdout0_108ck1290 FIND v(dout0_108) AT=650.025n

.meas tran vdout0_109ck1290 FIND v(dout0_109) AT=650.025n

.meas tran vdout0_110ck1290 FIND v(dout0_110) AT=650.025n

.meas tran vdout0_111ck1290 FIND v(dout0_111) AT=650.025n

.meas tran vdout0_112ck1290 FIND v(dout0_112) AT=650.025n

.meas tran vdout0_113ck1290 FIND v(dout0_113) AT=650.025n

.meas tran vdout0_114ck1290 FIND v(dout0_114) AT=650.025n

.meas tran vdout0_115ck1290 FIND v(dout0_115) AT=650.025n

.meas tran vdout0_116ck1290 FIND v(dout0_116) AT=650.025n

.meas tran vdout0_117ck1290 FIND v(dout0_117) AT=650.025n

.meas tran vdout0_118ck1290 FIND v(dout0_118) AT=650.025n

.meas tran vdout0_119ck1290 FIND v(dout0_119) AT=650.025n

.meas tran vdout0_120ck1290 FIND v(dout0_120) AT=650.025n

.meas tran vdout0_121ck1290 FIND v(dout0_121) AT=650.025n

.meas tran vdout0_122ck1290 FIND v(dout0_122) AT=650.025n

.meas tran vdout0_123ck1290 FIND v(dout0_123) AT=650.025n

.meas tran vdout0_124ck1290 FIND v(dout0_124) AT=650.025n

.meas tran vdout0_125ck1290 FIND v(dout0_125) AT=650.025n

.meas tran vdout0_126ck1290 FIND v(dout0_126) AT=650.025n

.meas tran vdout0_127ck1290 FIND v(dout0_127) AT=650.025n

.meas tran vdout0_128ck1290 FIND v(dout0_128) AT=650.025n

.meas tran vdout0_129ck1290 FIND v(dout0_129) AT=650.025n

.meas tran vdout0_130ck1290 FIND v(dout0_130) AT=650.025n

.meas tran vdout0_131ck1290 FIND v(dout0_131) AT=650.025n

.meas tran vdout0_132ck1290 FIND v(dout0_132) AT=650.025n

.meas tran vdout0_133ck1290 FIND v(dout0_133) AT=650.025n

.meas tran vdout0_134ck1290 FIND v(dout0_134) AT=650.025n

.meas tran vdout0_135ck1290 FIND v(dout0_135) AT=650.025n

.meas tran vdout0_136ck1290 FIND v(dout0_136) AT=650.025n

.meas tran vdout0_137ck1290 FIND v(dout0_137) AT=650.025n

.meas tran vdout0_138ck1290 FIND v(dout0_138) AT=650.025n

.meas tran vdout0_139ck1290 FIND v(dout0_139) AT=650.025n

.meas tran vdout0_140ck1290 FIND v(dout0_140) AT=650.025n

.meas tran vdout0_141ck1290 FIND v(dout0_141) AT=650.025n

.meas tran vdout0_142ck1290 FIND v(dout0_142) AT=650.025n

.meas tran vdout0_143ck1290 FIND v(dout0_143) AT=650.025n

.meas tran vdout0_144ck1290 FIND v(dout0_144) AT=650.025n

.meas tran vdout0_145ck1290 FIND v(dout0_145) AT=650.025n

.meas tran vdout0_146ck1290 FIND v(dout0_146) AT=650.025n

.meas tran vdout0_147ck1290 FIND v(dout0_147) AT=650.025n

.meas tran vdout0_148ck1290 FIND v(dout0_148) AT=650.025n

.meas tran vdout0_149ck1290 FIND v(dout0_149) AT=650.025n

.meas tran vdout0_150ck1290 FIND v(dout0_150) AT=650.025n

.meas tran vdout0_151ck1290 FIND v(dout0_151) AT=650.025n

.meas tran vdout0_152ck1290 FIND v(dout0_152) AT=650.025n

.meas tran vdout0_153ck1290 FIND v(dout0_153) AT=650.025n

.meas tran vdout0_154ck1290 FIND v(dout0_154) AT=650.025n

.meas tran vdout0_155ck1290 FIND v(dout0_155) AT=650.025n

.meas tran vdout0_156ck1290 FIND v(dout0_156) AT=650.025n

.meas tran vdout0_157ck1290 FIND v(dout0_157) AT=650.025n

.meas tran vdout0_158ck1290 FIND v(dout0_158) AT=650.025n

.meas tran vdout0_159ck1290 FIND v(dout0_159) AT=650.025n

.meas tran vdout0_160ck1290 FIND v(dout0_160) AT=650.025n

.meas tran vdout0_161ck1290 FIND v(dout0_161) AT=650.025n

.meas tran vdout0_162ck1290 FIND v(dout0_162) AT=650.025n

.meas tran vdout0_163ck1290 FIND v(dout0_163) AT=650.025n

.meas tran vdout0_164ck1290 FIND v(dout0_164) AT=650.025n

.meas tran vdout0_165ck1290 FIND v(dout0_165) AT=650.025n

.meas tran vdout0_166ck1290 FIND v(dout0_166) AT=650.025n

.meas tran vdout0_167ck1290 FIND v(dout0_167) AT=650.025n

.meas tran vdout0_168ck1290 FIND v(dout0_168) AT=650.025n

.meas tran vdout0_169ck1290 FIND v(dout0_169) AT=650.025n

.meas tran vdout0_170ck1290 FIND v(dout0_170) AT=650.025n

.meas tran vdout0_171ck1290 FIND v(dout0_171) AT=650.025n

.meas tran vdout0_172ck1290 FIND v(dout0_172) AT=650.025n

.meas tran vdout0_173ck1290 FIND v(dout0_173) AT=650.025n

.meas tran vdout0_174ck1290 FIND v(dout0_174) AT=650.025n

.meas tran vdout0_175ck1290 FIND v(dout0_175) AT=650.025n

.meas tran vdout0_176ck1290 FIND v(dout0_176) AT=650.025n

.meas tran vdout0_177ck1290 FIND v(dout0_177) AT=650.025n

.meas tran vdout0_178ck1290 FIND v(dout0_178) AT=650.025n

.meas tran vdout0_179ck1290 FIND v(dout0_179) AT=650.025n

.meas tran vdout0_180ck1290 FIND v(dout0_180) AT=650.025n

.meas tran vdout0_181ck1290 FIND v(dout0_181) AT=650.025n

.meas tran vdout0_182ck1290 FIND v(dout0_182) AT=650.025n

.meas tran vdout0_183ck1290 FIND v(dout0_183) AT=650.025n

.meas tran vdout0_184ck1290 FIND v(dout0_184) AT=650.025n

.meas tran vdout0_185ck1290 FIND v(dout0_185) AT=650.025n

.meas tran vdout0_186ck1290 FIND v(dout0_186) AT=650.025n

.meas tran vdout0_187ck1290 FIND v(dout0_187) AT=650.025n

.meas tran vdout0_188ck1290 FIND v(dout0_188) AT=650.025n

.meas tran vdout0_189ck1290 FIND v(dout0_189) AT=650.025n

.meas tran vdout0_190ck1290 FIND v(dout0_190) AT=650.025n

.meas tran vdout0_191ck1290 FIND v(dout0_191) AT=650.025n

.meas tran vdout0_192ck1290 FIND v(dout0_192) AT=650.025n

.meas tran vdout0_193ck1290 FIND v(dout0_193) AT=650.025n

.meas tran vdout0_194ck1290 FIND v(dout0_194) AT=650.025n

.meas tran vdout0_195ck1290 FIND v(dout0_195) AT=650.025n

.meas tran vdout0_196ck1290 FIND v(dout0_196) AT=650.025n

.meas tran vdout0_197ck1290 FIND v(dout0_197) AT=650.025n

.meas tran vdout0_198ck1290 FIND v(dout0_198) AT=650.025n

.meas tran vdout0_199ck1290 FIND v(dout0_199) AT=650.025n

.meas tran vdout0_200ck1290 FIND v(dout0_200) AT=650.025n

.meas tran vdout0_201ck1290 FIND v(dout0_201) AT=650.025n

.meas tran vdout0_202ck1290 FIND v(dout0_202) AT=650.025n

.meas tran vdout0_203ck1290 FIND v(dout0_203) AT=650.025n

.meas tran vdout0_204ck1290 FIND v(dout0_204) AT=650.025n

.meas tran vdout0_205ck1290 FIND v(dout0_205) AT=650.025n

.meas tran vdout0_206ck1290 FIND v(dout0_206) AT=650.025n

.meas tran vdout0_207ck1290 FIND v(dout0_207) AT=650.025n

.meas tran vdout0_208ck1290 FIND v(dout0_208) AT=650.025n

.meas tran vdout0_209ck1290 FIND v(dout0_209) AT=650.025n

.meas tran vdout0_210ck1290 FIND v(dout0_210) AT=650.025n

.meas tran vdout0_211ck1290 FIND v(dout0_211) AT=650.025n

.meas tran vdout0_212ck1290 FIND v(dout0_212) AT=650.025n

.meas tran vdout0_213ck1290 FIND v(dout0_213) AT=650.025n

.meas tran vdout0_214ck1290 FIND v(dout0_214) AT=650.025n

.meas tran vdout0_215ck1290 FIND v(dout0_215) AT=650.025n

.meas tran vdout0_216ck1290 FIND v(dout0_216) AT=650.025n

.meas tran vdout0_217ck1290 FIND v(dout0_217) AT=650.025n

.meas tran vdout0_218ck1290 FIND v(dout0_218) AT=650.025n

.meas tran vdout0_219ck1290 FIND v(dout0_219) AT=650.025n

.meas tran vdout0_220ck1290 FIND v(dout0_220) AT=650.025n

.meas tran vdout0_221ck1290 FIND v(dout0_221) AT=650.025n

.meas tran vdout0_222ck1290 FIND v(dout0_222) AT=650.025n

.meas tran vdout0_223ck1290 FIND v(dout0_223) AT=650.025n

.meas tran vdout0_224ck1290 FIND v(dout0_224) AT=650.025n

.meas tran vdout0_225ck1290 FIND v(dout0_225) AT=650.025n

.meas tran vdout0_226ck1290 FIND v(dout0_226) AT=650.025n

.meas tran vdout0_227ck1290 FIND v(dout0_227) AT=650.025n

.meas tran vdout0_228ck1290 FIND v(dout0_228) AT=650.025n

.meas tran vdout0_229ck1290 FIND v(dout0_229) AT=650.025n

.meas tran vdout0_230ck1290 FIND v(dout0_230) AT=650.025n

.meas tran vdout0_231ck1290 FIND v(dout0_231) AT=650.025n

.meas tran vdout0_232ck1290 FIND v(dout0_232) AT=650.025n

.meas tran vdout0_233ck1290 FIND v(dout0_233) AT=650.025n

.meas tran vdout0_234ck1290 FIND v(dout0_234) AT=650.025n

.meas tran vdout0_235ck1290 FIND v(dout0_235) AT=650.025n

.meas tran vdout0_236ck1290 FIND v(dout0_236) AT=650.025n

.meas tran vdout0_237ck1290 FIND v(dout0_237) AT=650.025n

.meas tran vdout0_238ck1290 FIND v(dout0_238) AT=650.025n

.meas tran vdout0_239ck1290 FIND v(dout0_239) AT=650.025n

.meas tran vdout0_240ck1290 FIND v(dout0_240) AT=650.025n

.meas tran vdout0_241ck1290 FIND v(dout0_241) AT=650.025n

.meas tran vdout0_242ck1290 FIND v(dout0_242) AT=650.025n

.meas tran vdout0_243ck1290 FIND v(dout0_243) AT=650.025n

.meas tran vdout0_244ck1290 FIND v(dout0_244) AT=650.025n

.meas tran vdout0_245ck1290 FIND v(dout0_245) AT=650.025n

.meas tran vdout0_246ck1290 FIND v(dout0_246) AT=650.025n

.meas tran vdout0_247ck1290 FIND v(dout0_247) AT=650.025n

.meas tran vdout0_248ck1290 FIND v(dout0_248) AT=650.025n

.meas tran vdout0_249ck1290 FIND v(dout0_249) AT=650.025n

.meas tran vdout0_250ck1290 FIND v(dout0_250) AT=650.025n

.meas tran vdout0_251ck1290 FIND v(dout0_251) AT=650.025n

.meas tran vdout0_252ck1290 FIND v(dout0_252) AT=650.025n

.meas tran vdout0_253ck1290 FIND v(dout0_253) AT=650.025n

.meas tran vdout0_254ck1290 FIND v(dout0_254) AT=650.025n

.meas tran vdout0_255ck1290 FIND v(dout0_255) AT=650.025n

.meas tran vdout0_0ck1300 FIND v(dout0_0) AT=655.025n

.meas tran vdout0_1ck1300 FIND v(dout0_1) AT=655.025n

.meas tran vdout0_2ck1300 FIND v(dout0_2) AT=655.025n

.meas tran vdout0_3ck1300 FIND v(dout0_3) AT=655.025n

.meas tran vdout0_4ck1300 FIND v(dout0_4) AT=655.025n

.meas tran vdout0_5ck1300 FIND v(dout0_5) AT=655.025n

.meas tran vdout0_6ck1300 FIND v(dout0_6) AT=655.025n

.meas tran vdout0_7ck1300 FIND v(dout0_7) AT=655.025n

.meas tran vdout0_8ck1300 FIND v(dout0_8) AT=655.025n

.meas tran vdout0_9ck1300 FIND v(dout0_9) AT=655.025n

.meas tran vdout0_10ck1300 FIND v(dout0_10) AT=655.025n

.meas tran vdout0_11ck1300 FIND v(dout0_11) AT=655.025n

.meas tran vdout0_12ck1300 FIND v(dout0_12) AT=655.025n

.meas tran vdout0_13ck1300 FIND v(dout0_13) AT=655.025n

.meas tran vdout0_14ck1300 FIND v(dout0_14) AT=655.025n

.meas tran vdout0_15ck1300 FIND v(dout0_15) AT=655.025n

.meas tran vdout0_16ck1300 FIND v(dout0_16) AT=655.025n

.meas tran vdout0_17ck1300 FIND v(dout0_17) AT=655.025n

.meas tran vdout0_18ck1300 FIND v(dout0_18) AT=655.025n

.meas tran vdout0_19ck1300 FIND v(dout0_19) AT=655.025n

.meas tran vdout0_20ck1300 FIND v(dout0_20) AT=655.025n

.meas tran vdout0_21ck1300 FIND v(dout0_21) AT=655.025n

.meas tran vdout0_22ck1300 FIND v(dout0_22) AT=655.025n

.meas tran vdout0_23ck1300 FIND v(dout0_23) AT=655.025n

.meas tran vdout0_24ck1300 FIND v(dout0_24) AT=655.025n

.meas tran vdout0_25ck1300 FIND v(dout0_25) AT=655.025n

.meas tran vdout0_26ck1300 FIND v(dout0_26) AT=655.025n

.meas tran vdout0_27ck1300 FIND v(dout0_27) AT=655.025n

.meas tran vdout0_28ck1300 FIND v(dout0_28) AT=655.025n

.meas tran vdout0_29ck1300 FIND v(dout0_29) AT=655.025n

.meas tran vdout0_30ck1300 FIND v(dout0_30) AT=655.025n

.meas tran vdout0_31ck1300 FIND v(dout0_31) AT=655.025n

.meas tran vdout0_32ck1300 FIND v(dout0_32) AT=655.025n

.meas tran vdout0_33ck1300 FIND v(dout0_33) AT=655.025n

.meas tran vdout0_34ck1300 FIND v(dout0_34) AT=655.025n

.meas tran vdout0_35ck1300 FIND v(dout0_35) AT=655.025n

.meas tran vdout0_36ck1300 FIND v(dout0_36) AT=655.025n

.meas tran vdout0_37ck1300 FIND v(dout0_37) AT=655.025n

.meas tran vdout0_38ck1300 FIND v(dout0_38) AT=655.025n

.meas tran vdout0_39ck1300 FIND v(dout0_39) AT=655.025n

.meas tran vdout0_40ck1300 FIND v(dout0_40) AT=655.025n

.meas tran vdout0_41ck1300 FIND v(dout0_41) AT=655.025n

.meas tran vdout0_42ck1300 FIND v(dout0_42) AT=655.025n

.meas tran vdout0_43ck1300 FIND v(dout0_43) AT=655.025n

.meas tran vdout0_44ck1300 FIND v(dout0_44) AT=655.025n

.meas tran vdout0_45ck1300 FIND v(dout0_45) AT=655.025n

.meas tran vdout0_46ck1300 FIND v(dout0_46) AT=655.025n

.meas tran vdout0_47ck1300 FIND v(dout0_47) AT=655.025n

.meas tran vdout0_48ck1300 FIND v(dout0_48) AT=655.025n

.meas tran vdout0_49ck1300 FIND v(dout0_49) AT=655.025n

.meas tran vdout0_50ck1300 FIND v(dout0_50) AT=655.025n

.meas tran vdout0_51ck1300 FIND v(dout0_51) AT=655.025n

.meas tran vdout0_52ck1300 FIND v(dout0_52) AT=655.025n

.meas tran vdout0_53ck1300 FIND v(dout0_53) AT=655.025n

.meas tran vdout0_54ck1300 FIND v(dout0_54) AT=655.025n

.meas tran vdout0_55ck1300 FIND v(dout0_55) AT=655.025n

.meas tran vdout0_56ck1300 FIND v(dout0_56) AT=655.025n

.meas tran vdout0_57ck1300 FIND v(dout0_57) AT=655.025n

.meas tran vdout0_58ck1300 FIND v(dout0_58) AT=655.025n

.meas tran vdout0_59ck1300 FIND v(dout0_59) AT=655.025n

.meas tran vdout0_60ck1300 FIND v(dout0_60) AT=655.025n

.meas tran vdout0_61ck1300 FIND v(dout0_61) AT=655.025n

.meas tran vdout0_62ck1300 FIND v(dout0_62) AT=655.025n

.meas tran vdout0_63ck1300 FIND v(dout0_63) AT=655.025n

.meas tran vdout0_64ck1300 FIND v(dout0_64) AT=655.025n

.meas tran vdout0_65ck1300 FIND v(dout0_65) AT=655.025n

.meas tran vdout0_66ck1300 FIND v(dout0_66) AT=655.025n

.meas tran vdout0_67ck1300 FIND v(dout0_67) AT=655.025n

.meas tran vdout0_68ck1300 FIND v(dout0_68) AT=655.025n

.meas tran vdout0_69ck1300 FIND v(dout0_69) AT=655.025n

.meas tran vdout0_70ck1300 FIND v(dout0_70) AT=655.025n

.meas tran vdout0_71ck1300 FIND v(dout0_71) AT=655.025n

.meas tran vdout0_72ck1300 FIND v(dout0_72) AT=655.025n

.meas tran vdout0_73ck1300 FIND v(dout0_73) AT=655.025n

.meas tran vdout0_74ck1300 FIND v(dout0_74) AT=655.025n

.meas tran vdout0_75ck1300 FIND v(dout0_75) AT=655.025n

.meas tran vdout0_76ck1300 FIND v(dout0_76) AT=655.025n

.meas tran vdout0_77ck1300 FIND v(dout0_77) AT=655.025n

.meas tran vdout0_78ck1300 FIND v(dout0_78) AT=655.025n

.meas tran vdout0_79ck1300 FIND v(dout0_79) AT=655.025n

.meas tran vdout0_80ck1300 FIND v(dout0_80) AT=655.025n

.meas tran vdout0_81ck1300 FIND v(dout0_81) AT=655.025n

.meas tran vdout0_82ck1300 FIND v(dout0_82) AT=655.025n

.meas tran vdout0_83ck1300 FIND v(dout0_83) AT=655.025n

.meas tran vdout0_84ck1300 FIND v(dout0_84) AT=655.025n

.meas tran vdout0_85ck1300 FIND v(dout0_85) AT=655.025n

.meas tran vdout0_86ck1300 FIND v(dout0_86) AT=655.025n

.meas tran vdout0_87ck1300 FIND v(dout0_87) AT=655.025n

.meas tran vdout0_88ck1300 FIND v(dout0_88) AT=655.025n

.meas tran vdout0_89ck1300 FIND v(dout0_89) AT=655.025n

.meas tran vdout0_90ck1300 FIND v(dout0_90) AT=655.025n

.meas tran vdout0_91ck1300 FIND v(dout0_91) AT=655.025n

.meas tran vdout0_92ck1300 FIND v(dout0_92) AT=655.025n

.meas tran vdout0_93ck1300 FIND v(dout0_93) AT=655.025n

.meas tran vdout0_94ck1300 FIND v(dout0_94) AT=655.025n

.meas tran vdout0_95ck1300 FIND v(dout0_95) AT=655.025n

.meas tran vdout0_96ck1300 FIND v(dout0_96) AT=655.025n

.meas tran vdout0_97ck1300 FIND v(dout0_97) AT=655.025n

.meas tran vdout0_98ck1300 FIND v(dout0_98) AT=655.025n

.meas tran vdout0_99ck1300 FIND v(dout0_99) AT=655.025n

.meas tran vdout0_100ck1300 FIND v(dout0_100) AT=655.025n

.meas tran vdout0_101ck1300 FIND v(dout0_101) AT=655.025n

.meas tran vdout0_102ck1300 FIND v(dout0_102) AT=655.025n

.meas tran vdout0_103ck1300 FIND v(dout0_103) AT=655.025n

.meas tran vdout0_104ck1300 FIND v(dout0_104) AT=655.025n

.meas tran vdout0_105ck1300 FIND v(dout0_105) AT=655.025n

.meas tran vdout0_106ck1300 FIND v(dout0_106) AT=655.025n

.meas tran vdout0_107ck1300 FIND v(dout0_107) AT=655.025n

.meas tran vdout0_108ck1300 FIND v(dout0_108) AT=655.025n

.meas tran vdout0_109ck1300 FIND v(dout0_109) AT=655.025n

.meas tran vdout0_110ck1300 FIND v(dout0_110) AT=655.025n

.meas tran vdout0_111ck1300 FIND v(dout0_111) AT=655.025n

.meas tran vdout0_112ck1300 FIND v(dout0_112) AT=655.025n

.meas tran vdout0_113ck1300 FIND v(dout0_113) AT=655.025n

.meas tran vdout0_114ck1300 FIND v(dout0_114) AT=655.025n

.meas tran vdout0_115ck1300 FIND v(dout0_115) AT=655.025n

.meas tran vdout0_116ck1300 FIND v(dout0_116) AT=655.025n

.meas tran vdout0_117ck1300 FIND v(dout0_117) AT=655.025n

.meas tran vdout0_118ck1300 FIND v(dout0_118) AT=655.025n

.meas tran vdout0_119ck1300 FIND v(dout0_119) AT=655.025n

.meas tran vdout0_120ck1300 FIND v(dout0_120) AT=655.025n

.meas tran vdout0_121ck1300 FIND v(dout0_121) AT=655.025n

.meas tran vdout0_122ck1300 FIND v(dout0_122) AT=655.025n

.meas tran vdout0_123ck1300 FIND v(dout0_123) AT=655.025n

.meas tran vdout0_124ck1300 FIND v(dout0_124) AT=655.025n

.meas tran vdout0_125ck1300 FIND v(dout0_125) AT=655.025n

.meas tran vdout0_126ck1300 FIND v(dout0_126) AT=655.025n

.meas tran vdout0_127ck1300 FIND v(dout0_127) AT=655.025n

.meas tran vdout0_128ck1300 FIND v(dout0_128) AT=655.025n

.meas tran vdout0_129ck1300 FIND v(dout0_129) AT=655.025n

.meas tran vdout0_130ck1300 FIND v(dout0_130) AT=655.025n

.meas tran vdout0_131ck1300 FIND v(dout0_131) AT=655.025n

.meas tran vdout0_132ck1300 FIND v(dout0_132) AT=655.025n

.meas tran vdout0_133ck1300 FIND v(dout0_133) AT=655.025n

.meas tran vdout0_134ck1300 FIND v(dout0_134) AT=655.025n

.meas tran vdout0_135ck1300 FIND v(dout0_135) AT=655.025n

.meas tran vdout0_136ck1300 FIND v(dout0_136) AT=655.025n

.meas tran vdout0_137ck1300 FIND v(dout0_137) AT=655.025n

.meas tran vdout0_138ck1300 FIND v(dout0_138) AT=655.025n

.meas tran vdout0_139ck1300 FIND v(dout0_139) AT=655.025n

.meas tran vdout0_140ck1300 FIND v(dout0_140) AT=655.025n

.meas tran vdout0_141ck1300 FIND v(dout0_141) AT=655.025n

.meas tran vdout0_142ck1300 FIND v(dout0_142) AT=655.025n

.meas tran vdout0_143ck1300 FIND v(dout0_143) AT=655.025n

.meas tran vdout0_144ck1300 FIND v(dout0_144) AT=655.025n

.meas tran vdout0_145ck1300 FIND v(dout0_145) AT=655.025n

.meas tran vdout0_146ck1300 FIND v(dout0_146) AT=655.025n

.meas tran vdout0_147ck1300 FIND v(dout0_147) AT=655.025n

.meas tran vdout0_148ck1300 FIND v(dout0_148) AT=655.025n

.meas tran vdout0_149ck1300 FIND v(dout0_149) AT=655.025n

.meas tran vdout0_150ck1300 FIND v(dout0_150) AT=655.025n

.meas tran vdout0_151ck1300 FIND v(dout0_151) AT=655.025n

.meas tran vdout0_152ck1300 FIND v(dout0_152) AT=655.025n

.meas tran vdout0_153ck1300 FIND v(dout0_153) AT=655.025n

.meas tran vdout0_154ck1300 FIND v(dout0_154) AT=655.025n

.meas tran vdout0_155ck1300 FIND v(dout0_155) AT=655.025n

.meas tran vdout0_156ck1300 FIND v(dout0_156) AT=655.025n

.meas tran vdout0_157ck1300 FIND v(dout0_157) AT=655.025n

.meas tran vdout0_158ck1300 FIND v(dout0_158) AT=655.025n

.meas tran vdout0_159ck1300 FIND v(dout0_159) AT=655.025n

.meas tran vdout0_160ck1300 FIND v(dout0_160) AT=655.025n

.meas tran vdout0_161ck1300 FIND v(dout0_161) AT=655.025n

.meas tran vdout0_162ck1300 FIND v(dout0_162) AT=655.025n

.meas tran vdout0_163ck1300 FIND v(dout0_163) AT=655.025n

.meas tran vdout0_164ck1300 FIND v(dout0_164) AT=655.025n

.meas tran vdout0_165ck1300 FIND v(dout0_165) AT=655.025n

.meas tran vdout0_166ck1300 FIND v(dout0_166) AT=655.025n

.meas tran vdout0_167ck1300 FIND v(dout0_167) AT=655.025n

.meas tran vdout0_168ck1300 FIND v(dout0_168) AT=655.025n

.meas tran vdout0_169ck1300 FIND v(dout0_169) AT=655.025n

.meas tran vdout0_170ck1300 FIND v(dout0_170) AT=655.025n

.meas tran vdout0_171ck1300 FIND v(dout0_171) AT=655.025n

.meas tran vdout0_172ck1300 FIND v(dout0_172) AT=655.025n

.meas tran vdout0_173ck1300 FIND v(dout0_173) AT=655.025n

.meas tran vdout0_174ck1300 FIND v(dout0_174) AT=655.025n

.meas tran vdout0_175ck1300 FIND v(dout0_175) AT=655.025n

.meas tran vdout0_176ck1300 FIND v(dout0_176) AT=655.025n

.meas tran vdout0_177ck1300 FIND v(dout0_177) AT=655.025n

.meas tran vdout0_178ck1300 FIND v(dout0_178) AT=655.025n

.meas tran vdout0_179ck1300 FIND v(dout0_179) AT=655.025n

.meas tran vdout0_180ck1300 FIND v(dout0_180) AT=655.025n

.meas tran vdout0_181ck1300 FIND v(dout0_181) AT=655.025n

.meas tran vdout0_182ck1300 FIND v(dout0_182) AT=655.025n

.meas tran vdout0_183ck1300 FIND v(dout0_183) AT=655.025n

.meas tran vdout0_184ck1300 FIND v(dout0_184) AT=655.025n

.meas tran vdout0_185ck1300 FIND v(dout0_185) AT=655.025n

.meas tran vdout0_186ck1300 FIND v(dout0_186) AT=655.025n

.meas tran vdout0_187ck1300 FIND v(dout0_187) AT=655.025n

.meas tran vdout0_188ck1300 FIND v(dout0_188) AT=655.025n

.meas tran vdout0_189ck1300 FIND v(dout0_189) AT=655.025n

.meas tran vdout0_190ck1300 FIND v(dout0_190) AT=655.025n

.meas tran vdout0_191ck1300 FIND v(dout0_191) AT=655.025n

.meas tran vdout0_192ck1300 FIND v(dout0_192) AT=655.025n

.meas tran vdout0_193ck1300 FIND v(dout0_193) AT=655.025n

.meas tran vdout0_194ck1300 FIND v(dout0_194) AT=655.025n

.meas tran vdout0_195ck1300 FIND v(dout0_195) AT=655.025n

.meas tran vdout0_196ck1300 FIND v(dout0_196) AT=655.025n

.meas tran vdout0_197ck1300 FIND v(dout0_197) AT=655.025n

.meas tran vdout0_198ck1300 FIND v(dout0_198) AT=655.025n

.meas tran vdout0_199ck1300 FIND v(dout0_199) AT=655.025n

.meas tran vdout0_200ck1300 FIND v(dout0_200) AT=655.025n

.meas tran vdout0_201ck1300 FIND v(dout0_201) AT=655.025n

.meas tran vdout0_202ck1300 FIND v(dout0_202) AT=655.025n

.meas tran vdout0_203ck1300 FIND v(dout0_203) AT=655.025n

.meas tran vdout0_204ck1300 FIND v(dout0_204) AT=655.025n

.meas tran vdout0_205ck1300 FIND v(dout0_205) AT=655.025n

.meas tran vdout0_206ck1300 FIND v(dout0_206) AT=655.025n

.meas tran vdout0_207ck1300 FIND v(dout0_207) AT=655.025n

.meas tran vdout0_208ck1300 FIND v(dout0_208) AT=655.025n

.meas tran vdout0_209ck1300 FIND v(dout0_209) AT=655.025n

.meas tran vdout0_210ck1300 FIND v(dout0_210) AT=655.025n

.meas tran vdout0_211ck1300 FIND v(dout0_211) AT=655.025n

.meas tran vdout0_212ck1300 FIND v(dout0_212) AT=655.025n

.meas tran vdout0_213ck1300 FIND v(dout0_213) AT=655.025n

.meas tran vdout0_214ck1300 FIND v(dout0_214) AT=655.025n

.meas tran vdout0_215ck1300 FIND v(dout0_215) AT=655.025n

.meas tran vdout0_216ck1300 FIND v(dout0_216) AT=655.025n

.meas tran vdout0_217ck1300 FIND v(dout0_217) AT=655.025n

.meas tran vdout0_218ck1300 FIND v(dout0_218) AT=655.025n

.meas tran vdout0_219ck1300 FIND v(dout0_219) AT=655.025n

.meas tran vdout0_220ck1300 FIND v(dout0_220) AT=655.025n

.meas tran vdout0_221ck1300 FIND v(dout0_221) AT=655.025n

.meas tran vdout0_222ck1300 FIND v(dout0_222) AT=655.025n

.meas tran vdout0_223ck1300 FIND v(dout0_223) AT=655.025n

.meas tran vdout0_224ck1300 FIND v(dout0_224) AT=655.025n

.meas tran vdout0_225ck1300 FIND v(dout0_225) AT=655.025n

.meas tran vdout0_226ck1300 FIND v(dout0_226) AT=655.025n

.meas tran vdout0_227ck1300 FIND v(dout0_227) AT=655.025n

.meas tran vdout0_228ck1300 FIND v(dout0_228) AT=655.025n

.meas tran vdout0_229ck1300 FIND v(dout0_229) AT=655.025n

.meas tran vdout0_230ck1300 FIND v(dout0_230) AT=655.025n

.meas tran vdout0_231ck1300 FIND v(dout0_231) AT=655.025n

.meas tran vdout0_232ck1300 FIND v(dout0_232) AT=655.025n

.meas tran vdout0_233ck1300 FIND v(dout0_233) AT=655.025n

.meas tran vdout0_234ck1300 FIND v(dout0_234) AT=655.025n

.meas tran vdout0_235ck1300 FIND v(dout0_235) AT=655.025n

.meas tran vdout0_236ck1300 FIND v(dout0_236) AT=655.025n

.meas tran vdout0_237ck1300 FIND v(dout0_237) AT=655.025n

.meas tran vdout0_238ck1300 FIND v(dout0_238) AT=655.025n

.meas tran vdout0_239ck1300 FIND v(dout0_239) AT=655.025n

.meas tran vdout0_240ck1300 FIND v(dout0_240) AT=655.025n

.meas tran vdout0_241ck1300 FIND v(dout0_241) AT=655.025n

.meas tran vdout0_242ck1300 FIND v(dout0_242) AT=655.025n

.meas tran vdout0_243ck1300 FIND v(dout0_243) AT=655.025n

.meas tran vdout0_244ck1300 FIND v(dout0_244) AT=655.025n

.meas tran vdout0_245ck1300 FIND v(dout0_245) AT=655.025n

.meas tran vdout0_246ck1300 FIND v(dout0_246) AT=655.025n

.meas tran vdout0_247ck1300 FIND v(dout0_247) AT=655.025n

.meas tran vdout0_248ck1300 FIND v(dout0_248) AT=655.025n

.meas tran vdout0_249ck1300 FIND v(dout0_249) AT=655.025n

.meas tran vdout0_250ck1300 FIND v(dout0_250) AT=655.025n

.meas tran vdout0_251ck1300 FIND v(dout0_251) AT=655.025n

.meas tran vdout0_252ck1300 FIND v(dout0_252) AT=655.025n

.meas tran vdout0_253ck1300 FIND v(dout0_253) AT=655.025n

.meas tran vdout0_254ck1300 FIND v(dout0_254) AT=655.025n

.meas tran vdout0_255ck1300 FIND v(dout0_255) AT=655.025n

.meas tran vdout0_0ck1310 FIND v(dout0_0) AT=660.025n

.meas tran vdout0_1ck1310 FIND v(dout0_1) AT=660.025n

.meas tran vdout0_2ck1310 FIND v(dout0_2) AT=660.025n

.meas tran vdout0_3ck1310 FIND v(dout0_3) AT=660.025n

.meas tran vdout0_4ck1310 FIND v(dout0_4) AT=660.025n

.meas tran vdout0_5ck1310 FIND v(dout0_5) AT=660.025n

.meas tran vdout0_6ck1310 FIND v(dout0_6) AT=660.025n

.meas tran vdout0_7ck1310 FIND v(dout0_7) AT=660.025n

.meas tran vdout0_8ck1310 FIND v(dout0_8) AT=660.025n

.meas tran vdout0_9ck1310 FIND v(dout0_9) AT=660.025n

.meas tran vdout0_10ck1310 FIND v(dout0_10) AT=660.025n

.meas tran vdout0_11ck1310 FIND v(dout0_11) AT=660.025n

.meas tran vdout0_12ck1310 FIND v(dout0_12) AT=660.025n

.meas tran vdout0_13ck1310 FIND v(dout0_13) AT=660.025n

.meas tran vdout0_14ck1310 FIND v(dout0_14) AT=660.025n

.meas tran vdout0_15ck1310 FIND v(dout0_15) AT=660.025n

.meas tran vdout0_16ck1310 FIND v(dout0_16) AT=660.025n

.meas tran vdout0_17ck1310 FIND v(dout0_17) AT=660.025n

.meas tran vdout0_18ck1310 FIND v(dout0_18) AT=660.025n

.meas tran vdout0_19ck1310 FIND v(dout0_19) AT=660.025n

.meas tran vdout0_20ck1310 FIND v(dout0_20) AT=660.025n

.meas tran vdout0_21ck1310 FIND v(dout0_21) AT=660.025n

.meas tran vdout0_22ck1310 FIND v(dout0_22) AT=660.025n

.meas tran vdout0_23ck1310 FIND v(dout0_23) AT=660.025n

.meas tran vdout0_24ck1310 FIND v(dout0_24) AT=660.025n

.meas tran vdout0_25ck1310 FIND v(dout0_25) AT=660.025n

.meas tran vdout0_26ck1310 FIND v(dout0_26) AT=660.025n

.meas tran vdout0_27ck1310 FIND v(dout0_27) AT=660.025n

.meas tran vdout0_28ck1310 FIND v(dout0_28) AT=660.025n

.meas tran vdout0_29ck1310 FIND v(dout0_29) AT=660.025n

.meas tran vdout0_30ck1310 FIND v(dout0_30) AT=660.025n

.meas tran vdout0_31ck1310 FIND v(dout0_31) AT=660.025n

.meas tran vdout0_32ck1310 FIND v(dout0_32) AT=660.025n

.meas tran vdout0_33ck1310 FIND v(dout0_33) AT=660.025n

.meas tran vdout0_34ck1310 FIND v(dout0_34) AT=660.025n

.meas tran vdout0_35ck1310 FIND v(dout0_35) AT=660.025n

.meas tran vdout0_36ck1310 FIND v(dout0_36) AT=660.025n

.meas tran vdout0_37ck1310 FIND v(dout0_37) AT=660.025n

.meas tran vdout0_38ck1310 FIND v(dout0_38) AT=660.025n

.meas tran vdout0_39ck1310 FIND v(dout0_39) AT=660.025n

.meas tran vdout0_40ck1310 FIND v(dout0_40) AT=660.025n

.meas tran vdout0_41ck1310 FIND v(dout0_41) AT=660.025n

.meas tran vdout0_42ck1310 FIND v(dout0_42) AT=660.025n

.meas tran vdout0_43ck1310 FIND v(dout0_43) AT=660.025n

.meas tran vdout0_44ck1310 FIND v(dout0_44) AT=660.025n

.meas tran vdout0_45ck1310 FIND v(dout0_45) AT=660.025n

.meas tran vdout0_46ck1310 FIND v(dout0_46) AT=660.025n

.meas tran vdout0_47ck1310 FIND v(dout0_47) AT=660.025n

.meas tran vdout0_48ck1310 FIND v(dout0_48) AT=660.025n

.meas tran vdout0_49ck1310 FIND v(dout0_49) AT=660.025n

.meas tran vdout0_50ck1310 FIND v(dout0_50) AT=660.025n

.meas tran vdout0_51ck1310 FIND v(dout0_51) AT=660.025n

.meas tran vdout0_52ck1310 FIND v(dout0_52) AT=660.025n

.meas tran vdout0_53ck1310 FIND v(dout0_53) AT=660.025n

.meas tran vdout0_54ck1310 FIND v(dout0_54) AT=660.025n

.meas tran vdout0_55ck1310 FIND v(dout0_55) AT=660.025n

.meas tran vdout0_56ck1310 FIND v(dout0_56) AT=660.025n

.meas tran vdout0_57ck1310 FIND v(dout0_57) AT=660.025n

.meas tran vdout0_58ck1310 FIND v(dout0_58) AT=660.025n

.meas tran vdout0_59ck1310 FIND v(dout0_59) AT=660.025n

.meas tran vdout0_60ck1310 FIND v(dout0_60) AT=660.025n

.meas tran vdout0_61ck1310 FIND v(dout0_61) AT=660.025n

.meas tran vdout0_62ck1310 FIND v(dout0_62) AT=660.025n

.meas tran vdout0_63ck1310 FIND v(dout0_63) AT=660.025n

.meas tran vdout0_64ck1310 FIND v(dout0_64) AT=660.025n

.meas tran vdout0_65ck1310 FIND v(dout0_65) AT=660.025n

.meas tran vdout0_66ck1310 FIND v(dout0_66) AT=660.025n

.meas tran vdout0_67ck1310 FIND v(dout0_67) AT=660.025n

.meas tran vdout0_68ck1310 FIND v(dout0_68) AT=660.025n

.meas tran vdout0_69ck1310 FIND v(dout0_69) AT=660.025n

.meas tran vdout0_70ck1310 FIND v(dout0_70) AT=660.025n

.meas tran vdout0_71ck1310 FIND v(dout0_71) AT=660.025n

.meas tran vdout0_72ck1310 FIND v(dout0_72) AT=660.025n

.meas tran vdout0_73ck1310 FIND v(dout0_73) AT=660.025n

.meas tran vdout0_74ck1310 FIND v(dout0_74) AT=660.025n

.meas tran vdout0_75ck1310 FIND v(dout0_75) AT=660.025n

.meas tran vdout0_76ck1310 FIND v(dout0_76) AT=660.025n

.meas tran vdout0_77ck1310 FIND v(dout0_77) AT=660.025n

.meas tran vdout0_78ck1310 FIND v(dout0_78) AT=660.025n

.meas tran vdout0_79ck1310 FIND v(dout0_79) AT=660.025n

.meas tran vdout0_80ck1310 FIND v(dout0_80) AT=660.025n

.meas tran vdout0_81ck1310 FIND v(dout0_81) AT=660.025n

.meas tran vdout0_82ck1310 FIND v(dout0_82) AT=660.025n

.meas tran vdout0_83ck1310 FIND v(dout0_83) AT=660.025n

.meas tran vdout0_84ck1310 FIND v(dout0_84) AT=660.025n

.meas tran vdout0_85ck1310 FIND v(dout0_85) AT=660.025n

.meas tran vdout0_86ck1310 FIND v(dout0_86) AT=660.025n

.meas tran vdout0_87ck1310 FIND v(dout0_87) AT=660.025n

.meas tran vdout0_88ck1310 FIND v(dout0_88) AT=660.025n

.meas tran vdout0_89ck1310 FIND v(dout0_89) AT=660.025n

.meas tran vdout0_90ck1310 FIND v(dout0_90) AT=660.025n

.meas tran vdout0_91ck1310 FIND v(dout0_91) AT=660.025n

.meas tran vdout0_92ck1310 FIND v(dout0_92) AT=660.025n

.meas tran vdout0_93ck1310 FIND v(dout0_93) AT=660.025n

.meas tran vdout0_94ck1310 FIND v(dout0_94) AT=660.025n

.meas tran vdout0_95ck1310 FIND v(dout0_95) AT=660.025n

.meas tran vdout0_96ck1310 FIND v(dout0_96) AT=660.025n

.meas tran vdout0_97ck1310 FIND v(dout0_97) AT=660.025n

.meas tran vdout0_98ck1310 FIND v(dout0_98) AT=660.025n

.meas tran vdout0_99ck1310 FIND v(dout0_99) AT=660.025n

.meas tran vdout0_100ck1310 FIND v(dout0_100) AT=660.025n

.meas tran vdout0_101ck1310 FIND v(dout0_101) AT=660.025n

.meas tran vdout0_102ck1310 FIND v(dout0_102) AT=660.025n

.meas tran vdout0_103ck1310 FIND v(dout0_103) AT=660.025n

.meas tran vdout0_104ck1310 FIND v(dout0_104) AT=660.025n

.meas tran vdout0_105ck1310 FIND v(dout0_105) AT=660.025n

.meas tran vdout0_106ck1310 FIND v(dout0_106) AT=660.025n

.meas tran vdout0_107ck1310 FIND v(dout0_107) AT=660.025n

.meas tran vdout0_108ck1310 FIND v(dout0_108) AT=660.025n

.meas tran vdout0_109ck1310 FIND v(dout0_109) AT=660.025n

.meas tran vdout0_110ck1310 FIND v(dout0_110) AT=660.025n

.meas tran vdout0_111ck1310 FIND v(dout0_111) AT=660.025n

.meas tran vdout0_112ck1310 FIND v(dout0_112) AT=660.025n

.meas tran vdout0_113ck1310 FIND v(dout0_113) AT=660.025n

.meas tran vdout0_114ck1310 FIND v(dout0_114) AT=660.025n

.meas tran vdout0_115ck1310 FIND v(dout0_115) AT=660.025n

.meas tran vdout0_116ck1310 FIND v(dout0_116) AT=660.025n

.meas tran vdout0_117ck1310 FIND v(dout0_117) AT=660.025n

.meas tran vdout0_118ck1310 FIND v(dout0_118) AT=660.025n

.meas tran vdout0_119ck1310 FIND v(dout0_119) AT=660.025n

.meas tran vdout0_120ck1310 FIND v(dout0_120) AT=660.025n

.meas tran vdout0_121ck1310 FIND v(dout0_121) AT=660.025n

.meas tran vdout0_122ck1310 FIND v(dout0_122) AT=660.025n

.meas tran vdout0_123ck1310 FIND v(dout0_123) AT=660.025n

.meas tran vdout0_124ck1310 FIND v(dout0_124) AT=660.025n

.meas tran vdout0_125ck1310 FIND v(dout0_125) AT=660.025n

.meas tran vdout0_126ck1310 FIND v(dout0_126) AT=660.025n

.meas tran vdout0_127ck1310 FIND v(dout0_127) AT=660.025n

.meas tran vdout0_128ck1310 FIND v(dout0_128) AT=660.025n

.meas tran vdout0_129ck1310 FIND v(dout0_129) AT=660.025n

.meas tran vdout0_130ck1310 FIND v(dout0_130) AT=660.025n

.meas tran vdout0_131ck1310 FIND v(dout0_131) AT=660.025n

.meas tran vdout0_132ck1310 FIND v(dout0_132) AT=660.025n

.meas tran vdout0_133ck1310 FIND v(dout0_133) AT=660.025n

.meas tran vdout0_134ck1310 FIND v(dout0_134) AT=660.025n

.meas tran vdout0_135ck1310 FIND v(dout0_135) AT=660.025n

.meas tran vdout0_136ck1310 FIND v(dout0_136) AT=660.025n

.meas tran vdout0_137ck1310 FIND v(dout0_137) AT=660.025n

.meas tran vdout0_138ck1310 FIND v(dout0_138) AT=660.025n

.meas tran vdout0_139ck1310 FIND v(dout0_139) AT=660.025n

.meas tran vdout0_140ck1310 FIND v(dout0_140) AT=660.025n

.meas tran vdout0_141ck1310 FIND v(dout0_141) AT=660.025n

.meas tran vdout0_142ck1310 FIND v(dout0_142) AT=660.025n

.meas tran vdout0_143ck1310 FIND v(dout0_143) AT=660.025n

.meas tran vdout0_144ck1310 FIND v(dout0_144) AT=660.025n

.meas tran vdout0_145ck1310 FIND v(dout0_145) AT=660.025n

.meas tran vdout0_146ck1310 FIND v(dout0_146) AT=660.025n

.meas tran vdout0_147ck1310 FIND v(dout0_147) AT=660.025n

.meas tran vdout0_148ck1310 FIND v(dout0_148) AT=660.025n

.meas tran vdout0_149ck1310 FIND v(dout0_149) AT=660.025n

.meas tran vdout0_150ck1310 FIND v(dout0_150) AT=660.025n

.meas tran vdout0_151ck1310 FIND v(dout0_151) AT=660.025n

.meas tran vdout0_152ck1310 FIND v(dout0_152) AT=660.025n

.meas tran vdout0_153ck1310 FIND v(dout0_153) AT=660.025n

.meas tran vdout0_154ck1310 FIND v(dout0_154) AT=660.025n

.meas tran vdout0_155ck1310 FIND v(dout0_155) AT=660.025n

.meas tran vdout0_156ck1310 FIND v(dout0_156) AT=660.025n

.meas tran vdout0_157ck1310 FIND v(dout0_157) AT=660.025n

.meas tran vdout0_158ck1310 FIND v(dout0_158) AT=660.025n

.meas tran vdout0_159ck1310 FIND v(dout0_159) AT=660.025n

.meas tran vdout0_160ck1310 FIND v(dout0_160) AT=660.025n

.meas tran vdout0_161ck1310 FIND v(dout0_161) AT=660.025n

.meas tran vdout0_162ck1310 FIND v(dout0_162) AT=660.025n

.meas tran vdout0_163ck1310 FIND v(dout0_163) AT=660.025n

.meas tran vdout0_164ck1310 FIND v(dout0_164) AT=660.025n

.meas tran vdout0_165ck1310 FIND v(dout0_165) AT=660.025n

.meas tran vdout0_166ck1310 FIND v(dout0_166) AT=660.025n

.meas tran vdout0_167ck1310 FIND v(dout0_167) AT=660.025n

.meas tran vdout0_168ck1310 FIND v(dout0_168) AT=660.025n

.meas tran vdout0_169ck1310 FIND v(dout0_169) AT=660.025n

.meas tran vdout0_170ck1310 FIND v(dout0_170) AT=660.025n

.meas tran vdout0_171ck1310 FIND v(dout0_171) AT=660.025n

.meas tran vdout0_172ck1310 FIND v(dout0_172) AT=660.025n

.meas tran vdout0_173ck1310 FIND v(dout0_173) AT=660.025n

.meas tran vdout0_174ck1310 FIND v(dout0_174) AT=660.025n

.meas tran vdout0_175ck1310 FIND v(dout0_175) AT=660.025n

.meas tran vdout0_176ck1310 FIND v(dout0_176) AT=660.025n

.meas tran vdout0_177ck1310 FIND v(dout0_177) AT=660.025n

.meas tran vdout0_178ck1310 FIND v(dout0_178) AT=660.025n

.meas tran vdout0_179ck1310 FIND v(dout0_179) AT=660.025n

.meas tran vdout0_180ck1310 FIND v(dout0_180) AT=660.025n

.meas tran vdout0_181ck1310 FIND v(dout0_181) AT=660.025n

.meas tran vdout0_182ck1310 FIND v(dout0_182) AT=660.025n

.meas tran vdout0_183ck1310 FIND v(dout0_183) AT=660.025n

.meas tran vdout0_184ck1310 FIND v(dout0_184) AT=660.025n

.meas tran vdout0_185ck1310 FIND v(dout0_185) AT=660.025n

.meas tran vdout0_186ck1310 FIND v(dout0_186) AT=660.025n

.meas tran vdout0_187ck1310 FIND v(dout0_187) AT=660.025n

.meas tran vdout0_188ck1310 FIND v(dout0_188) AT=660.025n

.meas tran vdout0_189ck1310 FIND v(dout0_189) AT=660.025n

.meas tran vdout0_190ck1310 FIND v(dout0_190) AT=660.025n

.meas tran vdout0_191ck1310 FIND v(dout0_191) AT=660.025n

.meas tran vdout0_192ck1310 FIND v(dout0_192) AT=660.025n

.meas tran vdout0_193ck1310 FIND v(dout0_193) AT=660.025n

.meas tran vdout0_194ck1310 FIND v(dout0_194) AT=660.025n

.meas tran vdout0_195ck1310 FIND v(dout0_195) AT=660.025n

.meas tran vdout0_196ck1310 FIND v(dout0_196) AT=660.025n

.meas tran vdout0_197ck1310 FIND v(dout0_197) AT=660.025n

.meas tran vdout0_198ck1310 FIND v(dout0_198) AT=660.025n

.meas tran vdout0_199ck1310 FIND v(dout0_199) AT=660.025n

.meas tran vdout0_200ck1310 FIND v(dout0_200) AT=660.025n

.meas tran vdout0_201ck1310 FIND v(dout0_201) AT=660.025n

.meas tran vdout0_202ck1310 FIND v(dout0_202) AT=660.025n

.meas tran vdout0_203ck1310 FIND v(dout0_203) AT=660.025n

.meas tran vdout0_204ck1310 FIND v(dout0_204) AT=660.025n

.meas tran vdout0_205ck1310 FIND v(dout0_205) AT=660.025n

.meas tran vdout0_206ck1310 FIND v(dout0_206) AT=660.025n

.meas tran vdout0_207ck1310 FIND v(dout0_207) AT=660.025n

.meas tran vdout0_208ck1310 FIND v(dout0_208) AT=660.025n

.meas tran vdout0_209ck1310 FIND v(dout0_209) AT=660.025n

.meas tran vdout0_210ck1310 FIND v(dout0_210) AT=660.025n

.meas tran vdout0_211ck1310 FIND v(dout0_211) AT=660.025n

.meas tran vdout0_212ck1310 FIND v(dout0_212) AT=660.025n

.meas tran vdout0_213ck1310 FIND v(dout0_213) AT=660.025n

.meas tran vdout0_214ck1310 FIND v(dout0_214) AT=660.025n

.meas tran vdout0_215ck1310 FIND v(dout0_215) AT=660.025n

.meas tran vdout0_216ck1310 FIND v(dout0_216) AT=660.025n

.meas tran vdout0_217ck1310 FIND v(dout0_217) AT=660.025n

.meas tran vdout0_218ck1310 FIND v(dout0_218) AT=660.025n

.meas tran vdout0_219ck1310 FIND v(dout0_219) AT=660.025n

.meas tran vdout0_220ck1310 FIND v(dout0_220) AT=660.025n

.meas tran vdout0_221ck1310 FIND v(dout0_221) AT=660.025n

.meas tran vdout0_222ck1310 FIND v(dout0_222) AT=660.025n

.meas tran vdout0_223ck1310 FIND v(dout0_223) AT=660.025n

.meas tran vdout0_224ck1310 FIND v(dout0_224) AT=660.025n

.meas tran vdout0_225ck1310 FIND v(dout0_225) AT=660.025n

.meas tran vdout0_226ck1310 FIND v(dout0_226) AT=660.025n

.meas tran vdout0_227ck1310 FIND v(dout0_227) AT=660.025n

.meas tran vdout0_228ck1310 FIND v(dout0_228) AT=660.025n

.meas tran vdout0_229ck1310 FIND v(dout0_229) AT=660.025n

.meas tran vdout0_230ck1310 FIND v(dout0_230) AT=660.025n

.meas tran vdout0_231ck1310 FIND v(dout0_231) AT=660.025n

.meas tran vdout0_232ck1310 FIND v(dout0_232) AT=660.025n

.meas tran vdout0_233ck1310 FIND v(dout0_233) AT=660.025n

.meas tran vdout0_234ck1310 FIND v(dout0_234) AT=660.025n

.meas tran vdout0_235ck1310 FIND v(dout0_235) AT=660.025n

.meas tran vdout0_236ck1310 FIND v(dout0_236) AT=660.025n

.meas tran vdout0_237ck1310 FIND v(dout0_237) AT=660.025n

.meas tran vdout0_238ck1310 FIND v(dout0_238) AT=660.025n

.meas tran vdout0_239ck1310 FIND v(dout0_239) AT=660.025n

.meas tran vdout0_240ck1310 FIND v(dout0_240) AT=660.025n

.meas tran vdout0_241ck1310 FIND v(dout0_241) AT=660.025n

.meas tran vdout0_242ck1310 FIND v(dout0_242) AT=660.025n

.meas tran vdout0_243ck1310 FIND v(dout0_243) AT=660.025n

.meas tran vdout0_244ck1310 FIND v(dout0_244) AT=660.025n

.meas tran vdout0_245ck1310 FIND v(dout0_245) AT=660.025n

.meas tran vdout0_246ck1310 FIND v(dout0_246) AT=660.025n

.meas tran vdout0_247ck1310 FIND v(dout0_247) AT=660.025n

.meas tran vdout0_248ck1310 FIND v(dout0_248) AT=660.025n

.meas tran vdout0_249ck1310 FIND v(dout0_249) AT=660.025n

.meas tran vdout0_250ck1310 FIND v(dout0_250) AT=660.025n

.meas tran vdout0_251ck1310 FIND v(dout0_251) AT=660.025n

.meas tran vdout0_252ck1310 FIND v(dout0_252) AT=660.025n

.meas tran vdout0_253ck1310 FIND v(dout0_253) AT=660.025n

.meas tran vdout0_254ck1310 FIND v(dout0_254) AT=660.025n

.meas tran vdout0_255ck1310 FIND v(dout0_255) AT=660.025n

.meas tran vdout0_0ck1320 FIND v(dout0_0) AT=665.025n

.meas tran vdout0_1ck1320 FIND v(dout0_1) AT=665.025n

.meas tran vdout0_2ck1320 FIND v(dout0_2) AT=665.025n

.meas tran vdout0_3ck1320 FIND v(dout0_3) AT=665.025n

.meas tran vdout0_4ck1320 FIND v(dout0_4) AT=665.025n

.meas tran vdout0_5ck1320 FIND v(dout0_5) AT=665.025n

.meas tran vdout0_6ck1320 FIND v(dout0_6) AT=665.025n

.meas tran vdout0_7ck1320 FIND v(dout0_7) AT=665.025n

.meas tran vdout0_8ck1320 FIND v(dout0_8) AT=665.025n

.meas tran vdout0_9ck1320 FIND v(dout0_9) AT=665.025n

.meas tran vdout0_10ck1320 FIND v(dout0_10) AT=665.025n

.meas tran vdout0_11ck1320 FIND v(dout0_11) AT=665.025n

.meas tran vdout0_12ck1320 FIND v(dout0_12) AT=665.025n

.meas tran vdout0_13ck1320 FIND v(dout0_13) AT=665.025n

.meas tran vdout0_14ck1320 FIND v(dout0_14) AT=665.025n

.meas tran vdout0_15ck1320 FIND v(dout0_15) AT=665.025n

.meas tran vdout0_16ck1320 FIND v(dout0_16) AT=665.025n

.meas tran vdout0_17ck1320 FIND v(dout0_17) AT=665.025n

.meas tran vdout0_18ck1320 FIND v(dout0_18) AT=665.025n

.meas tran vdout0_19ck1320 FIND v(dout0_19) AT=665.025n

.meas tran vdout0_20ck1320 FIND v(dout0_20) AT=665.025n

.meas tran vdout0_21ck1320 FIND v(dout0_21) AT=665.025n

.meas tran vdout0_22ck1320 FIND v(dout0_22) AT=665.025n

.meas tran vdout0_23ck1320 FIND v(dout0_23) AT=665.025n

.meas tran vdout0_24ck1320 FIND v(dout0_24) AT=665.025n

.meas tran vdout0_25ck1320 FIND v(dout0_25) AT=665.025n

.meas tran vdout0_26ck1320 FIND v(dout0_26) AT=665.025n

.meas tran vdout0_27ck1320 FIND v(dout0_27) AT=665.025n

.meas tran vdout0_28ck1320 FIND v(dout0_28) AT=665.025n

.meas tran vdout0_29ck1320 FIND v(dout0_29) AT=665.025n

.meas tran vdout0_30ck1320 FIND v(dout0_30) AT=665.025n

.meas tran vdout0_31ck1320 FIND v(dout0_31) AT=665.025n

.meas tran vdout0_32ck1320 FIND v(dout0_32) AT=665.025n

.meas tran vdout0_33ck1320 FIND v(dout0_33) AT=665.025n

.meas tran vdout0_34ck1320 FIND v(dout0_34) AT=665.025n

.meas tran vdout0_35ck1320 FIND v(dout0_35) AT=665.025n

.meas tran vdout0_36ck1320 FIND v(dout0_36) AT=665.025n

.meas tran vdout0_37ck1320 FIND v(dout0_37) AT=665.025n

.meas tran vdout0_38ck1320 FIND v(dout0_38) AT=665.025n

.meas tran vdout0_39ck1320 FIND v(dout0_39) AT=665.025n

.meas tran vdout0_40ck1320 FIND v(dout0_40) AT=665.025n

.meas tran vdout0_41ck1320 FIND v(dout0_41) AT=665.025n

.meas tran vdout0_42ck1320 FIND v(dout0_42) AT=665.025n

.meas tran vdout0_43ck1320 FIND v(dout0_43) AT=665.025n

.meas tran vdout0_44ck1320 FIND v(dout0_44) AT=665.025n

.meas tran vdout0_45ck1320 FIND v(dout0_45) AT=665.025n

.meas tran vdout0_46ck1320 FIND v(dout0_46) AT=665.025n

.meas tran vdout0_47ck1320 FIND v(dout0_47) AT=665.025n

.meas tran vdout0_48ck1320 FIND v(dout0_48) AT=665.025n

.meas tran vdout0_49ck1320 FIND v(dout0_49) AT=665.025n

.meas tran vdout0_50ck1320 FIND v(dout0_50) AT=665.025n

.meas tran vdout0_51ck1320 FIND v(dout0_51) AT=665.025n

.meas tran vdout0_52ck1320 FIND v(dout0_52) AT=665.025n

.meas tran vdout0_53ck1320 FIND v(dout0_53) AT=665.025n

.meas tran vdout0_54ck1320 FIND v(dout0_54) AT=665.025n

.meas tran vdout0_55ck1320 FIND v(dout0_55) AT=665.025n

.meas tran vdout0_56ck1320 FIND v(dout0_56) AT=665.025n

.meas tran vdout0_57ck1320 FIND v(dout0_57) AT=665.025n

.meas tran vdout0_58ck1320 FIND v(dout0_58) AT=665.025n

.meas tran vdout0_59ck1320 FIND v(dout0_59) AT=665.025n

.meas tran vdout0_60ck1320 FIND v(dout0_60) AT=665.025n

.meas tran vdout0_61ck1320 FIND v(dout0_61) AT=665.025n

.meas tran vdout0_62ck1320 FIND v(dout0_62) AT=665.025n

.meas tran vdout0_63ck1320 FIND v(dout0_63) AT=665.025n

.meas tran vdout0_64ck1320 FIND v(dout0_64) AT=665.025n

.meas tran vdout0_65ck1320 FIND v(dout0_65) AT=665.025n

.meas tran vdout0_66ck1320 FIND v(dout0_66) AT=665.025n

.meas tran vdout0_67ck1320 FIND v(dout0_67) AT=665.025n

.meas tran vdout0_68ck1320 FIND v(dout0_68) AT=665.025n

.meas tran vdout0_69ck1320 FIND v(dout0_69) AT=665.025n

.meas tran vdout0_70ck1320 FIND v(dout0_70) AT=665.025n

.meas tran vdout0_71ck1320 FIND v(dout0_71) AT=665.025n

.meas tran vdout0_72ck1320 FIND v(dout0_72) AT=665.025n

.meas tran vdout0_73ck1320 FIND v(dout0_73) AT=665.025n

.meas tran vdout0_74ck1320 FIND v(dout0_74) AT=665.025n

.meas tran vdout0_75ck1320 FIND v(dout0_75) AT=665.025n

.meas tran vdout0_76ck1320 FIND v(dout0_76) AT=665.025n

.meas tran vdout0_77ck1320 FIND v(dout0_77) AT=665.025n

.meas tran vdout0_78ck1320 FIND v(dout0_78) AT=665.025n

.meas tran vdout0_79ck1320 FIND v(dout0_79) AT=665.025n

.meas tran vdout0_80ck1320 FIND v(dout0_80) AT=665.025n

.meas tran vdout0_81ck1320 FIND v(dout0_81) AT=665.025n

.meas tran vdout0_82ck1320 FIND v(dout0_82) AT=665.025n

.meas tran vdout0_83ck1320 FIND v(dout0_83) AT=665.025n

.meas tran vdout0_84ck1320 FIND v(dout0_84) AT=665.025n

.meas tran vdout0_85ck1320 FIND v(dout0_85) AT=665.025n

.meas tran vdout0_86ck1320 FIND v(dout0_86) AT=665.025n

.meas tran vdout0_87ck1320 FIND v(dout0_87) AT=665.025n

.meas tran vdout0_88ck1320 FIND v(dout0_88) AT=665.025n

.meas tran vdout0_89ck1320 FIND v(dout0_89) AT=665.025n

.meas tran vdout0_90ck1320 FIND v(dout0_90) AT=665.025n

.meas tran vdout0_91ck1320 FIND v(dout0_91) AT=665.025n

.meas tran vdout0_92ck1320 FIND v(dout0_92) AT=665.025n

.meas tran vdout0_93ck1320 FIND v(dout0_93) AT=665.025n

.meas tran vdout0_94ck1320 FIND v(dout0_94) AT=665.025n

.meas tran vdout0_95ck1320 FIND v(dout0_95) AT=665.025n

.meas tran vdout0_96ck1320 FIND v(dout0_96) AT=665.025n

.meas tran vdout0_97ck1320 FIND v(dout0_97) AT=665.025n

.meas tran vdout0_98ck1320 FIND v(dout0_98) AT=665.025n

.meas tran vdout0_99ck1320 FIND v(dout0_99) AT=665.025n

.meas tran vdout0_100ck1320 FIND v(dout0_100) AT=665.025n

.meas tran vdout0_101ck1320 FIND v(dout0_101) AT=665.025n

.meas tran vdout0_102ck1320 FIND v(dout0_102) AT=665.025n

.meas tran vdout0_103ck1320 FIND v(dout0_103) AT=665.025n

.meas tran vdout0_104ck1320 FIND v(dout0_104) AT=665.025n

.meas tran vdout0_105ck1320 FIND v(dout0_105) AT=665.025n

.meas tran vdout0_106ck1320 FIND v(dout0_106) AT=665.025n

.meas tran vdout0_107ck1320 FIND v(dout0_107) AT=665.025n

.meas tran vdout0_108ck1320 FIND v(dout0_108) AT=665.025n

.meas tran vdout0_109ck1320 FIND v(dout0_109) AT=665.025n

.meas tran vdout0_110ck1320 FIND v(dout0_110) AT=665.025n

.meas tran vdout0_111ck1320 FIND v(dout0_111) AT=665.025n

.meas tran vdout0_112ck1320 FIND v(dout0_112) AT=665.025n

.meas tran vdout0_113ck1320 FIND v(dout0_113) AT=665.025n

.meas tran vdout0_114ck1320 FIND v(dout0_114) AT=665.025n

.meas tran vdout0_115ck1320 FIND v(dout0_115) AT=665.025n

.meas tran vdout0_116ck1320 FIND v(dout0_116) AT=665.025n

.meas tran vdout0_117ck1320 FIND v(dout0_117) AT=665.025n

.meas tran vdout0_118ck1320 FIND v(dout0_118) AT=665.025n

.meas tran vdout0_119ck1320 FIND v(dout0_119) AT=665.025n

.meas tran vdout0_120ck1320 FIND v(dout0_120) AT=665.025n

.meas tran vdout0_121ck1320 FIND v(dout0_121) AT=665.025n

.meas tran vdout0_122ck1320 FIND v(dout0_122) AT=665.025n

.meas tran vdout0_123ck1320 FIND v(dout0_123) AT=665.025n

.meas tran vdout0_124ck1320 FIND v(dout0_124) AT=665.025n

.meas tran vdout0_125ck1320 FIND v(dout0_125) AT=665.025n

.meas tran vdout0_126ck1320 FIND v(dout0_126) AT=665.025n

.meas tran vdout0_127ck1320 FIND v(dout0_127) AT=665.025n

.meas tran vdout0_128ck1320 FIND v(dout0_128) AT=665.025n

.meas tran vdout0_129ck1320 FIND v(dout0_129) AT=665.025n

.meas tran vdout0_130ck1320 FIND v(dout0_130) AT=665.025n

.meas tran vdout0_131ck1320 FIND v(dout0_131) AT=665.025n

.meas tran vdout0_132ck1320 FIND v(dout0_132) AT=665.025n

.meas tran vdout0_133ck1320 FIND v(dout0_133) AT=665.025n

.meas tran vdout0_134ck1320 FIND v(dout0_134) AT=665.025n

.meas tran vdout0_135ck1320 FIND v(dout0_135) AT=665.025n

.meas tran vdout0_136ck1320 FIND v(dout0_136) AT=665.025n

.meas tran vdout0_137ck1320 FIND v(dout0_137) AT=665.025n

.meas tran vdout0_138ck1320 FIND v(dout0_138) AT=665.025n

.meas tran vdout0_139ck1320 FIND v(dout0_139) AT=665.025n

.meas tran vdout0_140ck1320 FIND v(dout0_140) AT=665.025n

.meas tran vdout0_141ck1320 FIND v(dout0_141) AT=665.025n

.meas tran vdout0_142ck1320 FIND v(dout0_142) AT=665.025n

.meas tran vdout0_143ck1320 FIND v(dout0_143) AT=665.025n

.meas tran vdout0_144ck1320 FIND v(dout0_144) AT=665.025n

.meas tran vdout0_145ck1320 FIND v(dout0_145) AT=665.025n

.meas tran vdout0_146ck1320 FIND v(dout0_146) AT=665.025n

.meas tran vdout0_147ck1320 FIND v(dout0_147) AT=665.025n

.meas tran vdout0_148ck1320 FIND v(dout0_148) AT=665.025n

.meas tran vdout0_149ck1320 FIND v(dout0_149) AT=665.025n

.meas tran vdout0_150ck1320 FIND v(dout0_150) AT=665.025n

.meas tran vdout0_151ck1320 FIND v(dout0_151) AT=665.025n

.meas tran vdout0_152ck1320 FIND v(dout0_152) AT=665.025n

.meas tran vdout0_153ck1320 FIND v(dout0_153) AT=665.025n

.meas tran vdout0_154ck1320 FIND v(dout0_154) AT=665.025n

.meas tran vdout0_155ck1320 FIND v(dout0_155) AT=665.025n

.meas tran vdout0_156ck1320 FIND v(dout0_156) AT=665.025n

.meas tran vdout0_157ck1320 FIND v(dout0_157) AT=665.025n

.meas tran vdout0_158ck1320 FIND v(dout0_158) AT=665.025n

.meas tran vdout0_159ck1320 FIND v(dout0_159) AT=665.025n

.meas tran vdout0_160ck1320 FIND v(dout0_160) AT=665.025n

.meas tran vdout0_161ck1320 FIND v(dout0_161) AT=665.025n

.meas tran vdout0_162ck1320 FIND v(dout0_162) AT=665.025n

.meas tran vdout0_163ck1320 FIND v(dout0_163) AT=665.025n

.meas tran vdout0_164ck1320 FIND v(dout0_164) AT=665.025n

.meas tran vdout0_165ck1320 FIND v(dout0_165) AT=665.025n

.meas tran vdout0_166ck1320 FIND v(dout0_166) AT=665.025n

.meas tran vdout0_167ck1320 FIND v(dout0_167) AT=665.025n

.meas tran vdout0_168ck1320 FIND v(dout0_168) AT=665.025n

.meas tran vdout0_169ck1320 FIND v(dout0_169) AT=665.025n

.meas tran vdout0_170ck1320 FIND v(dout0_170) AT=665.025n

.meas tran vdout0_171ck1320 FIND v(dout0_171) AT=665.025n

.meas tran vdout0_172ck1320 FIND v(dout0_172) AT=665.025n

.meas tran vdout0_173ck1320 FIND v(dout0_173) AT=665.025n

.meas tran vdout0_174ck1320 FIND v(dout0_174) AT=665.025n

.meas tran vdout0_175ck1320 FIND v(dout0_175) AT=665.025n

.meas tran vdout0_176ck1320 FIND v(dout0_176) AT=665.025n

.meas tran vdout0_177ck1320 FIND v(dout0_177) AT=665.025n

.meas tran vdout0_178ck1320 FIND v(dout0_178) AT=665.025n

.meas tran vdout0_179ck1320 FIND v(dout0_179) AT=665.025n

.meas tran vdout0_180ck1320 FIND v(dout0_180) AT=665.025n

.meas tran vdout0_181ck1320 FIND v(dout0_181) AT=665.025n

.meas tran vdout0_182ck1320 FIND v(dout0_182) AT=665.025n

.meas tran vdout0_183ck1320 FIND v(dout0_183) AT=665.025n

.meas tran vdout0_184ck1320 FIND v(dout0_184) AT=665.025n

.meas tran vdout0_185ck1320 FIND v(dout0_185) AT=665.025n

.meas tran vdout0_186ck1320 FIND v(dout0_186) AT=665.025n

.meas tran vdout0_187ck1320 FIND v(dout0_187) AT=665.025n

.meas tran vdout0_188ck1320 FIND v(dout0_188) AT=665.025n

.meas tran vdout0_189ck1320 FIND v(dout0_189) AT=665.025n

.meas tran vdout0_190ck1320 FIND v(dout0_190) AT=665.025n

.meas tran vdout0_191ck1320 FIND v(dout0_191) AT=665.025n

.meas tran vdout0_192ck1320 FIND v(dout0_192) AT=665.025n

.meas tran vdout0_193ck1320 FIND v(dout0_193) AT=665.025n

.meas tran vdout0_194ck1320 FIND v(dout0_194) AT=665.025n

.meas tran vdout0_195ck1320 FIND v(dout0_195) AT=665.025n

.meas tran vdout0_196ck1320 FIND v(dout0_196) AT=665.025n

.meas tran vdout0_197ck1320 FIND v(dout0_197) AT=665.025n

.meas tran vdout0_198ck1320 FIND v(dout0_198) AT=665.025n

.meas tran vdout0_199ck1320 FIND v(dout0_199) AT=665.025n

.meas tran vdout0_200ck1320 FIND v(dout0_200) AT=665.025n

.meas tran vdout0_201ck1320 FIND v(dout0_201) AT=665.025n

.meas tran vdout0_202ck1320 FIND v(dout0_202) AT=665.025n

.meas tran vdout0_203ck1320 FIND v(dout0_203) AT=665.025n

.meas tran vdout0_204ck1320 FIND v(dout0_204) AT=665.025n

.meas tran vdout0_205ck1320 FIND v(dout0_205) AT=665.025n

.meas tran vdout0_206ck1320 FIND v(dout0_206) AT=665.025n

.meas tran vdout0_207ck1320 FIND v(dout0_207) AT=665.025n

.meas tran vdout0_208ck1320 FIND v(dout0_208) AT=665.025n

.meas tran vdout0_209ck1320 FIND v(dout0_209) AT=665.025n

.meas tran vdout0_210ck1320 FIND v(dout0_210) AT=665.025n

.meas tran vdout0_211ck1320 FIND v(dout0_211) AT=665.025n

.meas tran vdout0_212ck1320 FIND v(dout0_212) AT=665.025n

.meas tran vdout0_213ck1320 FIND v(dout0_213) AT=665.025n

.meas tran vdout0_214ck1320 FIND v(dout0_214) AT=665.025n

.meas tran vdout0_215ck1320 FIND v(dout0_215) AT=665.025n

.meas tran vdout0_216ck1320 FIND v(dout0_216) AT=665.025n

.meas tran vdout0_217ck1320 FIND v(dout0_217) AT=665.025n

.meas tran vdout0_218ck1320 FIND v(dout0_218) AT=665.025n

.meas tran vdout0_219ck1320 FIND v(dout0_219) AT=665.025n

.meas tran vdout0_220ck1320 FIND v(dout0_220) AT=665.025n

.meas tran vdout0_221ck1320 FIND v(dout0_221) AT=665.025n

.meas tran vdout0_222ck1320 FIND v(dout0_222) AT=665.025n

.meas tran vdout0_223ck1320 FIND v(dout0_223) AT=665.025n

.meas tran vdout0_224ck1320 FIND v(dout0_224) AT=665.025n

.meas tran vdout0_225ck1320 FIND v(dout0_225) AT=665.025n

.meas tran vdout0_226ck1320 FIND v(dout0_226) AT=665.025n

.meas tran vdout0_227ck1320 FIND v(dout0_227) AT=665.025n

.meas tran vdout0_228ck1320 FIND v(dout0_228) AT=665.025n

.meas tran vdout0_229ck1320 FIND v(dout0_229) AT=665.025n

.meas tran vdout0_230ck1320 FIND v(dout0_230) AT=665.025n

.meas tran vdout0_231ck1320 FIND v(dout0_231) AT=665.025n

.meas tran vdout0_232ck1320 FIND v(dout0_232) AT=665.025n

.meas tran vdout0_233ck1320 FIND v(dout0_233) AT=665.025n

.meas tran vdout0_234ck1320 FIND v(dout0_234) AT=665.025n

.meas tran vdout0_235ck1320 FIND v(dout0_235) AT=665.025n

.meas tran vdout0_236ck1320 FIND v(dout0_236) AT=665.025n

.meas tran vdout0_237ck1320 FIND v(dout0_237) AT=665.025n

.meas tran vdout0_238ck1320 FIND v(dout0_238) AT=665.025n

.meas tran vdout0_239ck1320 FIND v(dout0_239) AT=665.025n

.meas tran vdout0_240ck1320 FIND v(dout0_240) AT=665.025n

.meas tran vdout0_241ck1320 FIND v(dout0_241) AT=665.025n

.meas tran vdout0_242ck1320 FIND v(dout0_242) AT=665.025n

.meas tran vdout0_243ck1320 FIND v(dout0_243) AT=665.025n

.meas tran vdout0_244ck1320 FIND v(dout0_244) AT=665.025n

.meas tran vdout0_245ck1320 FIND v(dout0_245) AT=665.025n

.meas tran vdout0_246ck1320 FIND v(dout0_246) AT=665.025n

.meas tran vdout0_247ck1320 FIND v(dout0_247) AT=665.025n

.meas tran vdout0_248ck1320 FIND v(dout0_248) AT=665.025n

.meas tran vdout0_249ck1320 FIND v(dout0_249) AT=665.025n

.meas tran vdout0_250ck1320 FIND v(dout0_250) AT=665.025n

.meas tran vdout0_251ck1320 FIND v(dout0_251) AT=665.025n

.meas tran vdout0_252ck1320 FIND v(dout0_252) AT=665.025n

.meas tran vdout0_253ck1320 FIND v(dout0_253) AT=665.025n

.meas tran vdout0_254ck1320 FIND v(dout0_254) AT=665.025n

.meas tran vdout0_255ck1320 FIND v(dout0_255) AT=665.025n

.meas tran vdout0_0ck1340 FIND v(dout0_0) AT=675.025n

.meas tran vdout0_1ck1340 FIND v(dout0_1) AT=675.025n

.meas tran vdout0_2ck1340 FIND v(dout0_2) AT=675.025n

.meas tran vdout0_3ck1340 FIND v(dout0_3) AT=675.025n

.meas tran vdout0_4ck1340 FIND v(dout0_4) AT=675.025n

.meas tran vdout0_5ck1340 FIND v(dout0_5) AT=675.025n

.meas tran vdout0_6ck1340 FIND v(dout0_6) AT=675.025n

.meas tran vdout0_7ck1340 FIND v(dout0_7) AT=675.025n

.meas tran vdout0_8ck1340 FIND v(dout0_8) AT=675.025n

.meas tran vdout0_9ck1340 FIND v(dout0_9) AT=675.025n

.meas tran vdout0_10ck1340 FIND v(dout0_10) AT=675.025n

.meas tran vdout0_11ck1340 FIND v(dout0_11) AT=675.025n

.meas tran vdout0_12ck1340 FIND v(dout0_12) AT=675.025n

.meas tran vdout0_13ck1340 FIND v(dout0_13) AT=675.025n

.meas tran vdout0_14ck1340 FIND v(dout0_14) AT=675.025n

.meas tran vdout0_15ck1340 FIND v(dout0_15) AT=675.025n

.meas tran vdout0_16ck1340 FIND v(dout0_16) AT=675.025n

.meas tran vdout0_17ck1340 FIND v(dout0_17) AT=675.025n

.meas tran vdout0_18ck1340 FIND v(dout0_18) AT=675.025n

.meas tran vdout0_19ck1340 FIND v(dout0_19) AT=675.025n

.meas tran vdout0_20ck1340 FIND v(dout0_20) AT=675.025n

.meas tran vdout0_21ck1340 FIND v(dout0_21) AT=675.025n

.meas tran vdout0_22ck1340 FIND v(dout0_22) AT=675.025n

.meas tran vdout0_23ck1340 FIND v(dout0_23) AT=675.025n

.meas tran vdout0_24ck1340 FIND v(dout0_24) AT=675.025n

.meas tran vdout0_25ck1340 FIND v(dout0_25) AT=675.025n

.meas tran vdout0_26ck1340 FIND v(dout0_26) AT=675.025n

.meas tran vdout0_27ck1340 FIND v(dout0_27) AT=675.025n

.meas tran vdout0_28ck1340 FIND v(dout0_28) AT=675.025n

.meas tran vdout0_29ck1340 FIND v(dout0_29) AT=675.025n

.meas tran vdout0_30ck1340 FIND v(dout0_30) AT=675.025n

.meas tran vdout0_31ck1340 FIND v(dout0_31) AT=675.025n

.meas tran vdout0_32ck1340 FIND v(dout0_32) AT=675.025n

.meas tran vdout0_33ck1340 FIND v(dout0_33) AT=675.025n

.meas tran vdout0_34ck1340 FIND v(dout0_34) AT=675.025n

.meas tran vdout0_35ck1340 FIND v(dout0_35) AT=675.025n

.meas tran vdout0_36ck1340 FIND v(dout0_36) AT=675.025n

.meas tran vdout0_37ck1340 FIND v(dout0_37) AT=675.025n

.meas tran vdout0_38ck1340 FIND v(dout0_38) AT=675.025n

.meas tran vdout0_39ck1340 FIND v(dout0_39) AT=675.025n

.meas tran vdout0_40ck1340 FIND v(dout0_40) AT=675.025n

.meas tran vdout0_41ck1340 FIND v(dout0_41) AT=675.025n

.meas tran vdout0_42ck1340 FIND v(dout0_42) AT=675.025n

.meas tran vdout0_43ck1340 FIND v(dout0_43) AT=675.025n

.meas tran vdout0_44ck1340 FIND v(dout0_44) AT=675.025n

.meas tran vdout0_45ck1340 FIND v(dout0_45) AT=675.025n

.meas tran vdout0_46ck1340 FIND v(dout0_46) AT=675.025n

.meas tran vdout0_47ck1340 FIND v(dout0_47) AT=675.025n

.meas tran vdout0_48ck1340 FIND v(dout0_48) AT=675.025n

.meas tran vdout0_49ck1340 FIND v(dout0_49) AT=675.025n

.meas tran vdout0_50ck1340 FIND v(dout0_50) AT=675.025n

.meas tran vdout0_51ck1340 FIND v(dout0_51) AT=675.025n

.meas tran vdout0_52ck1340 FIND v(dout0_52) AT=675.025n

.meas tran vdout0_53ck1340 FIND v(dout0_53) AT=675.025n

.meas tran vdout0_54ck1340 FIND v(dout0_54) AT=675.025n

.meas tran vdout0_55ck1340 FIND v(dout0_55) AT=675.025n

.meas tran vdout0_56ck1340 FIND v(dout0_56) AT=675.025n

.meas tran vdout0_57ck1340 FIND v(dout0_57) AT=675.025n

.meas tran vdout0_58ck1340 FIND v(dout0_58) AT=675.025n

.meas tran vdout0_59ck1340 FIND v(dout0_59) AT=675.025n

.meas tran vdout0_60ck1340 FIND v(dout0_60) AT=675.025n

.meas tran vdout0_61ck1340 FIND v(dout0_61) AT=675.025n

.meas tran vdout0_62ck1340 FIND v(dout0_62) AT=675.025n

.meas tran vdout0_63ck1340 FIND v(dout0_63) AT=675.025n

.meas tran vdout0_64ck1340 FIND v(dout0_64) AT=675.025n

.meas tran vdout0_65ck1340 FIND v(dout0_65) AT=675.025n

.meas tran vdout0_66ck1340 FIND v(dout0_66) AT=675.025n

.meas tran vdout0_67ck1340 FIND v(dout0_67) AT=675.025n

.meas tran vdout0_68ck1340 FIND v(dout0_68) AT=675.025n

.meas tran vdout0_69ck1340 FIND v(dout0_69) AT=675.025n

.meas tran vdout0_70ck1340 FIND v(dout0_70) AT=675.025n

.meas tran vdout0_71ck1340 FIND v(dout0_71) AT=675.025n

.meas tran vdout0_72ck1340 FIND v(dout0_72) AT=675.025n

.meas tran vdout0_73ck1340 FIND v(dout0_73) AT=675.025n

.meas tran vdout0_74ck1340 FIND v(dout0_74) AT=675.025n

.meas tran vdout0_75ck1340 FIND v(dout0_75) AT=675.025n

.meas tran vdout0_76ck1340 FIND v(dout0_76) AT=675.025n

.meas tran vdout0_77ck1340 FIND v(dout0_77) AT=675.025n

.meas tran vdout0_78ck1340 FIND v(dout0_78) AT=675.025n

.meas tran vdout0_79ck1340 FIND v(dout0_79) AT=675.025n

.meas tran vdout0_80ck1340 FIND v(dout0_80) AT=675.025n

.meas tran vdout0_81ck1340 FIND v(dout0_81) AT=675.025n

.meas tran vdout0_82ck1340 FIND v(dout0_82) AT=675.025n

.meas tran vdout0_83ck1340 FIND v(dout0_83) AT=675.025n

.meas tran vdout0_84ck1340 FIND v(dout0_84) AT=675.025n

.meas tran vdout0_85ck1340 FIND v(dout0_85) AT=675.025n

.meas tran vdout0_86ck1340 FIND v(dout0_86) AT=675.025n

.meas tran vdout0_87ck1340 FIND v(dout0_87) AT=675.025n

.meas tran vdout0_88ck1340 FIND v(dout0_88) AT=675.025n

.meas tran vdout0_89ck1340 FIND v(dout0_89) AT=675.025n

.meas tran vdout0_90ck1340 FIND v(dout0_90) AT=675.025n

.meas tran vdout0_91ck1340 FIND v(dout0_91) AT=675.025n

.meas tran vdout0_92ck1340 FIND v(dout0_92) AT=675.025n

.meas tran vdout0_93ck1340 FIND v(dout0_93) AT=675.025n

.meas tran vdout0_94ck1340 FIND v(dout0_94) AT=675.025n

.meas tran vdout0_95ck1340 FIND v(dout0_95) AT=675.025n

.meas tran vdout0_96ck1340 FIND v(dout0_96) AT=675.025n

.meas tran vdout0_97ck1340 FIND v(dout0_97) AT=675.025n

.meas tran vdout0_98ck1340 FIND v(dout0_98) AT=675.025n

.meas tran vdout0_99ck1340 FIND v(dout0_99) AT=675.025n

.meas tran vdout0_100ck1340 FIND v(dout0_100) AT=675.025n

.meas tran vdout0_101ck1340 FIND v(dout0_101) AT=675.025n

.meas tran vdout0_102ck1340 FIND v(dout0_102) AT=675.025n

.meas tran vdout0_103ck1340 FIND v(dout0_103) AT=675.025n

.meas tran vdout0_104ck1340 FIND v(dout0_104) AT=675.025n

.meas tran vdout0_105ck1340 FIND v(dout0_105) AT=675.025n

.meas tran vdout0_106ck1340 FIND v(dout0_106) AT=675.025n

.meas tran vdout0_107ck1340 FIND v(dout0_107) AT=675.025n

.meas tran vdout0_108ck1340 FIND v(dout0_108) AT=675.025n

.meas tran vdout0_109ck1340 FIND v(dout0_109) AT=675.025n

.meas tran vdout0_110ck1340 FIND v(dout0_110) AT=675.025n

.meas tran vdout0_111ck1340 FIND v(dout0_111) AT=675.025n

.meas tran vdout0_112ck1340 FIND v(dout0_112) AT=675.025n

.meas tran vdout0_113ck1340 FIND v(dout0_113) AT=675.025n

.meas tran vdout0_114ck1340 FIND v(dout0_114) AT=675.025n

.meas tran vdout0_115ck1340 FIND v(dout0_115) AT=675.025n

.meas tran vdout0_116ck1340 FIND v(dout0_116) AT=675.025n

.meas tran vdout0_117ck1340 FIND v(dout0_117) AT=675.025n

.meas tran vdout0_118ck1340 FIND v(dout0_118) AT=675.025n

.meas tran vdout0_119ck1340 FIND v(dout0_119) AT=675.025n

.meas tran vdout0_120ck1340 FIND v(dout0_120) AT=675.025n

.meas tran vdout0_121ck1340 FIND v(dout0_121) AT=675.025n

.meas tran vdout0_122ck1340 FIND v(dout0_122) AT=675.025n

.meas tran vdout0_123ck1340 FIND v(dout0_123) AT=675.025n

.meas tran vdout0_124ck1340 FIND v(dout0_124) AT=675.025n

.meas tran vdout0_125ck1340 FIND v(dout0_125) AT=675.025n

.meas tran vdout0_126ck1340 FIND v(dout0_126) AT=675.025n

.meas tran vdout0_127ck1340 FIND v(dout0_127) AT=675.025n

.meas tran vdout0_128ck1340 FIND v(dout0_128) AT=675.025n

.meas tran vdout0_129ck1340 FIND v(dout0_129) AT=675.025n

.meas tran vdout0_130ck1340 FIND v(dout0_130) AT=675.025n

.meas tran vdout0_131ck1340 FIND v(dout0_131) AT=675.025n

.meas tran vdout0_132ck1340 FIND v(dout0_132) AT=675.025n

.meas tran vdout0_133ck1340 FIND v(dout0_133) AT=675.025n

.meas tran vdout0_134ck1340 FIND v(dout0_134) AT=675.025n

.meas tran vdout0_135ck1340 FIND v(dout0_135) AT=675.025n

.meas tran vdout0_136ck1340 FIND v(dout0_136) AT=675.025n

.meas tran vdout0_137ck1340 FIND v(dout0_137) AT=675.025n

.meas tran vdout0_138ck1340 FIND v(dout0_138) AT=675.025n

.meas tran vdout0_139ck1340 FIND v(dout0_139) AT=675.025n

.meas tran vdout0_140ck1340 FIND v(dout0_140) AT=675.025n

.meas tran vdout0_141ck1340 FIND v(dout0_141) AT=675.025n

.meas tran vdout0_142ck1340 FIND v(dout0_142) AT=675.025n

.meas tran vdout0_143ck1340 FIND v(dout0_143) AT=675.025n

.meas tran vdout0_144ck1340 FIND v(dout0_144) AT=675.025n

.meas tran vdout0_145ck1340 FIND v(dout0_145) AT=675.025n

.meas tran vdout0_146ck1340 FIND v(dout0_146) AT=675.025n

.meas tran vdout0_147ck1340 FIND v(dout0_147) AT=675.025n

.meas tran vdout0_148ck1340 FIND v(dout0_148) AT=675.025n

.meas tran vdout0_149ck1340 FIND v(dout0_149) AT=675.025n

.meas tran vdout0_150ck1340 FIND v(dout0_150) AT=675.025n

.meas tran vdout0_151ck1340 FIND v(dout0_151) AT=675.025n

.meas tran vdout0_152ck1340 FIND v(dout0_152) AT=675.025n

.meas tran vdout0_153ck1340 FIND v(dout0_153) AT=675.025n

.meas tran vdout0_154ck1340 FIND v(dout0_154) AT=675.025n

.meas tran vdout0_155ck1340 FIND v(dout0_155) AT=675.025n

.meas tran vdout0_156ck1340 FIND v(dout0_156) AT=675.025n

.meas tran vdout0_157ck1340 FIND v(dout0_157) AT=675.025n

.meas tran vdout0_158ck1340 FIND v(dout0_158) AT=675.025n

.meas tran vdout0_159ck1340 FIND v(dout0_159) AT=675.025n

.meas tran vdout0_160ck1340 FIND v(dout0_160) AT=675.025n

.meas tran vdout0_161ck1340 FIND v(dout0_161) AT=675.025n

.meas tran vdout0_162ck1340 FIND v(dout0_162) AT=675.025n

.meas tran vdout0_163ck1340 FIND v(dout0_163) AT=675.025n

.meas tran vdout0_164ck1340 FIND v(dout0_164) AT=675.025n

.meas tran vdout0_165ck1340 FIND v(dout0_165) AT=675.025n

.meas tran vdout0_166ck1340 FIND v(dout0_166) AT=675.025n

.meas tran vdout0_167ck1340 FIND v(dout0_167) AT=675.025n

.meas tran vdout0_168ck1340 FIND v(dout0_168) AT=675.025n

.meas tran vdout0_169ck1340 FIND v(dout0_169) AT=675.025n

.meas tran vdout0_170ck1340 FIND v(dout0_170) AT=675.025n

.meas tran vdout0_171ck1340 FIND v(dout0_171) AT=675.025n

.meas tran vdout0_172ck1340 FIND v(dout0_172) AT=675.025n

.meas tran vdout0_173ck1340 FIND v(dout0_173) AT=675.025n

.meas tran vdout0_174ck1340 FIND v(dout0_174) AT=675.025n

.meas tran vdout0_175ck1340 FIND v(dout0_175) AT=675.025n

.meas tran vdout0_176ck1340 FIND v(dout0_176) AT=675.025n

.meas tran vdout0_177ck1340 FIND v(dout0_177) AT=675.025n

.meas tran vdout0_178ck1340 FIND v(dout0_178) AT=675.025n

.meas tran vdout0_179ck1340 FIND v(dout0_179) AT=675.025n

.meas tran vdout0_180ck1340 FIND v(dout0_180) AT=675.025n

.meas tran vdout0_181ck1340 FIND v(dout0_181) AT=675.025n

.meas tran vdout0_182ck1340 FIND v(dout0_182) AT=675.025n

.meas tran vdout0_183ck1340 FIND v(dout0_183) AT=675.025n

.meas tran vdout0_184ck1340 FIND v(dout0_184) AT=675.025n

.meas tran vdout0_185ck1340 FIND v(dout0_185) AT=675.025n

.meas tran vdout0_186ck1340 FIND v(dout0_186) AT=675.025n

.meas tran vdout0_187ck1340 FIND v(dout0_187) AT=675.025n

.meas tran vdout0_188ck1340 FIND v(dout0_188) AT=675.025n

.meas tran vdout0_189ck1340 FIND v(dout0_189) AT=675.025n

.meas tran vdout0_190ck1340 FIND v(dout0_190) AT=675.025n

.meas tran vdout0_191ck1340 FIND v(dout0_191) AT=675.025n

.meas tran vdout0_192ck1340 FIND v(dout0_192) AT=675.025n

.meas tran vdout0_193ck1340 FIND v(dout0_193) AT=675.025n

.meas tran vdout0_194ck1340 FIND v(dout0_194) AT=675.025n

.meas tran vdout0_195ck1340 FIND v(dout0_195) AT=675.025n

.meas tran vdout0_196ck1340 FIND v(dout0_196) AT=675.025n

.meas tran vdout0_197ck1340 FIND v(dout0_197) AT=675.025n

.meas tran vdout0_198ck1340 FIND v(dout0_198) AT=675.025n

.meas tran vdout0_199ck1340 FIND v(dout0_199) AT=675.025n

.meas tran vdout0_200ck1340 FIND v(dout0_200) AT=675.025n

.meas tran vdout0_201ck1340 FIND v(dout0_201) AT=675.025n

.meas tran vdout0_202ck1340 FIND v(dout0_202) AT=675.025n

.meas tran vdout0_203ck1340 FIND v(dout0_203) AT=675.025n

.meas tran vdout0_204ck1340 FIND v(dout0_204) AT=675.025n

.meas tran vdout0_205ck1340 FIND v(dout0_205) AT=675.025n

.meas tran vdout0_206ck1340 FIND v(dout0_206) AT=675.025n

.meas tran vdout0_207ck1340 FIND v(dout0_207) AT=675.025n

.meas tran vdout0_208ck1340 FIND v(dout0_208) AT=675.025n

.meas tran vdout0_209ck1340 FIND v(dout0_209) AT=675.025n

.meas tran vdout0_210ck1340 FIND v(dout0_210) AT=675.025n

.meas tran vdout0_211ck1340 FIND v(dout0_211) AT=675.025n

.meas tran vdout0_212ck1340 FIND v(dout0_212) AT=675.025n

.meas tran vdout0_213ck1340 FIND v(dout0_213) AT=675.025n

.meas tran vdout0_214ck1340 FIND v(dout0_214) AT=675.025n

.meas tran vdout0_215ck1340 FIND v(dout0_215) AT=675.025n

.meas tran vdout0_216ck1340 FIND v(dout0_216) AT=675.025n

.meas tran vdout0_217ck1340 FIND v(dout0_217) AT=675.025n

.meas tran vdout0_218ck1340 FIND v(dout0_218) AT=675.025n

.meas tran vdout0_219ck1340 FIND v(dout0_219) AT=675.025n

.meas tran vdout0_220ck1340 FIND v(dout0_220) AT=675.025n

.meas tran vdout0_221ck1340 FIND v(dout0_221) AT=675.025n

.meas tran vdout0_222ck1340 FIND v(dout0_222) AT=675.025n

.meas tran vdout0_223ck1340 FIND v(dout0_223) AT=675.025n

.meas tran vdout0_224ck1340 FIND v(dout0_224) AT=675.025n

.meas tran vdout0_225ck1340 FIND v(dout0_225) AT=675.025n

.meas tran vdout0_226ck1340 FIND v(dout0_226) AT=675.025n

.meas tran vdout0_227ck1340 FIND v(dout0_227) AT=675.025n

.meas tran vdout0_228ck1340 FIND v(dout0_228) AT=675.025n

.meas tran vdout0_229ck1340 FIND v(dout0_229) AT=675.025n

.meas tran vdout0_230ck1340 FIND v(dout0_230) AT=675.025n

.meas tran vdout0_231ck1340 FIND v(dout0_231) AT=675.025n

.meas tran vdout0_232ck1340 FIND v(dout0_232) AT=675.025n

.meas tran vdout0_233ck1340 FIND v(dout0_233) AT=675.025n

.meas tran vdout0_234ck1340 FIND v(dout0_234) AT=675.025n

.meas tran vdout0_235ck1340 FIND v(dout0_235) AT=675.025n

.meas tran vdout0_236ck1340 FIND v(dout0_236) AT=675.025n

.meas tran vdout0_237ck1340 FIND v(dout0_237) AT=675.025n

.meas tran vdout0_238ck1340 FIND v(dout0_238) AT=675.025n

.meas tran vdout0_239ck1340 FIND v(dout0_239) AT=675.025n

.meas tran vdout0_240ck1340 FIND v(dout0_240) AT=675.025n

.meas tran vdout0_241ck1340 FIND v(dout0_241) AT=675.025n

.meas tran vdout0_242ck1340 FIND v(dout0_242) AT=675.025n

.meas tran vdout0_243ck1340 FIND v(dout0_243) AT=675.025n

.meas tran vdout0_244ck1340 FIND v(dout0_244) AT=675.025n

.meas tran vdout0_245ck1340 FIND v(dout0_245) AT=675.025n

.meas tran vdout0_246ck1340 FIND v(dout0_246) AT=675.025n

.meas tran vdout0_247ck1340 FIND v(dout0_247) AT=675.025n

.meas tran vdout0_248ck1340 FIND v(dout0_248) AT=675.025n

.meas tran vdout0_249ck1340 FIND v(dout0_249) AT=675.025n

.meas tran vdout0_250ck1340 FIND v(dout0_250) AT=675.025n

.meas tran vdout0_251ck1340 FIND v(dout0_251) AT=675.025n

.meas tran vdout0_252ck1340 FIND v(dout0_252) AT=675.025n

.meas tran vdout0_253ck1340 FIND v(dout0_253) AT=675.025n

.meas tran vdout0_254ck1340 FIND v(dout0_254) AT=675.025n

.meas tran vdout0_255ck1340 FIND v(dout0_255) AT=675.025n

.meas tran vdout0_0ck1360 FIND v(dout0_0) AT=685.025n

.meas tran vdout0_1ck1360 FIND v(dout0_1) AT=685.025n

.meas tran vdout0_2ck1360 FIND v(dout0_2) AT=685.025n

.meas tran vdout0_3ck1360 FIND v(dout0_3) AT=685.025n

.meas tran vdout0_4ck1360 FIND v(dout0_4) AT=685.025n

.meas tran vdout0_5ck1360 FIND v(dout0_5) AT=685.025n

.meas tran vdout0_6ck1360 FIND v(dout0_6) AT=685.025n

.meas tran vdout0_7ck1360 FIND v(dout0_7) AT=685.025n

.meas tran vdout0_8ck1360 FIND v(dout0_8) AT=685.025n

.meas tran vdout0_9ck1360 FIND v(dout0_9) AT=685.025n

.meas tran vdout0_10ck1360 FIND v(dout0_10) AT=685.025n

.meas tran vdout0_11ck1360 FIND v(dout0_11) AT=685.025n

.meas tran vdout0_12ck1360 FIND v(dout0_12) AT=685.025n

.meas tran vdout0_13ck1360 FIND v(dout0_13) AT=685.025n

.meas tran vdout0_14ck1360 FIND v(dout0_14) AT=685.025n

.meas tran vdout0_15ck1360 FIND v(dout0_15) AT=685.025n

.meas tran vdout0_16ck1360 FIND v(dout0_16) AT=685.025n

.meas tran vdout0_17ck1360 FIND v(dout0_17) AT=685.025n

.meas tran vdout0_18ck1360 FIND v(dout0_18) AT=685.025n

.meas tran vdout0_19ck1360 FIND v(dout0_19) AT=685.025n

.meas tran vdout0_20ck1360 FIND v(dout0_20) AT=685.025n

.meas tran vdout0_21ck1360 FIND v(dout0_21) AT=685.025n

.meas tran vdout0_22ck1360 FIND v(dout0_22) AT=685.025n

.meas tran vdout0_23ck1360 FIND v(dout0_23) AT=685.025n

.meas tran vdout0_24ck1360 FIND v(dout0_24) AT=685.025n

.meas tran vdout0_25ck1360 FIND v(dout0_25) AT=685.025n

.meas tran vdout0_26ck1360 FIND v(dout0_26) AT=685.025n

.meas tran vdout0_27ck1360 FIND v(dout0_27) AT=685.025n

.meas tran vdout0_28ck1360 FIND v(dout0_28) AT=685.025n

.meas tran vdout0_29ck1360 FIND v(dout0_29) AT=685.025n

.meas tran vdout0_30ck1360 FIND v(dout0_30) AT=685.025n

.meas tran vdout0_31ck1360 FIND v(dout0_31) AT=685.025n

.meas tran vdout0_32ck1360 FIND v(dout0_32) AT=685.025n

.meas tran vdout0_33ck1360 FIND v(dout0_33) AT=685.025n

.meas tran vdout0_34ck1360 FIND v(dout0_34) AT=685.025n

.meas tran vdout0_35ck1360 FIND v(dout0_35) AT=685.025n

.meas tran vdout0_36ck1360 FIND v(dout0_36) AT=685.025n

.meas tran vdout0_37ck1360 FIND v(dout0_37) AT=685.025n

.meas tran vdout0_38ck1360 FIND v(dout0_38) AT=685.025n

.meas tran vdout0_39ck1360 FIND v(dout0_39) AT=685.025n

.meas tran vdout0_40ck1360 FIND v(dout0_40) AT=685.025n

.meas tran vdout0_41ck1360 FIND v(dout0_41) AT=685.025n

.meas tran vdout0_42ck1360 FIND v(dout0_42) AT=685.025n

.meas tran vdout0_43ck1360 FIND v(dout0_43) AT=685.025n

.meas tran vdout0_44ck1360 FIND v(dout0_44) AT=685.025n

.meas tran vdout0_45ck1360 FIND v(dout0_45) AT=685.025n

.meas tran vdout0_46ck1360 FIND v(dout0_46) AT=685.025n

.meas tran vdout0_47ck1360 FIND v(dout0_47) AT=685.025n

.meas tran vdout0_48ck1360 FIND v(dout0_48) AT=685.025n

.meas tran vdout0_49ck1360 FIND v(dout0_49) AT=685.025n

.meas tran vdout0_50ck1360 FIND v(dout0_50) AT=685.025n

.meas tran vdout0_51ck1360 FIND v(dout0_51) AT=685.025n

.meas tran vdout0_52ck1360 FIND v(dout0_52) AT=685.025n

.meas tran vdout0_53ck1360 FIND v(dout0_53) AT=685.025n

.meas tran vdout0_54ck1360 FIND v(dout0_54) AT=685.025n

.meas tran vdout0_55ck1360 FIND v(dout0_55) AT=685.025n

.meas tran vdout0_56ck1360 FIND v(dout0_56) AT=685.025n

.meas tran vdout0_57ck1360 FIND v(dout0_57) AT=685.025n

.meas tran vdout0_58ck1360 FIND v(dout0_58) AT=685.025n

.meas tran vdout0_59ck1360 FIND v(dout0_59) AT=685.025n

.meas tran vdout0_60ck1360 FIND v(dout0_60) AT=685.025n

.meas tran vdout0_61ck1360 FIND v(dout0_61) AT=685.025n

.meas tran vdout0_62ck1360 FIND v(dout0_62) AT=685.025n

.meas tran vdout0_63ck1360 FIND v(dout0_63) AT=685.025n

.meas tran vdout0_64ck1360 FIND v(dout0_64) AT=685.025n

.meas tran vdout0_65ck1360 FIND v(dout0_65) AT=685.025n

.meas tran vdout0_66ck1360 FIND v(dout0_66) AT=685.025n

.meas tran vdout0_67ck1360 FIND v(dout0_67) AT=685.025n

.meas tran vdout0_68ck1360 FIND v(dout0_68) AT=685.025n

.meas tran vdout0_69ck1360 FIND v(dout0_69) AT=685.025n

.meas tran vdout0_70ck1360 FIND v(dout0_70) AT=685.025n

.meas tran vdout0_71ck1360 FIND v(dout0_71) AT=685.025n

.meas tran vdout0_72ck1360 FIND v(dout0_72) AT=685.025n

.meas tran vdout0_73ck1360 FIND v(dout0_73) AT=685.025n

.meas tran vdout0_74ck1360 FIND v(dout0_74) AT=685.025n

.meas tran vdout0_75ck1360 FIND v(dout0_75) AT=685.025n

.meas tran vdout0_76ck1360 FIND v(dout0_76) AT=685.025n

.meas tran vdout0_77ck1360 FIND v(dout0_77) AT=685.025n

.meas tran vdout0_78ck1360 FIND v(dout0_78) AT=685.025n

.meas tran vdout0_79ck1360 FIND v(dout0_79) AT=685.025n

.meas tran vdout0_80ck1360 FIND v(dout0_80) AT=685.025n

.meas tran vdout0_81ck1360 FIND v(dout0_81) AT=685.025n

.meas tran vdout0_82ck1360 FIND v(dout0_82) AT=685.025n

.meas tran vdout0_83ck1360 FIND v(dout0_83) AT=685.025n

.meas tran vdout0_84ck1360 FIND v(dout0_84) AT=685.025n

.meas tran vdout0_85ck1360 FIND v(dout0_85) AT=685.025n

.meas tran vdout0_86ck1360 FIND v(dout0_86) AT=685.025n

.meas tran vdout0_87ck1360 FIND v(dout0_87) AT=685.025n

.meas tran vdout0_88ck1360 FIND v(dout0_88) AT=685.025n

.meas tran vdout0_89ck1360 FIND v(dout0_89) AT=685.025n

.meas tran vdout0_90ck1360 FIND v(dout0_90) AT=685.025n

.meas tran vdout0_91ck1360 FIND v(dout0_91) AT=685.025n

.meas tran vdout0_92ck1360 FIND v(dout0_92) AT=685.025n

.meas tran vdout0_93ck1360 FIND v(dout0_93) AT=685.025n

.meas tran vdout0_94ck1360 FIND v(dout0_94) AT=685.025n

.meas tran vdout0_95ck1360 FIND v(dout0_95) AT=685.025n

.meas tran vdout0_96ck1360 FIND v(dout0_96) AT=685.025n

.meas tran vdout0_97ck1360 FIND v(dout0_97) AT=685.025n

.meas tran vdout0_98ck1360 FIND v(dout0_98) AT=685.025n

.meas tran vdout0_99ck1360 FIND v(dout0_99) AT=685.025n

.meas tran vdout0_100ck1360 FIND v(dout0_100) AT=685.025n

.meas tran vdout0_101ck1360 FIND v(dout0_101) AT=685.025n

.meas tran vdout0_102ck1360 FIND v(dout0_102) AT=685.025n

.meas tran vdout0_103ck1360 FIND v(dout0_103) AT=685.025n

.meas tran vdout0_104ck1360 FIND v(dout0_104) AT=685.025n

.meas tran vdout0_105ck1360 FIND v(dout0_105) AT=685.025n

.meas tran vdout0_106ck1360 FIND v(dout0_106) AT=685.025n

.meas tran vdout0_107ck1360 FIND v(dout0_107) AT=685.025n

.meas tran vdout0_108ck1360 FIND v(dout0_108) AT=685.025n

.meas tran vdout0_109ck1360 FIND v(dout0_109) AT=685.025n

.meas tran vdout0_110ck1360 FIND v(dout0_110) AT=685.025n

.meas tran vdout0_111ck1360 FIND v(dout0_111) AT=685.025n

.meas tran vdout0_112ck1360 FIND v(dout0_112) AT=685.025n

.meas tran vdout0_113ck1360 FIND v(dout0_113) AT=685.025n

.meas tran vdout0_114ck1360 FIND v(dout0_114) AT=685.025n

.meas tran vdout0_115ck1360 FIND v(dout0_115) AT=685.025n

.meas tran vdout0_116ck1360 FIND v(dout0_116) AT=685.025n

.meas tran vdout0_117ck1360 FIND v(dout0_117) AT=685.025n

.meas tran vdout0_118ck1360 FIND v(dout0_118) AT=685.025n

.meas tran vdout0_119ck1360 FIND v(dout0_119) AT=685.025n

.meas tran vdout0_120ck1360 FIND v(dout0_120) AT=685.025n

.meas tran vdout0_121ck1360 FIND v(dout0_121) AT=685.025n

.meas tran vdout0_122ck1360 FIND v(dout0_122) AT=685.025n

.meas tran vdout0_123ck1360 FIND v(dout0_123) AT=685.025n

.meas tran vdout0_124ck1360 FIND v(dout0_124) AT=685.025n

.meas tran vdout0_125ck1360 FIND v(dout0_125) AT=685.025n

.meas tran vdout0_126ck1360 FIND v(dout0_126) AT=685.025n

.meas tran vdout0_127ck1360 FIND v(dout0_127) AT=685.025n

.meas tran vdout0_128ck1360 FIND v(dout0_128) AT=685.025n

.meas tran vdout0_129ck1360 FIND v(dout0_129) AT=685.025n

.meas tran vdout0_130ck1360 FIND v(dout0_130) AT=685.025n

.meas tran vdout0_131ck1360 FIND v(dout0_131) AT=685.025n

.meas tran vdout0_132ck1360 FIND v(dout0_132) AT=685.025n

.meas tran vdout0_133ck1360 FIND v(dout0_133) AT=685.025n

.meas tran vdout0_134ck1360 FIND v(dout0_134) AT=685.025n

.meas tran vdout0_135ck1360 FIND v(dout0_135) AT=685.025n

.meas tran vdout0_136ck1360 FIND v(dout0_136) AT=685.025n

.meas tran vdout0_137ck1360 FIND v(dout0_137) AT=685.025n

.meas tran vdout0_138ck1360 FIND v(dout0_138) AT=685.025n

.meas tran vdout0_139ck1360 FIND v(dout0_139) AT=685.025n

.meas tran vdout0_140ck1360 FIND v(dout0_140) AT=685.025n

.meas tran vdout0_141ck1360 FIND v(dout0_141) AT=685.025n

.meas tran vdout0_142ck1360 FIND v(dout0_142) AT=685.025n

.meas tran vdout0_143ck1360 FIND v(dout0_143) AT=685.025n

.meas tran vdout0_144ck1360 FIND v(dout0_144) AT=685.025n

.meas tran vdout0_145ck1360 FIND v(dout0_145) AT=685.025n

.meas tran vdout0_146ck1360 FIND v(dout0_146) AT=685.025n

.meas tran vdout0_147ck1360 FIND v(dout0_147) AT=685.025n

.meas tran vdout0_148ck1360 FIND v(dout0_148) AT=685.025n

.meas tran vdout0_149ck1360 FIND v(dout0_149) AT=685.025n

.meas tran vdout0_150ck1360 FIND v(dout0_150) AT=685.025n

.meas tran vdout0_151ck1360 FIND v(dout0_151) AT=685.025n

.meas tran vdout0_152ck1360 FIND v(dout0_152) AT=685.025n

.meas tran vdout0_153ck1360 FIND v(dout0_153) AT=685.025n

.meas tran vdout0_154ck1360 FIND v(dout0_154) AT=685.025n

.meas tran vdout0_155ck1360 FIND v(dout0_155) AT=685.025n

.meas tran vdout0_156ck1360 FIND v(dout0_156) AT=685.025n

.meas tran vdout0_157ck1360 FIND v(dout0_157) AT=685.025n

.meas tran vdout0_158ck1360 FIND v(dout0_158) AT=685.025n

.meas tran vdout0_159ck1360 FIND v(dout0_159) AT=685.025n

.meas tran vdout0_160ck1360 FIND v(dout0_160) AT=685.025n

.meas tran vdout0_161ck1360 FIND v(dout0_161) AT=685.025n

.meas tran vdout0_162ck1360 FIND v(dout0_162) AT=685.025n

.meas tran vdout0_163ck1360 FIND v(dout0_163) AT=685.025n

.meas tran vdout0_164ck1360 FIND v(dout0_164) AT=685.025n

.meas tran vdout0_165ck1360 FIND v(dout0_165) AT=685.025n

.meas tran vdout0_166ck1360 FIND v(dout0_166) AT=685.025n

.meas tran vdout0_167ck1360 FIND v(dout0_167) AT=685.025n

.meas tran vdout0_168ck1360 FIND v(dout0_168) AT=685.025n

.meas tran vdout0_169ck1360 FIND v(dout0_169) AT=685.025n

.meas tran vdout0_170ck1360 FIND v(dout0_170) AT=685.025n

.meas tran vdout0_171ck1360 FIND v(dout0_171) AT=685.025n

.meas tran vdout0_172ck1360 FIND v(dout0_172) AT=685.025n

.meas tran vdout0_173ck1360 FIND v(dout0_173) AT=685.025n

.meas tran vdout0_174ck1360 FIND v(dout0_174) AT=685.025n

.meas tran vdout0_175ck1360 FIND v(dout0_175) AT=685.025n

.meas tran vdout0_176ck1360 FIND v(dout0_176) AT=685.025n

.meas tran vdout0_177ck1360 FIND v(dout0_177) AT=685.025n

.meas tran vdout0_178ck1360 FIND v(dout0_178) AT=685.025n

.meas tran vdout0_179ck1360 FIND v(dout0_179) AT=685.025n

.meas tran vdout0_180ck1360 FIND v(dout0_180) AT=685.025n

.meas tran vdout0_181ck1360 FIND v(dout0_181) AT=685.025n

.meas tran vdout0_182ck1360 FIND v(dout0_182) AT=685.025n

.meas tran vdout0_183ck1360 FIND v(dout0_183) AT=685.025n

.meas tran vdout0_184ck1360 FIND v(dout0_184) AT=685.025n

.meas tran vdout0_185ck1360 FIND v(dout0_185) AT=685.025n

.meas tran vdout0_186ck1360 FIND v(dout0_186) AT=685.025n

.meas tran vdout0_187ck1360 FIND v(dout0_187) AT=685.025n

.meas tran vdout0_188ck1360 FIND v(dout0_188) AT=685.025n

.meas tran vdout0_189ck1360 FIND v(dout0_189) AT=685.025n

.meas tran vdout0_190ck1360 FIND v(dout0_190) AT=685.025n

.meas tran vdout0_191ck1360 FIND v(dout0_191) AT=685.025n

.meas tran vdout0_192ck1360 FIND v(dout0_192) AT=685.025n

.meas tran vdout0_193ck1360 FIND v(dout0_193) AT=685.025n

.meas tran vdout0_194ck1360 FIND v(dout0_194) AT=685.025n

.meas tran vdout0_195ck1360 FIND v(dout0_195) AT=685.025n

.meas tran vdout0_196ck1360 FIND v(dout0_196) AT=685.025n

.meas tran vdout0_197ck1360 FIND v(dout0_197) AT=685.025n

.meas tran vdout0_198ck1360 FIND v(dout0_198) AT=685.025n

.meas tran vdout0_199ck1360 FIND v(dout0_199) AT=685.025n

.meas tran vdout0_200ck1360 FIND v(dout0_200) AT=685.025n

.meas tran vdout0_201ck1360 FIND v(dout0_201) AT=685.025n

.meas tran vdout0_202ck1360 FIND v(dout0_202) AT=685.025n

.meas tran vdout0_203ck1360 FIND v(dout0_203) AT=685.025n

.meas tran vdout0_204ck1360 FIND v(dout0_204) AT=685.025n

.meas tran vdout0_205ck1360 FIND v(dout0_205) AT=685.025n

.meas tran vdout0_206ck1360 FIND v(dout0_206) AT=685.025n

.meas tran vdout0_207ck1360 FIND v(dout0_207) AT=685.025n

.meas tran vdout0_208ck1360 FIND v(dout0_208) AT=685.025n

.meas tran vdout0_209ck1360 FIND v(dout0_209) AT=685.025n

.meas tran vdout0_210ck1360 FIND v(dout0_210) AT=685.025n

.meas tran vdout0_211ck1360 FIND v(dout0_211) AT=685.025n

.meas tran vdout0_212ck1360 FIND v(dout0_212) AT=685.025n

.meas tran vdout0_213ck1360 FIND v(dout0_213) AT=685.025n

.meas tran vdout0_214ck1360 FIND v(dout0_214) AT=685.025n

.meas tran vdout0_215ck1360 FIND v(dout0_215) AT=685.025n

.meas tran vdout0_216ck1360 FIND v(dout0_216) AT=685.025n

.meas tran vdout0_217ck1360 FIND v(dout0_217) AT=685.025n

.meas tran vdout0_218ck1360 FIND v(dout0_218) AT=685.025n

.meas tran vdout0_219ck1360 FIND v(dout0_219) AT=685.025n

.meas tran vdout0_220ck1360 FIND v(dout0_220) AT=685.025n

.meas tran vdout0_221ck1360 FIND v(dout0_221) AT=685.025n

.meas tran vdout0_222ck1360 FIND v(dout0_222) AT=685.025n

.meas tran vdout0_223ck1360 FIND v(dout0_223) AT=685.025n

.meas tran vdout0_224ck1360 FIND v(dout0_224) AT=685.025n

.meas tran vdout0_225ck1360 FIND v(dout0_225) AT=685.025n

.meas tran vdout0_226ck1360 FIND v(dout0_226) AT=685.025n

.meas tran vdout0_227ck1360 FIND v(dout0_227) AT=685.025n

.meas tran vdout0_228ck1360 FIND v(dout0_228) AT=685.025n

.meas tran vdout0_229ck1360 FIND v(dout0_229) AT=685.025n

.meas tran vdout0_230ck1360 FIND v(dout0_230) AT=685.025n

.meas tran vdout0_231ck1360 FIND v(dout0_231) AT=685.025n

.meas tran vdout0_232ck1360 FIND v(dout0_232) AT=685.025n

.meas tran vdout0_233ck1360 FIND v(dout0_233) AT=685.025n

.meas tran vdout0_234ck1360 FIND v(dout0_234) AT=685.025n

.meas tran vdout0_235ck1360 FIND v(dout0_235) AT=685.025n

.meas tran vdout0_236ck1360 FIND v(dout0_236) AT=685.025n

.meas tran vdout0_237ck1360 FIND v(dout0_237) AT=685.025n

.meas tran vdout0_238ck1360 FIND v(dout0_238) AT=685.025n

.meas tran vdout0_239ck1360 FIND v(dout0_239) AT=685.025n

.meas tran vdout0_240ck1360 FIND v(dout0_240) AT=685.025n

.meas tran vdout0_241ck1360 FIND v(dout0_241) AT=685.025n

.meas tran vdout0_242ck1360 FIND v(dout0_242) AT=685.025n

.meas tran vdout0_243ck1360 FIND v(dout0_243) AT=685.025n

.meas tran vdout0_244ck1360 FIND v(dout0_244) AT=685.025n

.meas tran vdout0_245ck1360 FIND v(dout0_245) AT=685.025n

.meas tran vdout0_246ck1360 FIND v(dout0_246) AT=685.025n

.meas tran vdout0_247ck1360 FIND v(dout0_247) AT=685.025n

.meas tran vdout0_248ck1360 FIND v(dout0_248) AT=685.025n

.meas tran vdout0_249ck1360 FIND v(dout0_249) AT=685.025n

.meas tran vdout0_250ck1360 FIND v(dout0_250) AT=685.025n

.meas tran vdout0_251ck1360 FIND v(dout0_251) AT=685.025n

.meas tran vdout0_252ck1360 FIND v(dout0_252) AT=685.025n

.meas tran vdout0_253ck1360 FIND v(dout0_253) AT=685.025n

.meas tran vdout0_254ck1360 FIND v(dout0_254) AT=685.025n

.meas tran vdout0_255ck1360 FIND v(dout0_255) AT=685.025n

.meas tran vdout0_0ck1430 FIND v(dout0_0) AT=720.025n

.meas tran vdout0_1ck1430 FIND v(dout0_1) AT=720.025n

.meas tran vdout0_2ck1430 FIND v(dout0_2) AT=720.025n

.meas tran vdout0_3ck1430 FIND v(dout0_3) AT=720.025n

.meas tran vdout0_4ck1430 FIND v(dout0_4) AT=720.025n

.meas tran vdout0_5ck1430 FIND v(dout0_5) AT=720.025n

.meas tran vdout0_6ck1430 FIND v(dout0_6) AT=720.025n

.meas tran vdout0_7ck1430 FIND v(dout0_7) AT=720.025n

.meas tran vdout0_8ck1430 FIND v(dout0_8) AT=720.025n

.meas tran vdout0_9ck1430 FIND v(dout0_9) AT=720.025n

.meas tran vdout0_10ck1430 FIND v(dout0_10) AT=720.025n

.meas tran vdout0_11ck1430 FIND v(dout0_11) AT=720.025n

.meas tran vdout0_12ck1430 FIND v(dout0_12) AT=720.025n

.meas tran vdout0_13ck1430 FIND v(dout0_13) AT=720.025n

.meas tran vdout0_14ck1430 FIND v(dout0_14) AT=720.025n

.meas tran vdout0_15ck1430 FIND v(dout0_15) AT=720.025n

.meas tran vdout0_16ck1430 FIND v(dout0_16) AT=720.025n

.meas tran vdout0_17ck1430 FIND v(dout0_17) AT=720.025n

.meas tran vdout0_18ck1430 FIND v(dout0_18) AT=720.025n

.meas tran vdout0_19ck1430 FIND v(dout0_19) AT=720.025n

.meas tran vdout0_20ck1430 FIND v(dout0_20) AT=720.025n

.meas tran vdout0_21ck1430 FIND v(dout0_21) AT=720.025n

.meas tran vdout0_22ck1430 FIND v(dout0_22) AT=720.025n

.meas tran vdout0_23ck1430 FIND v(dout0_23) AT=720.025n

.meas tran vdout0_24ck1430 FIND v(dout0_24) AT=720.025n

.meas tran vdout0_25ck1430 FIND v(dout0_25) AT=720.025n

.meas tran vdout0_26ck1430 FIND v(dout0_26) AT=720.025n

.meas tran vdout0_27ck1430 FIND v(dout0_27) AT=720.025n

.meas tran vdout0_28ck1430 FIND v(dout0_28) AT=720.025n

.meas tran vdout0_29ck1430 FIND v(dout0_29) AT=720.025n

.meas tran vdout0_30ck1430 FIND v(dout0_30) AT=720.025n

.meas tran vdout0_31ck1430 FIND v(dout0_31) AT=720.025n

.meas tran vdout0_32ck1430 FIND v(dout0_32) AT=720.025n

.meas tran vdout0_33ck1430 FIND v(dout0_33) AT=720.025n

.meas tran vdout0_34ck1430 FIND v(dout0_34) AT=720.025n

.meas tran vdout0_35ck1430 FIND v(dout0_35) AT=720.025n

.meas tran vdout0_36ck1430 FIND v(dout0_36) AT=720.025n

.meas tran vdout0_37ck1430 FIND v(dout0_37) AT=720.025n

.meas tran vdout0_38ck1430 FIND v(dout0_38) AT=720.025n

.meas tran vdout0_39ck1430 FIND v(dout0_39) AT=720.025n

.meas tran vdout0_40ck1430 FIND v(dout0_40) AT=720.025n

.meas tran vdout0_41ck1430 FIND v(dout0_41) AT=720.025n

.meas tran vdout0_42ck1430 FIND v(dout0_42) AT=720.025n

.meas tran vdout0_43ck1430 FIND v(dout0_43) AT=720.025n

.meas tran vdout0_44ck1430 FIND v(dout0_44) AT=720.025n

.meas tran vdout0_45ck1430 FIND v(dout0_45) AT=720.025n

.meas tran vdout0_46ck1430 FIND v(dout0_46) AT=720.025n

.meas tran vdout0_47ck1430 FIND v(dout0_47) AT=720.025n

.meas tran vdout0_48ck1430 FIND v(dout0_48) AT=720.025n

.meas tran vdout0_49ck1430 FIND v(dout0_49) AT=720.025n

.meas tran vdout0_50ck1430 FIND v(dout0_50) AT=720.025n

.meas tran vdout0_51ck1430 FIND v(dout0_51) AT=720.025n

.meas tran vdout0_52ck1430 FIND v(dout0_52) AT=720.025n

.meas tran vdout0_53ck1430 FIND v(dout0_53) AT=720.025n

.meas tran vdout0_54ck1430 FIND v(dout0_54) AT=720.025n

.meas tran vdout0_55ck1430 FIND v(dout0_55) AT=720.025n

.meas tran vdout0_56ck1430 FIND v(dout0_56) AT=720.025n

.meas tran vdout0_57ck1430 FIND v(dout0_57) AT=720.025n

.meas tran vdout0_58ck1430 FIND v(dout0_58) AT=720.025n

.meas tran vdout0_59ck1430 FIND v(dout0_59) AT=720.025n

.meas tran vdout0_60ck1430 FIND v(dout0_60) AT=720.025n

.meas tran vdout0_61ck1430 FIND v(dout0_61) AT=720.025n

.meas tran vdout0_62ck1430 FIND v(dout0_62) AT=720.025n

.meas tran vdout0_63ck1430 FIND v(dout0_63) AT=720.025n

.meas tran vdout0_64ck1430 FIND v(dout0_64) AT=720.025n

.meas tran vdout0_65ck1430 FIND v(dout0_65) AT=720.025n

.meas tran vdout0_66ck1430 FIND v(dout0_66) AT=720.025n

.meas tran vdout0_67ck1430 FIND v(dout0_67) AT=720.025n

.meas tran vdout0_68ck1430 FIND v(dout0_68) AT=720.025n

.meas tran vdout0_69ck1430 FIND v(dout0_69) AT=720.025n

.meas tran vdout0_70ck1430 FIND v(dout0_70) AT=720.025n

.meas tran vdout0_71ck1430 FIND v(dout0_71) AT=720.025n

.meas tran vdout0_72ck1430 FIND v(dout0_72) AT=720.025n

.meas tran vdout0_73ck1430 FIND v(dout0_73) AT=720.025n

.meas tran vdout0_74ck1430 FIND v(dout0_74) AT=720.025n

.meas tran vdout0_75ck1430 FIND v(dout0_75) AT=720.025n

.meas tran vdout0_76ck1430 FIND v(dout0_76) AT=720.025n

.meas tran vdout0_77ck1430 FIND v(dout0_77) AT=720.025n

.meas tran vdout0_78ck1430 FIND v(dout0_78) AT=720.025n

.meas tran vdout0_79ck1430 FIND v(dout0_79) AT=720.025n

.meas tran vdout0_80ck1430 FIND v(dout0_80) AT=720.025n

.meas tran vdout0_81ck1430 FIND v(dout0_81) AT=720.025n

.meas tran vdout0_82ck1430 FIND v(dout0_82) AT=720.025n

.meas tran vdout0_83ck1430 FIND v(dout0_83) AT=720.025n

.meas tran vdout0_84ck1430 FIND v(dout0_84) AT=720.025n

.meas tran vdout0_85ck1430 FIND v(dout0_85) AT=720.025n

.meas tran vdout0_86ck1430 FIND v(dout0_86) AT=720.025n

.meas tran vdout0_87ck1430 FIND v(dout0_87) AT=720.025n

.meas tran vdout0_88ck1430 FIND v(dout0_88) AT=720.025n

.meas tran vdout0_89ck1430 FIND v(dout0_89) AT=720.025n

.meas tran vdout0_90ck1430 FIND v(dout0_90) AT=720.025n

.meas tran vdout0_91ck1430 FIND v(dout0_91) AT=720.025n

.meas tran vdout0_92ck1430 FIND v(dout0_92) AT=720.025n

.meas tran vdout0_93ck1430 FIND v(dout0_93) AT=720.025n

.meas tran vdout0_94ck1430 FIND v(dout0_94) AT=720.025n

.meas tran vdout0_95ck1430 FIND v(dout0_95) AT=720.025n

.meas tran vdout0_96ck1430 FIND v(dout0_96) AT=720.025n

.meas tran vdout0_97ck1430 FIND v(dout0_97) AT=720.025n

.meas tran vdout0_98ck1430 FIND v(dout0_98) AT=720.025n

.meas tran vdout0_99ck1430 FIND v(dout0_99) AT=720.025n

.meas tran vdout0_100ck1430 FIND v(dout0_100) AT=720.025n

.meas tran vdout0_101ck1430 FIND v(dout0_101) AT=720.025n

.meas tran vdout0_102ck1430 FIND v(dout0_102) AT=720.025n

.meas tran vdout0_103ck1430 FIND v(dout0_103) AT=720.025n

.meas tran vdout0_104ck1430 FIND v(dout0_104) AT=720.025n

.meas tran vdout0_105ck1430 FIND v(dout0_105) AT=720.025n

.meas tran vdout0_106ck1430 FIND v(dout0_106) AT=720.025n

.meas tran vdout0_107ck1430 FIND v(dout0_107) AT=720.025n

.meas tran vdout0_108ck1430 FIND v(dout0_108) AT=720.025n

.meas tran vdout0_109ck1430 FIND v(dout0_109) AT=720.025n

.meas tran vdout0_110ck1430 FIND v(dout0_110) AT=720.025n

.meas tran vdout0_111ck1430 FIND v(dout0_111) AT=720.025n

.meas tran vdout0_112ck1430 FIND v(dout0_112) AT=720.025n

.meas tran vdout0_113ck1430 FIND v(dout0_113) AT=720.025n

.meas tran vdout0_114ck1430 FIND v(dout0_114) AT=720.025n

.meas tran vdout0_115ck1430 FIND v(dout0_115) AT=720.025n

.meas tran vdout0_116ck1430 FIND v(dout0_116) AT=720.025n

.meas tran vdout0_117ck1430 FIND v(dout0_117) AT=720.025n

.meas tran vdout0_118ck1430 FIND v(dout0_118) AT=720.025n

.meas tran vdout0_119ck1430 FIND v(dout0_119) AT=720.025n

.meas tran vdout0_120ck1430 FIND v(dout0_120) AT=720.025n

.meas tran vdout0_121ck1430 FIND v(dout0_121) AT=720.025n

.meas tran vdout0_122ck1430 FIND v(dout0_122) AT=720.025n

.meas tran vdout0_123ck1430 FIND v(dout0_123) AT=720.025n

.meas tran vdout0_124ck1430 FIND v(dout0_124) AT=720.025n

.meas tran vdout0_125ck1430 FIND v(dout0_125) AT=720.025n

.meas tran vdout0_126ck1430 FIND v(dout0_126) AT=720.025n

.meas tran vdout0_127ck1430 FIND v(dout0_127) AT=720.025n

.meas tran vdout0_128ck1430 FIND v(dout0_128) AT=720.025n

.meas tran vdout0_129ck1430 FIND v(dout0_129) AT=720.025n

.meas tran vdout0_130ck1430 FIND v(dout0_130) AT=720.025n

.meas tran vdout0_131ck1430 FIND v(dout0_131) AT=720.025n

.meas tran vdout0_132ck1430 FIND v(dout0_132) AT=720.025n

.meas tran vdout0_133ck1430 FIND v(dout0_133) AT=720.025n

.meas tran vdout0_134ck1430 FIND v(dout0_134) AT=720.025n

.meas tran vdout0_135ck1430 FIND v(dout0_135) AT=720.025n

.meas tran vdout0_136ck1430 FIND v(dout0_136) AT=720.025n

.meas tran vdout0_137ck1430 FIND v(dout0_137) AT=720.025n

.meas tran vdout0_138ck1430 FIND v(dout0_138) AT=720.025n

.meas tran vdout0_139ck1430 FIND v(dout0_139) AT=720.025n

.meas tran vdout0_140ck1430 FIND v(dout0_140) AT=720.025n

.meas tran vdout0_141ck1430 FIND v(dout0_141) AT=720.025n

.meas tran vdout0_142ck1430 FIND v(dout0_142) AT=720.025n

.meas tran vdout0_143ck1430 FIND v(dout0_143) AT=720.025n

.meas tran vdout0_144ck1430 FIND v(dout0_144) AT=720.025n

.meas tran vdout0_145ck1430 FIND v(dout0_145) AT=720.025n

.meas tran vdout0_146ck1430 FIND v(dout0_146) AT=720.025n

.meas tran vdout0_147ck1430 FIND v(dout0_147) AT=720.025n

.meas tran vdout0_148ck1430 FIND v(dout0_148) AT=720.025n

.meas tran vdout0_149ck1430 FIND v(dout0_149) AT=720.025n

.meas tran vdout0_150ck1430 FIND v(dout0_150) AT=720.025n

.meas tran vdout0_151ck1430 FIND v(dout0_151) AT=720.025n

.meas tran vdout0_152ck1430 FIND v(dout0_152) AT=720.025n

.meas tran vdout0_153ck1430 FIND v(dout0_153) AT=720.025n

.meas tran vdout0_154ck1430 FIND v(dout0_154) AT=720.025n

.meas tran vdout0_155ck1430 FIND v(dout0_155) AT=720.025n

.meas tran vdout0_156ck1430 FIND v(dout0_156) AT=720.025n

.meas tran vdout0_157ck1430 FIND v(dout0_157) AT=720.025n

.meas tran vdout0_158ck1430 FIND v(dout0_158) AT=720.025n

.meas tran vdout0_159ck1430 FIND v(dout0_159) AT=720.025n

.meas tran vdout0_160ck1430 FIND v(dout0_160) AT=720.025n

.meas tran vdout0_161ck1430 FIND v(dout0_161) AT=720.025n

.meas tran vdout0_162ck1430 FIND v(dout0_162) AT=720.025n

.meas tran vdout0_163ck1430 FIND v(dout0_163) AT=720.025n

.meas tran vdout0_164ck1430 FIND v(dout0_164) AT=720.025n

.meas tran vdout0_165ck1430 FIND v(dout0_165) AT=720.025n

.meas tran vdout0_166ck1430 FIND v(dout0_166) AT=720.025n

.meas tran vdout0_167ck1430 FIND v(dout0_167) AT=720.025n

.meas tran vdout0_168ck1430 FIND v(dout0_168) AT=720.025n

.meas tran vdout0_169ck1430 FIND v(dout0_169) AT=720.025n

.meas tran vdout0_170ck1430 FIND v(dout0_170) AT=720.025n

.meas tran vdout0_171ck1430 FIND v(dout0_171) AT=720.025n

.meas tran vdout0_172ck1430 FIND v(dout0_172) AT=720.025n

.meas tran vdout0_173ck1430 FIND v(dout0_173) AT=720.025n

.meas tran vdout0_174ck1430 FIND v(dout0_174) AT=720.025n

.meas tran vdout0_175ck1430 FIND v(dout0_175) AT=720.025n

.meas tran vdout0_176ck1430 FIND v(dout0_176) AT=720.025n

.meas tran vdout0_177ck1430 FIND v(dout0_177) AT=720.025n

.meas tran vdout0_178ck1430 FIND v(dout0_178) AT=720.025n

.meas tran vdout0_179ck1430 FIND v(dout0_179) AT=720.025n

.meas tran vdout0_180ck1430 FIND v(dout0_180) AT=720.025n

.meas tran vdout0_181ck1430 FIND v(dout0_181) AT=720.025n

.meas tran vdout0_182ck1430 FIND v(dout0_182) AT=720.025n

.meas tran vdout0_183ck1430 FIND v(dout0_183) AT=720.025n

.meas tran vdout0_184ck1430 FIND v(dout0_184) AT=720.025n

.meas tran vdout0_185ck1430 FIND v(dout0_185) AT=720.025n

.meas tran vdout0_186ck1430 FIND v(dout0_186) AT=720.025n

.meas tran vdout0_187ck1430 FIND v(dout0_187) AT=720.025n

.meas tran vdout0_188ck1430 FIND v(dout0_188) AT=720.025n

.meas tran vdout0_189ck1430 FIND v(dout0_189) AT=720.025n

.meas tran vdout0_190ck1430 FIND v(dout0_190) AT=720.025n

.meas tran vdout0_191ck1430 FIND v(dout0_191) AT=720.025n

.meas tran vdout0_192ck1430 FIND v(dout0_192) AT=720.025n

.meas tran vdout0_193ck1430 FIND v(dout0_193) AT=720.025n

.meas tran vdout0_194ck1430 FIND v(dout0_194) AT=720.025n

.meas tran vdout0_195ck1430 FIND v(dout0_195) AT=720.025n

.meas tran vdout0_196ck1430 FIND v(dout0_196) AT=720.025n

.meas tran vdout0_197ck1430 FIND v(dout0_197) AT=720.025n

.meas tran vdout0_198ck1430 FIND v(dout0_198) AT=720.025n

.meas tran vdout0_199ck1430 FIND v(dout0_199) AT=720.025n

.meas tran vdout0_200ck1430 FIND v(dout0_200) AT=720.025n

.meas tran vdout0_201ck1430 FIND v(dout0_201) AT=720.025n

.meas tran vdout0_202ck1430 FIND v(dout0_202) AT=720.025n

.meas tran vdout0_203ck1430 FIND v(dout0_203) AT=720.025n

.meas tran vdout0_204ck1430 FIND v(dout0_204) AT=720.025n

.meas tran vdout0_205ck1430 FIND v(dout0_205) AT=720.025n

.meas tran vdout0_206ck1430 FIND v(dout0_206) AT=720.025n

.meas tran vdout0_207ck1430 FIND v(dout0_207) AT=720.025n

.meas tran vdout0_208ck1430 FIND v(dout0_208) AT=720.025n

.meas tran vdout0_209ck1430 FIND v(dout0_209) AT=720.025n

.meas tran vdout0_210ck1430 FIND v(dout0_210) AT=720.025n

.meas tran vdout0_211ck1430 FIND v(dout0_211) AT=720.025n

.meas tran vdout0_212ck1430 FIND v(dout0_212) AT=720.025n

.meas tran vdout0_213ck1430 FIND v(dout0_213) AT=720.025n

.meas tran vdout0_214ck1430 FIND v(dout0_214) AT=720.025n

.meas tran vdout0_215ck1430 FIND v(dout0_215) AT=720.025n

.meas tran vdout0_216ck1430 FIND v(dout0_216) AT=720.025n

.meas tran vdout0_217ck1430 FIND v(dout0_217) AT=720.025n

.meas tran vdout0_218ck1430 FIND v(dout0_218) AT=720.025n

.meas tran vdout0_219ck1430 FIND v(dout0_219) AT=720.025n

.meas tran vdout0_220ck1430 FIND v(dout0_220) AT=720.025n

.meas tran vdout0_221ck1430 FIND v(dout0_221) AT=720.025n

.meas tran vdout0_222ck1430 FIND v(dout0_222) AT=720.025n

.meas tran vdout0_223ck1430 FIND v(dout0_223) AT=720.025n

.meas tran vdout0_224ck1430 FIND v(dout0_224) AT=720.025n

.meas tran vdout0_225ck1430 FIND v(dout0_225) AT=720.025n

.meas tran vdout0_226ck1430 FIND v(dout0_226) AT=720.025n

.meas tran vdout0_227ck1430 FIND v(dout0_227) AT=720.025n

.meas tran vdout0_228ck1430 FIND v(dout0_228) AT=720.025n

.meas tran vdout0_229ck1430 FIND v(dout0_229) AT=720.025n

.meas tran vdout0_230ck1430 FIND v(dout0_230) AT=720.025n

.meas tran vdout0_231ck1430 FIND v(dout0_231) AT=720.025n

.meas tran vdout0_232ck1430 FIND v(dout0_232) AT=720.025n

.meas tran vdout0_233ck1430 FIND v(dout0_233) AT=720.025n

.meas tran vdout0_234ck1430 FIND v(dout0_234) AT=720.025n

.meas tran vdout0_235ck1430 FIND v(dout0_235) AT=720.025n

.meas tran vdout0_236ck1430 FIND v(dout0_236) AT=720.025n

.meas tran vdout0_237ck1430 FIND v(dout0_237) AT=720.025n

.meas tran vdout0_238ck1430 FIND v(dout0_238) AT=720.025n

.meas tran vdout0_239ck1430 FIND v(dout0_239) AT=720.025n

.meas tran vdout0_240ck1430 FIND v(dout0_240) AT=720.025n

.meas tran vdout0_241ck1430 FIND v(dout0_241) AT=720.025n

.meas tran vdout0_242ck1430 FIND v(dout0_242) AT=720.025n

.meas tran vdout0_243ck1430 FIND v(dout0_243) AT=720.025n

.meas tran vdout0_244ck1430 FIND v(dout0_244) AT=720.025n

.meas tran vdout0_245ck1430 FIND v(dout0_245) AT=720.025n

.meas tran vdout0_246ck1430 FIND v(dout0_246) AT=720.025n

.meas tran vdout0_247ck1430 FIND v(dout0_247) AT=720.025n

.meas tran vdout0_248ck1430 FIND v(dout0_248) AT=720.025n

.meas tran vdout0_249ck1430 FIND v(dout0_249) AT=720.025n

.meas tran vdout0_250ck1430 FIND v(dout0_250) AT=720.025n

.meas tran vdout0_251ck1430 FIND v(dout0_251) AT=720.025n

.meas tran vdout0_252ck1430 FIND v(dout0_252) AT=720.025n

.meas tran vdout0_253ck1430 FIND v(dout0_253) AT=720.025n

.meas tran vdout0_254ck1430 FIND v(dout0_254) AT=720.025n

.meas tran vdout0_255ck1430 FIND v(dout0_255) AT=720.025n

.meas tran vdout0_0ck1450 FIND v(dout0_0) AT=730.025n

.meas tran vdout0_1ck1450 FIND v(dout0_1) AT=730.025n

.meas tran vdout0_2ck1450 FIND v(dout0_2) AT=730.025n

.meas tran vdout0_3ck1450 FIND v(dout0_3) AT=730.025n

.meas tran vdout0_4ck1450 FIND v(dout0_4) AT=730.025n

.meas tran vdout0_5ck1450 FIND v(dout0_5) AT=730.025n

.meas tran vdout0_6ck1450 FIND v(dout0_6) AT=730.025n

.meas tran vdout0_7ck1450 FIND v(dout0_7) AT=730.025n

.meas tran vdout0_8ck1450 FIND v(dout0_8) AT=730.025n

.meas tran vdout0_9ck1450 FIND v(dout0_9) AT=730.025n

.meas tran vdout0_10ck1450 FIND v(dout0_10) AT=730.025n

.meas tran vdout0_11ck1450 FIND v(dout0_11) AT=730.025n

.meas tran vdout0_12ck1450 FIND v(dout0_12) AT=730.025n

.meas tran vdout0_13ck1450 FIND v(dout0_13) AT=730.025n

.meas tran vdout0_14ck1450 FIND v(dout0_14) AT=730.025n

.meas tran vdout0_15ck1450 FIND v(dout0_15) AT=730.025n

.meas tran vdout0_16ck1450 FIND v(dout0_16) AT=730.025n

.meas tran vdout0_17ck1450 FIND v(dout0_17) AT=730.025n

.meas tran vdout0_18ck1450 FIND v(dout0_18) AT=730.025n

.meas tran vdout0_19ck1450 FIND v(dout0_19) AT=730.025n

.meas tran vdout0_20ck1450 FIND v(dout0_20) AT=730.025n

.meas tran vdout0_21ck1450 FIND v(dout0_21) AT=730.025n

.meas tran vdout0_22ck1450 FIND v(dout0_22) AT=730.025n

.meas tran vdout0_23ck1450 FIND v(dout0_23) AT=730.025n

.meas tran vdout0_24ck1450 FIND v(dout0_24) AT=730.025n

.meas tran vdout0_25ck1450 FIND v(dout0_25) AT=730.025n

.meas tran vdout0_26ck1450 FIND v(dout0_26) AT=730.025n

.meas tran vdout0_27ck1450 FIND v(dout0_27) AT=730.025n

.meas tran vdout0_28ck1450 FIND v(dout0_28) AT=730.025n

.meas tran vdout0_29ck1450 FIND v(dout0_29) AT=730.025n

.meas tran vdout0_30ck1450 FIND v(dout0_30) AT=730.025n

.meas tran vdout0_31ck1450 FIND v(dout0_31) AT=730.025n

.meas tran vdout0_32ck1450 FIND v(dout0_32) AT=730.025n

.meas tran vdout0_33ck1450 FIND v(dout0_33) AT=730.025n

.meas tran vdout0_34ck1450 FIND v(dout0_34) AT=730.025n

.meas tran vdout0_35ck1450 FIND v(dout0_35) AT=730.025n

.meas tran vdout0_36ck1450 FIND v(dout0_36) AT=730.025n

.meas tran vdout0_37ck1450 FIND v(dout0_37) AT=730.025n

.meas tran vdout0_38ck1450 FIND v(dout0_38) AT=730.025n

.meas tran vdout0_39ck1450 FIND v(dout0_39) AT=730.025n

.meas tran vdout0_40ck1450 FIND v(dout0_40) AT=730.025n

.meas tran vdout0_41ck1450 FIND v(dout0_41) AT=730.025n

.meas tran vdout0_42ck1450 FIND v(dout0_42) AT=730.025n

.meas tran vdout0_43ck1450 FIND v(dout0_43) AT=730.025n

.meas tran vdout0_44ck1450 FIND v(dout0_44) AT=730.025n

.meas tran vdout0_45ck1450 FIND v(dout0_45) AT=730.025n

.meas tran vdout0_46ck1450 FIND v(dout0_46) AT=730.025n

.meas tran vdout0_47ck1450 FIND v(dout0_47) AT=730.025n

.meas tran vdout0_48ck1450 FIND v(dout0_48) AT=730.025n

.meas tran vdout0_49ck1450 FIND v(dout0_49) AT=730.025n

.meas tran vdout0_50ck1450 FIND v(dout0_50) AT=730.025n

.meas tran vdout0_51ck1450 FIND v(dout0_51) AT=730.025n

.meas tran vdout0_52ck1450 FIND v(dout0_52) AT=730.025n

.meas tran vdout0_53ck1450 FIND v(dout0_53) AT=730.025n

.meas tran vdout0_54ck1450 FIND v(dout0_54) AT=730.025n

.meas tran vdout0_55ck1450 FIND v(dout0_55) AT=730.025n

.meas tran vdout0_56ck1450 FIND v(dout0_56) AT=730.025n

.meas tran vdout0_57ck1450 FIND v(dout0_57) AT=730.025n

.meas tran vdout0_58ck1450 FIND v(dout0_58) AT=730.025n

.meas tran vdout0_59ck1450 FIND v(dout0_59) AT=730.025n

.meas tran vdout0_60ck1450 FIND v(dout0_60) AT=730.025n

.meas tran vdout0_61ck1450 FIND v(dout0_61) AT=730.025n

.meas tran vdout0_62ck1450 FIND v(dout0_62) AT=730.025n

.meas tran vdout0_63ck1450 FIND v(dout0_63) AT=730.025n

.meas tran vdout0_64ck1450 FIND v(dout0_64) AT=730.025n

.meas tran vdout0_65ck1450 FIND v(dout0_65) AT=730.025n

.meas tran vdout0_66ck1450 FIND v(dout0_66) AT=730.025n

.meas tran vdout0_67ck1450 FIND v(dout0_67) AT=730.025n

.meas tran vdout0_68ck1450 FIND v(dout0_68) AT=730.025n

.meas tran vdout0_69ck1450 FIND v(dout0_69) AT=730.025n

.meas tran vdout0_70ck1450 FIND v(dout0_70) AT=730.025n

.meas tran vdout0_71ck1450 FIND v(dout0_71) AT=730.025n

.meas tran vdout0_72ck1450 FIND v(dout0_72) AT=730.025n

.meas tran vdout0_73ck1450 FIND v(dout0_73) AT=730.025n

.meas tran vdout0_74ck1450 FIND v(dout0_74) AT=730.025n

.meas tran vdout0_75ck1450 FIND v(dout0_75) AT=730.025n

.meas tran vdout0_76ck1450 FIND v(dout0_76) AT=730.025n

.meas tran vdout0_77ck1450 FIND v(dout0_77) AT=730.025n

.meas tran vdout0_78ck1450 FIND v(dout0_78) AT=730.025n

.meas tran vdout0_79ck1450 FIND v(dout0_79) AT=730.025n

.meas tran vdout0_80ck1450 FIND v(dout0_80) AT=730.025n

.meas tran vdout0_81ck1450 FIND v(dout0_81) AT=730.025n

.meas tran vdout0_82ck1450 FIND v(dout0_82) AT=730.025n

.meas tran vdout0_83ck1450 FIND v(dout0_83) AT=730.025n

.meas tran vdout0_84ck1450 FIND v(dout0_84) AT=730.025n

.meas tran vdout0_85ck1450 FIND v(dout0_85) AT=730.025n

.meas tran vdout0_86ck1450 FIND v(dout0_86) AT=730.025n

.meas tran vdout0_87ck1450 FIND v(dout0_87) AT=730.025n

.meas tran vdout0_88ck1450 FIND v(dout0_88) AT=730.025n

.meas tran vdout0_89ck1450 FIND v(dout0_89) AT=730.025n

.meas tran vdout0_90ck1450 FIND v(dout0_90) AT=730.025n

.meas tran vdout0_91ck1450 FIND v(dout0_91) AT=730.025n

.meas tran vdout0_92ck1450 FIND v(dout0_92) AT=730.025n

.meas tran vdout0_93ck1450 FIND v(dout0_93) AT=730.025n

.meas tran vdout0_94ck1450 FIND v(dout0_94) AT=730.025n

.meas tran vdout0_95ck1450 FIND v(dout0_95) AT=730.025n

.meas tran vdout0_96ck1450 FIND v(dout0_96) AT=730.025n

.meas tran vdout0_97ck1450 FIND v(dout0_97) AT=730.025n

.meas tran vdout0_98ck1450 FIND v(dout0_98) AT=730.025n

.meas tran vdout0_99ck1450 FIND v(dout0_99) AT=730.025n

.meas tran vdout0_100ck1450 FIND v(dout0_100) AT=730.025n

.meas tran vdout0_101ck1450 FIND v(dout0_101) AT=730.025n

.meas tran vdout0_102ck1450 FIND v(dout0_102) AT=730.025n

.meas tran vdout0_103ck1450 FIND v(dout0_103) AT=730.025n

.meas tran vdout0_104ck1450 FIND v(dout0_104) AT=730.025n

.meas tran vdout0_105ck1450 FIND v(dout0_105) AT=730.025n

.meas tran vdout0_106ck1450 FIND v(dout0_106) AT=730.025n

.meas tran vdout0_107ck1450 FIND v(dout0_107) AT=730.025n

.meas tran vdout0_108ck1450 FIND v(dout0_108) AT=730.025n

.meas tran vdout0_109ck1450 FIND v(dout0_109) AT=730.025n

.meas tran vdout0_110ck1450 FIND v(dout0_110) AT=730.025n

.meas tran vdout0_111ck1450 FIND v(dout0_111) AT=730.025n

.meas tran vdout0_112ck1450 FIND v(dout0_112) AT=730.025n

.meas tran vdout0_113ck1450 FIND v(dout0_113) AT=730.025n

.meas tran vdout0_114ck1450 FIND v(dout0_114) AT=730.025n

.meas tran vdout0_115ck1450 FIND v(dout0_115) AT=730.025n

.meas tran vdout0_116ck1450 FIND v(dout0_116) AT=730.025n

.meas tran vdout0_117ck1450 FIND v(dout0_117) AT=730.025n

.meas tran vdout0_118ck1450 FIND v(dout0_118) AT=730.025n

.meas tran vdout0_119ck1450 FIND v(dout0_119) AT=730.025n

.meas tran vdout0_120ck1450 FIND v(dout0_120) AT=730.025n

.meas tran vdout0_121ck1450 FIND v(dout0_121) AT=730.025n

.meas tran vdout0_122ck1450 FIND v(dout0_122) AT=730.025n

.meas tran vdout0_123ck1450 FIND v(dout0_123) AT=730.025n

.meas tran vdout0_124ck1450 FIND v(dout0_124) AT=730.025n

.meas tran vdout0_125ck1450 FIND v(dout0_125) AT=730.025n

.meas tran vdout0_126ck1450 FIND v(dout0_126) AT=730.025n

.meas tran vdout0_127ck1450 FIND v(dout0_127) AT=730.025n

.meas tran vdout0_128ck1450 FIND v(dout0_128) AT=730.025n

.meas tran vdout0_129ck1450 FIND v(dout0_129) AT=730.025n

.meas tran vdout0_130ck1450 FIND v(dout0_130) AT=730.025n

.meas tran vdout0_131ck1450 FIND v(dout0_131) AT=730.025n

.meas tran vdout0_132ck1450 FIND v(dout0_132) AT=730.025n

.meas tran vdout0_133ck1450 FIND v(dout0_133) AT=730.025n

.meas tran vdout0_134ck1450 FIND v(dout0_134) AT=730.025n

.meas tran vdout0_135ck1450 FIND v(dout0_135) AT=730.025n

.meas tran vdout0_136ck1450 FIND v(dout0_136) AT=730.025n

.meas tran vdout0_137ck1450 FIND v(dout0_137) AT=730.025n

.meas tran vdout0_138ck1450 FIND v(dout0_138) AT=730.025n

.meas tran vdout0_139ck1450 FIND v(dout0_139) AT=730.025n

.meas tran vdout0_140ck1450 FIND v(dout0_140) AT=730.025n

.meas tran vdout0_141ck1450 FIND v(dout0_141) AT=730.025n

.meas tran vdout0_142ck1450 FIND v(dout0_142) AT=730.025n

.meas tran vdout0_143ck1450 FIND v(dout0_143) AT=730.025n

.meas tran vdout0_144ck1450 FIND v(dout0_144) AT=730.025n

.meas tran vdout0_145ck1450 FIND v(dout0_145) AT=730.025n

.meas tran vdout0_146ck1450 FIND v(dout0_146) AT=730.025n

.meas tran vdout0_147ck1450 FIND v(dout0_147) AT=730.025n

.meas tran vdout0_148ck1450 FIND v(dout0_148) AT=730.025n

.meas tran vdout0_149ck1450 FIND v(dout0_149) AT=730.025n

.meas tran vdout0_150ck1450 FIND v(dout0_150) AT=730.025n

.meas tran vdout0_151ck1450 FIND v(dout0_151) AT=730.025n

.meas tran vdout0_152ck1450 FIND v(dout0_152) AT=730.025n

.meas tran vdout0_153ck1450 FIND v(dout0_153) AT=730.025n

.meas tran vdout0_154ck1450 FIND v(dout0_154) AT=730.025n

.meas tran vdout0_155ck1450 FIND v(dout0_155) AT=730.025n

.meas tran vdout0_156ck1450 FIND v(dout0_156) AT=730.025n

.meas tran vdout0_157ck1450 FIND v(dout0_157) AT=730.025n

.meas tran vdout0_158ck1450 FIND v(dout0_158) AT=730.025n

.meas tran vdout0_159ck1450 FIND v(dout0_159) AT=730.025n

.meas tran vdout0_160ck1450 FIND v(dout0_160) AT=730.025n

.meas tran vdout0_161ck1450 FIND v(dout0_161) AT=730.025n

.meas tran vdout0_162ck1450 FIND v(dout0_162) AT=730.025n

.meas tran vdout0_163ck1450 FIND v(dout0_163) AT=730.025n

.meas tran vdout0_164ck1450 FIND v(dout0_164) AT=730.025n

.meas tran vdout0_165ck1450 FIND v(dout0_165) AT=730.025n

.meas tran vdout0_166ck1450 FIND v(dout0_166) AT=730.025n

.meas tran vdout0_167ck1450 FIND v(dout0_167) AT=730.025n

.meas tran vdout0_168ck1450 FIND v(dout0_168) AT=730.025n

.meas tran vdout0_169ck1450 FIND v(dout0_169) AT=730.025n

.meas tran vdout0_170ck1450 FIND v(dout0_170) AT=730.025n

.meas tran vdout0_171ck1450 FIND v(dout0_171) AT=730.025n

.meas tran vdout0_172ck1450 FIND v(dout0_172) AT=730.025n

.meas tran vdout0_173ck1450 FIND v(dout0_173) AT=730.025n

.meas tran vdout0_174ck1450 FIND v(dout0_174) AT=730.025n

.meas tran vdout0_175ck1450 FIND v(dout0_175) AT=730.025n

.meas tran vdout0_176ck1450 FIND v(dout0_176) AT=730.025n

.meas tran vdout0_177ck1450 FIND v(dout0_177) AT=730.025n

.meas tran vdout0_178ck1450 FIND v(dout0_178) AT=730.025n

.meas tran vdout0_179ck1450 FIND v(dout0_179) AT=730.025n

.meas tran vdout0_180ck1450 FIND v(dout0_180) AT=730.025n

.meas tran vdout0_181ck1450 FIND v(dout0_181) AT=730.025n

.meas tran vdout0_182ck1450 FIND v(dout0_182) AT=730.025n

.meas tran vdout0_183ck1450 FIND v(dout0_183) AT=730.025n

.meas tran vdout0_184ck1450 FIND v(dout0_184) AT=730.025n

.meas tran vdout0_185ck1450 FIND v(dout0_185) AT=730.025n

.meas tran vdout0_186ck1450 FIND v(dout0_186) AT=730.025n

.meas tran vdout0_187ck1450 FIND v(dout0_187) AT=730.025n

.meas tran vdout0_188ck1450 FIND v(dout0_188) AT=730.025n

.meas tran vdout0_189ck1450 FIND v(dout0_189) AT=730.025n

.meas tran vdout0_190ck1450 FIND v(dout0_190) AT=730.025n

.meas tran vdout0_191ck1450 FIND v(dout0_191) AT=730.025n

.meas tran vdout0_192ck1450 FIND v(dout0_192) AT=730.025n

.meas tran vdout0_193ck1450 FIND v(dout0_193) AT=730.025n

.meas tran vdout0_194ck1450 FIND v(dout0_194) AT=730.025n

.meas tran vdout0_195ck1450 FIND v(dout0_195) AT=730.025n

.meas tran vdout0_196ck1450 FIND v(dout0_196) AT=730.025n

.meas tran vdout0_197ck1450 FIND v(dout0_197) AT=730.025n

.meas tran vdout0_198ck1450 FIND v(dout0_198) AT=730.025n

.meas tran vdout0_199ck1450 FIND v(dout0_199) AT=730.025n

.meas tran vdout0_200ck1450 FIND v(dout0_200) AT=730.025n

.meas tran vdout0_201ck1450 FIND v(dout0_201) AT=730.025n

.meas tran vdout0_202ck1450 FIND v(dout0_202) AT=730.025n

.meas tran vdout0_203ck1450 FIND v(dout0_203) AT=730.025n

.meas tran vdout0_204ck1450 FIND v(dout0_204) AT=730.025n

.meas tran vdout0_205ck1450 FIND v(dout0_205) AT=730.025n

.meas tran vdout0_206ck1450 FIND v(dout0_206) AT=730.025n

.meas tran vdout0_207ck1450 FIND v(dout0_207) AT=730.025n

.meas tran vdout0_208ck1450 FIND v(dout0_208) AT=730.025n

.meas tran vdout0_209ck1450 FIND v(dout0_209) AT=730.025n

.meas tran vdout0_210ck1450 FIND v(dout0_210) AT=730.025n

.meas tran vdout0_211ck1450 FIND v(dout0_211) AT=730.025n

.meas tran vdout0_212ck1450 FIND v(dout0_212) AT=730.025n

.meas tran vdout0_213ck1450 FIND v(dout0_213) AT=730.025n

.meas tran vdout0_214ck1450 FIND v(dout0_214) AT=730.025n

.meas tran vdout0_215ck1450 FIND v(dout0_215) AT=730.025n

.meas tran vdout0_216ck1450 FIND v(dout0_216) AT=730.025n

.meas tran vdout0_217ck1450 FIND v(dout0_217) AT=730.025n

.meas tran vdout0_218ck1450 FIND v(dout0_218) AT=730.025n

.meas tran vdout0_219ck1450 FIND v(dout0_219) AT=730.025n

.meas tran vdout0_220ck1450 FIND v(dout0_220) AT=730.025n

.meas tran vdout0_221ck1450 FIND v(dout0_221) AT=730.025n

.meas tran vdout0_222ck1450 FIND v(dout0_222) AT=730.025n

.meas tran vdout0_223ck1450 FIND v(dout0_223) AT=730.025n

.meas tran vdout0_224ck1450 FIND v(dout0_224) AT=730.025n

.meas tran vdout0_225ck1450 FIND v(dout0_225) AT=730.025n

.meas tran vdout0_226ck1450 FIND v(dout0_226) AT=730.025n

.meas tran vdout0_227ck1450 FIND v(dout0_227) AT=730.025n

.meas tran vdout0_228ck1450 FIND v(dout0_228) AT=730.025n

.meas tran vdout0_229ck1450 FIND v(dout0_229) AT=730.025n

.meas tran vdout0_230ck1450 FIND v(dout0_230) AT=730.025n

.meas tran vdout0_231ck1450 FIND v(dout0_231) AT=730.025n

.meas tran vdout0_232ck1450 FIND v(dout0_232) AT=730.025n

.meas tran vdout0_233ck1450 FIND v(dout0_233) AT=730.025n

.meas tran vdout0_234ck1450 FIND v(dout0_234) AT=730.025n

.meas tran vdout0_235ck1450 FIND v(dout0_235) AT=730.025n

.meas tran vdout0_236ck1450 FIND v(dout0_236) AT=730.025n

.meas tran vdout0_237ck1450 FIND v(dout0_237) AT=730.025n

.meas tran vdout0_238ck1450 FIND v(dout0_238) AT=730.025n

.meas tran vdout0_239ck1450 FIND v(dout0_239) AT=730.025n

.meas tran vdout0_240ck1450 FIND v(dout0_240) AT=730.025n

.meas tran vdout0_241ck1450 FIND v(dout0_241) AT=730.025n

.meas tran vdout0_242ck1450 FIND v(dout0_242) AT=730.025n

.meas tran vdout0_243ck1450 FIND v(dout0_243) AT=730.025n

.meas tran vdout0_244ck1450 FIND v(dout0_244) AT=730.025n

.meas tran vdout0_245ck1450 FIND v(dout0_245) AT=730.025n

.meas tran vdout0_246ck1450 FIND v(dout0_246) AT=730.025n

.meas tran vdout0_247ck1450 FIND v(dout0_247) AT=730.025n

.meas tran vdout0_248ck1450 FIND v(dout0_248) AT=730.025n

.meas tran vdout0_249ck1450 FIND v(dout0_249) AT=730.025n

.meas tran vdout0_250ck1450 FIND v(dout0_250) AT=730.025n

.meas tran vdout0_251ck1450 FIND v(dout0_251) AT=730.025n

.meas tran vdout0_252ck1450 FIND v(dout0_252) AT=730.025n

.meas tran vdout0_253ck1450 FIND v(dout0_253) AT=730.025n

.meas tran vdout0_254ck1450 FIND v(dout0_254) AT=730.025n

.meas tran vdout0_255ck1450 FIND v(dout0_255) AT=730.025n

.meas tran vdout0_0ck1460 FIND v(dout0_0) AT=735.025n

.meas tran vdout0_1ck1460 FIND v(dout0_1) AT=735.025n

.meas tran vdout0_2ck1460 FIND v(dout0_2) AT=735.025n

.meas tran vdout0_3ck1460 FIND v(dout0_3) AT=735.025n

.meas tran vdout0_4ck1460 FIND v(dout0_4) AT=735.025n

.meas tran vdout0_5ck1460 FIND v(dout0_5) AT=735.025n

.meas tran vdout0_6ck1460 FIND v(dout0_6) AT=735.025n

.meas tran vdout0_7ck1460 FIND v(dout0_7) AT=735.025n

.meas tran vdout0_8ck1460 FIND v(dout0_8) AT=735.025n

.meas tran vdout0_9ck1460 FIND v(dout0_9) AT=735.025n

.meas tran vdout0_10ck1460 FIND v(dout0_10) AT=735.025n

.meas tran vdout0_11ck1460 FIND v(dout0_11) AT=735.025n

.meas tran vdout0_12ck1460 FIND v(dout0_12) AT=735.025n

.meas tran vdout0_13ck1460 FIND v(dout0_13) AT=735.025n

.meas tran vdout0_14ck1460 FIND v(dout0_14) AT=735.025n

.meas tran vdout0_15ck1460 FIND v(dout0_15) AT=735.025n

.meas tran vdout0_16ck1460 FIND v(dout0_16) AT=735.025n

.meas tran vdout0_17ck1460 FIND v(dout0_17) AT=735.025n

.meas tran vdout0_18ck1460 FIND v(dout0_18) AT=735.025n

.meas tran vdout0_19ck1460 FIND v(dout0_19) AT=735.025n

.meas tran vdout0_20ck1460 FIND v(dout0_20) AT=735.025n

.meas tran vdout0_21ck1460 FIND v(dout0_21) AT=735.025n

.meas tran vdout0_22ck1460 FIND v(dout0_22) AT=735.025n

.meas tran vdout0_23ck1460 FIND v(dout0_23) AT=735.025n

.meas tran vdout0_24ck1460 FIND v(dout0_24) AT=735.025n

.meas tran vdout0_25ck1460 FIND v(dout0_25) AT=735.025n

.meas tran vdout0_26ck1460 FIND v(dout0_26) AT=735.025n

.meas tran vdout0_27ck1460 FIND v(dout0_27) AT=735.025n

.meas tran vdout0_28ck1460 FIND v(dout0_28) AT=735.025n

.meas tran vdout0_29ck1460 FIND v(dout0_29) AT=735.025n

.meas tran vdout0_30ck1460 FIND v(dout0_30) AT=735.025n

.meas tran vdout0_31ck1460 FIND v(dout0_31) AT=735.025n

.meas tran vdout0_32ck1460 FIND v(dout0_32) AT=735.025n

.meas tran vdout0_33ck1460 FIND v(dout0_33) AT=735.025n

.meas tran vdout0_34ck1460 FIND v(dout0_34) AT=735.025n

.meas tran vdout0_35ck1460 FIND v(dout0_35) AT=735.025n

.meas tran vdout0_36ck1460 FIND v(dout0_36) AT=735.025n

.meas tran vdout0_37ck1460 FIND v(dout0_37) AT=735.025n

.meas tran vdout0_38ck1460 FIND v(dout0_38) AT=735.025n

.meas tran vdout0_39ck1460 FIND v(dout0_39) AT=735.025n

.meas tran vdout0_40ck1460 FIND v(dout0_40) AT=735.025n

.meas tran vdout0_41ck1460 FIND v(dout0_41) AT=735.025n

.meas tran vdout0_42ck1460 FIND v(dout0_42) AT=735.025n

.meas tran vdout0_43ck1460 FIND v(dout0_43) AT=735.025n

.meas tran vdout0_44ck1460 FIND v(dout0_44) AT=735.025n

.meas tran vdout0_45ck1460 FIND v(dout0_45) AT=735.025n

.meas tran vdout0_46ck1460 FIND v(dout0_46) AT=735.025n

.meas tran vdout0_47ck1460 FIND v(dout0_47) AT=735.025n

.meas tran vdout0_48ck1460 FIND v(dout0_48) AT=735.025n

.meas tran vdout0_49ck1460 FIND v(dout0_49) AT=735.025n

.meas tran vdout0_50ck1460 FIND v(dout0_50) AT=735.025n

.meas tran vdout0_51ck1460 FIND v(dout0_51) AT=735.025n

.meas tran vdout0_52ck1460 FIND v(dout0_52) AT=735.025n

.meas tran vdout0_53ck1460 FIND v(dout0_53) AT=735.025n

.meas tran vdout0_54ck1460 FIND v(dout0_54) AT=735.025n

.meas tran vdout0_55ck1460 FIND v(dout0_55) AT=735.025n

.meas tran vdout0_56ck1460 FIND v(dout0_56) AT=735.025n

.meas tran vdout0_57ck1460 FIND v(dout0_57) AT=735.025n

.meas tran vdout0_58ck1460 FIND v(dout0_58) AT=735.025n

.meas tran vdout0_59ck1460 FIND v(dout0_59) AT=735.025n

.meas tran vdout0_60ck1460 FIND v(dout0_60) AT=735.025n

.meas tran vdout0_61ck1460 FIND v(dout0_61) AT=735.025n

.meas tran vdout0_62ck1460 FIND v(dout0_62) AT=735.025n

.meas tran vdout0_63ck1460 FIND v(dout0_63) AT=735.025n

.meas tran vdout0_64ck1460 FIND v(dout0_64) AT=735.025n

.meas tran vdout0_65ck1460 FIND v(dout0_65) AT=735.025n

.meas tran vdout0_66ck1460 FIND v(dout0_66) AT=735.025n

.meas tran vdout0_67ck1460 FIND v(dout0_67) AT=735.025n

.meas tran vdout0_68ck1460 FIND v(dout0_68) AT=735.025n

.meas tran vdout0_69ck1460 FIND v(dout0_69) AT=735.025n

.meas tran vdout0_70ck1460 FIND v(dout0_70) AT=735.025n

.meas tran vdout0_71ck1460 FIND v(dout0_71) AT=735.025n

.meas tran vdout0_72ck1460 FIND v(dout0_72) AT=735.025n

.meas tran vdout0_73ck1460 FIND v(dout0_73) AT=735.025n

.meas tran vdout0_74ck1460 FIND v(dout0_74) AT=735.025n

.meas tran vdout0_75ck1460 FIND v(dout0_75) AT=735.025n

.meas tran vdout0_76ck1460 FIND v(dout0_76) AT=735.025n

.meas tran vdout0_77ck1460 FIND v(dout0_77) AT=735.025n

.meas tran vdout0_78ck1460 FIND v(dout0_78) AT=735.025n

.meas tran vdout0_79ck1460 FIND v(dout0_79) AT=735.025n

.meas tran vdout0_80ck1460 FIND v(dout0_80) AT=735.025n

.meas tran vdout0_81ck1460 FIND v(dout0_81) AT=735.025n

.meas tran vdout0_82ck1460 FIND v(dout0_82) AT=735.025n

.meas tran vdout0_83ck1460 FIND v(dout0_83) AT=735.025n

.meas tran vdout0_84ck1460 FIND v(dout0_84) AT=735.025n

.meas tran vdout0_85ck1460 FIND v(dout0_85) AT=735.025n

.meas tran vdout0_86ck1460 FIND v(dout0_86) AT=735.025n

.meas tran vdout0_87ck1460 FIND v(dout0_87) AT=735.025n

.meas tran vdout0_88ck1460 FIND v(dout0_88) AT=735.025n

.meas tran vdout0_89ck1460 FIND v(dout0_89) AT=735.025n

.meas tran vdout0_90ck1460 FIND v(dout0_90) AT=735.025n

.meas tran vdout0_91ck1460 FIND v(dout0_91) AT=735.025n

.meas tran vdout0_92ck1460 FIND v(dout0_92) AT=735.025n

.meas tran vdout0_93ck1460 FIND v(dout0_93) AT=735.025n

.meas tran vdout0_94ck1460 FIND v(dout0_94) AT=735.025n

.meas tran vdout0_95ck1460 FIND v(dout0_95) AT=735.025n

.meas tran vdout0_96ck1460 FIND v(dout0_96) AT=735.025n

.meas tran vdout0_97ck1460 FIND v(dout0_97) AT=735.025n

.meas tran vdout0_98ck1460 FIND v(dout0_98) AT=735.025n

.meas tran vdout0_99ck1460 FIND v(dout0_99) AT=735.025n

.meas tran vdout0_100ck1460 FIND v(dout0_100) AT=735.025n

.meas tran vdout0_101ck1460 FIND v(dout0_101) AT=735.025n

.meas tran vdout0_102ck1460 FIND v(dout0_102) AT=735.025n

.meas tran vdout0_103ck1460 FIND v(dout0_103) AT=735.025n

.meas tran vdout0_104ck1460 FIND v(dout0_104) AT=735.025n

.meas tran vdout0_105ck1460 FIND v(dout0_105) AT=735.025n

.meas tran vdout0_106ck1460 FIND v(dout0_106) AT=735.025n

.meas tran vdout0_107ck1460 FIND v(dout0_107) AT=735.025n

.meas tran vdout0_108ck1460 FIND v(dout0_108) AT=735.025n

.meas tran vdout0_109ck1460 FIND v(dout0_109) AT=735.025n

.meas tran vdout0_110ck1460 FIND v(dout0_110) AT=735.025n

.meas tran vdout0_111ck1460 FIND v(dout0_111) AT=735.025n

.meas tran vdout0_112ck1460 FIND v(dout0_112) AT=735.025n

.meas tran vdout0_113ck1460 FIND v(dout0_113) AT=735.025n

.meas tran vdout0_114ck1460 FIND v(dout0_114) AT=735.025n

.meas tran vdout0_115ck1460 FIND v(dout0_115) AT=735.025n

.meas tran vdout0_116ck1460 FIND v(dout0_116) AT=735.025n

.meas tran vdout0_117ck1460 FIND v(dout0_117) AT=735.025n

.meas tran vdout0_118ck1460 FIND v(dout0_118) AT=735.025n

.meas tran vdout0_119ck1460 FIND v(dout0_119) AT=735.025n

.meas tran vdout0_120ck1460 FIND v(dout0_120) AT=735.025n

.meas tran vdout0_121ck1460 FIND v(dout0_121) AT=735.025n

.meas tran vdout0_122ck1460 FIND v(dout0_122) AT=735.025n

.meas tran vdout0_123ck1460 FIND v(dout0_123) AT=735.025n

.meas tran vdout0_124ck1460 FIND v(dout0_124) AT=735.025n

.meas tran vdout0_125ck1460 FIND v(dout0_125) AT=735.025n

.meas tran vdout0_126ck1460 FIND v(dout0_126) AT=735.025n

.meas tran vdout0_127ck1460 FIND v(dout0_127) AT=735.025n

.meas tran vdout0_128ck1460 FIND v(dout0_128) AT=735.025n

.meas tran vdout0_129ck1460 FIND v(dout0_129) AT=735.025n

.meas tran vdout0_130ck1460 FIND v(dout0_130) AT=735.025n

.meas tran vdout0_131ck1460 FIND v(dout0_131) AT=735.025n

.meas tran vdout0_132ck1460 FIND v(dout0_132) AT=735.025n

.meas tran vdout0_133ck1460 FIND v(dout0_133) AT=735.025n

.meas tran vdout0_134ck1460 FIND v(dout0_134) AT=735.025n

.meas tran vdout0_135ck1460 FIND v(dout0_135) AT=735.025n

.meas tran vdout0_136ck1460 FIND v(dout0_136) AT=735.025n

.meas tran vdout0_137ck1460 FIND v(dout0_137) AT=735.025n

.meas tran vdout0_138ck1460 FIND v(dout0_138) AT=735.025n

.meas tran vdout0_139ck1460 FIND v(dout0_139) AT=735.025n

.meas tran vdout0_140ck1460 FIND v(dout0_140) AT=735.025n

.meas tran vdout0_141ck1460 FIND v(dout0_141) AT=735.025n

.meas tran vdout0_142ck1460 FIND v(dout0_142) AT=735.025n

.meas tran vdout0_143ck1460 FIND v(dout0_143) AT=735.025n

.meas tran vdout0_144ck1460 FIND v(dout0_144) AT=735.025n

.meas tran vdout0_145ck1460 FIND v(dout0_145) AT=735.025n

.meas tran vdout0_146ck1460 FIND v(dout0_146) AT=735.025n

.meas tran vdout0_147ck1460 FIND v(dout0_147) AT=735.025n

.meas tran vdout0_148ck1460 FIND v(dout0_148) AT=735.025n

.meas tran vdout0_149ck1460 FIND v(dout0_149) AT=735.025n

.meas tran vdout0_150ck1460 FIND v(dout0_150) AT=735.025n

.meas tran vdout0_151ck1460 FIND v(dout0_151) AT=735.025n

.meas tran vdout0_152ck1460 FIND v(dout0_152) AT=735.025n

.meas tran vdout0_153ck1460 FIND v(dout0_153) AT=735.025n

.meas tran vdout0_154ck1460 FIND v(dout0_154) AT=735.025n

.meas tran vdout0_155ck1460 FIND v(dout0_155) AT=735.025n

.meas tran vdout0_156ck1460 FIND v(dout0_156) AT=735.025n

.meas tran vdout0_157ck1460 FIND v(dout0_157) AT=735.025n

.meas tran vdout0_158ck1460 FIND v(dout0_158) AT=735.025n

.meas tran vdout0_159ck1460 FIND v(dout0_159) AT=735.025n

.meas tran vdout0_160ck1460 FIND v(dout0_160) AT=735.025n

.meas tran vdout0_161ck1460 FIND v(dout0_161) AT=735.025n

.meas tran vdout0_162ck1460 FIND v(dout0_162) AT=735.025n

.meas tran vdout0_163ck1460 FIND v(dout0_163) AT=735.025n

.meas tran vdout0_164ck1460 FIND v(dout0_164) AT=735.025n

.meas tran vdout0_165ck1460 FIND v(dout0_165) AT=735.025n

.meas tran vdout0_166ck1460 FIND v(dout0_166) AT=735.025n

.meas tran vdout0_167ck1460 FIND v(dout0_167) AT=735.025n

.meas tran vdout0_168ck1460 FIND v(dout0_168) AT=735.025n

.meas tran vdout0_169ck1460 FIND v(dout0_169) AT=735.025n

.meas tran vdout0_170ck1460 FIND v(dout0_170) AT=735.025n

.meas tran vdout0_171ck1460 FIND v(dout0_171) AT=735.025n

.meas tran vdout0_172ck1460 FIND v(dout0_172) AT=735.025n

.meas tran vdout0_173ck1460 FIND v(dout0_173) AT=735.025n

.meas tran vdout0_174ck1460 FIND v(dout0_174) AT=735.025n

.meas tran vdout0_175ck1460 FIND v(dout0_175) AT=735.025n

.meas tran vdout0_176ck1460 FIND v(dout0_176) AT=735.025n

.meas tran vdout0_177ck1460 FIND v(dout0_177) AT=735.025n

.meas tran vdout0_178ck1460 FIND v(dout0_178) AT=735.025n

.meas tran vdout0_179ck1460 FIND v(dout0_179) AT=735.025n

.meas tran vdout0_180ck1460 FIND v(dout0_180) AT=735.025n

.meas tran vdout0_181ck1460 FIND v(dout0_181) AT=735.025n

.meas tran vdout0_182ck1460 FIND v(dout0_182) AT=735.025n

.meas tran vdout0_183ck1460 FIND v(dout0_183) AT=735.025n

.meas tran vdout0_184ck1460 FIND v(dout0_184) AT=735.025n

.meas tran vdout0_185ck1460 FIND v(dout0_185) AT=735.025n

.meas tran vdout0_186ck1460 FIND v(dout0_186) AT=735.025n

.meas tran vdout0_187ck1460 FIND v(dout0_187) AT=735.025n

.meas tran vdout0_188ck1460 FIND v(dout0_188) AT=735.025n

.meas tran vdout0_189ck1460 FIND v(dout0_189) AT=735.025n

.meas tran vdout0_190ck1460 FIND v(dout0_190) AT=735.025n

.meas tran vdout0_191ck1460 FIND v(dout0_191) AT=735.025n

.meas tran vdout0_192ck1460 FIND v(dout0_192) AT=735.025n

.meas tran vdout0_193ck1460 FIND v(dout0_193) AT=735.025n

.meas tran vdout0_194ck1460 FIND v(dout0_194) AT=735.025n

.meas tran vdout0_195ck1460 FIND v(dout0_195) AT=735.025n

.meas tran vdout0_196ck1460 FIND v(dout0_196) AT=735.025n

.meas tran vdout0_197ck1460 FIND v(dout0_197) AT=735.025n

.meas tran vdout0_198ck1460 FIND v(dout0_198) AT=735.025n

.meas tran vdout0_199ck1460 FIND v(dout0_199) AT=735.025n

.meas tran vdout0_200ck1460 FIND v(dout0_200) AT=735.025n

.meas tran vdout0_201ck1460 FIND v(dout0_201) AT=735.025n

.meas tran vdout0_202ck1460 FIND v(dout0_202) AT=735.025n

.meas tran vdout0_203ck1460 FIND v(dout0_203) AT=735.025n

.meas tran vdout0_204ck1460 FIND v(dout0_204) AT=735.025n

.meas tran vdout0_205ck1460 FIND v(dout0_205) AT=735.025n

.meas tran vdout0_206ck1460 FIND v(dout0_206) AT=735.025n

.meas tran vdout0_207ck1460 FIND v(dout0_207) AT=735.025n

.meas tran vdout0_208ck1460 FIND v(dout0_208) AT=735.025n

.meas tran vdout0_209ck1460 FIND v(dout0_209) AT=735.025n

.meas tran vdout0_210ck1460 FIND v(dout0_210) AT=735.025n

.meas tran vdout0_211ck1460 FIND v(dout0_211) AT=735.025n

.meas tran vdout0_212ck1460 FIND v(dout0_212) AT=735.025n

.meas tran vdout0_213ck1460 FIND v(dout0_213) AT=735.025n

.meas tran vdout0_214ck1460 FIND v(dout0_214) AT=735.025n

.meas tran vdout0_215ck1460 FIND v(dout0_215) AT=735.025n

.meas tran vdout0_216ck1460 FIND v(dout0_216) AT=735.025n

.meas tran vdout0_217ck1460 FIND v(dout0_217) AT=735.025n

.meas tran vdout0_218ck1460 FIND v(dout0_218) AT=735.025n

.meas tran vdout0_219ck1460 FIND v(dout0_219) AT=735.025n

.meas tran vdout0_220ck1460 FIND v(dout0_220) AT=735.025n

.meas tran vdout0_221ck1460 FIND v(dout0_221) AT=735.025n

.meas tran vdout0_222ck1460 FIND v(dout0_222) AT=735.025n

.meas tran vdout0_223ck1460 FIND v(dout0_223) AT=735.025n

.meas tran vdout0_224ck1460 FIND v(dout0_224) AT=735.025n

.meas tran vdout0_225ck1460 FIND v(dout0_225) AT=735.025n

.meas tran vdout0_226ck1460 FIND v(dout0_226) AT=735.025n

.meas tran vdout0_227ck1460 FIND v(dout0_227) AT=735.025n

.meas tran vdout0_228ck1460 FIND v(dout0_228) AT=735.025n

.meas tran vdout0_229ck1460 FIND v(dout0_229) AT=735.025n

.meas tran vdout0_230ck1460 FIND v(dout0_230) AT=735.025n

.meas tran vdout0_231ck1460 FIND v(dout0_231) AT=735.025n

.meas tran vdout0_232ck1460 FIND v(dout0_232) AT=735.025n

.meas tran vdout0_233ck1460 FIND v(dout0_233) AT=735.025n

.meas tran vdout0_234ck1460 FIND v(dout0_234) AT=735.025n

.meas tran vdout0_235ck1460 FIND v(dout0_235) AT=735.025n

.meas tran vdout0_236ck1460 FIND v(dout0_236) AT=735.025n

.meas tran vdout0_237ck1460 FIND v(dout0_237) AT=735.025n

.meas tran vdout0_238ck1460 FIND v(dout0_238) AT=735.025n

.meas tran vdout0_239ck1460 FIND v(dout0_239) AT=735.025n

.meas tran vdout0_240ck1460 FIND v(dout0_240) AT=735.025n

.meas tran vdout0_241ck1460 FIND v(dout0_241) AT=735.025n

.meas tran vdout0_242ck1460 FIND v(dout0_242) AT=735.025n

.meas tran vdout0_243ck1460 FIND v(dout0_243) AT=735.025n

.meas tran vdout0_244ck1460 FIND v(dout0_244) AT=735.025n

.meas tran vdout0_245ck1460 FIND v(dout0_245) AT=735.025n

.meas tran vdout0_246ck1460 FIND v(dout0_246) AT=735.025n

.meas tran vdout0_247ck1460 FIND v(dout0_247) AT=735.025n

.meas tran vdout0_248ck1460 FIND v(dout0_248) AT=735.025n

.meas tran vdout0_249ck1460 FIND v(dout0_249) AT=735.025n

.meas tran vdout0_250ck1460 FIND v(dout0_250) AT=735.025n

.meas tran vdout0_251ck1460 FIND v(dout0_251) AT=735.025n

.meas tran vdout0_252ck1460 FIND v(dout0_252) AT=735.025n

.meas tran vdout0_253ck1460 FIND v(dout0_253) AT=735.025n

.meas tran vdout0_254ck1460 FIND v(dout0_254) AT=735.025n

.meas tran vdout0_255ck1460 FIND v(dout0_255) AT=735.025n

.meas tran vdout0_0ck1470 FIND v(dout0_0) AT=740.025n

.meas tran vdout0_1ck1470 FIND v(dout0_1) AT=740.025n

.meas tran vdout0_2ck1470 FIND v(dout0_2) AT=740.025n

.meas tran vdout0_3ck1470 FIND v(dout0_3) AT=740.025n

.meas tran vdout0_4ck1470 FIND v(dout0_4) AT=740.025n

.meas tran vdout0_5ck1470 FIND v(dout0_5) AT=740.025n

.meas tran vdout0_6ck1470 FIND v(dout0_6) AT=740.025n

.meas tran vdout0_7ck1470 FIND v(dout0_7) AT=740.025n

.meas tran vdout0_8ck1470 FIND v(dout0_8) AT=740.025n

.meas tran vdout0_9ck1470 FIND v(dout0_9) AT=740.025n

.meas tran vdout0_10ck1470 FIND v(dout0_10) AT=740.025n

.meas tran vdout0_11ck1470 FIND v(dout0_11) AT=740.025n

.meas tran vdout0_12ck1470 FIND v(dout0_12) AT=740.025n

.meas tran vdout0_13ck1470 FIND v(dout0_13) AT=740.025n

.meas tran vdout0_14ck1470 FIND v(dout0_14) AT=740.025n

.meas tran vdout0_15ck1470 FIND v(dout0_15) AT=740.025n

.meas tran vdout0_16ck1470 FIND v(dout0_16) AT=740.025n

.meas tran vdout0_17ck1470 FIND v(dout0_17) AT=740.025n

.meas tran vdout0_18ck1470 FIND v(dout0_18) AT=740.025n

.meas tran vdout0_19ck1470 FIND v(dout0_19) AT=740.025n

.meas tran vdout0_20ck1470 FIND v(dout0_20) AT=740.025n

.meas tran vdout0_21ck1470 FIND v(dout0_21) AT=740.025n

.meas tran vdout0_22ck1470 FIND v(dout0_22) AT=740.025n

.meas tran vdout0_23ck1470 FIND v(dout0_23) AT=740.025n

.meas tran vdout0_24ck1470 FIND v(dout0_24) AT=740.025n

.meas tran vdout0_25ck1470 FIND v(dout0_25) AT=740.025n

.meas tran vdout0_26ck1470 FIND v(dout0_26) AT=740.025n

.meas tran vdout0_27ck1470 FIND v(dout0_27) AT=740.025n

.meas tran vdout0_28ck1470 FIND v(dout0_28) AT=740.025n

.meas tran vdout0_29ck1470 FIND v(dout0_29) AT=740.025n

.meas tran vdout0_30ck1470 FIND v(dout0_30) AT=740.025n

.meas tran vdout0_31ck1470 FIND v(dout0_31) AT=740.025n

.meas tran vdout0_32ck1470 FIND v(dout0_32) AT=740.025n

.meas tran vdout0_33ck1470 FIND v(dout0_33) AT=740.025n

.meas tran vdout0_34ck1470 FIND v(dout0_34) AT=740.025n

.meas tran vdout0_35ck1470 FIND v(dout0_35) AT=740.025n

.meas tran vdout0_36ck1470 FIND v(dout0_36) AT=740.025n

.meas tran vdout0_37ck1470 FIND v(dout0_37) AT=740.025n

.meas tran vdout0_38ck1470 FIND v(dout0_38) AT=740.025n

.meas tran vdout0_39ck1470 FIND v(dout0_39) AT=740.025n

.meas tran vdout0_40ck1470 FIND v(dout0_40) AT=740.025n

.meas tran vdout0_41ck1470 FIND v(dout0_41) AT=740.025n

.meas tran vdout0_42ck1470 FIND v(dout0_42) AT=740.025n

.meas tran vdout0_43ck1470 FIND v(dout0_43) AT=740.025n

.meas tran vdout0_44ck1470 FIND v(dout0_44) AT=740.025n

.meas tran vdout0_45ck1470 FIND v(dout0_45) AT=740.025n

.meas tran vdout0_46ck1470 FIND v(dout0_46) AT=740.025n

.meas tran vdout0_47ck1470 FIND v(dout0_47) AT=740.025n

.meas tran vdout0_48ck1470 FIND v(dout0_48) AT=740.025n

.meas tran vdout0_49ck1470 FIND v(dout0_49) AT=740.025n

.meas tran vdout0_50ck1470 FIND v(dout0_50) AT=740.025n

.meas tran vdout0_51ck1470 FIND v(dout0_51) AT=740.025n

.meas tran vdout0_52ck1470 FIND v(dout0_52) AT=740.025n

.meas tran vdout0_53ck1470 FIND v(dout0_53) AT=740.025n

.meas tran vdout0_54ck1470 FIND v(dout0_54) AT=740.025n

.meas tran vdout0_55ck1470 FIND v(dout0_55) AT=740.025n

.meas tran vdout0_56ck1470 FIND v(dout0_56) AT=740.025n

.meas tran vdout0_57ck1470 FIND v(dout0_57) AT=740.025n

.meas tran vdout0_58ck1470 FIND v(dout0_58) AT=740.025n

.meas tran vdout0_59ck1470 FIND v(dout0_59) AT=740.025n

.meas tran vdout0_60ck1470 FIND v(dout0_60) AT=740.025n

.meas tran vdout0_61ck1470 FIND v(dout0_61) AT=740.025n

.meas tran vdout0_62ck1470 FIND v(dout0_62) AT=740.025n

.meas tran vdout0_63ck1470 FIND v(dout0_63) AT=740.025n

.meas tran vdout0_64ck1470 FIND v(dout0_64) AT=740.025n

.meas tran vdout0_65ck1470 FIND v(dout0_65) AT=740.025n

.meas tran vdout0_66ck1470 FIND v(dout0_66) AT=740.025n

.meas tran vdout0_67ck1470 FIND v(dout0_67) AT=740.025n

.meas tran vdout0_68ck1470 FIND v(dout0_68) AT=740.025n

.meas tran vdout0_69ck1470 FIND v(dout0_69) AT=740.025n

.meas tran vdout0_70ck1470 FIND v(dout0_70) AT=740.025n

.meas tran vdout0_71ck1470 FIND v(dout0_71) AT=740.025n

.meas tran vdout0_72ck1470 FIND v(dout0_72) AT=740.025n

.meas tran vdout0_73ck1470 FIND v(dout0_73) AT=740.025n

.meas tran vdout0_74ck1470 FIND v(dout0_74) AT=740.025n

.meas tran vdout0_75ck1470 FIND v(dout0_75) AT=740.025n

.meas tran vdout0_76ck1470 FIND v(dout0_76) AT=740.025n

.meas tran vdout0_77ck1470 FIND v(dout0_77) AT=740.025n

.meas tran vdout0_78ck1470 FIND v(dout0_78) AT=740.025n

.meas tran vdout0_79ck1470 FIND v(dout0_79) AT=740.025n

.meas tran vdout0_80ck1470 FIND v(dout0_80) AT=740.025n

.meas tran vdout0_81ck1470 FIND v(dout0_81) AT=740.025n

.meas tran vdout0_82ck1470 FIND v(dout0_82) AT=740.025n

.meas tran vdout0_83ck1470 FIND v(dout0_83) AT=740.025n

.meas tran vdout0_84ck1470 FIND v(dout0_84) AT=740.025n

.meas tran vdout0_85ck1470 FIND v(dout0_85) AT=740.025n

.meas tran vdout0_86ck1470 FIND v(dout0_86) AT=740.025n

.meas tran vdout0_87ck1470 FIND v(dout0_87) AT=740.025n

.meas tran vdout0_88ck1470 FIND v(dout0_88) AT=740.025n

.meas tran vdout0_89ck1470 FIND v(dout0_89) AT=740.025n

.meas tran vdout0_90ck1470 FIND v(dout0_90) AT=740.025n

.meas tran vdout0_91ck1470 FIND v(dout0_91) AT=740.025n

.meas tran vdout0_92ck1470 FIND v(dout0_92) AT=740.025n

.meas tran vdout0_93ck1470 FIND v(dout0_93) AT=740.025n

.meas tran vdout0_94ck1470 FIND v(dout0_94) AT=740.025n

.meas tran vdout0_95ck1470 FIND v(dout0_95) AT=740.025n

.meas tran vdout0_96ck1470 FIND v(dout0_96) AT=740.025n

.meas tran vdout0_97ck1470 FIND v(dout0_97) AT=740.025n

.meas tran vdout0_98ck1470 FIND v(dout0_98) AT=740.025n

.meas tran vdout0_99ck1470 FIND v(dout0_99) AT=740.025n

.meas tran vdout0_100ck1470 FIND v(dout0_100) AT=740.025n

.meas tran vdout0_101ck1470 FIND v(dout0_101) AT=740.025n

.meas tran vdout0_102ck1470 FIND v(dout0_102) AT=740.025n

.meas tran vdout0_103ck1470 FIND v(dout0_103) AT=740.025n

.meas tran vdout0_104ck1470 FIND v(dout0_104) AT=740.025n

.meas tran vdout0_105ck1470 FIND v(dout0_105) AT=740.025n

.meas tran vdout0_106ck1470 FIND v(dout0_106) AT=740.025n

.meas tran vdout0_107ck1470 FIND v(dout0_107) AT=740.025n

.meas tran vdout0_108ck1470 FIND v(dout0_108) AT=740.025n

.meas tran vdout0_109ck1470 FIND v(dout0_109) AT=740.025n

.meas tran vdout0_110ck1470 FIND v(dout0_110) AT=740.025n

.meas tran vdout0_111ck1470 FIND v(dout0_111) AT=740.025n

.meas tran vdout0_112ck1470 FIND v(dout0_112) AT=740.025n

.meas tran vdout0_113ck1470 FIND v(dout0_113) AT=740.025n

.meas tran vdout0_114ck1470 FIND v(dout0_114) AT=740.025n

.meas tran vdout0_115ck1470 FIND v(dout0_115) AT=740.025n

.meas tran vdout0_116ck1470 FIND v(dout0_116) AT=740.025n

.meas tran vdout0_117ck1470 FIND v(dout0_117) AT=740.025n

.meas tran vdout0_118ck1470 FIND v(dout0_118) AT=740.025n

.meas tran vdout0_119ck1470 FIND v(dout0_119) AT=740.025n

.meas tran vdout0_120ck1470 FIND v(dout0_120) AT=740.025n

.meas tran vdout0_121ck1470 FIND v(dout0_121) AT=740.025n

.meas tran vdout0_122ck1470 FIND v(dout0_122) AT=740.025n

.meas tran vdout0_123ck1470 FIND v(dout0_123) AT=740.025n

.meas tran vdout0_124ck1470 FIND v(dout0_124) AT=740.025n

.meas tran vdout0_125ck1470 FIND v(dout0_125) AT=740.025n

.meas tran vdout0_126ck1470 FIND v(dout0_126) AT=740.025n

.meas tran vdout0_127ck1470 FIND v(dout0_127) AT=740.025n

.meas tran vdout0_128ck1470 FIND v(dout0_128) AT=740.025n

.meas tran vdout0_129ck1470 FIND v(dout0_129) AT=740.025n

.meas tran vdout0_130ck1470 FIND v(dout0_130) AT=740.025n

.meas tran vdout0_131ck1470 FIND v(dout0_131) AT=740.025n

.meas tran vdout0_132ck1470 FIND v(dout0_132) AT=740.025n

.meas tran vdout0_133ck1470 FIND v(dout0_133) AT=740.025n

.meas tran vdout0_134ck1470 FIND v(dout0_134) AT=740.025n

.meas tran vdout0_135ck1470 FIND v(dout0_135) AT=740.025n

.meas tran vdout0_136ck1470 FIND v(dout0_136) AT=740.025n

.meas tran vdout0_137ck1470 FIND v(dout0_137) AT=740.025n

.meas tran vdout0_138ck1470 FIND v(dout0_138) AT=740.025n

.meas tran vdout0_139ck1470 FIND v(dout0_139) AT=740.025n

.meas tran vdout0_140ck1470 FIND v(dout0_140) AT=740.025n

.meas tran vdout0_141ck1470 FIND v(dout0_141) AT=740.025n

.meas tran vdout0_142ck1470 FIND v(dout0_142) AT=740.025n

.meas tran vdout0_143ck1470 FIND v(dout0_143) AT=740.025n

.meas tran vdout0_144ck1470 FIND v(dout0_144) AT=740.025n

.meas tran vdout0_145ck1470 FIND v(dout0_145) AT=740.025n

.meas tran vdout0_146ck1470 FIND v(dout0_146) AT=740.025n

.meas tran vdout0_147ck1470 FIND v(dout0_147) AT=740.025n

.meas tran vdout0_148ck1470 FIND v(dout0_148) AT=740.025n

.meas tran vdout0_149ck1470 FIND v(dout0_149) AT=740.025n

.meas tran vdout0_150ck1470 FIND v(dout0_150) AT=740.025n

.meas tran vdout0_151ck1470 FIND v(dout0_151) AT=740.025n

.meas tran vdout0_152ck1470 FIND v(dout0_152) AT=740.025n

.meas tran vdout0_153ck1470 FIND v(dout0_153) AT=740.025n

.meas tran vdout0_154ck1470 FIND v(dout0_154) AT=740.025n

.meas tran vdout0_155ck1470 FIND v(dout0_155) AT=740.025n

.meas tran vdout0_156ck1470 FIND v(dout0_156) AT=740.025n

.meas tran vdout0_157ck1470 FIND v(dout0_157) AT=740.025n

.meas tran vdout0_158ck1470 FIND v(dout0_158) AT=740.025n

.meas tran vdout0_159ck1470 FIND v(dout0_159) AT=740.025n

.meas tran vdout0_160ck1470 FIND v(dout0_160) AT=740.025n

.meas tran vdout0_161ck1470 FIND v(dout0_161) AT=740.025n

.meas tran vdout0_162ck1470 FIND v(dout0_162) AT=740.025n

.meas tran vdout0_163ck1470 FIND v(dout0_163) AT=740.025n

.meas tran vdout0_164ck1470 FIND v(dout0_164) AT=740.025n

.meas tran vdout0_165ck1470 FIND v(dout0_165) AT=740.025n

.meas tran vdout0_166ck1470 FIND v(dout0_166) AT=740.025n

.meas tran vdout0_167ck1470 FIND v(dout0_167) AT=740.025n

.meas tran vdout0_168ck1470 FIND v(dout0_168) AT=740.025n

.meas tran vdout0_169ck1470 FIND v(dout0_169) AT=740.025n

.meas tran vdout0_170ck1470 FIND v(dout0_170) AT=740.025n

.meas tran vdout0_171ck1470 FIND v(dout0_171) AT=740.025n

.meas tran vdout0_172ck1470 FIND v(dout0_172) AT=740.025n

.meas tran vdout0_173ck1470 FIND v(dout0_173) AT=740.025n

.meas tran vdout0_174ck1470 FIND v(dout0_174) AT=740.025n

.meas tran vdout0_175ck1470 FIND v(dout0_175) AT=740.025n

.meas tran vdout0_176ck1470 FIND v(dout0_176) AT=740.025n

.meas tran vdout0_177ck1470 FIND v(dout0_177) AT=740.025n

.meas tran vdout0_178ck1470 FIND v(dout0_178) AT=740.025n

.meas tran vdout0_179ck1470 FIND v(dout0_179) AT=740.025n

.meas tran vdout0_180ck1470 FIND v(dout0_180) AT=740.025n

.meas tran vdout0_181ck1470 FIND v(dout0_181) AT=740.025n

.meas tran vdout0_182ck1470 FIND v(dout0_182) AT=740.025n

.meas tran vdout0_183ck1470 FIND v(dout0_183) AT=740.025n

.meas tran vdout0_184ck1470 FIND v(dout0_184) AT=740.025n

.meas tran vdout0_185ck1470 FIND v(dout0_185) AT=740.025n

.meas tran vdout0_186ck1470 FIND v(dout0_186) AT=740.025n

.meas tran vdout0_187ck1470 FIND v(dout0_187) AT=740.025n

.meas tran vdout0_188ck1470 FIND v(dout0_188) AT=740.025n

.meas tran vdout0_189ck1470 FIND v(dout0_189) AT=740.025n

.meas tran vdout0_190ck1470 FIND v(dout0_190) AT=740.025n

.meas tran vdout0_191ck1470 FIND v(dout0_191) AT=740.025n

.meas tran vdout0_192ck1470 FIND v(dout0_192) AT=740.025n

.meas tran vdout0_193ck1470 FIND v(dout0_193) AT=740.025n

.meas tran vdout0_194ck1470 FIND v(dout0_194) AT=740.025n

.meas tran vdout0_195ck1470 FIND v(dout0_195) AT=740.025n

.meas tran vdout0_196ck1470 FIND v(dout0_196) AT=740.025n

.meas tran vdout0_197ck1470 FIND v(dout0_197) AT=740.025n

.meas tran vdout0_198ck1470 FIND v(dout0_198) AT=740.025n

.meas tran vdout0_199ck1470 FIND v(dout0_199) AT=740.025n

.meas tran vdout0_200ck1470 FIND v(dout0_200) AT=740.025n

.meas tran vdout0_201ck1470 FIND v(dout0_201) AT=740.025n

.meas tran vdout0_202ck1470 FIND v(dout0_202) AT=740.025n

.meas tran vdout0_203ck1470 FIND v(dout0_203) AT=740.025n

.meas tran vdout0_204ck1470 FIND v(dout0_204) AT=740.025n

.meas tran vdout0_205ck1470 FIND v(dout0_205) AT=740.025n

.meas tran vdout0_206ck1470 FIND v(dout0_206) AT=740.025n

.meas tran vdout0_207ck1470 FIND v(dout0_207) AT=740.025n

.meas tran vdout0_208ck1470 FIND v(dout0_208) AT=740.025n

.meas tran vdout0_209ck1470 FIND v(dout0_209) AT=740.025n

.meas tran vdout0_210ck1470 FIND v(dout0_210) AT=740.025n

.meas tran vdout0_211ck1470 FIND v(dout0_211) AT=740.025n

.meas tran vdout0_212ck1470 FIND v(dout0_212) AT=740.025n

.meas tran vdout0_213ck1470 FIND v(dout0_213) AT=740.025n

.meas tran vdout0_214ck1470 FIND v(dout0_214) AT=740.025n

.meas tran vdout0_215ck1470 FIND v(dout0_215) AT=740.025n

.meas tran vdout0_216ck1470 FIND v(dout0_216) AT=740.025n

.meas tran vdout0_217ck1470 FIND v(dout0_217) AT=740.025n

.meas tran vdout0_218ck1470 FIND v(dout0_218) AT=740.025n

.meas tran vdout0_219ck1470 FIND v(dout0_219) AT=740.025n

.meas tran vdout0_220ck1470 FIND v(dout0_220) AT=740.025n

.meas tran vdout0_221ck1470 FIND v(dout0_221) AT=740.025n

.meas tran vdout0_222ck1470 FIND v(dout0_222) AT=740.025n

.meas tran vdout0_223ck1470 FIND v(dout0_223) AT=740.025n

.meas tran vdout0_224ck1470 FIND v(dout0_224) AT=740.025n

.meas tran vdout0_225ck1470 FIND v(dout0_225) AT=740.025n

.meas tran vdout0_226ck1470 FIND v(dout0_226) AT=740.025n

.meas tran vdout0_227ck1470 FIND v(dout0_227) AT=740.025n

.meas tran vdout0_228ck1470 FIND v(dout0_228) AT=740.025n

.meas tran vdout0_229ck1470 FIND v(dout0_229) AT=740.025n

.meas tran vdout0_230ck1470 FIND v(dout0_230) AT=740.025n

.meas tran vdout0_231ck1470 FIND v(dout0_231) AT=740.025n

.meas tran vdout0_232ck1470 FIND v(dout0_232) AT=740.025n

.meas tran vdout0_233ck1470 FIND v(dout0_233) AT=740.025n

.meas tran vdout0_234ck1470 FIND v(dout0_234) AT=740.025n

.meas tran vdout0_235ck1470 FIND v(dout0_235) AT=740.025n

.meas tran vdout0_236ck1470 FIND v(dout0_236) AT=740.025n

.meas tran vdout0_237ck1470 FIND v(dout0_237) AT=740.025n

.meas tran vdout0_238ck1470 FIND v(dout0_238) AT=740.025n

.meas tran vdout0_239ck1470 FIND v(dout0_239) AT=740.025n

.meas tran vdout0_240ck1470 FIND v(dout0_240) AT=740.025n

.meas tran vdout0_241ck1470 FIND v(dout0_241) AT=740.025n

.meas tran vdout0_242ck1470 FIND v(dout0_242) AT=740.025n

.meas tran vdout0_243ck1470 FIND v(dout0_243) AT=740.025n

.meas tran vdout0_244ck1470 FIND v(dout0_244) AT=740.025n

.meas tran vdout0_245ck1470 FIND v(dout0_245) AT=740.025n

.meas tran vdout0_246ck1470 FIND v(dout0_246) AT=740.025n

.meas tran vdout0_247ck1470 FIND v(dout0_247) AT=740.025n

.meas tran vdout0_248ck1470 FIND v(dout0_248) AT=740.025n

.meas tran vdout0_249ck1470 FIND v(dout0_249) AT=740.025n

.meas tran vdout0_250ck1470 FIND v(dout0_250) AT=740.025n

.meas tran vdout0_251ck1470 FIND v(dout0_251) AT=740.025n

.meas tran vdout0_252ck1470 FIND v(dout0_252) AT=740.025n

.meas tran vdout0_253ck1470 FIND v(dout0_253) AT=740.025n

.meas tran vdout0_254ck1470 FIND v(dout0_254) AT=740.025n

.meas tran vdout0_255ck1470 FIND v(dout0_255) AT=740.025n

.meas tran vdout0_0ck1480 FIND v(dout0_0) AT=745.025n

.meas tran vdout0_1ck1480 FIND v(dout0_1) AT=745.025n

.meas tran vdout0_2ck1480 FIND v(dout0_2) AT=745.025n

.meas tran vdout0_3ck1480 FIND v(dout0_3) AT=745.025n

.meas tran vdout0_4ck1480 FIND v(dout0_4) AT=745.025n

.meas tran vdout0_5ck1480 FIND v(dout0_5) AT=745.025n

.meas tran vdout0_6ck1480 FIND v(dout0_6) AT=745.025n

.meas tran vdout0_7ck1480 FIND v(dout0_7) AT=745.025n

.meas tran vdout0_8ck1480 FIND v(dout0_8) AT=745.025n

.meas tran vdout0_9ck1480 FIND v(dout0_9) AT=745.025n

.meas tran vdout0_10ck1480 FIND v(dout0_10) AT=745.025n

.meas tran vdout0_11ck1480 FIND v(dout0_11) AT=745.025n

.meas tran vdout0_12ck1480 FIND v(dout0_12) AT=745.025n

.meas tran vdout0_13ck1480 FIND v(dout0_13) AT=745.025n

.meas tran vdout0_14ck1480 FIND v(dout0_14) AT=745.025n

.meas tran vdout0_15ck1480 FIND v(dout0_15) AT=745.025n

.meas tran vdout0_16ck1480 FIND v(dout0_16) AT=745.025n

.meas tran vdout0_17ck1480 FIND v(dout0_17) AT=745.025n

.meas tran vdout0_18ck1480 FIND v(dout0_18) AT=745.025n

.meas tran vdout0_19ck1480 FIND v(dout0_19) AT=745.025n

.meas tran vdout0_20ck1480 FIND v(dout0_20) AT=745.025n

.meas tran vdout0_21ck1480 FIND v(dout0_21) AT=745.025n

.meas tran vdout0_22ck1480 FIND v(dout0_22) AT=745.025n

.meas tran vdout0_23ck1480 FIND v(dout0_23) AT=745.025n

.meas tran vdout0_24ck1480 FIND v(dout0_24) AT=745.025n

.meas tran vdout0_25ck1480 FIND v(dout0_25) AT=745.025n

.meas tran vdout0_26ck1480 FIND v(dout0_26) AT=745.025n

.meas tran vdout0_27ck1480 FIND v(dout0_27) AT=745.025n

.meas tran vdout0_28ck1480 FIND v(dout0_28) AT=745.025n

.meas tran vdout0_29ck1480 FIND v(dout0_29) AT=745.025n

.meas tran vdout0_30ck1480 FIND v(dout0_30) AT=745.025n

.meas tran vdout0_31ck1480 FIND v(dout0_31) AT=745.025n

.meas tran vdout0_32ck1480 FIND v(dout0_32) AT=745.025n

.meas tran vdout0_33ck1480 FIND v(dout0_33) AT=745.025n

.meas tran vdout0_34ck1480 FIND v(dout0_34) AT=745.025n

.meas tran vdout0_35ck1480 FIND v(dout0_35) AT=745.025n

.meas tran vdout0_36ck1480 FIND v(dout0_36) AT=745.025n

.meas tran vdout0_37ck1480 FIND v(dout0_37) AT=745.025n

.meas tran vdout0_38ck1480 FIND v(dout0_38) AT=745.025n

.meas tran vdout0_39ck1480 FIND v(dout0_39) AT=745.025n

.meas tran vdout0_40ck1480 FIND v(dout0_40) AT=745.025n

.meas tran vdout0_41ck1480 FIND v(dout0_41) AT=745.025n

.meas tran vdout0_42ck1480 FIND v(dout0_42) AT=745.025n

.meas tran vdout0_43ck1480 FIND v(dout0_43) AT=745.025n

.meas tran vdout0_44ck1480 FIND v(dout0_44) AT=745.025n

.meas tran vdout0_45ck1480 FIND v(dout0_45) AT=745.025n

.meas tran vdout0_46ck1480 FIND v(dout0_46) AT=745.025n

.meas tran vdout0_47ck1480 FIND v(dout0_47) AT=745.025n

.meas tran vdout0_48ck1480 FIND v(dout0_48) AT=745.025n

.meas tran vdout0_49ck1480 FIND v(dout0_49) AT=745.025n

.meas tran vdout0_50ck1480 FIND v(dout0_50) AT=745.025n

.meas tran vdout0_51ck1480 FIND v(dout0_51) AT=745.025n

.meas tran vdout0_52ck1480 FIND v(dout0_52) AT=745.025n

.meas tran vdout0_53ck1480 FIND v(dout0_53) AT=745.025n

.meas tran vdout0_54ck1480 FIND v(dout0_54) AT=745.025n

.meas tran vdout0_55ck1480 FIND v(dout0_55) AT=745.025n

.meas tran vdout0_56ck1480 FIND v(dout0_56) AT=745.025n

.meas tran vdout0_57ck1480 FIND v(dout0_57) AT=745.025n

.meas tran vdout0_58ck1480 FIND v(dout0_58) AT=745.025n

.meas tran vdout0_59ck1480 FIND v(dout0_59) AT=745.025n

.meas tran vdout0_60ck1480 FIND v(dout0_60) AT=745.025n

.meas tran vdout0_61ck1480 FIND v(dout0_61) AT=745.025n

.meas tran vdout0_62ck1480 FIND v(dout0_62) AT=745.025n

.meas tran vdout0_63ck1480 FIND v(dout0_63) AT=745.025n

.meas tran vdout0_64ck1480 FIND v(dout0_64) AT=745.025n

.meas tran vdout0_65ck1480 FIND v(dout0_65) AT=745.025n

.meas tran vdout0_66ck1480 FIND v(dout0_66) AT=745.025n

.meas tran vdout0_67ck1480 FIND v(dout0_67) AT=745.025n

.meas tran vdout0_68ck1480 FIND v(dout0_68) AT=745.025n

.meas tran vdout0_69ck1480 FIND v(dout0_69) AT=745.025n

.meas tran vdout0_70ck1480 FIND v(dout0_70) AT=745.025n

.meas tran vdout0_71ck1480 FIND v(dout0_71) AT=745.025n

.meas tran vdout0_72ck1480 FIND v(dout0_72) AT=745.025n

.meas tran vdout0_73ck1480 FIND v(dout0_73) AT=745.025n

.meas tran vdout0_74ck1480 FIND v(dout0_74) AT=745.025n

.meas tran vdout0_75ck1480 FIND v(dout0_75) AT=745.025n

.meas tran vdout0_76ck1480 FIND v(dout0_76) AT=745.025n

.meas tran vdout0_77ck1480 FIND v(dout0_77) AT=745.025n

.meas tran vdout0_78ck1480 FIND v(dout0_78) AT=745.025n

.meas tran vdout0_79ck1480 FIND v(dout0_79) AT=745.025n

.meas tran vdout0_80ck1480 FIND v(dout0_80) AT=745.025n

.meas tran vdout0_81ck1480 FIND v(dout0_81) AT=745.025n

.meas tran vdout0_82ck1480 FIND v(dout0_82) AT=745.025n

.meas tran vdout0_83ck1480 FIND v(dout0_83) AT=745.025n

.meas tran vdout0_84ck1480 FIND v(dout0_84) AT=745.025n

.meas tran vdout0_85ck1480 FIND v(dout0_85) AT=745.025n

.meas tran vdout0_86ck1480 FIND v(dout0_86) AT=745.025n

.meas tran vdout0_87ck1480 FIND v(dout0_87) AT=745.025n

.meas tran vdout0_88ck1480 FIND v(dout0_88) AT=745.025n

.meas tran vdout0_89ck1480 FIND v(dout0_89) AT=745.025n

.meas tran vdout0_90ck1480 FIND v(dout0_90) AT=745.025n

.meas tran vdout0_91ck1480 FIND v(dout0_91) AT=745.025n

.meas tran vdout0_92ck1480 FIND v(dout0_92) AT=745.025n

.meas tran vdout0_93ck1480 FIND v(dout0_93) AT=745.025n

.meas tran vdout0_94ck1480 FIND v(dout0_94) AT=745.025n

.meas tran vdout0_95ck1480 FIND v(dout0_95) AT=745.025n

.meas tran vdout0_96ck1480 FIND v(dout0_96) AT=745.025n

.meas tran vdout0_97ck1480 FIND v(dout0_97) AT=745.025n

.meas tran vdout0_98ck1480 FIND v(dout0_98) AT=745.025n

.meas tran vdout0_99ck1480 FIND v(dout0_99) AT=745.025n

.meas tran vdout0_100ck1480 FIND v(dout0_100) AT=745.025n

.meas tran vdout0_101ck1480 FIND v(dout0_101) AT=745.025n

.meas tran vdout0_102ck1480 FIND v(dout0_102) AT=745.025n

.meas tran vdout0_103ck1480 FIND v(dout0_103) AT=745.025n

.meas tran vdout0_104ck1480 FIND v(dout0_104) AT=745.025n

.meas tran vdout0_105ck1480 FIND v(dout0_105) AT=745.025n

.meas tran vdout0_106ck1480 FIND v(dout0_106) AT=745.025n

.meas tran vdout0_107ck1480 FIND v(dout0_107) AT=745.025n

.meas tran vdout0_108ck1480 FIND v(dout0_108) AT=745.025n

.meas tran vdout0_109ck1480 FIND v(dout0_109) AT=745.025n

.meas tran vdout0_110ck1480 FIND v(dout0_110) AT=745.025n

.meas tran vdout0_111ck1480 FIND v(dout0_111) AT=745.025n

.meas tran vdout0_112ck1480 FIND v(dout0_112) AT=745.025n

.meas tran vdout0_113ck1480 FIND v(dout0_113) AT=745.025n

.meas tran vdout0_114ck1480 FIND v(dout0_114) AT=745.025n

.meas tran vdout0_115ck1480 FIND v(dout0_115) AT=745.025n

.meas tran vdout0_116ck1480 FIND v(dout0_116) AT=745.025n

.meas tran vdout0_117ck1480 FIND v(dout0_117) AT=745.025n

.meas tran vdout0_118ck1480 FIND v(dout0_118) AT=745.025n

.meas tran vdout0_119ck1480 FIND v(dout0_119) AT=745.025n

.meas tran vdout0_120ck1480 FIND v(dout0_120) AT=745.025n

.meas tran vdout0_121ck1480 FIND v(dout0_121) AT=745.025n

.meas tran vdout0_122ck1480 FIND v(dout0_122) AT=745.025n

.meas tran vdout0_123ck1480 FIND v(dout0_123) AT=745.025n

.meas tran vdout0_124ck1480 FIND v(dout0_124) AT=745.025n

.meas tran vdout0_125ck1480 FIND v(dout0_125) AT=745.025n

.meas tran vdout0_126ck1480 FIND v(dout0_126) AT=745.025n

.meas tran vdout0_127ck1480 FIND v(dout0_127) AT=745.025n

.meas tran vdout0_128ck1480 FIND v(dout0_128) AT=745.025n

.meas tran vdout0_129ck1480 FIND v(dout0_129) AT=745.025n

.meas tran vdout0_130ck1480 FIND v(dout0_130) AT=745.025n

.meas tran vdout0_131ck1480 FIND v(dout0_131) AT=745.025n

.meas tran vdout0_132ck1480 FIND v(dout0_132) AT=745.025n

.meas tran vdout0_133ck1480 FIND v(dout0_133) AT=745.025n

.meas tran vdout0_134ck1480 FIND v(dout0_134) AT=745.025n

.meas tran vdout0_135ck1480 FIND v(dout0_135) AT=745.025n

.meas tran vdout0_136ck1480 FIND v(dout0_136) AT=745.025n

.meas tran vdout0_137ck1480 FIND v(dout0_137) AT=745.025n

.meas tran vdout0_138ck1480 FIND v(dout0_138) AT=745.025n

.meas tran vdout0_139ck1480 FIND v(dout0_139) AT=745.025n

.meas tran vdout0_140ck1480 FIND v(dout0_140) AT=745.025n

.meas tran vdout0_141ck1480 FIND v(dout0_141) AT=745.025n

.meas tran vdout0_142ck1480 FIND v(dout0_142) AT=745.025n

.meas tran vdout0_143ck1480 FIND v(dout0_143) AT=745.025n

.meas tran vdout0_144ck1480 FIND v(dout0_144) AT=745.025n

.meas tran vdout0_145ck1480 FIND v(dout0_145) AT=745.025n

.meas tran vdout0_146ck1480 FIND v(dout0_146) AT=745.025n

.meas tran vdout0_147ck1480 FIND v(dout0_147) AT=745.025n

.meas tran vdout0_148ck1480 FIND v(dout0_148) AT=745.025n

.meas tran vdout0_149ck1480 FIND v(dout0_149) AT=745.025n

.meas tran vdout0_150ck1480 FIND v(dout0_150) AT=745.025n

.meas tran vdout0_151ck1480 FIND v(dout0_151) AT=745.025n

.meas tran vdout0_152ck1480 FIND v(dout0_152) AT=745.025n

.meas tran vdout0_153ck1480 FIND v(dout0_153) AT=745.025n

.meas tran vdout0_154ck1480 FIND v(dout0_154) AT=745.025n

.meas tran vdout0_155ck1480 FIND v(dout0_155) AT=745.025n

.meas tran vdout0_156ck1480 FIND v(dout0_156) AT=745.025n

.meas tran vdout0_157ck1480 FIND v(dout0_157) AT=745.025n

.meas tran vdout0_158ck1480 FIND v(dout0_158) AT=745.025n

.meas tran vdout0_159ck1480 FIND v(dout0_159) AT=745.025n

.meas tran vdout0_160ck1480 FIND v(dout0_160) AT=745.025n

.meas tran vdout0_161ck1480 FIND v(dout0_161) AT=745.025n

.meas tran vdout0_162ck1480 FIND v(dout0_162) AT=745.025n

.meas tran vdout0_163ck1480 FIND v(dout0_163) AT=745.025n

.meas tran vdout0_164ck1480 FIND v(dout0_164) AT=745.025n

.meas tran vdout0_165ck1480 FIND v(dout0_165) AT=745.025n

.meas tran vdout0_166ck1480 FIND v(dout0_166) AT=745.025n

.meas tran vdout0_167ck1480 FIND v(dout0_167) AT=745.025n

.meas tran vdout0_168ck1480 FIND v(dout0_168) AT=745.025n

.meas tran vdout0_169ck1480 FIND v(dout0_169) AT=745.025n

.meas tran vdout0_170ck1480 FIND v(dout0_170) AT=745.025n

.meas tran vdout0_171ck1480 FIND v(dout0_171) AT=745.025n

.meas tran vdout0_172ck1480 FIND v(dout0_172) AT=745.025n

.meas tran vdout0_173ck1480 FIND v(dout0_173) AT=745.025n

.meas tran vdout0_174ck1480 FIND v(dout0_174) AT=745.025n

.meas tran vdout0_175ck1480 FIND v(dout0_175) AT=745.025n

.meas tran vdout0_176ck1480 FIND v(dout0_176) AT=745.025n

.meas tran vdout0_177ck1480 FIND v(dout0_177) AT=745.025n

.meas tran vdout0_178ck1480 FIND v(dout0_178) AT=745.025n

.meas tran vdout0_179ck1480 FIND v(dout0_179) AT=745.025n

.meas tran vdout0_180ck1480 FIND v(dout0_180) AT=745.025n

.meas tran vdout0_181ck1480 FIND v(dout0_181) AT=745.025n

.meas tran vdout0_182ck1480 FIND v(dout0_182) AT=745.025n

.meas tran vdout0_183ck1480 FIND v(dout0_183) AT=745.025n

.meas tran vdout0_184ck1480 FIND v(dout0_184) AT=745.025n

.meas tran vdout0_185ck1480 FIND v(dout0_185) AT=745.025n

.meas tran vdout0_186ck1480 FIND v(dout0_186) AT=745.025n

.meas tran vdout0_187ck1480 FIND v(dout0_187) AT=745.025n

.meas tran vdout0_188ck1480 FIND v(dout0_188) AT=745.025n

.meas tran vdout0_189ck1480 FIND v(dout0_189) AT=745.025n

.meas tran vdout0_190ck1480 FIND v(dout0_190) AT=745.025n

.meas tran vdout0_191ck1480 FIND v(dout0_191) AT=745.025n

.meas tran vdout0_192ck1480 FIND v(dout0_192) AT=745.025n

.meas tran vdout0_193ck1480 FIND v(dout0_193) AT=745.025n

.meas tran vdout0_194ck1480 FIND v(dout0_194) AT=745.025n

.meas tran vdout0_195ck1480 FIND v(dout0_195) AT=745.025n

.meas tran vdout0_196ck1480 FIND v(dout0_196) AT=745.025n

.meas tran vdout0_197ck1480 FIND v(dout0_197) AT=745.025n

.meas tran vdout0_198ck1480 FIND v(dout0_198) AT=745.025n

.meas tran vdout0_199ck1480 FIND v(dout0_199) AT=745.025n

.meas tran vdout0_200ck1480 FIND v(dout0_200) AT=745.025n

.meas tran vdout0_201ck1480 FIND v(dout0_201) AT=745.025n

.meas tran vdout0_202ck1480 FIND v(dout0_202) AT=745.025n

.meas tran vdout0_203ck1480 FIND v(dout0_203) AT=745.025n

.meas tran vdout0_204ck1480 FIND v(dout0_204) AT=745.025n

.meas tran vdout0_205ck1480 FIND v(dout0_205) AT=745.025n

.meas tran vdout0_206ck1480 FIND v(dout0_206) AT=745.025n

.meas tran vdout0_207ck1480 FIND v(dout0_207) AT=745.025n

.meas tran vdout0_208ck1480 FIND v(dout0_208) AT=745.025n

.meas tran vdout0_209ck1480 FIND v(dout0_209) AT=745.025n

.meas tran vdout0_210ck1480 FIND v(dout0_210) AT=745.025n

.meas tran vdout0_211ck1480 FIND v(dout0_211) AT=745.025n

.meas tran vdout0_212ck1480 FIND v(dout0_212) AT=745.025n

.meas tran vdout0_213ck1480 FIND v(dout0_213) AT=745.025n

.meas tran vdout0_214ck1480 FIND v(dout0_214) AT=745.025n

.meas tran vdout0_215ck1480 FIND v(dout0_215) AT=745.025n

.meas tran vdout0_216ck1480 FIND v(dout0_216) AT=745.025n

.meas tran vdout0_217ck1480 FIND v(dout0_217) AT=745.025n

.meas tran vdout0_218ck1480 FIND v(dout0_218) AT=745.025n

.meas tran vdout0_219ck1480 FIND v(dout0_219) AT=745.025n

.meas tran vdout0_220ck1480 FIND v(dout0_220) AT=745.025n

.meas tran vdout0_221ck1480 FIND v(dout0_221) AT=745.025n

.meas tran vdout0_222ck1480 FIND v(dout0_222) AT=745.025n

.meas tran vdout0_223ck1480 FIND v(dout0_223) AT=745.025n

.meas tran vdout0_224ck1480 FIND v(dout0_224) AT=745.025n

.meas tran vdout0_225ck1480 FIND v(dout0_225) AT=745.025n

.meas tran vdout0_226ck1480 FIND v(dout0_226) AT=745.025n

.meas tran vdout0_227ck1480 FIND v(dout0_227) AT=745.025n

.meas tran vdout0_228ck1480 FIND v(dout0_228) AT=745.025n

.meas tran vdout0_229ck1480 FIND v(dout0_229) AT=745.025n

.meas tran vdout0_230ck1480 FIND v(dout0_230) AT=745.025n

.meas tran vdout0_231ck1480 FIND v(dout0_231) AT=745.025n

.meas tran vdout0_232ck1480 FIND v(dout0_232) AT=745.025n

.meas tran vdout0_233ck1480 FIND v(dout0_233) AT=745.025n

.meas tran vdout0_234ck1480 FIND v(dout0_234) AT=745.025n

.meas tran vdout0_235ck1480 FIND v(dout0_235) AT=745.025n

.meas tran vdout0_236ck1480 FIND v(dout0_236) AT=745.025n

.meas tran vdout0_237ck1480 FIND v(dout0_237) AT=745.025n

.meas tran vdout0_238ck1480 FIND v(dout0_238) AT=745.025n

.meas tran vdout0_239ck1480 FIND v(dout0_239) AT=745.025n

.meas tran vdout0_240ck1480 FIND v(dout0_240) AT=745.025n

.meas tran vdout0_241ck1480 FIND v(dout0_241) AT=745.025n

.meas tran vdout0_242ck1480 FIND v(dout0_242) AT=745.025n

.meas tran vdout0_243ck1480 FIND v(dout0_243) AT=745.025n

.meas tran vdout0_244ck1480 FIND v(dout0_244) AT=745.025n

.meas tran vdout0_245ck1480 FIND v(dout0_245) AT=745.025n

.meas tran vdout0_246ck1480 FIND v(dout0_246) AT=745.025n

.meas tran vdout0_247ck1480 FIND v(dout0_247) AT=745.025n

.meas tran vdout0_248ck1480 FIND v(dout0_248) AT=745.025n

.meas tran vdout0_249ck1480 FIND v(dout0_249) AT=745.025n

.meas tran vdout0_250ck1480 FIND v(dout0_250) AT=745.025n

.meas tran vdout0_251ck1480 FIND v(dout0_251) AT=745.025n

.meas tran vdout0_252ck1480 FIND v(dout0_252) AT=745.025n

.meas tran vdout0_253ck1480 FIND v(dout0_253) AT=745.025n

.meas tran vdout0_254ck1480 FIND v(dout0_254) AT=745.025n

.meas tran vdout0_255ck1480 FIND v(dout0_255) AT=745.025n

.meas tran vdout0_0ck1490 FIND v(dout0_0) AT=750.025n

.meas tran vdout0_1ck1490 FIND v(dout0_1) AT=750.025n

.meas tran vdout0_2ck1490 FIND v(dout0_2) AT=750.025n

.meas tran vdout0_3ck1490 FIND v(dout0_3) AT=750.025n

.meas tran vdout0_4ck1490 FIND v(dout0_4) AT=750.025n

.meas tran vdout0_5ck1490 FIND v(dout0_5) AT=750.025n

.meas tran vdout0_6ck1490 FIND v(dout0_6) AT=750.025n

.meas tran vdout0_7ck1490 FIND v(dout0_7) AT=750.025n

.meas tran vdout0_8ck1490 FIND v(dout0_8) AT=750.025n

.meas tran vdout0_9ck1490 FIND v(dout0_9) AT=750.025n

.meas tran vdout0_10ck1490 FIND v(dout0_10) AT=750.025n

.meas tran vdout0_11ck1490 FIND v(dout0_11) AT=750.025n

.meas tran vdout0_12ck1490 FIND v(dout0_12) AT=750.025n

.meas tran vdout0_13ck1490 FIND v(dout0_13) AT=750.025n

.meas tran vdout0_14ck1490 FIND v(dout0_14) AT=750.025n

.meas tran vdout0_15ck1490 FIND v(dout0_15) AT=750.025n

.meas tran vdout0_16ck1490 FIND v(dout0_16) AT=750.025n

.meas tran vdout0_17ck1490 FIND v(dout0_17) AT=750.025n

.meas tran vdout0_18ck1490 FIND v(dout0_18) AT=750.025n

.meas tran vdout0_19ck1490 FIND v(dout0_19) AT=750.025n

.meas tran vdout0_20ck1490 FIND v(dout0_20) AT=750.025n

.meas tran vdout0_21ck1490 FIND v(dout0_21) AT=750.025n

.meas tran vdout0_22ck1490 FIND v(dout0_22) AT=750.025n

.meas tran vdout0_23ck1490 FIND v(dout0_23) AT=750.025n

.meas tran vdout0_24ck1490 FIND v(dout0_24) AT=750.025n

.meas tran vdout0_25ck1490 FIND v(dout0_25) AT=750.025n

.meas tran vdout0_26ck1490 FIND v(dout0_26) AT=750.025n

.meas tran vdout0_27ck1490 FIND v(dout0_27) AT=750.025n

.meas tran vdout0_28ck1490 FIND v(dout0_28) AT=750.025n

.meas tran vdout0_29ck1490 FIND v(dout0_29) AT=750.025n

.meas tran vdout0_30ck1490 FIND v(dout0_30) AT=750.025n

.meas tran vdout0_31ck1490 FIND v(dout0_31) AT=750.025n

.meas tran vdout0_32ck1490 FIND v(dout0_32) AT=750.025n

.meas tran vdout0_33ck1490 FIND v(dout0_33) AT=750.025n

.meas tran vdout0_34ck1490 FIND v(dout0_34) AT=750.025n

.meas tran vdout0_35ck1490 FIND v(dout0_35) AT=750.025n

.meas tran vdout0_36ck1490 FIND v(dout0_36) AT=750.025n

.meas tran vdout0_37ck1490 FIND v(dout0_37) AT=750.025n

.meas tran vdout0_38ck1490 FIND v(dout0_38) AT=750.025n

.meas tran vdout0_39ck1490 FIND v(dout0_39) AT=750.025n

.meas tran vdout0_40ck1490 FIND v(dout0_40) AT=750.025n

.meas tran vdout0_41ck1490 FIND v(dout0_41) AT=750.025n

.meas tran vdout0_42ck1490 FIND v(dout0_42) AT=750.025n

.meas tran vdout0_43ck1490 FIND v(dout0_43) AT=750.025n

.meas tran vdout0_44ck1490 FIND v(dout0_44) AT=750.025n

.meas tran vdout0_45ck1490 FIND v(dout0_45) AT=750.025n

.meas tran vdout0_46ck1490 FIND v(dout0_46) AT=750.025n

.meas tran vdout0_47ck1490 FIND v(dout0_47) AT=750.025n

.meas tran vdout0_48ck1490 FIND v(dout0_48) AT=750.025n

.meas tran vdout0_49ck1490 FIND v(dout0_49) AT=750.025n

.meas tran vdout0_50ck1490 FIND v(dout0_50) AT=750.025n

.meas tran vdout0_51ck1490 FIND v(dout0_51) AT=750.025n

.meas tran vdout0_52ck1490 FIND v(dout0_52) AT=750.025n

.meas tran vdout0_53ck1490 FIND v(dout0_53) AT=750.025n

.meas tran vdout0_54ck1490 FIND v(dout0_54) AT=750.025n

.meas tran vdout0_55ck1490 FIND v(dout0_55) AT=750.025n

.meas tran vdout0_56ck1490 FIND v(dout0_56) AT=750.025n

.meas tran vdout0_57ck1490 FIND v(dout0_57) AT=750.025n

.meas tran vdout0_58ck1490 FIND v(dout0_58) AT=750.025n

.meas tran vdout0_59ck1490 FIND v(dout0_59) AT=750.025n

.meas tran vdout0_60ck1490 FIND v(dout0_60) AT=750.025n

.meas tran vdout0_61ck1490 FIND v(dout0_61) AT=750.025n

.meas tran vdout0_62ck1490 FIND v(dout0_62) AT=750.025n

.meas tran vdout0_63ck1490 FIND v(dout0_63) AT=750.025n

.meas tran vdout0_64ck1490 FIND v(dout0_64) AT=750.025n

.meas tran vdout0_65ck1490 FIND v(dout0_65) AT=750.025n

.meas tran vdout0_66ck1490 FIND v(dout0_66) AT=750.025n

.meas tran vdout0_67ck1490 FIND v(dout0_67) AT=750.025n

.meas tran vdout0_68ck1490 FIND v(dout0_68) AT=750.025n

.meas tran vdout0_69ck1490 FIND v(dout0_69) AT=750.025n

.meas tran vdout0_70ck1490 FIND v(dout0_70) AT=750.025n

.meas tran vdout0_71ck1490 FIND v(dout0_71) AT=750.025n

.meas tran vdout0_72ck1490 FIND v(dout0_72) AT=750.025n

.meas tran vdout0_73ck1490 FIND v(dout0_73) AT=750.025n

.meas tran vdout0_74ck1490 FIND v(dout0_74) AT=750.025n

.meas tran vdout0_75ck1490 FIND v(dout0_75) AT=750.025n

.meas tran vdout0_76ck1490 FIND v(dout0_76) AT=750.025n

.meas tran vdout0_77ck1490 FIND v(dout0_77) AT=750.025n

.meas tran vdout0_78ck1490 FIND v(dout0_78) AT=750.025n

.meas tran vdout0_79ck1490 FIND v(dout0_79) AT=750.025n

.meas tran vdout0_80ck1490 FIND v(dout0_80) AT=750.025n

.meas tran vdout0_81ck1490 FIND v(dout0_81) AT=750.025n

.meas tran vdout0_82ck1490 FIND v(dout0_82) AT=750.025n

.meas tran vdout0_83ck1490 FIND v(dout0_83) AT=750.025n

.meas tran vdout0_84ck1490 FIND v(dout0_84) AT=750.025n

.meas tran vdout0_85ck1490 FIND v(dout0_85) AT=750.025n

.meas tran vdout0_86ck1490 FIND v(dout0_86) AT=750.025n

.meas tran vdout0_87ck1490 FIND v(dout0_87) AT=750.025n

.meas tran vdout0_88ck1490 FIND v(dout0_88) AT=750.025n

.meas tran vdout0_89ck1490 FIND v(dout0_89) AT=750.025n

.meas tran vdout0_90ck1490 FIND v(dout0_90) AT=750.025n

.meas tran vdout0_91ck1490 FIND v(dout0_91) AT=750.025n

.meas tran vdout0_92ck1490 FIND v(dout0_92) AT=750.025n

.meas tran vdout0_93ck1490 FIND v(dout0_93) AT=750.025n

.meas tran vdout0_94ck1490 FIND v(dout0_94) AT=750.025n

.meas tran vdout0_95ck1490 FIND v(dout0_95) AT=750.025n

.meas tran vdout0_96ck1490 FIND v(dout0_96) AT=750.025n

.meas tran vdout0_97ck1490 FIND v(dout0_97) AT=750.025n

.meas tran vdout0_98ck1490 FIND v(dout0_98) AT=750.025n

.meas tran vdout0_99ck1490 FIND v(dout0_99) AT=750.025n

.meas tran vdout0_100ck1490 FIND v(dout0_100) AT=750.025n

.meas tran vdout0_101ck1490 FIND v(dout0_101) AT=750.025n

.meas tran vdout0_102ck1490 FIND v(dout0_102) AT=750.025n

.meas tran vdout0_103ck1490 FIND v(dout0_103) AT=750.025n

.meas tran vdout0_104ck1490 FIND v(dout0_104) AT=750.025n

.meas tran vdout0_105ck1490 FIND v(dout0_105) AT=750.025n

.meas tran vdout0_106ck1490 FIND v(dout0_106) AT=750.025n

.meas tran vdout0_107ck1490 FIND v(dout0_107) AT=750.025n

.meas tran vdout0_108ck1490 FIND v(dout0_108) AT=750.025n

.meas tran vdout0_109ck1490 FIND v(dout0_109) AT=750.025n

.meas tran vdout0_110ck1490 FIND v(dout0_110) AT=750.025n

.meas tran vdout0_111ck1490 FIND v(dout0_111) AT=750.025n

.meas tran vdout0_112ck1490 FIND v(dout0_112) AT=750.025n

.meas tran vdout0_113ck1490 FIND v(dout0_113) AT=750.025n

.meas tran vdout0_114ck1490 FIND v(dout0_114) AT=750.025n

.meas tran vdout0_115ck1490 FIND v(dout0_115) AT=750.025n

.meas tran vdout0_116ck1490 FIND v(dout0_116) AT=750.025n

.meas tran vdout0_117ck1490 FIND v(dout0_117) AT=750.025n

.meas tran vdout0_118ck1490 FIND v(dout0_118) AT=750.025n

.meas tran vdout0_119ck1490 FIND v(dout0_119) AT=750.025n

.meas tran vdout0_120ck1490 FIND v(dout0_120) AT=750.025n

.meas tran vdout0_121ck1490 FIND v(dout0_121) AT=750.025n

.meas tran vdout0_122ck1490 FIND v(dout0_122) AT=750.025n

.meas tran vdout0_123ck1490 FIND v(dout0_123) AT=750.025n

.meas tran vdout0_124ck1490 FIND v(dout0_124) AT=750.025n

.meas tran vdout0_125ck1490 FIND v(dout0_125) AT=750.025n

.meas tran vdout0_126ck1490 FIND v(dout0_126) AT=750.025n

.meas tran vdout0_127ck1490 FIND v(dout0_127) AT=750.025n

.meas tran vdout0_128ck1490 FIND v(dout0_128) AT=750.025n

.meas tran vdout0_129ck1490 FIND v(dout0_129) AT=750.025n

.meas tran vdout0_130ck1490 FIND v(dout0_130) AT=750.025n

.meas tran vdout0_131ck1490 FIND v(dout0_131) AT=750.025n

.meas tran vdout0_132ck1490 FIND v(dout0_132) AT=750.025n

.meas tran vdout0_133ck1490 FIND v(dout0_133) AT=750.025n

.meas tran vdout0_134ck1490 FIND v(dout0_134) AT=750.025n

.meas tran vdout0_135ck1490 FIND v(dout0_135) AT=750.025n

.meas tran vdout0_136ck1490 FIND v(dout0_136) AT=750.025n

.meas tran vdout0_137ck1490 FIND v(dout0_137) AT=750.025n

.meas tran vdout0_138ck1490 FIND v(dout0_138) AT=750.025n

.meas tran vdout0_139ck1490 FIND v(dout0_139) AT=750.025n

.meas tran vdout0_140ck1490 FIND v(dout0_140) AT=750.025n

.meas tran vdout0_141ck1490 FIND v(dout0_141) AT=750.025n

.meas tran vdout0_142ck1490 FIND v(dout0_142) AT=750.025n

.meas tran vdout0_143ck1490 FIND v(dout0_143) AT=750.025n

.meas tran vdout0_144ck1490 FIND v(dout0_144) AT=750.025n

.meas tran vdout0_145ck1490 FIND v(dout0_145) AT=750.025n

.meas tran vdout0_146ck1490 FIND v(dout0_146) AT=750.025n

.meas tran vdout0_147ck1490 FIND v(dout0_147) AT=750.025n

.meas tran vdout0_148ck1490 FIND v(dout0_148) AT=750.025n

.meas tran vdout0_149ck1490 FIND v(dout0_149) AT=750.025n

.meas tran vdout0_150ck1490 FIND v(dout0_150) AT=750.025n

.meas tran vdout0_151ck1490 FIND v(dout0_151) AT=750.025n

.meas tran vdout0_152ck1490 FIND v(dout0_152) AT=750.025n

.meas tran vdout0_153ck1490 FIND v(dout0_153) AT=750.025n

.meas tran vdout0_154ck1490 FIND v(dout0_154) AT=750.025n

.meas tran vdout0_155ck1490 FIND v(dout0_155) AT=750.025n

.meas tran vdout0_156ck1490 FIND v(dout0_156) AT=750.025n

.meas tran vdout0_157ck1490 FIND v(dout0_157) AT=750.025n

.meas tran vdout0_158ck1490 FIND v(dout0_158) AT=750.025n

.meas tran vdout0_159ck1490 FIND v(dout0_159) AT=750.025n

.meas tran vdout0_160ck1490 FIND v(dout0_160) AT=750.025n

.meas tran vdout0_161ck1490 FIND v(dout0_161) AT=750.025n

.meas tran vdout0_162ck1490 FIND v(dout0_162) AT=750.025n

.meas tran vdout0_163ck1490 FIND v(dout0_163) AT=750.025n

.meas tran vdout0_164ck1490 FIND v(dout0_164) AT=750.025n

.meas tran vdout0_165ck1490 FIND v(dout0_165) AT=750.025n

.meas tran vdout0_166ck1490 FIND v(dout0_166) AT=750.025n

.meas tran vdout0_167ck1490 FIND v(dout0_167) AT=750.025n

.meas tran vdout0_168ck1490 FIND v(dout0_168) AT=750.025n

.meas tran vdout0_169ck1490 FIND v(dout0_169) AT=750.025n

.meas tran vdout0_170ck1490 FIND v(dout0_170) AT=750.025n

.meas tran vdout0_171ck1490 FIND v(dout0_171) AT=750.025n

.meas tran vdout0_172ck1490 FIND v(dout0_172) AT=750.025n

.meas tran vdout0_173ck1490 FIND v(dout0_173) AT=750.025n

.meas tran vdout0_174ck1490 FIND v(dout0_174) AT=750.025n

.meas tran vdout0_175ck1490 FIND v(dout0_175) AT=750.025n

.meas tran vdout0_176ck1490 FIND v(dout0_176) AT=750.025n

.meas tran vdout0_177ck1490 FIND v(dout0_177) AT=750.025n

.meas tran vdout0_178ck1490 FIND v(dout0_178) AT=750.025n

.meas tran vdout0_179ck1490 FIND v(dout0_179) AT=750.025n

.meas tran vdout0_180ck1490 FIND v(dout0_180) AT=750.025n

.meas tran vdout0_181ck1490 FIND v(dout0_181) AT=750.025n

.meas tran vdout0_182ck1490 FIND v(dout0_182) AT=750.025n

.meas tran vdout0_183ck1490 FIND v(dout0_183) AT=750.025n

.meas tran vdout0_184ck1490 FIND v(dout0_184) AT=750.025n

.meas tran vdout0_185ck1490 FIND v(dout0_185) AT=750.025n

.meas tran vdout0_186ck1490 FIND v(dout0_186) AT=750.025n

.meas tran vdout0_187ck1490 FIND v(dout0_187) AT=750.025n

.meas tran vdout0_188ck1490 FIND v(dout0_188) AT=750.025n

.meas tran vdout0_189ck1490 FIND v(dout0_189) AT=750.025n

.meas tran vdout0_190ck1490 FIND v(dout0_190) AT=750.025n

.meas tran vdout0_191ck1490 FIND v(dout0_191) AT=750.025n

.meas tran vdout0_192ck1490 FIND v(dout0_192) AT=750.025n

.meas tran vdout0_193ck1490 FIND v(dout0_193) AT=750.025n

.meas tran vdout0_194ck1490 FIND v(dout0_194) AT=750.025n

.meas tran vdout0_195ck1490 FIND v(dout0_195) AT=750.025n

.meas tran vdout0_196ck1490 FIND v(dout0_196) AT=750.025n

.meas tran vdout0_197ck1490 FIND v(dout0_197) AT=750.025n

.meas tran vdout0_198ck1490 FIND v(dout0_198) AT=750.025n

.meas tran vdout0_199ck1490 FIND v(dout0_199) AT=750.025n

.meas tran vdout0_200ck1490 FIND v(dout0_200) AT=750.025n

.meas tran vdout0_201ck1490 FIND v(dout0_201) AT=750.025n

.meas tran vdout0_202ck1490 FIND v(dout0_202) AT=750.025n

.meas tran vdout0_203ck1490 FIND v(dout0_203) AT=750.025n

.meas tran vdout0_204ck1490 FIND v(dout0_204) AT=750.025n

.meas tran vdout0_205ck1490 FIND v(dout0_205) AT=750.025n

.meas tran vdout0_206ck1490 FIND v(dout0_206) AT=750.025n

.meas tran vdout0_207ck1490 FIND v(dout0_207) AT=750.025n

.meas tran vdout0_208ck1490 FIND v(dout0_208) AT=750.025n

.meas tran vdout0_209ck1490 FIND v(dout0_209) AT=750.025n

.meas tran vdout0_210ck1490 FIND v(dout0_210) AT=750.025n

.meas tran vdout0_211ck1490 FIND v(dout0_211) AT=750.025n

.meas tran vdout0_212ck1490 FIND v(dout0_212) AT=750.025n

.meas tran vdout0_213ck1490 FIND v(dout0_213) AT=750.025n

.meas tran vdout0_214ck1490 FIND v(dout0_214) AT=750.025n

.meas tran vdout0_215ck1490 FIND v(dout0_215) AT=750.025n

.meas tran vdout0_216ck1490 FIND v(dout0_216) AT=750.025n

.meas tran vdout0_217ck1490 FIND v(dout0_217) AT=750.025n

.meas tran vdout0_218ck1490 FIND v(dout0_218) AT=750.025n

.meas tran vdout0_219ck1490 FIND v(dout0_219) AT=750.025n

.meas tran vdout0_220ck1490 FIND v(dout0_220) AT=750.025n

.meas tran vdout0_221ck1490 FIND v(dout0_221) AT=750.025n

.meas tran vdout0_222ck1490 FIND v(dout0_222) AT=750.025n

.meas tran vdout0_223ck1490 FIND v(dout0_223) AT=750.025n

.meas tran vdout0_224ck1490 FIND v(dout0_224) AT=750.025n

.meas tran vdout0_225ck1490 FIND v(dout0_225) AT=750.025n

.meas tran vdout0_226ck1490 FIND v(dout0_226) AT=750.025n

.meas tran vdout0_227ck1490 FIND v(dout0_227) AT=750.025n

.meas tran vdout0_228ck1490 FIND v(dout0_228) AT=750.025n

.meas tran vdout0_229ck1490 FIND v(dout0_229) AT=750.025n

.meas tran vdout0_230ck1490 FIND v(dout0_230) AT=750.025n

.meas tran vdout0_231ck1490 FIND v(dout0_231) AT=750.025n

.meas tran vdout0_232ck1490 FIND v(dout0_232) AT=750.025n

.meas tran vdout0_233ck1490 FIND v(dout0_233) AT=750.025n

.meas tran vdout0_234ck1490 FIND v(dout0_234) AT=750.025n

.meas tran vdout0_235ck1490 FIND v(dout0_235) AT=750.025n

.meas tran vdout0_236ck1490 FIND v(dout0_236) AT=750.025n

.meas tran vdout0_237ck1490 FIND v(dout0_237) AT=750.025n

.meas tran vdout0_238ck1490 FIND v(dout0_238) AT=750.025n

.meas tran vdout0_239ck1490 FIND v(dout0_239) AT=750.025n

.meas tran vdout0_240ck1490 FIND v(dout0_240) AT=750.025n

.meas tran vdout0_241ck1490 FIND v(dout0_241) AT=750.025n

.meas tran vdout0_242ck1490 FIND v(dout0_242) AT=750.025n

.meas tran vdout0_243ck1490 FIND v(dout0_243) AT=750.025n

.meas tran vdout0_244ck1490 FIND v(dout0_244) AT=750.025n

.meas tran vdout0_245ck1490 FIND v(dout0_245) AT=750.025n

.meas tran vdout0_246ck1490 FIND v(dout0_246) AT=750.025n

.meas tran vdout0_247ck1490 FIND v(dout0_247) AT=750.025n

.meas tran vdout0_248ck1490 FIND v(dout0_248) AT=750.025n

.meas tran vdout0_249ck1490 FIND v(dout0_249) AT=750.025n

.meas tran vdout0_250ck1490 FIND v(dout0_250) AT=750.025n

.meas tran vdout0_251ck1490 FIND v(dout0_251) AT=750.025n

.meas tran vdout0_252ck1490 FIND v(dout0_252) AT=750.025n

.meas tran vdout0_253ck1490 FIND v(dout0_253) AT=750.025n

.meas tran vdout0_254ck1490 FIND v(dout0_254) AT=750.025n

.meas tran vdout0_255ck1490 FIND v(dout0_255) AT=750.025n

.meas tran vdout0_0ck1520 FIND v(dout0_0) AT=765.025n

.meas tran vdout0_1ck1520 FIND v(dout0_1) AT=765.025n

.meas tran vdout0_2ck1520 FIND v(dout0_2) AT=765.025n

.meas tran vdout0_3ck1520 FIND v(dout0_3) AT=765.025n

.meas tran vdout0_4ck1520 FIND v(dout0_4) AT=765.025n

.meas tran vdout0_5ck1520 FIND v(dout0_5) AT=765.025n

.meas tran vdout0_6ck1520 FIND v(dout0_6) AT=765.025n

.meas tran vdout0_7ck1520 FIND v(dout0_7) AT=765.025n

.meas tran vdout0_8ck1520 FIND v(dout0_8) AT=765.025n

.meas tran vdout0_9ck1520 FIND v(dout0_9) AT=765.025n

.meas tran vdout0_10ck1520 FIND v(dout0_10) AT=765.025n

.meas tran vdout0_11ck1520 FIND v(dout0_11) AT=765.025n

.meas tran vdout0_12ck1520 FIND v(dout0_12) AT=765.025n

.meas tran vdout0_13ck1520 FIND v(dout0_13) AT=765.025n

.meas tran vdout0_14ck1520 FIND v(dout0_14) AT=765.025n

.meas tran vdout0_15ck1520 FIND v(dout0_15) AT=765.025n

.meas tran vdout0_16ck1520 FIND v(dout0_16) AT=765.025n

.meas tran vdout0_17ck1520 FIND v(dout0_17) AT=765.025n

.meas tran vdout0_18ck1520 FIND v(dout0_18) AT=765.025n

.meas tran vdout0_19ck1520 FIND v(dout0_19) AT=765.025n

.meas tran vdout0_20ck1520 FIND v(dout0_20) AT=765.025n

.meas tran vdout0_21ck1520 FIND v(dout0_21) AT=765.025n

.meas tran vdout0_22ck1520 FIND v(dout0_22) AT=765.025n

.meas tran vdout0_23ck1520 FIND v(dout0_23) AT=765.025n

.meas tran vdout0_24ck1520 FIND v(dout0_24) AT=765.025n

.meas tran vdout0_25ck1520 FIND v(dout0_25) AT=765.025n

.meas tran vdout0_26ck1520 FIND v(dout0_26) AT=765.025n

.meas tran vdout0_27ck1520 FIND v(dout0_27) AT=765.025n

.meas tran vdout0_28ck1520 FIND v(dout0_28) AT=765.025n

.meas tran vdout0_29ck1520 FIND v(dout0_29) AT=765.025n

.meas tran vdout0_30ck1520 FIND v(dout0_30) AT=765.025n

.meas tran vdout0_31ck1520 FIND v(dout0_31) AT=765.025n

.meas tran vdout0_32ck1520 FIND v(dout0_32) AT=765.025n

.meas tran vdout0_33ck1520 FIND v(dout0_33) AT=765.025n

.meas tran vdout0_34ck1520 FIND v(dout0_34) AT=765.025n

.meas tran vdout0_35ck1520 FIND v(dout0_35) AT=765.025n

.meas tran vdout0_36ck1520 FIND v(dout0_36) AT=765.025n

.meas tran vdout0_37ck1520 FIND v(dout0_37) AT=765.025n

.meas tran vdout0_38ck1520 FIND v(dout0_38) AT=765.025n

.meas tran vdout0_39ck1520 FIND v(dout0_39) AT=765.025n

.meas tran vdout0_40ck1520 FIND v(dout0_40) AT=765.025n

.meas tran vdout0_41ck1520 FIND v(dout0_41) AT=765.025n

.meas tran vdout0_42ck1520 FIND v(dout0_42) AT=765.025n

.meas tran vdout0_43ck1520 FIND v(dout0_43) AT=765.025n

.meas tran vdout0_44ck1520 FIND v(dout0_44) AT=765.025n

.meas tran vdout0_45ck1520 FIND v(dout0_45) AT=765.025n

.meas tran vdout0_46ck1520 FIND v(dout0_46) AT=765.025n

.meas tran vdout0_47ck1520 FIND v(dout0_47) AT=765.025n

.meas tran vdout0_48ck1520 FIND v(dout0_48) AT=765.025n

.meas tran vdout0_49ck1520 FIND v(dout0_49) AT=765.025n

.meas tran vdout0_50ck1520 FIND v(dout0_50) AT=765.025n

.meas tran vdout0_51ck1520 FIND v(dout0_51) AT=765.025n

.meas tran vdout0_52ck1520 FIND v(dout0_52) AT=765.025n

.meas tran vdout0_53ck1520 FIND v(dout0_53) AT=765.025n

.meas tran vdout0_54ck1520 FIND v(dout0_54) AT=765.025n

.meas tran vdout0_55ck1520 FIND v(dout0_55) AT=765.025n

.meas tran vdout0_56ck1520 FIND v(dout0_56) AT=765.025n

.meas tran vdout0_57ck1520 FIND v(dout0_57) AT=765.025n

.meas tran vdout0_58ck1520 FIND v(dout0_58) AT=765.025n

.meas tran vdout0_59ck1520 FIND v(dout0_59) AT=765.025n

.meas tran vdout0_60ck1520 FIND v(dout0_60) AT=765.025n

.meas tran vdout0_61ck1520 FIND v(dout0_61) AT=765.025n

.meas tran vdout0_62ck1520 FIND v(dout0_62) AT=765.025n

.meas tran vdout0_63ck1520 FIND v(dout0_63) AT=765.025n

.meas tran vdout0_64ck1520 FIND v(dout0_64) AT=765.025n

.meas tran vdout0_65ck1520 FIND v(dout0_65) AT=765.025n

.meas tran vdout0_66ck1520 FIND v(dout0_66) AT=765.025n

.meas tran vdout0_67ck1520 FIND v(dout0_67) AT=765.025n

.meas tran vdout0_68ck1520 FIND v(dout0_68) AT=765.025n

.meas tran vdout0_69ck1520 FIND v(dout0_69) AT=765.025n

.meas tran vdout0_70ck1520 FIND v(dout0_70) AT=765.025n

.meas tran vdout0_71ck1520 FIND v(dout0_71) AT=765.025n

.meas tran vdout0_72ck1520 FIND v(dout0_72) AT=765.025n

.meas tran vdout0_73ck1520 FIND v(dout0_73) AT=765.025n

.meas tran vdout0_74ck1520 FIND v(dout0_74) AT=765.025n

.meas tran vdout0_75ck1520 FIND v(dout0_75) AT=765.025n

.meas tran vdout0_76ck1520 FIND v(dout0_76) AT=765.025n

.meas tran vdout0_77ck1520 FIND v(dout0_77) AT=765.025n

.meas tran vdout0_78ck1520 FIND v(dout0_78) AT=765.025n

.meas tran vdout0_79ck1520 FIND v(dout0_79) AT=765.025n

.meas tran vdout0_80ck1520 FIND v(dout0_80) AT=765.025n

.meas tran vdout0_81ck1520 FIND v(dout0_81) AT=765.025n

.meas tran vdout0_82ck1520 FIND v(dout0_82) AT=765.025n

.meas tran vdout0_83ck1520 FIND v(dout0_83) AT=765.025n

.meas tran vdout0_84ck1520 FIND v(dout0_84) AT=765.025n

.meas tran vdout0_85ck1520 FIND v(dout0_85) AT=765.025n

.meas tran vdout0_86ck1520 FIND v(dout0_86) AT=765.025n

.meas tran vdout0_87ck1520 FIND v(dout0_87) AT=765.025n

.meas tran vdout0_88ck1520 FIND v(dout0_88) AT=765.025n

.meas tran vdout0_89ck1520 FIND v(dout0_89) AT=765.025n

.meas tran vdout0_90ck1520 FIND v(dout0_90) AT=765.025n

.meas tran vdout0_91ck1520 FIND v(dout0_91) AT=765.025n

.meas tran vdout0_92ck1520 FIND v(dout0_92) AT=765.025n

.meas tran vdout0_93ck1520 FIND v(dout0_93) AT=765.025n

.meas tran vdout0_94ck1520 FIND v(dout0_94) AT=765.025n

.meas tran vdout0_95ck1520 FIND v(dout0_95) AT=765.025n

.meas tran vdout0_96ck1520 FIND v(dout0_96) AT=765.025n

.meas tran vdout0_97ck1520 FIND v(dout0_97) AT=765.025n

.meas tran vdout0_98ck1520 FIND v(dout0_98) AT=765.025n

.meas tran vdout0_99ck1520 FIND v(dout0_99) AT=765.025n

.meas tran vdout0_100ck1520 FIND v(dout0_100) AT=765.025n

.meas tran vdout0_101ck1520 FIND v(dout0_101) AT=765.025n

.meas tran vdout0_102ck1520 FIND v(dout0_102) AT=765.025n

.meas tran vdout0_103ck1520 FIND v(dout0_103) AT=765.025n

.meas tran vdout0_104ck1520 FIND v(dout0_104) AT=765.025n

.meas tran vdout0_105ck1520 FIND v(dout0_105) AT=765.025n

.meas tran vdout0_106ck1520 FIND v(dout0_106) AT=765.025n

.meas tran vdout0_107ck1520 FIND v(dout0_107) AT=765.025n

.meas tran vdout0_108ck1520 FIND v(dout0_108) AT=765.025n

.meas tran vdout0_109ck1520 FIND v(dout0_109) AT=765.025n

.meas tran vdout0_110ck1520 FIND v(dout0_110) AT=765.025n

.meas tran vdout0_111ck1520 FIND v(dout0_111) AT=765.025n

.meas tran vdout0_112ck1520 FIND v(dout0_112) AT=765.025n

.meas tran vdout0_113ck1520 FIND v(dout0_113) AT=765.025n

.meas tran vdout0_114ck1520 FIND v(dout0_114) AT=765.025n

.meas tran vdout0_115ck1520 FIND v(dout0_115) AT=765.025n

.meas tran vdout0_116ck1520 FIND v(dout0_116) AT=765.025n

.meas tran vdout0_117ck1520 FIND v(dout0_117) AT=765.025n

.meas tran vdout0_118ck1520 FIND v(dout0_118) AT=765.025n

.meas tran vdout0_119ck1520 FIND v(dout0_119) AT=765.025n

.meas tran vdout0_120ck1520 FIND v(dout0_120) AT=765.025n

.meas tran vdout0_121ck1520 FIND v(dout0_121) AT=765.025n

.meas tran vdout0_122ck1520 FIND v(dout0_122) AT=765.025n

.meas tran vdout0_123ck1520 FIND v(dout0_123) AT=765.025n

.meas tran vdout0_124ck1520 FIND v(dout0_124) AT=765.025n

.meas tran vdout0_125ck1520 FIND v(dout0_125) AT=765.025n

.meas tran vdout0_126ck1520 FIND v(dout0_126) AT=765.025n

.meas tran vdout0_127ck1520 FIND v(dout0_127) AT=765.025n

.meas tran vdout0_128ck1520 FIND v(dout0_128) AT=765.025n

.meas tran vdout0_129ck1520 FIND v(dout0_129) AT=765.025n

.meas tran vdout0_130ck1520 FIND v(dout0_130) AT=765.025n

.meas tran vdout0_131ck1520 FIND v(dout0_131) AT=765.025n

.meas tran vdout0_132ck1520 FIND v(dout0_132) AT=765.025n

.meas tran vdout0_133ck1520 FIND v(dout0_133) AT=765.025n

.meas tran vdout0_134ck1520 FIND v(dout0_134) AT=765.025n

.meas tran vdout0_135ck1520 FIND v(dout0_135) AT=765.025n

.meas tran vdout0_136ck1520 FIND v(dout0_136) AT=765.025n

.meas tran vdout0_137ck1520 FIND v(dout0_137) AT=765.025n

.meas tran vdout0_138ck1520 FIND v(dout0_138) AT=765.025n

.meas tran vdout0_139ck1520 FIND v(dout0_139) AT=765.025n

.meas tran vdout0_140ck1520 FIND v(dout0_140) AT=765.025n

.meas tran vdout0_141ck1520 FIND v(dout0_141) AT=765.025n

.meas tran vdout0_142ck1520 FIND v(dout0_142) AT=765.025n

.meas tran vdout0_143ck1520 FIND v(dout0_143) AT=765.025n

.meas tran vdout0_144ck1520 FIND v(dout0_144) AT=765.025n

.meas tran vdout0_145ck1520 FIND v(dout0_145) AT=765.025n

.meas tran vdout0_146ck1520 FIND v(dout0_146) AT=765.025n

.meas tran vdout0_147ck1520 FIND v(dout0_147) AT=765.025n

.meas tran vdout0_148ck1520 FIND v(dout0_148) AT=765.025n

.meas tran vdout0_149ck1520 FIND v(dout0_149) AT=765.025n

.meas tran vdout0_150ck1520 FIND v(dout0_150) AT=765.025n

.meas tran vdout0_151ck1520 FIND v(dout0_151) AT=765.025n

.meas tran vdout0_152ck1520 FIND v(dout0_152) AT=765.025n

.meas tran vdout0_153ck1520 FIND v(dout0_153) AT=765.025n

.meas tran vdout0_154ck1520 FIND v(dout0_154) AT=765.025n

.meas tran vdout0_155ck1520 FIND v(dout0_155) AT=765.025n

.meas tran vdout0_156ck1520 FIND v(dout0_156) AT=765.025n

.meas tran vdout0_157ck1520 FIND v(dout0_157) AT=765.025n

.meas tran vdout0_158ck1520 FIND v(dout0_158) AT=765.025n

.meas tran vdout0_159ck1520 FIND v(dout0_159) AT=765.025n

.meas tran vdout0_160ck1520 FIND v(dout0_160) AT=765.025n

.meas tran vdout0_161ck1520 FIND v(dout0_161) AT=765.025n

.meas tran vdout0_162ck1520 FIND v(dout0_162) AT=765.025n

.meas tran vdout0_163ck1520 FIND v(dout0_163) AT=765.025n

.meas tran vdout0_164ck1520 FIND v(dout0_164) AT=765.025n

.meas tran vdout0_165ck1520 FIND v(dout0_165) AT=765.025n

.meas tran vdout0_166ck1520 FIND v(dout0_166) AT=765.025n

.meas tran vdout0_167ck1520 FIND v(dout0_167) AT=765.025n

.meas tran vdout0_168ck1520 FIND v(dout0_168) AT=765.025n

.meas tran vdout0_169ck1520 FIND v(dout0_169) AT=765.025n

.meas tran vdout0_170ck1520 FIND v(dout0_170) AT=765.025n

.meas tran vdout0_171ck1520 FIND v(dout0_171) AT=765.025n

.meas tran vdout0_172ck1520 FIND v(dout0_172) AT=765.025n

.meas tran vdout0_173ck1520 FIND v(dout0_173) AT=765.025n

.meas tran vdout0_174ck1520 FIND v(dout0_174) AT=765.025n

.meas tran vdout0_175ck1520 FIND v(dout0_175) AT=765.025n

.meas tran vdout0_176ck1520 FIND v(dout0_176) AT=765.025n

.meas tran vdout0_177ck1520 FIND v(dout0_177) AT=765.025n

.meas tran vdout0_178ck1520 FIND v(dout0_178) AT=765.025n

.meas tran vdout0_179ck1520 FIND v(dout0_179) AT=765.025n

.meas tran vdout0_180ck1520 FIND v(dout0_180) AT=765.025n

.meas tran vdout0_181ck1520 FIND v(dout0_181) AT=765.025n

.meas tran vdout0_182ck1520 FIND v(dout0_182) AT=765.025n

.meas tran vdout0_183ck1520 FIND v(dout0_183) AT=765.025n

.meas tran vdout0_184ck1520 FIND v(dout0_184) AT=765.025n

.meas tran vdout0_185ck1520 FIND v(dout0_185) AT=765.025n

.meas tran vdout0_186ck1520 FIND v(dout0_186) AT=765.025n

.meas tran vdout0_187ck1520 FIND v(dout0_187) AT=765.025n

.meas tran vdout0_188ck1520 FIND v(dout0_188) AT=765.025n

.meas tran vdout0_189ck1520 FIND v(dout0_189) AT=765.025n

.meas tran vdout0_190ck1520 FIND v(dout0_190) AT=765.025n

.meas tran vdout0_191ck1520 FIND v(dout0_191) AT=765.025n

.meas tran vdout0_192ck1520 FIND v(dout0_192) AT=765.025n

.meas tran vdout0_193ck1520 FIND v(dout0_193) AT=765.025n

.meas tran vdout0_194ck1520 FIND v(dout0_194) AT=765.025n

.meas tran vdout0_195ck1520 FIND v(dout0_195) AT=765.025n

.meas tran vdout0_196ck1520 FIND v(dout0_196) AT=765.025n

.meas tran vdout0_197ck1520 FIND v(dout0_197) AT=765.025n

.meas tran vdout0_198ck1520 FIND v(dout0_198) AT=765.025n

.meas tran vdout0_199ck1520 FIND v(dout0_199) AT=765.025n

.meas tran vdout0_200ck1520 FIND v(dout0_200) AT=765.025n

.meas tran vdout0_201ck1520 FIND v(dout0_201) AT=765.025n

.meas tran vdout0_202ck1520 FIND v(dout0_202) AT=765.025n

.meas tran vdout0_203ck1520 FIND v(dout0_203) AT=765.025n

.meas tran vdout0_204ck1520 FIND v(dout0_204) AT=765.025n

.meas tran vdout0_205ck1520 FIND v(dout0_205) AT=765.025n

.meas tran vdout0_206ck1520 FIND v(dout0_206) AT=765.025n

.meas tran vdout0_207ck1520 FIND v(dout0_207) AT=765.025n

.meas tran vdout0_208ck1520 FIND v(dout0_208) AT=765.025n

.meas tran vdout0_209ck1520 FIND v(dout0_209) AT=765.025n

.meas tran vdout0_210ck1520 FIND v(dout0_210) AT=765.025n

.meas tran vdout0_211ck1520 FIND v(dout0_211) AT=765.025n

.meas tran vdout0_212ck1520 FIND v(dout0_212) AT=765.025n

.meas tran vdout0_213ck1520 FIND v(dout0_213) AT=765.025n

.meas tran vdout0_214ck1520 FIND v(dout0_214) AT=765.025n

.meas tran vdout0_215ck1520 FIND v(dout0_215) AT=765.025n

.meas tran vdout0_216ck1520 FIND v(dout0_216) AT=765.025n

.meas tran vdout0_217ck1520 FIND v(dout0_217) AT=765.025n

.meas tran vdout0_218ck1520 FIND v(dout0_218) AT=765.025n

.meas tran vdout0_219ck1520 FIND v(dout0_219) AT=765.025n

.meas tran vdout0_220ck1520 FIND v(dout0_220) AT=765.025n

.meas tran vdout0_221ck1520 FIND v(dout0_221) AT=765.025n

.meas tran vdout0_222ck1520 FIND v(dout0_222) AT=765.025n

.meas tran vdout0_223ck1520 FIND v(dout0_223) AT=765.025n

.meas tran vdout0_224ck1520 FIND v(dout0_224) AT=765.025n

.meas tran vdout0_225ck1520 FIND v(dout0_225) AT=765.025n

.meas tran vdout0_226ck1520 FIND v(dout0_226) AT=765.025n

.meas tran vdout0_227ck1520 FIND v(dout0_227) AT=765.025n

.meas tran vdout0_228ck1520 FIND v(dout0_228) AT=765.025n

.meas tran vdout0_229ck1520 FIND v(dout0_229) AT=765.025n

.meas tran vdout0_230ck1520 FIND v(dout0_230) AT=765.025n

.meas tran vdout0_231ck1520 FIND v(dout0_231) AT=765.025n

.meas tran vdout0_232ck1520 FIND v(dout0_232) AT=765.025n

.meas tran vdout0_233ck1520 FIND v(dout0_233) AT=765.025n

.meas tran vdout0_234ck1520 FIND v(dout0_234) AT=765.025n

.meas tran vdout0_235ck1520 FIND v(dout0_235) AT=765.025n

.meas tran vdout0_236ck1520 FIND v(dout0_236) AT=765.025n

.meas tran vdout0_237ck1520 FIND v(dout0_237) AT=765.025n

.meas tran vdout0_238ck1520 FIND v(dout0_238) AT=765.025n

.meas tran vdout0_239ck1520 FIND v(dout0_239) AT=765.025n

.meas tran vdout0_240ck1520 FIND v(dout0_240) AT=765.025n

.meas tran vdout0_241ck1520 FIND v(dout0_241) AT=765.025n

.meas tran vdout0_242ck1520 FIND v(dout0_242) AT=765.025n

.meas tran vdout0_243ck1520 FIND v(dout0_243) AT=765.025n

.meas tran vdout0_244ck1520 FIND v(dout0_244) AT=765.025n

.meas tran vdout0_245ck1520 FIND v(dout0_245) AT=765.025n

.meas tran vdout0_246ck1520 FIND v(dout0_246) AT=765.025n

.meas tran vdout0_247ck1520 FIND v(dout0_247) AT=765.025n

.meas tran vdout0_248ck1520 FIND v(dout0_248) AT=765.025n

.meas tran vdout0_249ck1520 FIND v(dout0_249) AT=765.025n

.meas tran vdout0_250ck1520 FIND v(dout0_250) AT=765.025n

.meas tran vdout0_251ck1520 FIND v(dout0_251) AT=765.025n

.meas tran vdout0_252ck1520 FIND v(dout0_252) AT=765.025n

.meas tran vdout0_253ck1520 FIND v(dout0_253) AT=765.025n

.meas tran vdout0_254ck1520 FIND v(dout0_254) AT=765.025n

.meas tran vdout0_255ck1520 FIND v(dout0_255) AT=765.025n

.meas tran vdout0_0ck1530 FIND v(dout0_0) AT=770.025n

.meas tran vdout0_1ck1530 FIND v(dout0_1) AT=770.025n

.meas tran vdout0_2ck1530 FIND v(dout0_2) AT=770.025n

.meas tran vdout0_3ck1530 FIND v(dout0_3) AT=770.025n

.meas tran vdout0_4ck1530 FIND v(dout0_4) AT=770.025n

.meas tran vdout0_5ck1530 FIND v(dout0_5) AT=770.025n

.meas tran vdout0_6ck1530 FIND v(dout0_6) AT=770.025n

.meas tran vdout0_7ck1530 FIND v(dout0_7) AT=770.025n

.meas tran vdout0_8ck1530 FIND v(dout0_8) AT=770.025n

.meas tran vdout0_9ck1530 FIND v(dout0_9) AT=770.025n

.meas tran vdout0_10ck1530 FIND v(dout0_10) AT=770.025n

.meas tran vdout0_11ck1530 FIND v(dout0_11) AT=770.025n

.meas tran vdout0_12ck1530 FIND v(dout0_12) AT=770.025n

.meas tran vdout0_13ck1530 FIND v(dout0_13) AT=770.025n

.meas tran vdout0_14ck1530 FIND v(dout0_14) AT=770.025n

.meas tran vdout0_15ck1530 FIND v(dout0_15) AT=770.025n

.meas tran vdout0_16ck1530 FIND v(dout0_16) AT=770.025n

.meas tran vdout0_17ck1530 FIND v(dout0_17) AT=770.025n

.meas tran vdout0_18ck1530 FIND v(dout0_18) AT=770.025n

.meas tran vdout0_19ck1530 FIND v(dout0_19) AT=770.025n

.meas tran vdout0_20ck1530 FIND v(dout0_20) AT=770.025n

.meas tran vdout0_21ck1530 FIND v(dout0_21) AT=770.025n

.meas tran vdout0_22ck1530 FIND v(dout0_22) AT=770.025n

.meas tran vdout0_23ck1530 FIND v(dout0_23) AT=770.025n

.meas tran vdout0_24ck1530 FIND v(dout0_24) AT=770.025n

.meas tran vdout0_25ck1530 FIND v(dout0_25) AT=770.025n

.meas tran vdout0_26ck1530 FIND v(dout0_26) AT=770.025n

.meas tran vdout0_27ck1530 FIND v(dout0_27) AT=770.025n

.meas tran vdout0_28ck1530 FIND v(dout0_28) AT=770.025n

.meas tran vdout0_29ck1530 FIND v(dout0_29) AT=770.025n

.meas tran vdout0_30ck1530 FIND v(dout0_30) AT=770.025n

.meas tran vdout0_31ck1530 FIND v(dout0_31) AT=770.025n

.meas tran vdout0_32ck1530 FIND v(dout0_32) AT=770.025n

.meas tran vdout0_33ck1530 FIND v(dout0_33) AT=770.025n

.meas tran vdout0_34ck1530 FIND v(dout0_34) AT=770.025n

.meas tran vdout0_35ck1530 FIND v(dout0_35) AT=770.025n

.meas tran vdout0_36ck1530 FIND v(dout0_36) AT=770.025n

.meas tran vdout0_37ck1530 FIND v(dout0_37) AT=770.025n

.meas tran vdout0_38ck1530 FIND v(dout0_38) AT=770.025n

.meas tran vdout0_39ck1530 FIND v(dout0_39) AT=770.025n

.meas tran vdout0_40ck1530 FIND v(dout0_40) AT=770.025n

.meas tran vdout0_41ck1530 FIND v(dout0_41) AT=770.025n

.meas tran vdout0_42ck1530 FIND v(dout0_42) AT=770.025n

.meas tran vdout0_43ck1530 FIND v(dout0_43) AT=770.025n

.meas tran vdout0_44ck1530 FIND v(dout0_44) AT=770.025n

.meas tran vdout0_45ck1530 FIND v(dout0_45) AT=770.025n

.meas tran vdout0_46ck1530 FIND v(dout0_46) AT=770.025n

.meas tran vdout0_47ck1530 FIND v(dout0_47) AT=770.025n

.meas tran vdout0_48ck1530 FIND v(dout0_48) AT=770.025n

.meas tran vdout0_49ck1530 FIND v(dout0_49) AT=770.025n

.meas tran vdout0_50ck1530 FIND v(dout0_50) AT=770.025n

.meas tran vdout0_51ck1530 FIND v(dout0_51) AT=770.025n

.meas tran vdout0_52ck1530 FIND v(dout0_52) AT=770.025n

.meas tran vdout0_53ck1530 FIND v(dout0_53) AT=770.025n

.meas tran vdout0_54ck1530 FIND v(dout0_54) AT=770.025n

.meas tran vdout0_55ck1530 FIND v(dout0_55) AT=770.025n

.meas tran vdout0_56ck1530 FIND v(dout0_56) AT=770.025n

.meas tran vdout0_57ck1530 FIND v(dout0_57) AT=770.025n

.meas tran vdout0_58ck1530 FIND v(dout0_58) AT=770.025n

.meas tran vdout0_59ck1530 FIND v(dout0_59) AT=770.025n

.meas tran vdout0_60ck1530 FIND v(dout0_60) AT=770.025n

.meas tran vdout0_61ck1530 FIND v(dout0_61) AT=770.025n

.meas tran vdout0_62ck1530 FIND v(dout0_62) AT=770.025n

.meas tran vdout0_63ck1530 FIND v(dout0_63) AT=770.025n

.meas tran vdout0_64ck1530 FIND v(dout0_64) AT=770.025n

.meas tran vdout0_65ck1530 FIND v(dout0_65) AT=770.025n

.meas tran vdout0_66ck1530 FIND v(dout0_66) AT=770.025n

.meas tran vdout0_67ck1530 FIND v(dout0_67) AT=770.025n

.meas tran vdout0_68ck1530 FIND v(dout0_68) AT=770.025n

.meas tran vdout0_69ck1530 FIND v(dout0_69) AT=770.025n

.meas tran vdout0_70ck1530 FIND v(dout0_70) AT=770.025n

.meas tran vdout0_71ck1530 FIND v(dout0_71) AT=770.025n

.meas tran vdout0_72ck1530 FIND v(dout0_72) AT=770.025n

.meas tran vdout0_73ck1530 FIND v(dout0_73) AT=770.025n

.meas tran vdout0_74ck1530 FIND v(dout0_74) AT=770.025n

.meas tran vdout0_75ck1530 FIND v(dout0_75) AT=770.025n

.meas tran vdout0_76ck1530 FIND v(dout0_76) AT=770.025n

.meas tran vdout0_77ck1530 FIND v(dout0_77) AT=770.025n

.meas tran vdout0_78ck1530 FIND v(dout0_78) AT=770.025n

.meas tran vdout0_79ck1530 FIND v(dout0_79) AT=770.025n

.meas tran vdout0_80ck1530 FIND v(dout0_80) AT=770.025n

.meas tran vdout0_81ck1530 FIND v(dout0_81) AT=770.025n

.meas tran vdout0_82ck1530 FIND v(dout0_82) AT=770.025n

.meas tran vdout0_83ck1530 FIND v(dout0_83) AT=770.025n

.meas tran vdout0_84ck1530 FIND v(dout0_84) AT=770.025n

.meas tran vdout0_85ck1530 FIND v(dout0_85) AT=770.025n

.meas tran vdout0_86ck1530 FIND v(dout0_86) AT=770.025n

.meas tran vdout0_87ck1530 FIND v(dout0_87) AT=770.025n

.meas tran vdout0_88ck1530 FIND v(dout0_88) AT=770.025n

.meas tran vdout0_89ck1530 FIND v(dout0_89) AT=770.025n

.meas tran vdout0_90ck1530 FIND v(dout0_90) AT=770.025n

.meas tran vdout0_91ck1530 FIND v(dout0_91) AT=770.025n

.meas tran vdout0_92ck1530 FIND v(dout0_92) AT=770.025n

.meas tran vdout0_93ck1530 FIND v(dout0_93) AT=770.025n

.meas tran vdout0_94ck1530 FIND v(dout0_94) AT=770.025n

.meas tran vdout0_95ck1530 FIND v(dout0_95) AT=770.025n

.meas tran vdout0_96ck1530 FIND v(dout0_96) AT=770.025n

.meas tran vdout0_97ck1530 FIND v(dout0_97) AT=770.025n

.meas tran vdout0_98ck1530 FIND v(dout0_98) AT=770.025n

.meas tran vdout0_99ck1530 FIND v(dout0_99) AT=770.025n

.meas tran vdout0_100ck1530 FIND v(dout0_100) AT=770.025n

.meas tran vdout0_101ck1530 FIND v(dout0_101) AT=770.025n

.meas tran vdout0_102ck1530 FIND v(dout0_102) AT=770.025n

.meas tran vdout0_103ck1530 FIND v(dout0_103) AT=770.025n

.meas tran vdout0_104ck1530 FIND v(dout0_104) AT=770.025n

.meas tran vdout0_105ck1530 FIND v(dout0_105) AT=770.025n

.meas tran vdout0_106ck1530 FIND v(dout0_106) AT=770.025n

.meas tran vdout0_107ck1530 FIND v(dout0_107) AT=770.025n

.meas tran vdout0_108ck1530 FIND v(dout0_108) AT=770.025n

.meas tran vdout0_109ck1530 FIND v(dout0_109) AT=770.025n

.meas tran vdout0_110ck1530 FIND v(dout0_110) AT=770.025n

.meas tran vdout0_111ck1530 FIND v(dout0_111) AT=770.025n

.meas tran vdout0_112ck1530 FIND v(dout0_112) AT=770.025n

.meas tran vdout0_113ck1530 FIND v(dout0_113) AT=770.025n

.meas tran vdout0_114ck1530 FIND v(dout0_114) AT=770.025n

.meas tran vdout0_115ck1530 FIND v(dout0_115) AT=770.025n

.meas tran vdout0_116ck1530 FIND v(dout0_116) AT=770.025n

.meas tran vdout0_117ck1530 FIND v(dout0_117) AT=770.025n

.meas tran vdout0_118ck1530 FIND v(dout0_118) AT=770.025n

.meas tran vdout0_119ck1530 FIND v(dout0_119) AT=770.025n

.meas tran vdout0_120ck1530 FIND v(dout0_120) AT=770.025n

.meas tran vdout0_121ck1530 FIND v(dout0_121) AT=770.025n

.meas tran vdout0_122ck1530 FIND v(dout0_122) AT=770.025n

.meas tran vdout0_123ck1530 FIND v(dout0_123) AT=770.025n

.meas tran vdout0_124ck1530 FIND v(dout0_124) AT=770.025n

.meas tran vdout0_125ck1530 FIND v(dout0_125) AT=770.025n

.meas tran vdout0_126ck1530 FIND v(dout0_126) AT=770.025n

.meas tran vdout0_127ck1530 FIND v(dout0_127) AT=770.025n

.meas tran vdout0_128ck1530 FIND v(dout0_128) AT=770.025n

.meas tran vdout0_129ck1530 FIND v(dout0_129) AT=770.025n

.meas tran vdout0_130ck1530 FIND v(dout0_130) AT=770.025n

.meas tran vdout0_131ck1530 FIND v(dout0_131) AT=770.025n

.meas tran vdout0_132ck1530 FIND v(dout0_132) AT=770.025n

.meas tran vdout0_133ck1530 FIND v(dout0_133) AT=770.025n

.meas tran vdout0_134ck1530 FIND v(dout0_134) AT=770.025n

.meas tran vdout0_135ck1530 FIND v(dout0_135) AT=770.025n

.meas tran vdout0_136ck1530 FIND v(dout0_136) AT=770.025n

.meas tran vdout0_137ck1530 FIND v(dout0_137) AT=770.025n

.meas tran vdout0_138ck1530 FIND v(dout0_138) AT=770.025n

.meas tran vdout0_139ck1530 FIND v(dout0_139) AT=770.025n

.meas tran vdout0_140ck1530 FIND v(dout0_140) AT=770.025n

.meas tran vdout0_141ck1530 FIND v(dout0_141) AT=770.025n

.meas tran vdout0_142ck1530 FIND v(dout0_142) AT=770.025n

.meas tran vdout0_143ck1530 FIND v(dout0_143) AT=770.025n

.meas tran vdout0_144ck1530 FIND v(dout0_144) AT=770.025n

.meas tran vdout0_145ck1530 FIND v(dout0_145) AT=770.025n

.meas tran vdout0_146ck1530 FIND v(dout0_146) AT=770.025n

.meas tran vdout0_147ck1530 FIND v(dout0_147) AT=770.025n

.meas tran vdout0_148ck1530 FIND v(dout0_148) AT=770.025n

.meas tran vdout0_149ck1530 FIND v(dout0_149) AT=770.025n

.meas tran vdout0_150ck1530 FIND v(dout0_150) AT=770.025n

.meas tran vdout0_151ck1530 FIND v(dout0_151) AT=770.025n

.meas tran vdout0_152ck1530 FIND v(dout0_152) AT=770.025n

.meas tran vdout0_153ck1530 FIND v(dout0_153) AT=770.025n

.meas tran vdout0_154ck1530 FIND v(dout0_154) AT=770.025n

.meas tran vdout0_155ck1530 FIND v(dout0_155) AT=770.025n

.meas tran vdout0_156ck1530 FIND v(dout0_156) AT=770.025n

.meas tran vdout0_157ck1530 FIND v(dout0_157) AT=770.025n

.meas tran vdout0_158ck1530 FIND v(dout0_158) AT=770.025n

.meas tran vdout0_159ck1530 FIND v(dout0_159) AT=770.025n

.meas tran vdout0_160ck1530 FIND v(dout0_160) AT=770.025n

.meas tran vdout0_161ck1530 FIND v(dout0_161) AT=770.025n

.meas tran vdout0_162ck1530 FIND v(dout0_162) AT=770.025n

.meas tran vdout0_163ck1530 FIND v(dout0_163) AT=770.025n

.meas tran vdout0_164ck1530 FIND v(dout0_164) AT=770.025n

.meas tran vdout0_165ck1530 FIND v(dout0_165) AT=770.025n

.meas tran vdout0_166ck1530 FIND v(dout0_166) AT=770.025n

.meas tran vdout0_167ck1530 FIND v(dout0_167) AT=770.025n

.meas tran vdout0_168ck1530 FIND v(dout0_168) AT=770.025n

.meas tran vdout0_169ck1530 FIND v(dout0_169) AT=770.025n

.meas tran vdout0_170ck1530 FIND v(dout0_170) AT=770.025n

.meas tran vdout0_171ck1530 FIND v(dout0_171) AT=770.025n

.meas tran vdout0_172ck1530 FIND v(dout0_172) AT=770.025n

.meas tran vdout0_173ck1530 FIND v(dout0_173) AT=770.025n

.meas tran vdout0_174ck1530 FIND v(dout0_174) AT=770.025n

.meas tran vdout0_175ck1530 FIND v(dout0_175) AT=770.025n

.meas tran vdout0_176ck1530 FIND v(dout0_176) AT=770.025n

.meas tran vdout0_177ck1530 FIND v(dout0_177) AT=770.025n

.meas tran vdout0_178ck1530 FIND v(dout0_178) AT=770.025n

.meas tran vdout0_179ck1530 FIND v(dout0_179) AT=770.025n

.meas tran vdout0_180ck1530 FIND v(dout0_180) AT=770.025n

.meas tran vdout0_181ck1530 FIND v(dout0_181) AT=770.025n

.meas tran vdout0_182ck1530 FIND v(dout0_182) AT=770.025n

.meas tran vdout0_183ck1530 FIND v(dout0_183) AT=770.025n

.meas tran vdout0_184ck1530 FIND v(dout0_184) AT=770.025n

.meas tran vdout0_185ck1530 FIND v(dout0_185) AT=770.025n

.meas tran vdout0_186ck1530 FIND v(dout0_186) AT=770.025n

.meas tran vdout0_187ck1530 FIND v(dout0_187) AT=770.025n

.meas tran vdout0_188ck1530 FIND v(dout0_188) AT=770.025n

.meas tran vdout0_189ck1530 FIND v(dout0_189) AT=770.025n

.meas tran vdout0_190ck1530 FIND v(dout0_190) AT=770.025n

.meas tran vdout0_191ck1530 FIND v(dout0_191) AT=770.025n

.meas tran vdout0_192ck1530 FIND v(dout0_192) AT=770.025n

.meas tran vdout0_193ck1530 FIND v(dout0_193) AT=770.025n

.meas tran vdout0_194ck1530 FIND v(dout0_194) AT=770.025n

.meas tran vdout0_195ck1530 FIND v(dout0_195) AT=770.025n

.meas tran vdout0_196ck1530 FIND v(dout0_196) AT=770.025n

.meas tran vdout0_197ck1530 FIND v(dout0_197) AT=770.025n

.meas tran vdout0_198ck1530 FIND v(dout0_198) AT=770.025n

.meas tran vdout0_199ck1530 FIND v(dout0_199) AT=770.025n

.meas tran vdout0_200ck1530 FIND v(dout0_200) AT=770.025n

.meas tran vdout0_201ck1530 FIND v(dout0_201) AT=770.025n

.meas tran vdout0_202ck1530 FIND v(dout0_202) AT=770.025n

.meas tran vdout0_203ck1530 FIND v(dout0_203) AT=770.025n

.meas tran vdout0_204ck1530 FIND v(dout0_204) AT=770.025n

.meas tran vdout0_205ck1530 FIND v(dout0_205) AT=770.025n

.meas tran vdout0_206ck1530 FIND v(dout0_206) AT=770.025n

.meas tran vdout0_207ck1530 FIND v(dout0_207) AT=770.025n

.meas tran vdout0_208ck1530 FIND v(dout0_208) AT=770.025n

.meas tran vdout0_209ck1530 FIND v(dout0_209) AT=770.025n

.meas tran vdout0_210ck1530 FIND v(dout0_210) AT=770.025n

.meas tran vdout0_211ck1530 FIND v(dout0_211) AT=770.025n

.meas tran vdout0_212ck1530 FIND v(dout0_212) AT=770.025n

.meas tran vdout0_213ck1530 FIND v(dout0_213) AT=770.025n

.meas tran vdout0_214ck1530 FIND v(dout0_214) AT=770.025n

.meas tran vdout0_215ck1530 FIND v(dout0_215) AT=770.025n

.meas tran vdout0_216ck1530 FIND v(dout0_216) AT=770.025n

.meas tran vdout0_217ck1530 FIND v(dout0_217) AT=770.025n

.meas tran vdout0_218ck1530 FIND v(dout0_218) AT=770.025n

.meas tran vdout0_219ck1530 FIND v(dout0_219) AT=770.025n

.meas tran vdout0_220ck1530 FIND v(dout0_220) AT=770.025n

.meas tran vdout0_221ck1530 FIND v(dout0_221) AT=770.025n

.meas tran vdout0_222ck1530 FIND v(dout0_222) AT=770.025n

.meas tran vdout0_223ck1530 FIND v(dout0_223) AT=770.025n

.meas tran vdout0_224ck1530 FIND v(dout0_224) AT=770.025n

.meas tran vdout0_225ck1530 FIND v(dout0_225) AT=770.025n

.meas tran vdout0_226ck1530 FIND v(dout0_226) AT=770.025n

.meas tran vdout0_227ck1530 FIND v(dout0_227) AT=770.025n

.meas tran vdout0_228ck1530 FIND v(dout0_228) AT=770.025n

.meas tran vdout0_229ck1530 FIND v(dout0_229) AT=770.025n

.meas tran vdout0_230ck1530 FIND v(dout0_230) AT=770.025n

.meas tran vdout0_231ck1530 FIND v(dout0_231) AT=770.025n

.meas tran vdout0_232ck1530 FIND v(dout0_232) AT=770.025n

.meas tran vdout0_233ck1530 FIND v(dout0_233) AT=770.025n

.meas tran vdout0_234ck1530 FIND v(dout0_234) AT=770.025n

.meas tran vdout0_235ck1530 FIND v(dout0_235) AT=770.025n

.meas tran vdout0_236ck1530 FIND v(dout0_236) AT=770.025n

.meas tran vdout0_237ck1530 FIND v(dout0_237) AT=770.025n

.meas tran vdout0_238ck1530 FIND v(dout0_238) AT=770.025n

.meas tran vdout0_239ck1530 FIND v(dout0_239) AT=770.025n

.meas tran vdout0_240ck1530 FIND v(dout0_240) AT=770.025n

.meas tran vdout0_241ck1530 FIND v(dout0_241) AT=770.025n

.meas tran vdout0_242ck1530 FIND v(dout0_242) AT=770.025n

.meas tran vdout0_243ck1530 FIND v(dout0_243) AT=770.025n

.meas tran vdout0_244ck1530 FIND v(dout0_244) AT=770.025n

.meas tran vdout0_245ck1530 FIND v(dout0_245) AT=770.025n

.meas tran vdout0_246ck1530 FIND v(dout0_246) AT=770.025n

.meas tran vdout0_247ck1530 FIND v(dout0_247) AT=770.025n

.meas tran vdout0_248ck1530 FIND v(dout0_248) AT=770.025n

.meas tran vdout0_249ck1530 FIND v(dout0_249) AT=770.025n

.meas tran vdout0_250ck1530 FIND v(dout0_250) AT=770.025n

.meas tran vdout0_251ck1530 FIND v(dout0_251) AT=770.025n

.meas tran vdout0_252ck1530 FIND v(dout0_252) AT=770.025n

.meas tran vdout0_253ck1530 FIND v(dout0_253) AT=770.025n

.meas tran vdout0_254ck1530 FIND v(dout0_254) AT=770.025n

.meas tran vdout0_255ck1530 FIND v(dout0_255) AT=770.025n

.meas tran vdout0_0ck1540 FIND v(dout0_0) AT=775.025n

.meas tran vdout0_1ck1540 FIND v(dout0_1) AT=775.025n

.meas tran vdout0_2ck1540 FIND v(dout0_2) AT=775.025n

.meas tran vdout0_3ck1540 FIND v(dout0_3) AT=775.025n

.meas tran vdout0_4ck1540 FIND v(dout0_4) AT=775.025n

.meas tran vdout0_5ck1540 FIND v(dout0_5) AT=775.025n

.meas tran vdout0_6ck1540 FIND v(dout0_6) AT=775.025n

.meas tran vdout0_7ck1540 FIND v(dout0_7) AT=775.025n

.meas tran vdout0_8ck1540 FIND v(dout0_8) AT=775.025n

.meas tran vdout0_9ck1540 FIND v(dout0_9) AT=775.025n

.meas tran vdout0_10ck1540 FIND v(dout0_10) AT=775.025n

.meas tran vdout0_11ck1540 FIND v(dout0_11) AT=775.025n

.meas tran vdout0_12ck1540 FIND v(dout0_12) AT=775.025n

.meas tran vdout0_13ck1540 FIND v(dout0_13) AT=775.025n

.meas tran vdout0_14ck1540 FIND v(dout0_14) AT=775.025n

.meas tran vdout0_15ck1540 FIND v(dout0_15) AT=775.025n

.meas tran vdout0_16ck1540 FIND v(dout0_16) AT=775.025n

.meas tran vdout0_17ck1540 FIND v(dout0_17) AT=775.025n

.meas tran vdout0_18ck1540 FIND v(dout0_18) AT=775.025n

.meas tran vdout0_19ck1540 FIND v(dout0_19) AT=775.025n

.meas tran vdout0_20ck1540 FIND v(dout0_20) AT=775.025n

.meas tran vdout0_21ck1540 FIND v(dout0_21) AT=775.025n

.meas tran vdout0_22ck1540 FIND v(dout0_22) AT=775.025n

.meas tran vdout0_23ck1540 FIND v(dout0_23) AT=775.025n

.meas tran vdout0_24ck1540 FIND v(dout0_24) AT=775.025n

.meas tran vdout0_25ck1540 FIND v(dout0_25) AT=775.025n

.meas tran vdout0_26ck1540 FIND v(dout0_26) AT=775.025n

.meas tran vdout0_27ck1540 FIND v(dout0_27) AT=775.025n

.meas tran vdout0_28ck1540 FIND v(dout0_28) AT=775.025n

.meas tran vdout0_29ck1540 FIND v(dout0_29) AT=775.025n

.meas tran vdout0_30ck1540 FIND v(dout0_30) AT=775.025n

.meas tran vdout0_31ck1540 FIND v(dout0_31) AT=775.025n

.meas tran vdout0_32ck1540 FIND v(dout0_32) AT=775.025n

.meas tran vdout0_33ck1540 FIND v(dout0_33) AT=775.025n

.meas tran vdout0_34ck1540 FIND v(dout0_34) AT=775.025n

.meas tran vdout0_35ck1540 FIND v(dout0_35) AT=775.025n

.meas tran vdout0_36ck1540 FIND v(dout0_36) AT=775.025n

.meas tran vdout0_37ck1540 FIND v(dout0_37) AT=775.025n

.meas tran vdout0_38ck1540 FIND v(dout0_38) AT=775.025n

.meas tran vdout0_39ck1540 FIND v(dout0_39) AT=775.025n

.meas tran vdout0_40ck1540 FIND v(dout0_40) AT=775.025n

.meas tran vdout0_41ck1540 FIND v(dout0_41) AT=775.025n

.meas tran vdout0_42ck1540 FIND v(dout0_42) AT=775.025n

.meas tran vdout0_43ck1540 FIND v(dout0_43) AT=775.025n

.meas tran vdout0_44ck1540 FIND v(dout0_44) AT=775.025n

.meas tran vdout0_45ck1540 FIND v(dout0_45) AT=775.025n

.meas tran vdout0_46ck1540 FIND v(dout0_46) AT=775.025n

.meas tran vdout0_47ck1540 FIND v(dout0_47) AT=775.025n

.meas tran vdout0_48ck1540 FIND v(dout0_48) AT=775.025n

.meas tran vdout0_49ck1540 FIND v(dout0_49) AT=775.025n

.meas tran vdout0_50ck1540 FIND v(dout0_50) AT=775.025n

.meas tran vdout0_51ck1540 FIND v(dout0_51) AT=775.025n

.meas tran vdout0_52ck1540 FIND v(dout0_52) AT=775.025n

.meas tran vdout0_53ck1540 FIND v(dout0_53) AT=775.025n

.meas tran vdout0_54ck1540 FIND v(dout0_54) AT=775.025n

.meas tran vdout0_55ck1540 FIND v(dout0_55) AT=775.025n

.meas tran vdout0_56ck1540 FIND v(dout0_56) AT=775.025n

.meas tran vdout0_57ck1540 FIND v(dout0_57) AT=775.025n

.meas tran vdout0_58ck1540 FIND v(dout0_58) AT=775.025n

.meas tran vdout0_59ck1540 FIND v(dout0_59) AT=775.025n

.meas tran vdout0_60ck1540 FIND v(dout0_60) AT=775.025n

.meas tran vdout0_61ck1540 FIND v(dout0_61) AT=775.025n

.meas tran vdout0_62ck1540 FIND v(dout0_62) AT=775.025n

.meas tran vdout0_63ck1540 FIND v(dout0_63) AT=775.025n

.meas tran vdout0_64ck1540 FIND v(dout0_64) AT=775.025n

.meas tran vdout0_65ck1540 FIND v(dout0_65) AT=775.025n

.meas tran vdout0_66ck1540 FIND v(dout0_66) AT=775.025n

.meas tran vdout0_67ck1540 FIND v(dout0_67) AT=775.025n

.meas tran vdout0_68ck1540 FIND v(dout0_68) AT=775.025n

.meas tran vdout0_69ck1540 FIND v(dout0_69) AT=775.025n

.meas tran vdout0_70ck1540 FIND v(dout0_70) AT=775.025n

.meas tran vdout0_71ck1540 FIND v(dout0_71) AT=775.025n

.meas tran vdout0_72ck1540 FIND v(dout0_72) AT=775.025n

.meas tran vdout0_73ck1540 FIND v(dout0_73) AT=775.025n

.meas tran vdout0_74ck1540 FIND v(dout0_74) AT=775.025n

.meas tran vdout0_75ck1540 FIND v(dout0_75) AT=775.025n

.meas tran vdout0_76ck1540 FIND v(dout0_76) AT=775.025n

.meas tran vdout0_77ck1540 FIND v(dout0_77) AT=775.025n

.meas tran vdout0_78ck1540 FIND v(dout0_78) AT=775.025n

.meas tran vdout0_79ck1540 FIND v(dout0_79) AT=775.025n

.meas tran vdout0_80ck1540 FIND v(dout0_80) AT=775.025n

.meas tran vdout0_81ck1540 FIND v(dout0_81) AT=775.025n

.meas tran vdout0_82ck1540 FIND v(dout0_82) AT=775.025n

.meas tran vdout0_83ck1540 FIND v(dout0_83) AT=775.025n

.meas tran vdout0_84ck1540 FIND v(dout0_84) AT=775.025n

.meas tran vdout0_85ck1540 FIND v(dout0_85) AT=775.025n

.meas tran vdout0_86ck1540 FIND v(dout0_86) AT=775.025n

.meas tran vdout0_87ck1540 FIND v(dout0_87) AT=775.025n

.meas tran vdout0_88ck1540 FIND v(dout0_88) AT=775.025n

.meas tran vdout0_89ck1540 FIND v(dout0_89) AT=775.025n

.meas tran vdout0_90ck1540 FIND v(dout0_90) AT=775.025n

.meas tran vdout0_91ck1540 FIND v(dout0_91) AT=775.025n

.meas tran vdout0_92ck1540 FIND v(dout0_92) AT=775.025n

.meas tran vdout0_93ck1540 FIND v(dout0_93) AT=775.025n

.meas tran vdout0_94ck1540 FIND v(dout0_94) AT=775.025n

.meas tran vdout0_95ck1540 FIND v(dout0_95) AT=775.025n

.meas tran vdout0_96ck1540 FIND v(dout0_96) AT=775.025n

.meas tran vdout0_97ck1540 FIND v(dout0_97) AT=775.025n

.meas tran vdout0_98ck1540 FIND v(dout0_98) AT=775.025n

.meas tran vdout0_99ck1540 FIND v(dout0_99) AT=775.025n

.meas tran vdout0_100ck1540 FIND v(dout0_100) AT=775.025n

.meas tran vdout0_101ck1540 FIND v(dout0_101) AT=775.025n

.meas tran vdout0_102ck1540 FIND v(dout0_102) AT=775.025n

.meas tran vdout0_103ck1540 FIND v(dout0_103) AT=775.025n

.meas tran vdout0_104ck1540 FIND v(dout0_104) AT=775.025n

.meas tran vdout0_105ck1540 FIND v(dout0_105) AT=775.025n

.meas tran vdout0_106ck1540 FIND v(dout0_106) AT=775.025n

.meas tran vdout0_107ck1540 FIND v(dout0_107) AT=775.025n

.meas tran vdout0_108ck1540 FIND v(dout0_108) AT=775.025n

.meas tran vdout0_109ck1540 FIND v(dout0_109) AT=775.025n

.meas tran vdout0_110ck1540 FIND v(dout0_110) AT=775.025n

.meas tran vdout0_111ck1540 FIND v(dout0_111) AT=775.025n

.meas tran vdout0_112ck1540 FIND v(dout0_112) AT=775.025n

.meas tran vdout0_113ck1540 FIND v(dout0_113) AT=775.025n

.meas tran vdout0_114ck1540 FIND v(dout0_114) AT=775.025n

.meas tran vdout0_115ck1540 FIND v(dout0_115) AT=775.025n

.meas tran vdout0_116ck1540 FIND v(dout0_116) AT=775.025n

.meas tran vdout0_117ck1540 FIND v(dout0_117) AT=775.025n

.meas tran vdout0_118ck1540 FIND v(dout0_118) AT=775.025n

.meas tran vdout0_119ck1540 FIND v(dout0_119) AT=775.025n

.meas tran vdout0_120ck1540 FIND v(dout0_120) AT=775.025n

.meas tran vdout0_121ck1540 FIND v(dout0_121) AT=775.025n

.meas tran vdout0_122ck1540 FIND v(dout0_122) AT=775.025n

.meas tran vdout0_123ck1540 FIND v(dout0_123) AT=775.025n

.meas tran vdout0_124ck1540 FIND v(dout0_124) AT=775.025n

.meas tran vdout0_125ck1540 FIND v(dout0_125) AT=775.025n

.meas tran vdout0_126ck1540 FIND v(dout0_126) AT=775.025n

.meas tran vdout0_127ck1540 FIND v(dout0_127) AT=775.025n

.meas tran vdout0_128ck1540 FIND v(dout0_128) AT=775.025n

.meas tran vdout0_129ck1540 FIND v(dout0_129) AT=775.025n

.meas tran vdout0_130ck1540 FIND v(dout0_130) AT=775.025n

.meas tran vdout0_131ck1540 FIND v(dout0_131) AT=775.025n

.meas tran vdout0_132ck1540 FIND v(dout0_132) AT=775.025n

.meas tran vdout0_133ck1540 FIND v(dout0_133) AT=775.025n

.meas tran vdout0_134ck1540 FIND v(dout0_134) AT=775.025n

.meas tran vdout0_135ck1540 FIND v(dout0_135) AT=775.025n

.meas tran vdout0_136ck1540 FIND v(dout0_136) AT=775.025n

.meas tran vdout0_137ck1540 FIND v(dout0_137) AT=775.025n

.meas tran vdout0_138ck1540 FIND v(dout0_138) AT=775.025n

.meas tran vdout0_139ck1540 FIND v(dout0_139) AT=775.025n

.meas tran vdout0_140ck1540 FIND v(dout0_140) AT=775.025n

.meas tran vdout0_141ck1540 FIND v(dout0_141) AT=775.025n

.meas tran vdout0_142ck1540 FIND v(dout0_142) AT=775.025n

.meas tran vdout0_143ck1540 FIND v(dout0_143) AT=775.025n

.meas tran vdout0_144ck1540 FIND v(dout0_144) AT=775.025n

.meas tran vdout0_145ck1540 FIND v(dout0_145) AT=775.025n

.meas tran vdout0_146ck1540 FIND v(dout0_146) AT=775.025n

.meas tran vdout0_147ck1540 FIND v(dout0_147) AT=775.025n

.meas tran vdout0_148ck1540 FIND v(dout0_148) AT=775.025n

.meas tran vdout0_149ck1540 FIND v(dout0_149) AT=775.025n

.meas tran vdout0_150ck1540 FIND v(dout0_150) AT=775.025n

.meas tran vdout0_151ck1540 FIND v(dout0_151) AT=775.025n

.meas tran vdout0_152ck1540 FIND v(dout0_152) AT=775.025n

.meas tran vdout0_153ck1540 FIND v(dout0_153) AT=775.025n

.meas tran vdout0_154ck1540 FIND v(dout0_154) AT=775.025n

.meas tran vdout0_155ck1540 FIND v(dout0_155) AT=775.025n

.meas tran vdout0_156ck1540 FIND v(dout0_156) AT=775.025n

.meas tran vdout0_157ck1540 FIND v(dout0_157) AT=775.025n

.meas tran vdout0_158ck1540 FIND v(dout0_158) AT=775.025n

.meas tran vdout0_159ck1540 FIND v(dout0_159) AT=775.025n

.meas tran vdout0_160ck1540 FIND v(dout0_160) AT=775.025n

.meas tran vdout0_161ck1540 FIND v(dout0_161) AT=775.025n

.meas tran vdout0_162ck1540 FIND v(dout0_162) AT=775.025n

.meas tran vdout0_163ck1540 FIND v(dout0_163) AT=775.025n

.meas tran vdout0_164ck1540 FIND v(dout0_164) AT=775.025n

.meas tran vdout0_165ck1540 FIND v(dout0_165) AT=775.025n

.meas tran vdout0_166ck1540 FIND v(dout0_166) AT=775.025n

.meas tran vdout0_167ck1540 FIND v(dout0_167) AT=775.025n

.meas tran vdout0_168ck1540 FIND v(dout0_168) AT=775.025n

.meas tran vdout0_169ck1540 FIND v(dout0_169) AT=775.025n

.meas tran vdout0_170ck1540 FIND v(dout0_170) AT=775.025n

.meas tran vdout0_171ck1540 FIND v(dout0_171) AT=775.025n

.meas tran vdout0_172ck1540 FIND v(dout0_172) AT=775.025n

.meas tran vdout0_173ck1540 FIND v(dout0_173) AT=775.025n

.meas tran vdout0_174ck1540 FIND v(dout0_174) AT=775.025n

.meas tran vdout0_175ck1540 FIND v(dout0_175) AT=775.025n

.meas tran vdout0_176ck1540 FIND v(dout0_176) AT=775.025n

.meas tran vdout0_177ck1540 FIND v(dout0_177) AT=775.025n

.meas tran vdout0_178ck1540 FIND v(dout0_178) AT=775.025n

.meas tran vdout0_179ck1540 FIND v(dout0_179) AT=775.025n

.meas tran vdout0_180ck1540 FIND v(dout0_180) AT=775.025n

.meas tran vdout0_181ck1540 FIND v(dout0_181) AT=775.025n

.meas tran vdout0_182ck1540 FIND v(dout0_182) AT=775.025n

.meas tran vdout0_183ck1540 FIND v(dout0_183) AT=775.025n

.meas tran vdout0_184ck1540 FIND v(dout0_184) AT=775.025n

.meas tran vdout0_185ck1540 FIND v(dout0_185) AT=775.025n

.meas tran vdout0_186ck1540 FIND v(dout0_186) AT=775.025n

.meas tran vdout0_187ck1540 FIND v(dout0_187) AT=775.025n

.meas tran vdout0_188ck1540 FIND v(dout0_188) AT=775.025n

.meas tran vdout0_189ck1540 FIND v(dout0_189) AT=775.025n

.meas tran vdout0_190ck1540 FIND v(dout0_190) AT=775.025n

.meas tran vdout0_191ck1540 FIND v(dout0_191) AT=775.025n

.meas tran vdout0_192ck1540 FIND v(dout0_192) AT=775.025n

.meas tran vdout0_193ck1540 FIND v(dout0_193) AT=775.025n

.meas tran vdout0_194ck1540 FIND v(dout0_194) AT=775.025n

.meas tran vdout0_195ck1540 FIND v(dout0_195) AT=775.025n

.meas tran vdout0_196ck1540 FIND v(dout0_196) AT=775.025n

.meas tran vdout0_197ck1540 FIND v(dout0_197) AT=775.025n

.meas tran vdout0_198ck1540 FIND v(dout0_198) AT=775.025n

.meas tran vdout0_199ck1540 FIND v(dout0_199) AT=775.025n

.meas tran vdout0_200ck1540 FIND v(dout0_200) AT=775.025n

.meas tran vdout0_201ck1540 FIND v(dout0_201) AT=775.025n

.meas tran vdout0_202ck1540 FIND v(dout0_202) AT=775.025n

.meas tran vdout0_203ck1540 FIND v(dout0_203) AT=775.025n

.meas tran vdout0_204ck1540 FIND v(dout0_204) AT=775.025n

.meas tran vdout0_205ck1540 FIND v(dout0_205) AT=775.025n

.meas tran vdout0_206ck1540 FIND v(dout0_206) AT=775.025n

.meas tran vdout0_207ck1540 FIND v(dout0_207) AT=775.025n

.meas tran vdout0_208ck1540 FIND v(dout0_208) AT=775.025n

.meas tran vdout0_209ck1540 FIND v(dout0_209) AT=775.025n

.meas tran vdout0_210ck1540 FIND v(dout0_210) AT=775.025n

.meas tran vdout0_211ck1540 FIND v(dout0_211) AT=775.025n

.meas tran vdout0_212ck1540 FIND v(dout0_212) AT=775.025n

.meas tran vdout0_213ck1540 FIND v(dout0_213) AT=775.025n

.meas tran vdout0_214ck1540 FIND v(dout0_214) AT=775.025n

.meas tran vdout0_215ck1540 FIND v(dout0_215) AT=775.025n

.meas tran vdout0_216ck1540 FIND v(dout0_216) AT=775.025n

.meas tran vdout0_217ck1540 FIND v(dout0_217) AT=775.025n

.meas tran vdout0_218ck1540 FIND v(dout0_218) AT=775.025n

.meas tran vdout0_219ck1540 FIND v(dout0_219) AT=775.025n

.meas tran vdout0_220ck1540 FIND v(dout0_220) AT=775.025n

.meas tran vdout0_221ck1540 FIND v(dout0_221) AT=775.025n

.meas tran vdout0_222ck1540 FIND v(dout0_222) AT=775.025n

.meas tran vdout0_223ck1540 FIND v(dout0_223) AT=775.025n

.meas tran vdout0_224ck1540 FIND v(dout0_224) AT=775.025n

.meas tran vdout0_225ck1540 FIND v(dout0_225) AT=775.025n

.meas tran vdout0_226ck1540 FIND v(dout0_226) AT=775.025n

.meas tran vdout0_227ck1540 FIND v(dout0_227) AT=775.025n

.meas tran vdout0_228ck1540 FIND v(dout0_228) AT=775.025n

.meas tran vdout0_229ck1540 FIND v(dout0_229) AT=775.025n

.meas tran vdout0_230ck1540 FIND v(dout0_230) AT=775.025n

.meas tran vdout0_231ck1540 FIND v(dout0_231) AT=775.025n

.meas tran vdout0_232ck1540 FIND v(dout0_232) AT=775.025n

.meas tran vdout0_233ck1540 FIND v(dout0_233) AT=775.025n

.meas tran vdout0_234ck1540 FIND v(dout0_234) AT=775.025n

.meas tran vdout0_235ck1540 FIND v(dout0_235) AT=775.025n

.meas tran vdout0_236ck1540 FIND v(dout0_236) AT=775.025n

.meas tran vdout0_237ck1540 FIND v(dout0_237) AT=775.025n

.meas tran vdout0_238ck1540 FIND v(dout0_238) AT=775.025n

.meas tran vdout0_239ck1540 FIND v(dout0_239) AT=775.025n

.meas tran vdout0_240ck1540 FIND v(dout0_240) AT=775.025n

.meas tran vdout0_241ck1540 FIND v(dout0_241) AT=775.025n

.meas tran vdout0_242ck1540 FIND v(dout0_242) AT=775.025n

.meas tran vdout0_243ck1540 FIND v(dout0_243) AT=775.025n

.meas tran vdout0_244ck1540 FIND v(dout0_244) AT=775.025n

.meas tran vdout0_245ck1540 FIND v(dout0_245) AT=775.025n

.meas tran vdout0_246ck1540 FIND v(dout0_246) AT=775.025n

.meas tran vdout0_247ck1540 FIND v(dout0_247) AT=775.025n

.meas tran vdout0_248ck1540 FIND v(dout0_248) AT=775.025n

.meas tran vdout0_249ck1540 FIND v(dout0_249) AT=775.025n

.meas tran vdout0_250ck1540 FIND v(dout0_250) AT=775.025n

.meas tran vdout0_251ck1540 FIND v(dout0_251) AT=775.025n

.meas tran vdout0_252ck1540 FIND v(dout0_252) AT=775.025n

.meas tran vdout0_253ck1540 FIND v(dout0_253) AT=775.025n

.meas tran vdout0_254ck1540 FIND v(dout0_254) AT=775.025n

.meas tran vdout0_255ck1540 FIND v(dout0_255) AT=775.025n

.meas tran vdout0_0ck1550 FIND v(dout0_0) AT=780.025n

.meas tran vdout0_1ck1550 FIND v(dout0_1) AT=780.025n

.meas tran vdout0_2ck1550 FIND v(dout0_2) AT=780.025n

.meas tran vdout0_3ck1550 FIND v(dout0_3) AT=780.025n

.meas tran vdout0_4ck1550 FIND v(dout0_4) AT=780.025n

.meas tran vdout0_5ck1550 FIND v(dout0_5) AT=780.025n

.meas tran vdout0_6ck1550 FIND v(dout0_6) AT=780.025n

.meas tran vdout0_7ck1550 FIND v(dout0_7) AT=780.025n

.meas tran vdout0_8ck1550 FIND v(dout0_8) AT=780.025n

.meas tran vdout0_9ck1550 FIND v(dout0_9) AT=780.025n

.meas tran vdout0_10ck1550 FIND v(dout0_10) AT=780.025n

.meas tran vdout0_11ck1550 FIND v(dout0_11) AT=780.025n

.meas tran vdout0_12ck1550 FIND v(dout0_12) AT=780.025n

.meas tran vdout0_13ck1550 FIND v(dout0_13) AT=780.025n

.meas tran vdout0_14ck1550 FIND v(dout0_14) AT=780.025n

.meas tran vdout0_15ck1550 FIND v(dout0_15) AT=780.025n

.meas tran vdout0_16ck1550 FIND v(dout0_16) AT=780.025n

.meas tran vdout0_17ck1550 FIND v(dout0_17) AT=780.025n

.meas tran vdout0_18ck1550 FIND v(dout0_18) AT=780.025n

.meas tran vdout0_19ck1550 FIND v(dout0_19) AT=780.025n

.meas tran vdout0_20ck1550 FIND v(dout0_20) AT=780.025n

.meas tran vdout0_21ck1550 FIND v(dout0_21) AT=780.025n

.meas tran vdout0_22ck1550 FIND v(dout0_22) AT=780.025n

.meas tran vdout0_23ck1550 FIND v(dout0_23) AT=780.025n

.meas tran vdout0_24ck1550 FIND v(dout0_24) AT=780.025n

.meas tran vdout0_25ck1550 FIND v(dout0_25) AT=780.025n

.meas tran vdout0_26ck1550 FIND v(dout0_26) AT=780.025n

.meas tran vdout0_27ck1550 FIND v(dout0_27) AT=780.025n

.meas tran vdout0_28ck1550 FIND v(dout0_28) AT=780.025n

.meas tran vdout0_29ck1550 FIND v(dout0_29) AT=780.025n

.meas tran vdout0_30ck1550 FIND v(dout0_30) AT=780.025n

.meas tran vdout0_31ck1550 FIND v(dout0_31) AT=780.025n

.meas tran vdout0_32ck1550 FIND v(dout0_32) AT=780.025n

.meas tran vdout0_33ck1550 FIND v(dout0_33) AT=780.025n

.meas tran vdout0_34ck1550 FIND v(dout0_34) AT=780.025n

.meas tran vdout0_35ck1550 FIND v(dout0_35) AT=780.025n

.meas tran vdout0_36ck1550 FIND v(dout0_36) AT=780.025n

.meas tran vdout0_37ck1550 FIND v(dout0_37) AT=780.025n

.meas tran vdout0_38ck1550 FIND v(dout0_38) AT=780.025n

.meas tran vdout0_39ck1550 FIND v(dout0_39) AT=780.025n

.meas tran vdout0_40ck1550 FIND v(dout0_40) AT=780.025n

.meas tran vdout0_41ck1550 FIND v(dout0_41) AT=780.025n

.meas tran vdout0_42ck1550 FIND v(dout0_42) AT=780.025n

.meas tran vdout0_43ck1550 FIND v(dout0_43) AT=780.025n

.meas tran vdout0_44ck1550 FIND v(dout0_44) AT=780.025n

.meas tran vdout0_45ck1550 FIND v(dout0_45) AT=780.025n

.meas tran vdout0_46ck1550 FIND v(dout0_46) AT=780.025n

.meas tran vdout0_47ck1550 FIND v(dout0_47) AT=780.025n

.meas tran vdout0_48ck1550 FIND v(dout0_48) AT=780.025n

.meas tran vdout0_49ck1550 FIND v(dout0_49) AT=780.025n

.meas tran vdout0_50ck1550 FIND v(dout0_50) AT=780.025n

.meas tran vdout0_51ck1550 FIND v(dout0_51) AT=780.025n

.meas tran vdout0_52ck1550 FIND v(dout0_52) AT=780.025n

.meas tran vdout0_53ck1550 FIND v(dout0_53) AT=780.025n

.meas tran vdout0_54ck1550 FIND v(dout0_54) AT=780.025n

.meas tran vdout0_55ck1550 FIND v(dout0_55) AT=780.025n

.meas tran vdout0_56ck1550 FIND v(dout0_56) AT=780.025n

.meas tran vdout0_57ck1550 FIND v(dout0_57) AT=780.025n

.meas tran vdout0_58ck1550 FIND v(dout0_58) AT=780.025n

.meas tran vdout0_59ck1550 FIND v(dout0_59) AT=780.025n

.meas tran vdout0_60ck1550 FIND v(dout0_60) AT=780.025n

.meas tran vdout0_61ck1550 FIND v(dout0_61) AT=780.025n

.meas tran vdout0_62ck1550 FIND v(dout0_62) AT=780.025n

.meas tran vdout0_63ck1550 FIND v(dout0_63) AT=780.025n

.meas tran vdout0_64ck1550 FIND v(dout0_64) AT=780.025n

.meas tran vdout0_65ck1550 FIND v(dout0_65) AT=780.025n

.meas tran vdout0_66ck1550 FIND v(dout0_66) AT=780.025n

.meas tran vdout0_67ck1550 FIND v(dout0_67) AT=780.025n

.meas tran vdout0_68ck1550 FIND v(dout0_68) AT=780.025n

.meas tran vdout0_69ck1550 FIND v(dout0_69) AT=780.025n

.meas tran vdout0_70ck1550 FIND v(dout0_70) AT=780.025n

.meas tran vdout0_71ck1550 FIND v(dout0_71) AT=780.025n

.meas tran vdout0_72ck1550 FIND v(dout0_72) AT=780.025n

.meas tran vdout0_73ck1550 FIND v(dout0_73) AT=780.025n

.meas tran vdout0_74ck1550 FIND v(dout0_74) AT=780.025n

.meas tran vdout0_75ck1550 FIND v(dout0_75) AT=780.025n

.meas tran vdout0_76ck1550 FIND v(dout0_76) AT=780.025n

.meas tran vdout0_77ck1550 FIND v(dout0_77) AT=780.025n

.meas tran vdout0_78ck1550 FIND v(dout0_78) AT=780.025n

.meas tran vdout0_79ck1550 FIND v(dout0_79) AT=780.025n

.meas tran vdout0_80ck1550 FIND v(dout0_80) AT=780.025n

.meas tran vdout0_81ck1550 FIND v(dout0_81) AT=780.025n

.meas tran vdout0_82ck1550 FIND v(dout0_82) AT=780.025n

.meas tran vdout0_83ck1550 FIND v(dout0_83) AT=780.025n

.meas tran vdout0_84ck1550 FIND v(dout0_84) AT=780.025n

.meas tran vdout0_85ck1550 FIND v(dout0_85) AT=780.025n

.meas tran vdout0_86ck1550 FIND v(dout0_86) AT=780.025n

.meas tran vdout0_87ck1550 FIND v(dout0_87) AT=780.025n

.meas tran vdout0_88ck1550 FIND v(dout0_88) AT=780.025n

.meas tran vdout0_89ck1550 FIND v(dout0_89) AT=780.025n

.meas tran vdout0_90ck1550 FIND v(dout0_90) AT=780.025n

.meas tran vdout0_91ck1550 FIND v(dout0_91) AT=780.025n

.meas tran vdout0_92ck1550 FIND v(dout0_92) AT=780.025n

.meas tran vdout0_93ck1550 FIND v(dout0_93) AT=780.025n

.meas tran vdout0_94ck1550 FIND v(dout0_94) AT=780.025n

.meas tran vdout0_95ck1550 FIND v(dout0_95) AT=780.025n

.meas tran vdout0_96ck1550 FIND v(dout0_96) AT=780.025n

.meas tran vdout0_97ck1550 FIND v(dout0_97) AT=780.025n

.meas tran vdout0_98ck1550 FIND v(dout0_98) AT=780.025n

.meas tran vdout0_99ck1550 FIND v(dout0_99) AT=780.025n

.meas tran vdout0_100ck1550 FIND v(dout0_100) AT=780.025n

.meas tran vdout0_101ck1550 FIND v(dout0_101) AT=780.025n

.meas tran vdout0_102ck1550 FIND v(dout0_102) AT=780.025n

.meas tran vdout0_103ck1550 FIND v(dout0_103) AT=780.025n

.meas tran vdout0_104ck1550 FIND v(dout0_104) AT=780.025n

.meas tran vdout0_105ck1550 FIND v(dout0_105) AT=780.025n

.meas tran vdout0_106ck1550 FIND v(dout0_106) AT=780.025n

.meas tran vdout0_107ck1550 FIND v(dout0_107) AT=780.025n

.meas tran vdout0_108ck1550 FIND v(dout0_108) AT=780.025n

.meas tran vdout0_109ck1550 FIND v(dout0_109) AT=780.025n

.meas tran vdout0_110ck1550 FIND v(dout0_110) AT=780.025n

.meas tran vdout0_111ck1550 FIND v(dout0_111) AT=780.025n

.meas tran vdout0_112ck1550 FIND v(dout0_112) AT=780.025n

.meas tran vdout0_113ck1550 FIND v(dout0_113) AT=780.025n

.meas tran vdout0_114ck1550 FIND v(dout0_114) AT=780.025n

.meas tran vdout0_115ck1550 FIND v(dout0_115) AT=780.025n

.meas tran vdout0_116ck1550 FIND v(dout0_116) AT=780.025n

.meas tran vdout0_117ck1550 FIND v(dout0_117) AT=780.025n

.meas tran vdout0_118ck1550 FIND v(dout0_118) AT=780.025n

.meas tran vdout0_119ck1550 FIND v(dout0_119) AT=780.025n

.meas tran vdout0_120ck1550 FIND v(dout0_120) AT=780.025n

.meas tran vdout0_121ck1550 FIND v(dout0_121) AT=780.025n

.meas tran vdout0_122ck1550 FIND v(dout0_122) AT=780.025n

.meas tran vdout0_123ck1550 FIND v(dout0_123) AT=780.025n

.meas tran vdout0_124ck1550 FIND v(dout0_124) AT=780.025n

.meas tran vdout0_125ck1550 FIND v(dout0_125) AT=780.025n

.meas tran vdout0_126ck1550 FIND v(dout0_126) AT=780.025n

.meas tran vdout0_127ck1550 FIND v(dout0_127) AT=780.025n

.meas tran vdout0_128ck1550 FIND v(dout0_128) AT=780.025n

.meas tran vdout0_129ck1550 FIND v(dout0_129) AT=780.025n

.meas tran vdout0_130ck1550 FIND v(dout0_130) AT=780.025n

.meas tran vdout0_131ck1550 FIND v(dout0_131) AT=780.025n

.meas tran vdout0_132ck1550 FIND v(dout0_132) AT=780.025n

.meas tran vdout0_133ck1550 FIND v(dout0_133) AT=780.025n

.meas tran vdout0_134ck1550 FIND v(dout0_134) AT=780.025n

.meas tran vdout0_135ck1550 FIND v(dout0_135) AT=780.025n

.meas tran vdout0_136ck1550 FIND v(dout0_136) AT=780.025n

.meas tran vdout0_137ck1550 FIND v(dout0_137) AT=780.025n

.meas tran vdout0_138ck1550 FIND v(dout0_138) AT=780.025n

.meas tran vdout0_139ck1550 FIND v(dout0_139) AT=780.025n

.meas tran vdout0_140ck1550 FIND v(dout0_140) AT=780.025n

.meas tran vdout0_141ck1550 FIND v(dout0_141) AT=780.025n

.meas tran vdout0_142ck1550 FIND v(dout0_142) AT=780.025n

.meas tran vdout0_143ck1550 FIND v(dout0_143) AT=780.025n

.meas tran vdout0_144ck1550 FIND v(dout0_144) AT=780.025n

.meas tran vdout0_145ck1550 FIND v(dout0_145) AT=780.025n

.meas tran vdout0_146ck1550 FIND v(dout0_146) AT=780.025n

.meas tran vdout0_147ck1550 FIND v(dout0_147) AT=780.025n

.meas tran vdout0_148ck1550 FIND v(dout0_148) AT=780.025n

.meas tran vdout0_149ck1550 FIND v(dout0_149) AT=780.025n

.meas tran vdout0_150ck1550 FIND v(dout0_150) AT=780.025n

.meas tran vdout0_151ck1550 FIND v(dout0_151) AT=780.025n

.meas tran vdout0_152ck1550 FIND v(dout0_152) AT=780.025n

.meas tran vdout0_153ck1550 FIND v(dout0_153) AT=780.025n

.meas tran vdout0_154ck1550 FIND v(dout0_154) AT=780.025n

.meas tran vdout0_155ck1550 FIND v(dout0_155) AT=780.025n

.meas tran vdout0_156ck1550 FIND v(dout0_156) AT=780.025n

.meas tran vdout0_157ck1550 FIND v(dout0_157) AT=780.025n

.meas tran vdout0_158ck1550 FIND v(dout0_158) AT=780.025n

.meas tran vdout0_159ck1550 FIND v(dout0_159) AT=780.025n

.meas tran vdout0_160ck1550 FIND v(dout0_160) AT=780.025n

.meas tran vdout0_161ck1550 FIND v(dout0_161) AT=780.025n

.meas tran vdout0_162ck1550 FIND v(dout0_162) AT=780.025n

.meas tran vdout0_163ck1550 FIND v(dout0_163) AT=780.025n

.meas tran vdout0_164ck1550 FIND v(dout0_164) AT=780.025n

.meas tran vdout0_165ck1550 FIND v(dout0_165) AT=780.025n

.meas tran vdout0_166ck1550 FIND v(dout0_166) AT=780.025n

.meas tran vdout0_167ck1550 FIND v(dout0_167) AT=780.025n

.meas tran vdout0_168ck1550 FIND v(dout0_168) AT=780.025n

.meas tran vdout0_169ck1550 FIND v(dout0_169) AT=780.025n

.meas tran vdout0_170ck1550 FIND v(dout0_170) AT=780.025n

.meas tran vdout0_171ck1550 FIND v(dout0_171) AT=780.025n

.meas tran vdout0_172ck1550 FIND v(dout0_172) AT=780.025n

.meas tran vdout0_173ck1550 FIND v(dout0_173) AT=780.025n

.meas tran vdout0_174ck1550 FIND v(dout0_174) AT=780.025n

.meas tran vdout0_175ck1550 FIND v(dout0_175) AT=780.025n

.meas tran vdout0_176ck1550 FIND v(dout0_176) AT=780.025n

.meas tran vdout0_177ck1550 FIND v(dout0_177) AT=780.025n

.meas tran vdout0_178ck1550 FIND v(dout0_178) AT=780.025n

.meas tran vdout0_179ck1550 FIND v(dout0_179) AT=780.025n

.meas tran vdout0_180ck1550 FIND v(dout0_180) AT=780.025n

.meas tran vdout0_181ck1550 FIND v(dout0_181) AT=780.025n

.meas tran vdout0_182ck1550 FIND v(dout0_182) AT=780.025n

.meas tran vdout0_183ck1550 FIND v(dout0_183) AT=780.025n

.meas tran vdout0_184ck1550 FIND v(dout0_184) AT=780.025n

.meas tran vdout0_185ck1550 FIND v(dout0_185) AT=780.025n

.meas tran vdout0_186ck1550 FIND v(dout0_186) AT=780.025n

.meas tran vdout0_187ck1550 FIND v(dout0_187) AT=780.025n

.meas tran vdout0_188ck1550 FIND v(dout0_188) AT=780.025n

.meas tran vdout0_189ck1550 FIND v(dout0_189) AT=780.025n

.meas tran vdout0_190ck1550 FIND v(dout0_190) AT=780.025n

.meas tran vdout0_191ck1550 FIND v(dout0_191) AT=780.025n

.meas tran vdout0_192ck1550 FIND v(dout0_192) AT=780.025n

.meas tran vdout0_193ck1550 FIND v(dout0_193) AT=780.025n

.meas tran vdout0_194ck1550 FIND v(dout0_194) AT=780.025n

.meas tran vdout0_195ck1550 FIND v(dout0_195) AT=780.025n

.meas tran vdout0_196ck1550 FIND v(dout0_196) AT=780.025n

.meas tran vdout0_197ck1550 FIND v(dout0_197) AT=780.025n

.meas tran vdout0_198ck1550 FIND v(dout0_198) AT=780.025n

.meas tran vdout0_199ck1550 FIND v(dout0_199) AT=780.025n

.meas tran vdout0_200ck1550 FIND v(dout0_200) AT=780.025n

.meas tran vdout0_201ck1550 FIND v(dout0_201) AT=780.025n

.meas tran vdout0_202ck1550 FIND v(dout0_202) AT=780.025n

.meas tran vdout0_203ck1550 FIND v(dout0_203) AT=780.025n

.meas tran vdout0_204ck1550 FIND v(dout0_204) AT=780.025n

.meas tran vdout0_205ck1550 FIND v(dout0_205) AT=780.025n

.meas tran vdout0_206ck1550 FIND v(dout0_206) AT=780.025n

.meas tran vdout0_207ck1550 FIND v(dout0_207) AT=780.025n

.meas tran vdout0_208ck1550 FIND v(dout0_208) AT=780.025n

.meas tran vdout0_209ck1550 FIND v(dout0_209) AT=780.025n

.meas tran vdout0_210ck1550 FIND v(dout0_210) AT=780.025n

.meas tran vdout0_211ck1550 FIND v(dout0_211) AT=780.025n

.meas tran vdout0_212ck1550 FIND v(dout0_212) AT=780.025n

.meas tran vdout0_213ck1550 FIND v(dout0_213) AT=780.025n

.meas tran vdout0_214ck1550 FIND v(dout0_214) AT=780.025n

.meas tran vdout0_215ck1550 FIND v(dout0_215) AT=780.025n

.meas tran vdout0_216ck1550 FIND v(dout0_216) AT=780.025n

.meas tran vdout0_217ck1550 FIND v(dout0_217) AT=780.025n

.meas tran vdout0_218ck1550 FIND v(dout0_218) AT=780.025n

.meas tran vdout0_219ck1550 FIND v(dout0_219) AT=780.025n

.meas tran vdout0_220ck1550 FIND v(dout0_220) AT=780.025n

.meas tran vdout0_221ck1550 FIND v(dout0_221) AT=780.025n

.meas tran vdout0_222ck1550 FIND v(dout0_222) AT=780.025n

.meas tran vdout0_223ck1550 FIND v(dout0_223) AT=780.025n

.meas tran vdout0_224ck1550 FIND v(dout0_224) AT=780.025n

.meas tran vdout0_225ck1550 FIND v(dout0_225) AT=780.025n

.meas tran vdout0_226ck1550 FIND v(dout0_226) AT=780.025n

.meas tran vdout0_227ck1550 FIND v(dout0_227) AT=780.025n

.meas tran vdout0_228ck1550 FIND v(dout0_228) AT=780.025n

.meas tran vdout0_229ck1550 FIND v(dout0_229) AT=780.025n

.meas tran vdout0_230ck1550 FIND v(dout0_230) AT=780.025n

.meas tran vdout0_231ck1550 FIND v(dout0_231) AT=780.025n

.meas tran vdout0_232ck1550 FIND v(dout0_232) AT=780.025n

.meas tran vdout0_233ck1550 FIND v(dout0_233) AT=780.025n

.meas tran vdout0_234ck1550 FIND v(dout0_234) AT=780.025n

.meas tran vdout0_235ck1550 FIND v(dout0_235) AT=780.025n

.meas tran vdout0_236ck1550 FIND v(dout0_236) AT=780.025n

.meas tran vdout0_237ck1550 FIND v(dout0_237) AT=780.025n

.meas tran vdout0_238ck1550 FIND v(dout0_238) AT=780.025n

.meas tran vdout0_239ck1550 FIND v(dout0_239) AT=780.025n

.meas tran vdout0_240ck1550 FIND v(dout0_240) AT=780.025n

.meas tran vdout0_241ck1550 FIND v(dout0_241) AT=780.025n

.meas tran vdout0_242ck1550 FIND v(dout0_242) AT=780.025n

.meas tran vdout0_243ck1550 FIND v(dout0_243) AT=780.025n

.meas tran vdout0_244ck1550 FIND v(dout0_244) AT=780.025n

.meas tran vdout0_245ck1550 FIND v(dout0_245) AT=780.025n

.meas tran vdout0_246ck1550 FIND v(dout0_246) AT=780.025n

.meas tran vdout0_247ck1550 FIND v(dout0_247) AT=780.025n

.meas tran vdout0_248ck1550 FIND v(dout0_248) AT=780.025n

.meas tran vdout0_249ck1550 FIND v(dout0_249) AT=780.025n

.meas tran vdout0_250ck1550 FIND v(dout0_250) AT=780.025n

.meas tran vdout0_251ck1550 FIND v(dout0_251) AT=780.025n

.meas tran vdout0_252ck1550 FIND v(dout0_252) AT=780.025n

.meas tran vdout0_253ck1550 FIND v(dout0_253) AT=780.025n

.meas tran vdout0_254ck1550 FIND v(dout0_254) AT=780.025n

.meas tran vdout0_255ck1550 FIND v(dout0_255) AT=780.025n

.meas tran vdout0_0ck1600 FIND v(dout0_0) AT=805.025n

.meas tran vdout0_1ck1600 FIND v(dout0_1) AT=805.025n

.meas tran vdout0_2ck1600 FIND v(dout0_2) AT=805.025n

.meas tran vdout0_3ck1600 FIND v(dout0_3) AT=805.025n

.meas tran vdout0_4ck1600 FIND v(dout0_4) AT=805.025n

.meas tran vdout0_5ck1600 FIND v(dout0_5) AT=805.025n

.meas tran vdout0_6ck1600 FIND v(dout0_6) AT=805.025n

.meas tran vdout0_7ck1600 FIND v(dout0_7) AT=805.025n

.meas tran vdout0_8ck1600 FIND v(dout0_8) AT=805.025n

.meas tran vdout0_9ck1600 FIND v(dout0_9) AT=805.025n

.meas tran vdout0_10ck1600 FIND v(dout0_10) AT=805.025n

.meas tran vdout0_11ck1600 FIND v(dout0_11) AT=805.025n

.meas tran vdout0_12ck1600 FIND v(dout0_12) AT=805.025n

.meas tran vdout0_13ck1600 FIND v(dout0_13) AT=805.025n

.meas tran vdout0_14ck1600 FIND v(dout0_14) AT=805.025n

.meas tran vdout0_15ck1600 FIND v(dout0_15) AT=805.025n

.meas tran vdout0_16ck1600 FIND v(dout0_16) AT=805.025n

.meas tran vdout0_17ck1600 FIND v(dout0_17) AT=805.025n

.meas tran vdout0_18ck1600 FIND v(dout0_18) AT=805.025n

.meas tran vdout0_19ck1600 FIND v(dout0_19) AT=805.025n

.meas tran vdout0_20ck1600 FIND v(dout0_20) AT=805.025n

.meas tran vdout0_21ck1600 FIND v(dout0_21) AT=805.025n

.meas tran vdout0_22ck1600 FIND v(dout0_22) AT=805.025n

.meas tran vdout0_23ck1600 FIND v(dout0_23) AT=805.025n

.meas tran vdout0_24ck1600 FIND v(dout0_24) AT=805.025n

.meas tran vdout0_25ck1600 FIND v(dout0_25) AT=805.025n

.meas tran vdout0_26ck1600 FIND v(dout0_26) AT=805.025n

.meas tran vdout0_27ck1600 FIND v(dout0_27) AT=805.025n

.meas tran vdout0_28ck1600 FIND v(dout0_28) AT=805.025n

.meas tran vdout0_29ck1600 FIND v(dout0_29) AT=805.025n

.meas tran vdout0_30ck1600 FIND v(dout0_30) AT=805.025n

.meas tran vdout0_31ck1600 FIND v(dout0_31) AT=805.025n

.meas tran vdout0_32ck1600 FIND v(dout0_32) AT=805.025n

.meas tran vdout0_33ck1600 FIND v(dout0_33) AT=805.025n

.meas tran vdout0_34ck1600 FIND v(dout0_34) AT=805.025n

.meas tran vdout0_35ck1600 FIND v(dout0_35) AT=805.025n

.meas tran vdout0_36ck1600 FIND v(dout0_36) AT=805.025n

.meas tran vdout0_37ck1600 FIND v(dout0_37) AT=805.025n

.meas tran vdout0_38ck1600 FIND v(dout0_38) AT=805.025n

.meas tran vdout0_39ck1600 FIND v(dout0_39) AT=805.025n

.meas tran vdout0_40ck1600 FIND v(dout0_40) AT=805.025n

.meas tran vdout0_41ck1600 FIND v(dout0_41) AT=805.025n

.meas tran vdout0_42ck1600 FIND v(dout0_42) AT=805.025n

.meas tran vdout0_43ck1600 FIND v(dout0_43) AT=805.025n

.meas tran vdout0_44ck1600 FIND v(dout0_44) AT=805.025n

.meas tran vdout0_45ck1600 FIND v(dout0_45) AT=805.025n

.meas tran vdout0_46ck1600 FIND v(dout0_46) AT=805.025n

.meas tran vdout0_47ck1600 FIND v(dout0_47) AT=805.025n

.meas tran vdout0_48ck1600 FIND v(dout0_48) AT=805.025n

.meas tran vdout0_49ck1600 FIND v(dout0_49) AT=805.025n

.meas tran vdout0_50ck1600 FIND v(dout0_50) AT=805.025n

.meas tran vdout0_51ck1600 FIND v(dout0_51) AT=805.025n

.meas tran vdout0_52ck1600 FIND v(dout0_52) AT=805.025n

.meas tran vdout0_53ck1600 FIND v(dout0_53) AT=805.025n

.meas tran vdout0_54ck1600 FIND v(dout0_54) AT=805.025n

.meas tran vdout0_55ck1600 FIND v(dout0_55) AT=805.025n

.meas tran vdout0_56ck1600 FIND v(dout0_56) AT=805.025n

.meas tran vdout0_57ck1600 FIND v(dout0_57) AT=805.025n

.meas tran vdout0_58ck1600 FIND v(dout0_58) AT=805.025n

.meas tran vdout0_59ck1600 FIND v(dout0_59) AT=805.025n

.meas tran vdout0_60ck1600 FIND v(dout0_60) AT=805.025n

.meas tran vdout0_61ck1600 FIND v(dout0_61) AT=805.025n

.meas tran vdout0_62ck1600 FIND v(dout0_62) AT=805.025n

.meas tran vdout0_63ck1600 FIND v(dout0_63) AT=805.025n

.meas tran vdout0_64ck1600 FIND v(dout0_64) AT=805.025n

.meas tran vdout0_65ck1600 FIND v(dout0_65) AT=805.025n

.meas tran vdout0_66ck1600 FIND v(dout0_66) AT=805.025n

.meas tran vdout0_67ck1600 FIND v(dout0_67) AT=805.025n

.meas tran vdout0_68ck1600 FIND v(dout0_68) AT=805.025n

.meas tran vdout0_69ck1600 FIND v(dout0_69) AT=805.025n

.meas tran vdout0_70ck1600 FIND v(dout0_70) AT=805.025n

.meas tran vdout0_71ck1600 FIND v(dout0_71) AT=805.025n

.meas tran vdout0_72ck1600 FIND v(dout0_72) AT=805.025n

.meas tran vdout0_73ck1600 FIND v(dout0_73) AT=805.025n

.meas tran vdout0_74ck1600 FIND v(dout0_74) AT=805.025n

.meas tran vdout0_75ck1600 FIND v(dout0_75) AT=805.025n

.meas tran vdout0_76ck1600 FIND v(dout0_76) AT=805.025n

.meas tran vdout0_77ck1600 FIND v(dout0_77) AT=805.025n

.meas tran vdout0_78ck1600 FIND v(dout0_78) AT=805.025n

.meas tran vdout0_79ck1600 FIND v(dout0_79) AT=805.025n

.meas tran vdout0_80ck1600 FIND v(dout0_80) AT=805.025n

.meas tran vdout0_81ck1600 FIND v(dout0_81) AT=805.025n

.meas tran vdout0_82ck1600 FIND v(dout0_82) AT=805.025n

.meas tran vdout0_83ck1600 FIND v(dout0_83) AT=805.025n

.meas tran vdout0_84ck1600 FIND v(dout0_84) AT=805.025n

.meas tran vdout0_85ck1600 FIND v(dout0_85) AT=805.025n

.meas tran vdout0_86ck1600 FIND v(dout0_86) AT=805.025n

.meas tran vdout0_87ck1600 FIND v(dout0_87) AT=805.025n

.meas tran vdout0_88ck1600 FIND v(dout0_88) AT=805.025n

.meas tran vdout0_89ck1600 FIND v(dout0_89) AT=805.025n

.meas tran vdout0_90ck1600 FIND v(dout0_90) AT=805.025n

.meas tran vdout0_91ck1600 FIND v(dout0_91) AT=805.025n

.meas tran vdout0_92ck1600 FIND v(dout0_92) AT=805.025n

.meas tran vdout0_93ck1600 FIND v(dout0_93) AT=805.025n

.meas tran vdout0_94ck1600 FIND v(dout0_94) AT=805.025n

.meas tran vdout0_95ck1600 FIND v(dout0_95) AT=805.025n

.meas tran vdout0_96ck1600 FIND v(dout0_96) AT=805.025n

.meas tran vdout0_97ck1600 FIND v(dout0_97) AT=805.025n

.meas tran vdout0_98ck1600 FIND v(dout0_98) AT=805.025n

.meas tran vdout0_99ck1600 FIND v(dout0_99) AT=805.025n

.meas tran vdout0_100ck1600 FIND v(dout0_100) AT=805.025n

.meas tran vdout0_101ck1600 FIND v(dout0_101) AT=805.025n

.meas tran vdout0_102ck1600 FIND v(dout0_102) AT=805.025n

.meas tran vdout0_103ck1600 FIND v(dout0_103) AT=805.025n

.meas tran vdout0_104ck1600 FIND v(dout0_104) AT=805.025n

.meas tran vdout0_105ck1600 FIND v(dout0_105) AT=805.025n

.meas tran vdout0_106ck1600 FIND v(dout0_106) AT=805.025n

.meas tran vdout0_107ck1600 FIND v(dout0_107) AT=805.025n

.meas tran vdout0_108ck1600 FIND v(dout0_108) AT=805.025n

.meas tran vdout0_109ck1600 FIND v(dout0_109) AT=805.025n

.meas tran vdout0_110ck1600 FIND v(dout0_110) AT=805.025n

.meas tran vdout0_111ck1600 FIND v(dout0_111) AT=805.025n

.meas tran vdout0_112ck1600 FIND v(dout0_112) AT=805.025n

.meas tran vdout0_113ck1600 FIND v(dout0_113) AT=805.025n

.meas tran vdout0_114ck1600 FIND v(dout0_114) AT=805.025n

.meas tran vdout0_115ck1600 FIND v(dout0_115) AT=805.025n

.meas tran vdout0_116ck1600 FIND v(dout0_116) AT=805.025n

.meas tran vdout0_117ck1600 FIND v(dout0_117) AT=805.025n

.meas tran vdout0_118ck1600 FIND v(dout0_118) AT=805.025n

.meas tran vdout0_119ck1600 FIND v(dout0_119) AT=805.025n

.meas tran vdout0_120ck1600 FIND v(dout0_120) AT=805.025n

.meas tran vdout0_121ck1600 FIND v(dout0_121) AT=805.025n

.meas tran vdout0_122ck1600 FIND v(dout0_122) AT=805.025n

.meas tran vdout0_123ck1600 FIND v(dout0_123) AT=805.025n

.meas tran vdout0_124ck1600 FIND v(dout0_124) AT=805.025n

.meas tran vdout0_125ck1600 FIND v(dout0_125) AT=805.025n

.meas tran vdout0_126ck1600 FIND v(dout0_126) AT=805.025n

.meas tran vdout0_127ck1600 FIND v(dout0_127) AT=805.025n

.meas tran vdout0_128ck1600 FIND v(dout0_128) AT=805.025n

.meas tran vdout0_129ck1600 FIND v(dout0_129) AT=805.025n

.meas tran vdout0_130ck1600 FIND v(dout0_130) AT=805.025n

.meas tran vdout0_131ck1600 FIND v(dout0_131) AT=805.025n

.meas tran vdout0_132ck1600 FIND v(dout0_132) AT=805.025n

.meas tran vdout0_133ck1600 FIND v(dout0_133) AT=805.025n

.meas tran vdout0_134ck1600 FIND v(dout0_134) AT=805.025n

.meas tran vdout0_135ck1600 FIND v(dout0_135) AT=805.025n

.meas tran vdout0_136ck1600 FIND v(dout0_136) AT=805.025n

.meas tran vdout0_137ck1600 FIND v(dout0_137) AT=805.025n

.meas tran vdout0_138ck1600 FIND v(dout0_138) AT=805.025n

.meas tran vdout0_139ck1600 FIND v(dout0_139) AT=805.025n

.meas tran vdout0_140ck1600 FIND v(dout0_140) AT=805.025n

.meas tran vdout0_141ck1600 FIND v(dout0_141) AT=805.025n

.meas tran vdout0_142ck1600 FIND v(dout0_142) AT=805.025n

.meas tran vdout0_143ck1600 FIND v(dout0_143) AT=805.025n

.meas tran vdout0_144ck1600 FIND v(dout0_144) AT=805.025n

.meas tran vdout0_145ck1600 FIND v(dout0_145) AT=805.025n

.meas tran vdout0_146ck1600 FIND v(dout0_146) AT=805.025n

.meas tran vdout0_147ck1600 FIND v(dout0_147) AT=805.025n

.meas tran vdout0_148ck1600 FIND v(dout0_148) AT=805.025n

.meas tran vdout0_149ck1600 FIND v(dout0_149) AT=805.025n

.meas tran vdout0_150ck1600 FIND v(dout0_150) AT=805.025n

.meas tran vdout0_151ck1600 FIND v(dout0_151) AT=805.025n

.meas tran vdout0_152ck1600 FIND v(dout0_152) AT=805.025n

.meas tran vdout0_153ck1600 FIND v(dout0_153) AT=805.025n

.meas tran vdout0_154ck1600 FIND v(dout0_154) AT=805.025n

.meas tran vdout0_155ck1600 FIND v(dout0_155) AT=805.025n

.meas tran vdout0_156ck1600 FIND v(dout0_156) AT=805.025n

.meas tran vdout0_157ck1600 FIND v(dout0_157) AT=805.025n

.meas tran vdout0_158ck1600 FIND v(dout0_158) AT=805.025n

.meas tran vdout0_159ck1600 FIND v(dout0_159) AT=805.025n

.meas tran vdout0_160ck1600 FIND v(dout0_160) AT=805.025n

.meas tran vdout0_161ck1600 FIND v(dout0_161) AT=805.025n

.meas tran vdout0_162ck1600 FIND v(dout0_162) AT=805.025n

.meas tran vdout0_163ck1600 FIND v(dout0_163) AT=805.025n

.meas tran vdout0_164ck1600 FIND v(dout0_164) AT=805.025n

.meas tran vdout0_165ck1600 FIND v(dout0_165) AT=805.025n

.meas tran vdout0_166ck1600 FIND v(dout0_166) AT=805.025n

.meas tran vdout0_167ck1600 FIND v(dout0_167) AT=805.025n

.meas tran vdout0_168ck1600 FIND v(dout0_168) AT=805.025n

.meas tran vdout0_169ck1600 FIND v(dout0_169) AT=805.025n

.meas tran vdout0_170ck1600 FIND v(dout0_170) AT=805.025n

.meas tran vdout0_171ck1600 FIND v(dout0_171) AT=805.025n

.meas tran vdout0_172ck1600 FIND v(dout0_172) AT=805.025n

.meas tran vdout0_173ck1600 FIND v(dout0_173) AT=805.025n

.meas tran vdout0_174ck1600 FIND v(dout0_174) AT=805.025n

.meas tran vdout0_175ck1600 FIND v(dout0_175) AT=805.025n

.meas tran vdout0_176ck1600 FIND v(dout0_176) AT=805.025n

.meas tran vdout0_177ck1600 FIND v(dout0_177) AT=805.025n

.meas tran vdout0_178ck1600 FIND v(dout0_178) AT=805.025n

.meas tran vdout0_179ck1600 FIND v(dout0_179) AT=805.025n

.meas tran vdout0_180ck1600 FIND v(dout0_180) AT=805.025n

.meas tran vdout0_181ck1600 FIND v(dout0_181) AT=805.025n

.meas tran vdout0_182ck1600 FIND v(dout0_182) AT=805.025n

.meas tran vdout0_183ck1600 FIND v(dout0_183) AT=805.025n

.meas tran vdout0_184ck1600 FIND v(dout0_184) AT=805.025n

.meas tran vdout0_185ck1600 FIND v(dout0_185) AT=805.025n

.meas tran vdout0_186ck1600 FIND v(dout0_186) AT=805.025n

.meas tran vdout0_187ck1600 FIND v(dout0_187) AT=805.025n

.meas tran vdout0_188ck1600 FIND v(dout0_188) AT=805.025n

.meas tran vdout0_189ck1600 FIND v(dout0_189) AT=805.025n

.meas tran vdout0_190ck1600 FIND v(dout0_190) AT=805.025n

.meas tran vdout0_191ck1600 FIND v(dout0_191) AT=805.025n

.meas tran vdout0_192ck1600 FIND v(dout0_192) AT=805.025n

.meas tran vdout0_193ck1600 FIND v(dout0_193) AT=805.025n

.meas tran vdout0_194ck1600 FIND v(dout0_194) AT=805.025n

.meas tran vdout0_195ck1600 FIND v(dout0_195) AT=805.025n

.meas tran vdout0_196ck1600 FIND v(dout0_196) AT=805.025n

.meas tran vdout0_197ck1600 FIND v(dout0_197) AT=805.025n

.meas tran vdout0_198ck1600 FIND v(dout0_198) AT=805.025n

.meas tran vdout0_199ck1600 FIND v(dout0_199) AT=805.025n

.meas tran vdout0_200ck1600 FIND v(dout0_200) AT=805.025n

.meas tran vdout0_201ck1600 FIND v(dout0_201) AT=805.025n

.meas tran vdout0_202ck1600 FIND v(dout0_202) AT=805.025n

.meas tran vdout0_203ck1600 FIND v(dout0_203) AT=805.025n

.meas tran vdout0_204ck1600 FIND v(dout0_204) AT=805.025n

.meas tran vdout0_205ck1600 FIND v(dout0_205) AT=805.025n

.meas tran vdout0_206ck1600 FIND v(dout0_206) AT=805.025n

.meas tran vdout0_207ck1600 FIND v(dout0_207) AT=805.025n

.meas tran vdout0_208ck1600 FIND v(dout0_208) AT=805.025n

.meas tran vdout0_209ck1600 FIND v(dout0_209) AT=805.025n

.meas tran vdout0_210ck1600 FIND v(dout0_210) AT=805.025n

.meas tran vdout0_211ck1600 FIND v(dout0_211) AT=805.025n

.meas tran vdout0_212ck1600 FIND v(dout0_212) AT=805.025n

.meas tran vdout0_213ck1600 FIND v(dout0_213) AT=805.025n

.meas tran vdout0_214ck1600 FIND v(dout0_214) AT=805.025n

.meas tran vdout0_215ck1600 FIND v(dout0_215) AT=805.025n

.meas tran vdout0_216ck1600 FIND v(dout0_216) AT=805.025n

.meas tran vdout0_217ck1600 FIND v(dout0_217) AT=805.025n

.meas tran vdout0_218ck1600 FIND v(dout0_218) AT=805.025n

.meas tran vdout0_219ck1600 FIND v(dout0_219) AT=805.025n

.meas tran vdout0_220ck1600 FIND v(dout0_220) AT=805.025n

.meas tran vdout0_221ck1600 FIND v(dout0_221) AT=805.025n

.meas tran vdout0_222ck1600 FIND v(dout0_222) AT=805.025n

.meas tran vdout0_223ck1600 FIND v(dout0_223) AT=805.025n

.meas tran vdout0_224ck1600 FIND v(dout0_224) AT=805.025n

.meas tran vdout0_225ck1600 FIND v(dout0_225) AT=805.025n

.meas tran vdout0_226ck1600 FIND v(dout0_226) AT=805.025n

.meas tran vdout0_227ck1600 FIND v(dout0_227) AT=805.025n

.meas tran vdout0_228ck1600 FIND v(dout0_228) AT=805.025n

.meas tran vdout0_229ck1600 FIND v(dout0_229) AT=805.025n

.meas tran vdout0_230ck1600 FIND v(dout0_230) AT=805.025n

.meas tran vdout0_231ck1600 FIND v(dout0_231) AT=805.025n

.meas tran vdout0_232ck1600 FIND v(dout0_232) AT=805.025n

.meas tran vdout0_233ck1600 FIND v(dout0_233) AT=805.025n

.meas tran vdout0_234ck1600 FIND v(dout0_234) AT=805.025n

.meas tran vdout0_235ck1600 FIND v(dout0_235) AT=805.025n

.meas tran vdout0_236ck1600 FIND v(dout0_236) AT=805.025n

.meas tran vdout0_237ck1600 FIND v(dout0_237) AT=805.025n

.meas tran vdout0_238ck1600 FIND v(dout0_238) AT=805.025n

.meas tran vdout0_239ck1600 FIND v(dout0_239) AT=805.025n

.meas tran vdout0_240ck1600 FIND v(dout0_240) AT=805.025n

.meas tran vdout0_241ck1600 FIND v(dout0_241) AT=805.025n

.meas tran vdout0_242ck1600 FIND v(dout0_242) AT=805.025n

.meas tran vdout0_243ck1600 FIND v(dout0_243) AT=805.025n

.meas tran vdout0_244ck1600 FIND v(dout0_244) AT=805.025n

.meas tran vdout0_245ck1600 FIND v(dout0_245) AT=805.025n

.meas tran vdout0_246ck1600 FIND v(dout0_246) AT=805.025n

.meas tran vdout0_247ck1600 FIND v(dout0_247) AT=805.025n

.meas tran vdout0_248ck1600 FIND v(dout0_248) AT=805.025n

.meas tran vdout0_249ck1600 FIND v(dout0_249) AT=805.025n

.meas tran vdout0_250ck1600 FIND v(dout0_250) AT=805.025n

.meas tran vdout0_251ck1600 FIND v(dout0_251) AT=805.025n

.meas tran vdout0_252ck1600 FIND v(dout0_252) AT=805.025n

.meas tran vdout0_253ck1600 FIND v(dout0_253) AT=805.025n

.meas tran vdout0_254ck1600 FIND v(dout0_254) AT=805.025n

.meas tran vdout0_255ck1600 FIND v(dout0_255) AT=805.025n

.meas tran vdout0_0ck1650 FIND v(dout0_0) AT=830.025n

.meas tran vdout0_1ck1650 FIND v(dout0_1) AT=830.025n

.meas tran vdout0_2ck1650 FIND v(dout0_2) AT=830.025n

.meas tran vdout0_3ck1650 FIND v(dout0_3) AT=830.025n

.meas tran vdout0_4ck1650 FIND v(dout0_4) AT=830.025n

.meas tran vdout0_5ck1650 FIND v(dout0_5) AT=830.025n

.meas tran vdout0_6ck1650 FIND v(dout0_6) AT=830.025n

.meas tran vdout0_7ck1650 FIND v(dout0_7) AT=830.025n

.meas tran vdout0_8ck1650 FIND v(dout0_8) AT=830.025n

.meas tran vdout0_9ck1650 FIND v(dout0_9) AT=830.025n

.meas tran vdout0_10ck1650 FIND v(dout0_10) AT=830.025n

.meas tran vdout0_11ck1650 FIND v(dout0_11) AT=830.025n

.meas tran vdout0_12ck1650 FIND v(dout0_12) AT=830.025n

.meas tran vdout0_13ck1650 FIND v(dout0_13) AT=830.025n

.meas tran vdout0_14ck1650 FIND v(dout0_14) AT=830.025n

.meas tran vdout0_15ck1650 FIND v(dout0_15) AT=830.025n

.meas tran vdout0_16ck1650 FIND v(dout0_16) AT=830.025n

.meas tran vdout0_17ck1650 FIND v(dout0_17) AT=830.025n

.meas tran vdout0_18ck1650 FIND v(dout0_18) AT=830.025n

.meas tran vdout0_19ck1650 FIND v(dout0_19) AT=830.025n

.meas tran vdout0_20ck1650 FIND v(dout0_20) AT=830.025n

.meas tran vdout0_21ck1650 FIND v(dout0_21) AT=830.025n

.meas tran vdout0_22ck1650 FIND v(dout0_22) AT=830.025n

.meas tran vdout0_23ck1650 FIND v(dout0_23) AT=830.025n

.meas tran vdout0_24ck1650 FIND v(dout0_24) AT=830.025n

.meas tran vdout0_25ck1650 FIND v(dout0_25) AT=830.025n

.meas tran vdout0_26ck1650 FIND v(dout0_26) AT=830.025n

.meas tran vdout0_27ck1650 FIND v(dout0_27) AT=830.025n

.meas tran vdout0_28ck1650 FIND v(dout0_28) AT=830.025n

.meas tran vdout0_29ck1650 FIND v(dout0_29) AT=830.025n

.meas tran vdout0_30ck1650 FIND v(dout0_30) AT=830.025n

.meas tran vdout0_31ck1650 FIND v(dout0_31) AT=830.025n

.meas tran vdout0_32ck1650 FIND v(dout0_32) AT=830.025n

.meas tran vdout0_33ck1650 FIND v(dout0_33) AT=830.025n

.meas tran vdout0_34ck1650 FIND v(dout0_34) AT=830.025n

.meas tran vdout0_35ck1650 FIND v(dout0_35) AT=830.025n

.meas tran vdout0_36ck1650 FIND v(dout0_36) AT=830.025n

.meas tran vdout0_37ck1650 FIND v(dout0_37) AT=830.025n

.meas tran vdout0_38ck1650 FIND v(dout0_38) AT=830.025n

.meas tran vdout0_39ck1650 FIND v(dout0_39) AT=830.025n

.meas tran vdout0_40ck1650 FIND v(dout0_40) AT=830.025n

.meas tran vdout0_41ck1650 FIND v(dout0_41) AT=830.025n

.meas tran vdout0_42ck1650 FIND v(dout0_42) AT=830.025n

.meas tran vdout0_43ck1650 FIND v(dout0_43) AT=830.025n

.meas tran vdout0_44ck1650 FIND v(dout0_44) AT=830.025n

.meas tran vdout0_45ck1650 FIND v(dout0_45) AT=830.025n

.meas tran vdout0_46ck1650 FIND v(dout0_46) AT=830.025n

.meas tran vdout0_47ck1650 FIND v(dout0_47) AT=830.025n

.meas tran vdout0_48ck1650 FIND v(dout0_48) AT=830.025n

.meas tran vdout0_49ck1650 FIND v(dout0_49) AT=830.025n

.meas tran vdout0_50ck1650 FIND v(dout0_50) AT=830.025n

.meas tran vdout0_51ck1650 FIND v(dout0_51) AT=830.025n

.meas tran vdout0_52ck1650 FIND v(dout0_52) AT=830.025n

.meas tran vdout0_53ck1650 FIND v(dout0_53) AT=830.025n

.meas tran vdout0_54ck1650 FIND v(dout0_54) AT=830.025n

.meas tran vdout0_55ck1650 FIND v(dout0_55) AT=830.025n

.meas tran vdout0_56ck1650 FIND v(dout0_56) AT=830.025n

.meas tran vdout0_57ck1650 FIND v(dout0_57) AT=830.025n

.meas tran vdout0_58ck1650 FIND v(dout0_58) AT=830.025n

.meas tran vdout0_59ck1650 FIND v(dout0_59) AT=830.025n

.meas tran vdout0_60ck1650 FIND v(dout0_60) AT=830.025n

.meas tran vdout0_61ck1650 FIND v(dout0_61) AT=830.025n

.meas tran vdout0_62ck1650 FIND v(dout0_62) AT=830.025n

.meas tran vdout0_63ck1650 FIND v(dout0_63) AT=830.025n

.meas tran vdout0_64ck1650 FIND v(dout0_64) AT=830.025n

.meas tran vdout0_65ck1650 FIND v(dout0_65) AT=830.025n

.meas tran vdout0_66ck1650 FIND v(dout0_66) AT=830.025n

.meas tran vdout0_67ck1650 FIND v(dout0_67) AT=830.025n

.meas tran vdout0_68ck1650 FIND v(dout0_68) AT=830.025n

.meas tran vdout0_69ck1650 FIND v(dout0_69) AT=830.025n

.meas tran vdout0_70ck1650 FIND v(dout0_70) AT=830.025n

.meas tran vdout0_71ck1650 FIND v(dout0_71) AT=830.025n

.meas tran vdout0_72ck1650 FIND v(dout0_72) AT=830.025n

.meas tran vdout0_73ck1650 FIND v(dout0_73) AT=830.025n

.meas tran vdout0_74ck1650 FIND v(dout0_74) AT=830.025n

.meas tran vdout0_75ck1650 FIND v(dout0_75) AT=830.025n

.meas tran vdout0_76ck1650 FIND v(dout0_76) AT=830.025n

.meas tran vdout0_77ck1650 FIND v(dout0_77) AT=830.025n

.meas tran vdout0_78ck1650 FIND v(dout0_78) AT=830.025n

.meas tran vdout0_79ck1650 FIND v(dout0_79) AT=830.025n

.meas tran vdout0_80ck1650 FIND v(dout0_80) AT=830.025n

.meas tran vdout0_81ck1650 FIND v(dout0_81) AT=830.025n

.meas tran vdout0_82ck1650 FIND v(dout0_82) AT=830.025n

.meas tran vdout0_83ck1650 FIND v(dout0_83) AT=830.025n

.meas tran vdout0_84ck1650 FIND v(dout0_84) AT=830.025n

.meas tran vdout0_85ck1650 FIND v(dout0_85) AT=830.025n

.meas tran vdout0_86ck1650 FIND v(dout0_86) AT=830.025n

.meas tran vdout0_87ck1650 FIND v(dout0_87) AT=830.025n

.meas tran vdout0_88ck1650 FIND v(dout0_88) AT=830.025n

.meas tran vdout0_89ck1650 FIND v(dout0_89) AT=830.025n

.meas tran vdout0_90ck1650 FIND v(dout0_90) AT=830.025n

.meas tran vdout0_91ck1650 FIND v(dout0_91) AT=830.025n

.meas tran vdout0_92ck1650 FIND v(dout0_92) AT=830.025n

.meas tran vdout0_93ck1650 FIND v(dout0_93) AT=830.025n

.meas tran vdout0_94ck1650 FIND v(dout0_94) AT=830.025n

.meas tran vdout0_95ck1650 FIND v(dout0_95) AT=830.025n

.meas tran vdout0_96ck1650 FIND v(dout0_96) AT=830.025n

.meas tran vdout0_97ck1650 FIND v(dout0_97) AT=830.025n

.meas tran vdout0_98ck1650 FIND v(dout0_98) AT=830.025n

.meas tran vdout0_99ck1650 FIND v(dout0_99) AT=830.025n

.meas tran vdout0_100ck1650 FIND v(dout0_100) AT=830.025n

.meas tran vdout0_101ck1650 FIND v(dout0_101) AT=830.025n

.meas tran vdout0_102ck1650 FIND v(dout0_102) AT=830.025n

.meas tran vdout0_103ck1650 FIND v(dout0_103) AT=830.025n

.meas tran vdout0_104ck1650 FIND v(dout0_104) AT=830.025n

.meas tran vdout0_105ck1650 FIND v(dout0_105) AT=830.025n

.meas tran vdout0_106ck1650 FIND v(dout0_106) AT=830.025n

.meas tran vdout0_107ck1650 FIND v(dout0_107) AT=830.025n

.meas tran vdout0_108ck1650 FIND v(dout0_108) AT=830.025n

.meas tran vdout0_109ck1650 FIND v(dout0_109) AT=830.025n

.meas tran vdout0_110ck1650 FIND v(dout0_110) AT=830.025n

.meas tran vdout0_111ck1650 FIND v(dout0_111) AT=830.025n

.meas tran vdout0_112ck1650 FIND v(dout0_112) AT=830.025n

.meas tran vdout0_113ck1650 FIND v(dout0_113) AT=830.025n

.meas tran vdout0_114ck1650 FIND v(dout0_114) AT=830.025n

.meas tran vdout0_115ck1650 FIND v(dout0_115) AT=830.025n

.meas tran vdout0_116ck1650 FIND v(dout0_116) AT=830.025n

.meas tran vdout0_117ck1650 FIND v(dout0_117) AT=830.025n

.meas tran vdout0_118ck1650 FIND v(dout0_118) AT=830.025n

.meas tran vdout0_119ck1650 FIND v(dout0_119) AT=830.025n

.meas tran vdout0_120ck1650 FIND v(dout0_120) AT=830.025n

.meas tran vdout0_121ck1650 FIND v(dout0_121) AT=830.025n

.meas tran vdout0_122ck1650 FIND v(dout0_122) AT=830.025n

.meas tran vdout0_123ck1650 FIND v(dout0_123) AT=830.025n

.meas tran vdout0_124ck1650 FIND v(dout0_124) AT=830.025n

.meas tran vdout0_125ck1650 FIND v(dout0_125) AT=830.025n

.meas tran vdout0_126ck1650 FIND v(dout0_126) AT=830.025n

.meas tran vdout0_127ck1650 FIND v(dout0_127) AT=830.025n

.meas tran vdout0_128ck1650 FIND v(dout0_128) AT=830.025n

.meas tran vdout0_129ck1650 FIND v(dout0_129) AT=830.025n

.meas tran vdout0_130ck1650 FIND v(dout0_130) AT=830.025n

.meas tran vdout0_131ck1650 FIND v(dout0_131) AT=830.025n

.meas tran vdout0_132ck1650 FIND v(dout0_132) AT=830.025n

.meas tran vdout0_133ck1650 FIND v(dout0_133) AT=830.025n

.meas tran vdout0_134ck1650 FIND v(dout0_134) AT=830.025n

.meas tran vdout0_135ck1650 FIND v(dout0_135) AT=830.025n

.meas tran vdout0_136ck1650 FIND v(dout0_136) AT=830.025n

.meas tran vdout0_137ck1650 FIND v(dout0_137) AT=830.025n

.meas tran vdout0_138ck1650 FIND v(dout0_138) AT=830.025n

.meas tran vdout0_139ck1650 FIND v(dout0_139) AT=830.025n

.meas tran vdout0_140ck1650 FIND v(dout0_140) AT=830.025n

.meas tran vdout0_141ck1650 FIND v(dout0_141) AT=830.025n

.meas tran vdout0_142ck1650 FIND v(dout0_142) AT=830.025n

.meas tran vdout0_143ck1650 FIND v(dout0_143) AT=830.025n

.meas tran vdout0_144ck1650 FIND v(dout0_144) AT=830.025n

.meas tran vdout0_145ck1650 FIND v(dout0_145) AT=830.025n

.meas tran vdout0_146ck1650 FIND v(dout0_146) AT=830.025n

.meas tran vdout0_147ck1650 FIND v(dout0_147) AT=830.025n

.meas tran vdout0_148ck1650 FIND v(dout0_148) AT=830.025n

.meas tran vdout0_149ck1650 FIND v(dout0_149) AT=830.025n

.meas tran vdout0_150ck1650 FIND v(dout0_150) AT=830.025n

.meas tran vdout0_151ck1650 FIND v(dout0_151) AT=830.025n

.meas tran vdout0_152ck1650 FIND v(dout0_152) AT=830.025n

.meas tran vdout0_153ck1650 FIND v(dout0_153) AT=830.025n

.meas tran vdout0_154ck1650 FIND v(dout0_154) AT=830.025n

.meas tran vdout0_155ck1650 FIND v(dout0_155) AT=830.025n

.meas tran vdout0_156ck1650 FIND v(dout0_156) AT=830.025n

.meas tran vdout0_157ck1650 FIND v(dout0_157) AT=830.025n

.meas tran vdout0_158ck1650 FIND v(dout0_158) AT=830.025n

.meas tran vdout0_159ck1650 FIND v(dout0_159) AT=830.025n

.meas tran vdout0_160ck1650 FIND v(dout0_160) AT=830.025n

.meas tran vdout0_161ck1650 FIND v(dout0_161) AT=830.025n

.meas tran vdout0_162ck1650 FIND v(dout0_162) AT=830.025n

.meas tran vdout0_163ck1650 FIND v(dout0_163) AT=830.025n

.meas tran vdout0_164ck1650 FIND v(dout0_164) AT=830.025n

.meas tran vdout0_165ck1650 FIND v(dout0_165) AT=830.025n

.meas tran vdout0_166ck1650 FIND v(dout0_166) AT=830.025n

.meas tran vdout0_167ck1650 FIND v(dout0_167) AT=830.025n

.meas tran vdout0_168ck1650 FIND v(dout0_168) AT=830.025n

.meas tran vdout0_169ck1650 FIND v(dout0_169) AT=830.025n

.meas tran vdout0_170ck1650 FIND v(dout0_170) AT=830.025n

.meas tran vdout0_171ck1650 FIND v(dout0_171) AT=830.025n

.meas tran vdout0_172ck1650 FIND v(dout0_172) AT=830.025n

.meas tran vdout0_173ck1650 FIND v(dout0_173) AT=830.025n

.meas tran vdout0_174ck1650 FIND v(dout0_174) AT=830.025n

.meas tran vdout0_175ck1650 FIND v(dout0_175) AT=830.025n

.meas tran vdout0_176ck1650 FIND v(dout0_176) AT=830.025n

.meas tran vdout0_177ck1650 FIND v(dout0_177) AT=830.025n

.meas tran vdout0_178ck1650 FIND v(dout0_178) AT=830.025n

.meas tran vdout0_179ck1650 FIND v(dout0_179) AT=830.025n

.meas tran vdout0_180ck1650 FIND v(dout0_180) AT=830.025n

.meas tran vdout0_181ck1650 FIND v(dout0_181) AT=830.025n

.meas tran vdout0_182ck1650 FIND v(dout0_182) AT=830.025n

.meas tran vdout0_183ck1650 FIND v(dout0_183) AT=830.025n

.meas tran vdout0_184ck1650 FIND v(dout0_184) AT=830.025n

.meas tran vdout0_185ck1650 FIND v(dout0_185) AT=830.025n

.meas tran vdout0_186ck1650 FIND v(dout0_186) AT=830.025n

.meas tran vdout0_187ck1650 FIND v(dout0_187) AT=830.025n

.meas tran vdout0_188ck1650 FIND v(dout0_188) AT=830.025n

.meas tran vdout0_189ck1650 FIND v(dout0_189) AT=830.025n

.meas tran vdout0_190ck1650 FIND v(dout0_190) AT=830.025n

.meas tran vdout0_191ck1650 FIND v(dout0_191) AT=830.025n

.meas tran vdout0_192ck1650 FIND v(dout0_192) AT=830.025n

.meas tran vdout0_193ck1650 FIND v(dout0_193) AT=830.025n

.meas tran vdout0_194ck1650 FIND v(dout0_194) AT=830.025n

.meas tran vdout0_195ck1650 FIND v(dout0_195) AT=830.025n

.meas tran vdout0_196ck1650 FIND v(dout0_196) AT=830.025n

.meas tran vdout0_197ck1650 FIND v(dout0_197) AT=830.025n

.meas tran vdout0_198ck1650 FIND v(dout0_198) AT=830.025n

.meas tran vdout0_199ck1650 FIND v(dout0_199) AT=830.025n

.meas tran vdout0_200ck1650 FIND v(dout0_200) AT=830.025n

.meas tran vdout0_201ck1650 FIND v(dout0_201) AT=830.025n

.meas tran vdout0_202ck1650 FIND v(dout0_202) AT=830.025n

.meas tran vdout0_203ck1650 FIND v(dout0_203) AT=830.025n

.meas tran vdout0_204ck1650 FIND v(dout0_204) AT=830.025n

.meas tran vdout0_205ck1650 FIND v(dout0_205) AT=830.025n

.meas tran vdout0_206ck1650 FIND v(dout0_206) AT=830.025n

.meas tran vdout0_207ck1650 FIND v(dout0_207) AT=830.025n

.meas tran vdout0_208ck1650 FIND v(dout0_208) AT=830.025n

.meas tran vdout0_209ck1650 FIND v(dout0_209) AT=830.025n

.meas tran vdout0_210ck1650 FIND v(dout0_210) AT=830.025n

.meas tran vdout0_211ck1650 FIND v(dout0_211) AT=830.025n

.meas tran vdout0_212ck1650 FIND v(dout0_212) AT=830.025n

.meas tran vdout0_213ck1650 FIND v(dout0_213) AT=830.025n

.meas tran vdout0_214ck1650 FIND v(dout0_214) AT=830.025n

.meas tran vdout0_215ck1650 FIND v(dout0_215) AT=830.025n

.meas tran vdout0_216ck1650 FIND v(dout0_216) AT=830.025n

.meas tran vdout0_217ck1650 FIND v(dout0_217) AT=830.025n

.meas tran vdout0_218ck1650 FIND v(dout0_218) AT=830.025n

.meas tran vdout0_219ck1650 FIND v(dout0_219) AT=830.025n

.meas tran vdout0_220ck1650 FIND v(dout0_220) AT=830.025n

.meas tran vdout0_221ck1650 FIND v(dout0_221) AT=830.025n

.meas tran vdout0_222ck1650 FIND v(dout0_222) AT=830.025n

.meas tran vdout0_223ck1650 FIND v(dout0_223) AT=830.025n

.meas tran vdout0_224ck1650 FIND v(dout0_224) AT=830.025n

.meas tran vdout0_225ck1650 FIND v(dout0_225) AT=830.025n

.meas tran vdout0_226ck1650 FIND v(dout0_226) AT=830.025n

.meas tran vdout0_227ck1650 FIND v(dout0_227) AT=830.025n

.meas tran vdout0_228ck1650 FIND v(dout0_228) AT=830.025n

.meas tran vdout0_229ck1650 FIND v(dout0_229) AT=830.025n

.meas tran vdout0_230ck1650 FIND v(dout0_230) AT=830.025n

.meas tran vdout0_231ck1650 FIND v(dout0_231) AT=830.025n

.meas tran vdout0_232ck1650 FIND v(dout0_232) AT=830.025n

.meas tran vdout0_233ck1650 FIND v(dout0_233) AT=830.025n

.meas tran vdout0_234ck1650 FIND v(dout0_234) AT=830.025n

.meas tran vdout0_235ck1650 FIND v(dout0_235) AT=830.025n

.meas tran vdout0_236ck1650 FIND v(dout0_236) AT=830.025n

.meas tran vdout0_237ck1650 FIND v(dout0_237) AT=830.025n

.meas tran vdout0_238ck1650 FIND v(dout0_238) AT=830.025n

.meas tran vdout0_239ck1650 FIND v(dout0_239) AT=830.025n

.meas tran vdout0_240ck1650 FIND v(dout0_240) AT=830.025n

.meas tran vdout0_241ck1650 FIND v(dout0_241) AT=830.025n

.meas tran vdout0_242ck1650 FIND v(dout0_242) AT=830.025n

.meas tran vdout0_243ck1650 FIND v(dout0_243) AT=830.025n

.meas tran vdout0_244ck1650 FIND v(dout0_244) AT=830.025n

.meas tran vdout0_245ck1650 FIND v(dout0_245) AT=830.025n

.meas tran vdout0_246ck1650 FIND v(dout0_246) AT=830.025n

.meas tran vdout0_247ck1650 FIND v(dout0_247) AT=830.025n

.meas tran vdout0_248ck1650 FIND v(dout0_248) AT=830.025n

.meas tran vdout0_249ck1650 FIND v(dout0_249) AT=830.025n

.meas tran vdout0_250ck1650 FIND v(dout0_250) AT=830.025n

.meas tran vdout0_251ck1650 FIND v(dout0_251) AT=830.025n

.meas tran vdout0_252ck1650 FIND v(dout0_252) AT=830.025n

.meas tran vdout0_253ck1650 FIND v(dout0_253) AT=830.025n

.meas tran vdout0_254ck1650 FIND v(dout0_254) AT=830.025n

.meas tran vdout0_255ck1650 FIND v(dout0_255) AT=830.025n

.meas tran vdout0_0ck1660 FIND v(dout0_0) AT=835.025n

.meas tran vdout0_1ck1660 FIND v(dout0_1) AT=835.025n

.meas tran vdout0_2ck1660 FIND v(dout0_2) AT=835.025n

.meas tran vdout0_3ck1660 FIND v(dout0_3) AT=835.025n

.meas tran vdout0_4ck1660 FIND v(dout0_4) AT=835.025n

.meas tran vdout0_5ck1660 FIND v(dout0_5) AT=835.025n

.meas tran vdout0_6ck1660 FIND v(dout0_6) AT=835.025n

.meas tran vdout0_7ck1660 FIND v(dout0_7) AT=835.025n

.meas tran vdout0_8ck1660 FIND v(dout0_8) AT=835.025n

.meas tran vdout0_9ck1660 FIND v(dout0_9) AT=835.025n

.meas tran vdout0_10ck1660 FIND v(dout0_10) AT=835.025n

.meas tran vdout0_11ck1660 FIND v(dout0_11) AT=835.025n

.meas tran vdout0_12ck1660 FIND v(dout0_12) AT=835.025n

.meas tran vdout0_13ck1660 FIND v(dout0_13) AT=835.025n

.meas tran vdout0_14ck1660 FIND v(dout0_14) AT=835.025n

.meas tran vdout0_15ck1660 FIND v(dout0_15) AT=835.025n

.meas tran vdout0_16ck1660 FIND v(dout0_16) AT=835.025n

.meas tran vdout0_17ck1660 FIND v(dout0_17) AT=835.025n

.meas tran vdout0_18ck1660 FIND v(dout0_18) AT=835.025n

.meas tran vdout0_19ck1660 FIND v(dout0_19) AT=835.025n

.meas tran vdout0_20ck1660 FIND v(dout0_20) AT=835.025n

.meas tran vdout0_21ck1660 FIND v(dout0_21) AT=835.025n

.meas tran vdout0_22ck1660 FIND v(dout0_22) AT=835.025n

.meas tran vdout0_23ck1660 FIND v(dout0_23) AT=835.025n

.meas tran vdout0_24ck1660 FIND v(dout0_24) AT=835.025n

.meas tran vdout0_25ck1660 FIND v(dout0_25) AT=835.025n

.meas tran vdout0_26ck1660 FIND v(dout0_26) AT=835.025n

.meas tran vdout0_27ck1660 FIND v(dout0_27) AT=835.025n

.meas tran vdout0_28ck1660 FIND v(dout0_28) AT=835.025n

.meas tran vdout0_29ck1660 FIND v(dout0_29) AT=835.025n

.meas tran vdout0_30ck1660 FIND v(dout0_30) AT=835.025n

.meas tran vdout0_31ck1660 FIND v(dout0_31) AT=835.025n

.meas tran vdout0_32ck1660 FIND v(dout0_32) AT=835.025n

.meas tran vdout0_33ck1660 FIND v(dout0_33) AT=835.025n

.meas tran vdout0_34ck1660 FIND v(dout0_34) AT=835.025n

.meas tran vdout0_35ck1660 FIND v(dout0_35) AT=835.025n

.meas tran vdout0_36ck1660 FIND v(dout0_36) AT=835.025n

.meas tran vdout0_37ck1660 FIND v(dout0_37) AT=835.025n

.meas tran vdout0_38ck1660 FIND v(dout0_38) AT=835.025n

.meas tran vdout0_39ck1660 FIND v(dout0_39) AT=835.025n

.meas tran vdout0_40ck1660 FIND v(dout0_40) AT=835.025n

.meas tran vdout0_41ck1660 FIND v(dout0_41) AT=835.025n

.meas tran vdout0_42ck1660 FIND v(dout0_42) AT=835.025n

.meas tran vdout0_43ck1660 FIND v(dout0_43) AT=835.025n

.meas tran vdout0_44ck1660 FIND v(dout0_44) AT=835.025n

.meas tran vdout0_45ck1660 FIND v(dout0_45) AT=835.025n

.meas tran vdout0_46ck1660 FIND v(dout0_46) AT=835.025n

.meas tran vdout0_47ck1660 FIND v(dout0_47) AT=835.025n

.meas tran vdout0_48ck1660 FIND v(dout0_48) AT=835.025n

.meas tran vdout0_49ck1660 FIND v(dout0_49) AT=835.025n

.meas tran vdout0_50ck1660 FIND v(dout0_50) AT=835.025n

.meas tran vdout0_51ck1660 FIND v(dout0_51) AT=835.025n

.meas tran vdout0_52ck1660 FIND v(dout0_52) AT=835.025n

.meas tran vdout0_53ck1660 FIND v(dout0_53) AT=835.025n

.meas tran vdout0_54ck1660 FIND v(dout0_54) AT=835.025n

.meas tran vdout0_55ck1660 FIND v(dout0_55) AT=835.025n

.meas tran vdout0_56ck1660 FIND v(dout0_56) AT=835.025n

.meas tran vdout0_57ck1660 FIND v(dout0_57) AT=835.025n

.meas tran vdout0_58ck1660 FIND v(dout0_58) AT=835.025n

.meas tran vdout0_59ck1660 FIND v(dout0_59) AT=835.025n

.meas tran vdout0_60ck1660 FIND v(dout0_60) AT=835.025n

.meas tran vdout0_61ck1660 FIND v(dout0_61) AT=835.025n

.meas tran vdout0_62ck1660 FIND v(dout0_62) AT=835.025n

.meas tran vdout0_63ck1660 FIND v(dout0_63) AT=835.025n

.meas tran vdout0_64ck1660 FIND v(dout0_64) AT=835.025n

.meas tran vdout0_65ck1660 FIND v(dout0_65) AT=835.025n

.meas tran vdout0_66ck1660 FIND v(dout0_66) AT=835.025n

.meas tran vdout0_67ck1660 FIND v(dout0_67) AT=835.025n

.meas tran vdout0_68ck1660 FIND v(dout0_68) AT=835.025n

.meas tran vdout0_69ck1660 FIND v(dout0_69) AT=835.025n

.meas tran vdout0_70ck1660 FIND v(dout0_70) AT=835.025n

.meas tran vdout0_71ck1660 FIND v(dout0_71) AT=835.025n

.meas tran vdout0_72ck1660 FIND v(dout0_72) AT=835.025n

.meas tran vdout0_73ck1660 FIND v(dout0_73) AT=835.025n

.meas tran vdout0_74ck1660 FIND v(dout0_74) AT=835.025n

.meas tran vdout0_75ck1660 FIND v(dout0_75) AT=835.025n

.meas tran vdout0_76ck1660 FIND v(dout0_76) AT=835.025n

.meas tran vdout0_77ck1660 FIND v(dout0_77) AT=835.025n

.meas tran vdout0_78ck1660 FIND v(dout0_78) AT=835.025n

.meas tran vdout0_79ck1660 FIND v(dout0_79) AT=835.025n

.meas tran vdout0_80ck1660 FIND v(dout0_80) AT=835.025n

.meas tran vdout0_81ck1660 FIND v(dout0_81) AT=835.025n

.meas tran vdout0_82ck1660 FIND v(dout0_82) AT=835.025n

.meas tran vdout0_83ck1660 FIND v(dout0_83) AT=835.025n

.meas tran vdout0_84ck1660 FIND v(dout0_84) AT=835.025n

.meas tran vdout0_85ck1660 FIND v(dout0_85) AT=835.025n

.meas tran vdout0_86ck1660 FIND v(dout0_86) AT=835.025n

.meas tran vdout0_87ck1660 FIND v(dout0_87) AT=835.025n

.meas tran vdout0_88ck1660 FIND v(dout0_88) AT=835.025n

.meas tran vdout0_89ck1660 FIND v(dout0_89) AT=835.025n

.meas tran vdout0_90ck1660 FIND v(dout0_90) AT=835.025n

.meas tran vdout0_91ck1660 FIND v(dout0_91) AT=835.025n

.meas tran vdout0_92ck1660 FIND v(dout0_92) AT=835.025n

.meas tran vdout0_93ck1660 FIND v(dout0_93) AT=835.025n

.meas tran vdout0_94ck1660 FIND v(dout0_94) AT=835.025n

.meas tran vdout0_95ck1660 FIND v(dout0_95) AT=835.025n

.meas tran vdout0_96ck1660 FIND v(dout0_96) AT=835.025n

.meas tran vdout0_97ck1660 FIND v(dout0_97) AT=835.025n

.meas tran vdout0_98ck1660 FIND v(dout0_98) AT=835.025n

.meas tran vdout0_99ck1660 FIND v(dout0_99) AT=835.025n

.meas tran vdout0_100ck1660 FIND v(dout0_100) AT=835.025n

.meas tran vdout0_101ck1660 FIND v(dout0_101) AT=835.025n

.meas tran vdout0_102ck1660 FIND v(dout0_102) AT=835.025n

.meas tran vdout0_103ck1660 FIND v(dout0_103) AT=835.025n

.meas tran vdout0_104ck1660 FIND v(dout0_104) AT=835.025n

.meas tran vdout0_105ck1660 FIND v(dout0_105) AT=835.025n

.meas tran vdout0_106ck1660 FIND v(dout0_106) AT=835.025n

.meas tran vdout0_107ck1660 FIND v(dout0_107) AT=835.025n

.meas tran vdout0_108ck1660 FIND v(dout0_108) AT=835.025n

.meas tran vdout0_109ck1660 FIND v(dout0_109) AT=835.025n

.meas tran vdout0_110ck1660 FIND v(dout0_110) AT=835.025n

.meas tran vdout0_111ck1660 FIND v(dout0_111) AT=835.025n

.meas tran vdout0_112ck1660 FIND v(dout0_112) AT=835.025n

.meas tran vdout0_113ck1660 FIND v(dout0_113) AT=835.025n

.meas tran vdout0_114ck1660 FIND v(dout0_114) AT=835.025n

.meas tran vdout0_115ck1660 FIND v(dout0_115) AT=835.025n

.meas tran vdout0_116ck1660 FIND v(dout0_116) AT=835.025n

.meas tran vdout0_117ck1660 FIND v(dout0_117) AT=835.025n

.meas tran vdout0_118ck1660 FIND v(dout0_118) AT=835.025n

.meas tran vdout0_119ck1660 FIND v(dout0_119) AT=835.025n

.meas tran vdout0_120ck1660 FIND v(dout0_120) AT=835.025n

.meas tran vdout0_121ck1660 FIND v(dout0_121) AT=835.025n

.meas tran vdout0_122ck1660 FIND v(dout0_122) AT=835.025n

.meas tran vdout0_123ck1660 FIND v(dout0_123) AT=835.025n

.meas tran vdout0_124ck1660 FIND v(dout0_124) AT=835.025n

.meas tran vdout0_125ck1660 FIND v(dout0_125) AT=835.025n

.meas tran vdout0_126ck1660 FIND v(dout0_126) AT=835.025n

.meas tran vdout0_127ck1660 FIND v(dout0_127) AT=835.025n

.meas tran vdout0_128ck1660 FIND v(dout0_128) AT=835.025n

.meas tran vdout0_129ck1660 FIND v(dout0_129) AT=835.025n

.meas tran vdout0_130ck1660 FIND v(dout0_130) AT=835.025n

.meas tran vdout0_131ck1660 FIND v(dout0_131) AT=835.025n

.meas tran vdout0_132ck1660 FIND v(dout0_132) AT=835.025n

.meas tran vdout0_133ck1660 FIND v(dout0_133) AT=835.025n

.meas tran vdout0_134ck1660 FIND v(dout0_134) AT=835.025n

.meas tran vdout0_135ck1660 FIND v(dout0_135) AT=835.025n

.meas tran vdout0_136ck1660 FIND v(dout0_136) AT=835.025n

.meas tran vdout0_137ck1660 FIND v(dout0_137) AT=835.025n

.meas tran vdout0_138ck1660 FIND v(dout0_138) AT=835.025n

.meas tran vdout0_139ck1660 FIND v(dout0_139) AT=835.025n

.meas tran vdout0_140ck1660 FIND v(dout0_140) AT=835.025n

.meas tran vdout0_141ck1660 FIND v(dout0_141) AT=835.025n

.meas tran vdout0_142ck1660 FIND v(dout0_142) AT=835.025n

.meas tran vdout0_143ck1660 FIND v(dout0_143) AT=835.025n

.meas tran vdout0_144ck1660 FIND v(dout0_144) AT=835.025n

.meas tran vdout0_145ck1660 FIND v(dout0_145) AT=835.025n

.meas tran vdout0_146ck1660 FIND v(dout0_146) AT=835.025n

.meas tran vdout0_147ck1660 FIND v(dout0_147) AT=835.025n

.meas tran vdout0_148ck1660 FIND v(dout0_148) AT=835.025n

.meas tran vdout0_149ck1660 FIND v(dout0_149) AT=835.025n

.meas tran vdout0_150ck1660 FIND v(dout0_150) AT=835.025n

.meas tran vdout0_151ck1660 FIND v(dout0_151) AT=835.025n

.meas tran vdout0_152ck1660 FIND v(dout0_152) AT=835.025n

.meas tran vdout0_153ck1660 FIND v(dout0_153) AT=835.025n

.meas tran vdout0_154ck1660 FIND v(dout0_154) AT=835.025n

.meas tran vdout0_155ck1660 FIND v(dout0_155) AT=835.025n

.meas tran vdout0_156ck1660 FIND v(dout0_156) AT=835.025n

.meas tran vdout0_157ck1660 FIND v(dout0_157) AT=835.025n

.meas tran vdout0_158ck1660 FIND v(dout0_158) AT=835.025n

.meas tran vdout0_159ck1660 FIND v(dout0_159) AT=835.025n

.meas tran vdout0_160ck1660 FIND v(dout0_160) AT=835.025n

.meas tran vdout0_161ck1660 FIND v(dout0_161) AT=835.025n

.meas tran vdout0_162ck1660 FIND v(dout0_162) AT=835.025n

.meas tran vdout0_163ck1660 FIND v(dout0_163) AT=835.025n

.meas tran vdout0_164ck1660 FIND v(dout0_164) AT=835.025n

.meas tran vdout0_165ck1660 FIND v(dout0_165) AT=835.025n

.meas tran vdout0_166ck1660 FIND v(dout0_166) AT=835.025n

.meas tran vdout0_167ck1660 FIND v(dout0_167) AT=835.025n

.meas tran vdout0_168ck1660 FIND v(dout0_168) AT=835.025n

.meas tran vdout0_169ck1660 FIND v(dout0_169) AT=835.025n

.meas tran vdout0_170ck1660 FIND v(dout0_170) AT=835.025n

.meas tran vdout0_171ck1660 FIND v(dout0_171) AT=835.025n

.meas tran vdout0_172ck1660 FIND v(dout0_172) AT=835.025n

.meas tran vdout0_173ck1660 FIND v(dout0_173) AT=835.025n

.meas tran vdout0_174ck1660 FIND v(dout0_174) AT=835.025n

.meas tran vdout0_175ck1660 FIND v(dout0_175) AT=835.025n

.meas tran vdout0_176ck1660 FIND v(dout0_176) AT=835.025n

.meas tran vdout0_177ck1660 FIND v(dout0_177) AT=835.025n

.meas tran vdout0_178ck1660 FIND v(dout0_178) AT=835.025n

.meas tran vdout0_179ck1660 FIND v(dout0_179) AT=835.025n

.meas tran vdout0_180ck1660 FIND v(dout0_180) AT=835.025n

.meas tran vdout0_181ck1660 FIND v(dout0_181) AT=835.025n

.meas tran vdout0_182ck1660 FIND v(dout0_182) AT=835.025n

.meas tran vdout0_183ck1660 FIND v(dout0_183) AT=835.025n

.meas tran vdout0_184ck1660 FIND v(dout0_184) AT=835.025n

.meas tran vdout0_185ck1660 FIND v(dout0_185) AT=835.025n

.meas tran vdout0_186ck1660 FIND v(dout0_186) AT=835.025n

.meas tran vdout0_187ck1660 FIND v(dout0_187) AT=835.025n

.meas tran vdout0_188ck1660 FIND v(dout0_188) AT=835.025n

.meas tran vdout0_189ck1660 FIND v(dout0_189) AT=835.025n

.meas tran vdout0_190ck1660 FIND v(dout0_190) AT=835.025n

.meas tran vdout0_191ck1660 FIND v(dout0_191) AT=835.025n

.meas tran vdout0_192ck1660 FIND v(dout0_192) AT=835.025n

.meas tran vdout0_193ck1660 FIND v(dout0_193) AT=835.025n

.meas tran vdout0_194ck1660 FIND v(dout0_194) AT=835.025n

.meas tran vdout0_195ck1660 FIND v(dout0_195) AT=835.025n

.meas tran vdout0_196ck1660 FIND v(dout0_196) AT=835.025n

.meas tran vdout0_197ck1660 FIND v(dout0_197) AT=835.025n

.meas tran vdout0_198ck1660 FIND v(dout0_198) AT=835.025n

.meas tran vdout0_199ck1660 FIND v(dout0_199) AT=835.025n

.meas tran vdout0_200ck1660 FIND v(dout0_200) AT=835.025n

.meas tran vdout0_201ck1660 FIND v(dout0_201) AT=835.025n

.meas tran vdout0_202ck1660 FIND v(dout0_202) AT=835.025n

.meas tran vdout0_203ck1660 FIND v(dout0_203) AT=835.025n

.meas tran vdout0_204ck1660 FIND v(dout0_204) AT=835.025n

.meas tran vdout0_205ck1660 FIND v(dout0_205) AT=835.025n

.meas tran vdout0_206ck1660 FIND v(dout0_206) AT=835.025n

.meas tran vdout0_207ck1660 FIND v(dout0_207) AT=835.025n

.meas tran vdout0_208ck1660 FIND v(dout0_208) AT=835.025n

.meas tran vdout0_209ck1660 FIND v(dout0_209) AT=835.025n

.meas tran vdout0_210ck1660 FIND v(dout0_210) AT=835.025n

.meas tran vdout0_211ck1660 FIND v(dout0_211) AT=835.025n

.meas tran vdout0_212ck1660 FIND v(dout0_212) AT=835.025n

.meas tran vdout0_213ck1660 FIND v(dout0_213) AT=835.025n

.meas tran vdout0_214ck1660 FIND v(dout0_214) AT=835.025n

.meas tran vdout0_215ck1660 FIND v(dout0_215) AT=835.025n

.meas tran vdout0_216ck1660 FIND v(dout0_216) AT=835.025n

.meas tran vdout0_217ck1660 FIND v(dout0_217) AT=835.025n

.meas tran vdout0_218ck1660 FIND v(dout0_218) AT=835.025n

.meas tran vdout0_219ck1660 FIND v(dout0_219) AT=835.025n

.meas tran vdout0_220ck1660 FIND v(dout0_220) AT=835.025n

.meas tran vdout0_221ck1660 FIND v(dout0_221) AT=835.025n

.meas tran vdout0_222ck1660 FIND v(dout0_222) AT=835.025n

.meas tran vdout0_223ck1660 FIND v(dout0_223) AT=835.025n

.meas tran vdout0_224ck1660 FIND v(dout0_224) AT=835.025n

.meas tran vdout0_225ck1660 FIND v(dout0_225) AT=835.025n

.meas tran vdout0_226ck1660 FIND v(dout0_226) AT=835.025n

.meas tran vdout0_227ck1660 FIND v(dout0_227) AT=835.025n

.meas tran vdout0_228ck1660 FIND v(dout0_228) AT=835.025n

.meas tran vdout0_229ck1660 FIND v(dout0_229) AT=835.025n

.meas tran vdout0_230ck1660 FIND v(dout0_230) AT=835.025n

.meas tran vdout0_231ck1660 FIND v(dout0_231) AT=835.025n

.meas tran vdout0_232ck1660 FIND v(dout0_232) AT=835.025n

.meas tran vdout0_233ck1660 FIND v(dout0_233) AT=835.025n

.meas tran vdout0_234ck1660 FIND v(dout0_234) AT=835.025n

.meas tran vdout0_235ck1660 FIND v(dout0_235) AT=835.025n

.meas tran vdout0_236ck1660 FIND v(dout0_236) AT=835.025n

.meas tran vdout0_237ck1660 FIND v(dout0_237) AT=835.025n

.meas tran vdout0_238ck1660 FIND v(dout0_238) AT=835.025n

.meas tran vdout0_239ck1660 FIND v(dout0_239) AT=835.025n

.meas tran vdout0_240ck1660 FIND v(dout0_240) AT=835.025n

.meas tran vdout0_241ck1660 FIND v(dout0_241) AT=835.025n

.meas tran vdout0_242ck1660 FIND v(dout0_242) AT=835.025n

.meas tran vdout0_243ck1660 FIND v(dout0_243) AT=835.025n

.meas tran vdout0_244ck1660 FIND v(dout0_244) AT=835.025n

.meas tran vdout0_245ck1660 FIND v(dout0_245) AT=835.025n

.meas tran vdout0_246ck1660 FIND v(dout0_246) AT=835.025n

.meas tran vdout0_247ck1660 FIND v(dout0_247) AT=835.025n

.meas tran vdout0_248ck1660 FIND v(dout0_248) AT=835.025n

.meas tran vdout0_249ck1660 FIND v(dout0_249) AT=835.025n

.meas tran vdout0_250ck1660 FIND v(dout0_250) AT=835.025n

.meas tran vdout0_251ck1660 FIND v(dout0_251) AT=835.025n

.meas tran vdout0_252ck1660 FIND v(dout0_252) AT=835.025n

.meas tran vdout0_253ck1660 FIND v(dout0_253) AT=835.025n

.meas tran vdout0_254ck1660 FIND v(dout0_254) AT=835.025n

.meas tran vdout0_255ck1660 FIND v(dout0_255) AT=835.025n

.meas tran vdout0_0ck1690 FIND v(dout0_0) AT=850.025n

.meas tran vdout0_1ck1690 FIND v(dout0_1) AT=850.025n

.meas tran vdout0_2ck1690 FIND v(dout0_2) AT=850.025n

.meas tran vdout0_3ck1690 FIND v(dout0_3) AT=850.025n

.meas tran vdout0_4ck1690 FIND v(dout0_4) AT=850.025n

.meas tran vdout0_5ck1690 FIND v(dout0_5) AT=850.025n

.meas tran vdout0_6ck1690 FIND v(dout0_6) AT=850.025n

.meas tran vdout0_7ck1690 FIND v(dout0_7) AT=850.025n

.meas tran vdout0_8ck1690 FIND v(dout0_8) AT=850.025n

.meas tran vdout0_9ck1690 FIND v(dout0_9) AT=850.025n

.meas tran vdout0_10ck1690 FIND v(dout0_10) AT=850.025n

.meas tran vdout0_11ck1690 FIND v(dout0_11) AT=850.025n

.meas tran vdout0_12ck1690 FIND v(dout0_12) AT=850.025n

.meas tran vdout0_13ck1690 FIND v(dout0_13) AT=850.025n

.meas tran vdout0_14ck1690 FIND v(dout0_14) AT=850.025n

.meas tran vdout0_15ck1690 FIND v(dout0_15) AT=850.025n

.meas tran vdout0_16ck1690 FIND v(dout0_16) AT=850.025n

.meas tran vdout0_17ck1690 FIND v(dout0_17) AT=850.025n

.meas tran vdout0_18ck1690 FIND v(dout0_18) AT=850.025n

.meas tran vdout0_19ck1690 FIND v(dout0_19) AT=850.025n

.meas tran vdout0_20ck1690 FIND v(dout0_20) AT=850.025n

.meas tran vdout0_21ck1690 FIND v(dout0_21) AT=850.025n

.meas tran vdout0_22ck1690 FIND v(dout0_22) AT=850.025n

.meas tran vdout0_23ck1690 FIND v(dout0_23) AT=850.025n

.meas tran vdout0_24ck1690 FIND v(dout0_24) AT=850.025n

.meas tran vdout0_25ck1690 FIND v(dout0_25) AT=850.025n

.meas tran vdout0_26ck1690 FIND v(dout0_26) AT=850.025n

.meas tran vdout0_27ck1690 FIND v(dout0_27) AT=850.025n

.meas tran vdout0_28ck1690 FIND v(dout0_28) AT=850.025n

.meas tran vdout0_29ck1690 FIND v(dout0_29) AT=850.025n

.meas tran vdout0_30ck1690 FIND v(dout0_30) AT=850.025n

.meas tran vdout0_31ck1690 FIND v(dout0_31) AT=850.025n

.meas tran vdout0_32ck1690 FIND v(dout0_32) AT=850.025n

.meas tran vdout0_33ck1690 FIND v(dout0_33) AT=850.025n

.meas tran vdout0_34ck1690 FIND v(dout0_34) AT=850.025n

.meas tran vdout0_35ck1690 FIND v(dout0_35) AT=850.025n

.meas tran vdout0_36ck1690 FIND v(dout0_36) AT=850.025n

.meas tran vdout0_37ck1690 FIND v(dout0_37) AT=850.025n

.meas tran vdout0_38ck1690 FIND v(dout0_38) AT=850.025n

.meas tran vdout0_39ck1690 FIND v(dout0_39) AT=850.025n

.meas tran vdout0_40ck1690 FIND v(dout0_40) AT=850.025n

.meas tran vdout0_41ck1690 FIND v(dout0_41) AT=850.025n

.meas tran vdout0_42ck1690 FIND v(dout0_42) AT=850.025n

.meas tran vdout0_43ck1690 FIND v(dout0_43) AT=850.025n

.meas tran vdout0_44ck1690 FIND v(dout0_44) AT=850.025n

.meas tran vdout0_45ck1690 FIND v(dout0_45) AT=850.025n

.meas tran vdout0_46ck1690 FIND v(dout0_46) AT=850.025n

.meas tran vdout0_47ck1690 FIND v(dout0_47) AT=850.025n

.meas tran vdout0_48ck1690 FIND v(dout0_48) AT=850.025n

.meas tran vdout0_49ck1690 FIND v(dout0_49) AT=850.025n

.meas tran vdout0_50ck1690 FIND v(dout0_50) AT=850.025n

.meas tran vdout0_51ck1690 FIND v(dout0_51) AT=850.025n

.meas tran vdout0_52ck1690 FIND v(dout0_52) AT=850.025n

.meas tran vdout0_53ck1690 FIND v(dout0_53) AT=850.025n

.meas tran vdout0_54ck1690 FIND v(dout0_54) AT=850.025n

.meas tran vdout0_55ck1690 FIND v(dout0_55) AT=850.025n

.meas tran vdout0_56ck1690 FIND v(dout0_56) AT=850.025n

.meas tran vdout0_57ck1690 FIND v(dout0_57) AT=850.025n

.meas tran vdout0_58ck1690 FIND v(dout0_58) AT=850.025n

.meas tran vdout0_59ck1690 FIND v(dout0_59) AT=850.025n

.meas tran vdout0_60ck1690 FIND v(dout0_60) AT=850.025n

.meas tran vdout0_61ck1690 FIND v(dout0_61) AT=850.025n

.meas tran vdout0_62ck1690 FIND v(dout0_62) AT=850.025n

.meas tran vdout0_63ck1690 FIND v(dout0_63) AT=850.025n

.meas tran vdout0_64ck1690 FIND v(dout0_64) AT=850.025n

.meas tran vdout0_65ck1690 FIND v(dout0_65) AT=850.025n

.meas tran vdout0_66ck1690 FIND v(dout0_66) AT=850.025n

.meas tran vdout0_67ck1690 FIND v(dout0_67) AT=850.025n

.meas tran vdout0_68ck1690 FIND v(dout0_68) AT=850.025n

.meas tran vdout0_69ck1690 FIND v(dout0_69) AT=850.025n

.meas tran vdout0_70ck1690 FIND v(dout0_70) AT=850.025n

.meas tran vdout0_71ck1690 FIND v(dout0_71) AT=850.025n

.meas tran vdout0_72ck1690 FIND v(dout0_72) AT=850.025n

.meas tran vdout0_73ck1690 FIND v(dout0_73) AT=850.025n

.meas tran vdout0_74ck1690 FIND v(dout0_74) AT=850.025n

.meas tran vdout0_75ck1690 FIND v(dout0_75) AT=850.025n

.meas tran vdout0_76ck1690 FIND v(dout0_76) AT=850.025n

.meas tran vdout0_77ck1690 FIND v(dout0_77) AT=850.025n

.meas tran vdout0_78ck1690 FIND v(dout0_78) AT=850.025n

.meas tran vdout0_79ck1690 FIND v(dout0_79) AT=850.025n

.meas tran vdout0_80ck1690 FIND v(dout0_80) AT=850.025n

.meas tran vdout0_81ck1690 FIND v(dout0_81) AT=850.025n

.meas tran vdout0_82ck1690 FIND v(dout0_82) AT=850.025n

.meas tran vdout0_83ck1690 FIND v(dout0_83) AT=850.025n

.meas tran vdout0_84ck1690 FIND v(dout0_84) AT=850.025n

.meas tran vdout0_85ck1690 FIND v(dout0_85) AT=850.025n

.meas tran vdout0_86ck1690 FIND v(dout0_86) AT=850.025n

.meas tran vdout0_87ck1690 FIND v(dout0_87) AT=850.025n

.meas tran vdout0_88ck1690 FIND v(dout0_88) AT=850.025n

.meas tran vdout0_89ck1690 FIND v(dout0_89) AT=850.025n

.meas tran vdout0_90ck1690 FIND v(dout0_90) AT=850.025n

.meas tran vdout0_91ck1690 FIND v(dout0_91) AT=850.025n

.meas tran vdout0_92ck1690 FIND v(dout0_92) AT=850.025n

.meas tran vdout0_93ck1690 FIND v(dout0_93) AT=850.025n

.meas tran vdout0_94ck1690 FIND v(dout0_94) AT=850.025n

.meas tran vdout0_95ck1690 FIND v(dout0_95) AT=850.025n

.meas tran vdout0_96ck1690 FIND v(dout0_96) AT=850.025n

.meas tran vdout0_97ck1690 FIND v(dout0_97) AT=850.025n

.meas tran vdout0_98ck1690 FIND v(dout0_98) AT=850.025n

.meas tran vdout0_99ck1690 FIND v(dout0_99) AT=850.025n

.meas tran vdout0_100ck1690 FIND v(dout0_100) AT=850.025n

.meas tran vdout0_101ck1690 FIND v(dout0_101) AT=850.025n

.meas tran vdout0_102ck1690 FIND v(dout0_102) AT=850.025n

.meas tran vdout0_103ck1690 FIND v(dout0_103) AT=850.025n

.meas tran vdout0_104ck1690 FIND v(dout0_104) AT=850.025n

.meas tran vdout0_105ck1690 FIND v(dout0_105) AT=850.025n

.meas tran vdout0_106ck1690 FIND v(dout0_106) AT=850.025n

.meas tran vdout0_107ck1690 FIND v(dout0_107) AT=850.025n

.meas tran vdout0_108ck1690 FIND v(dout0_108) AT=850.025n

.meas tran vdout0_109ck1690 FIND v(dout0_109) AT=850.025n

.meas tran vdout0_110ck1690 FIND v(dout0_110) AT=850.025n

.meas tran vdout0_111ck1690 FIND v(dout0_111) AT=850.025n

.meas tran vdout0_112ck1690 FIND v(dout0_112) AT=850.025n

.meas tran vdout0_113ck1690 FIND v(dout0_113) AT=850.025n

.meas tran vdout0_114ck1690 FIND v(dout0_114) AT=850.025n

.meas tran vdout0_115ck1690 FIND v(dout0_115) AT=850.025n

.meas tran vdout0_116ck1690 FIND v(dout0_116) AT=850.025n

.meas tran vdout0_117ck1690 FIND v(dout0_117) AT=850.025n

.meas tran vdout0_118ck1690 FIND v(dout0_118) AT=850.025n

.meas tran vdout0_119ck1690 FIND v(dout0_119) AT=850.025n

.meas tran vdout0_120ck1690 FIND v(dout0_120) AT=850.025n

.meas tran vdout0_121ck1690 FIND v(dout0_121) AT=850.025n

.meas tran vdout0_122ck1690 FIND v(dout0_122) AT=850.025n

.meas tran vdout0_123ck1690 FIND v(dout0_123) AT=850.025n

.meas tran vdout0_124ck1690 FIND v(dout0_124) AT=850.025n

.meas tran vdout0_125ck1690 FIND v(dout0_125) AT=850.025n

.meas tran vdout0_126ck1690 FIND v(dout0_126) AT=850.025n

.meas tran vdout0_127ck1690 FIND v(dout0_127) AT=850.025n

.meas tran vdout0_128ck1690 FIND v(dout0_128) AT=850.025n

.meas tran vdout0_129ck1690 FIND v(dout0_129) AT=850.025n

.meas tran vdout0_130ck1690 FIND v(dout0_130) AT=850.025n

.meas tran vdout0_131ck1690 FIND v(dout0_131) AT=850.025n

.meas tran vdout0_132ck1690 FIND v(dout0_132) AT=850.025n

.meas tran vdout0_133ck1690 FIND v(dout0_133) AT=850.025n

.meas tran vdout0_134ck1690 FIND v(dout0_134) AT=850.025n

.meas tran vdout0_135ck1690 FIND v(dout0_135) AT=850.025n

.meas tran vdout0_136ck1690 FIND v(dout0_136) AT=850.025n

.meas tran vdout0_137ck1690 FIND v(dout0_137) AT=850.025n

.meas tran vdout0_138ck1690 FIND v(dout0_138) AT=850.025n

.meas tran vdout0_139ck1690 FIND v(dout0_139) AT=850.025n

.meas tran vdout0_140ck1690 FIND v(dout0_140) AT=850.025n

.meas tran vdout0_141ck1690 FIND v(dout0_141) AT=850.025n

.meas tran vdout0_142ck1690 FIND v(dout0_142) AT=850.025n

.meas tran vdout0_143ck1690 FIND v(dout0_143) AT=850.025n

.meas tran vdout0_144ck1690 FIND v(dout0_144) AT=850.025n

.meas tran vdout0_145ck1690 FIND v(dout0_145) AT=850.025n

.meas tran vdout0_146ck1690 FIND v(dout0_146) AT=850.025n

.meas tran vdout0_147ck1690 FIND v(dout0_147) AT=850.025n

.meas tran vdout0_148ck1690 FIND v(dout0_148) AT=850.025n

.meas tran vdout0_149ck1690 FIND v(dout0_149) AT=850.025n

.meas tran vdout0_150ck1690 FIND v(dout0_150) AT=850.025n

.meas tran vdout0_151ck1690 FIND v(dout0_151) AT=850.025n

.meas tran vdout0_152ck1690 FIND v(dout0_152) AT=850.025n

.meas tran vdout0_153ck1690 FIND v(dout0_153) AT=850.025n

.meas tran vdout0_154ck1690 FIND v(dout0_154) AT=850.025n

.meas tran vdout0_155ck1690 FIND v(dout0_155) AT=850.025n

.meas tran vdout0_156ck1690 FIND v(dout0_156) AT=850.025n

.meas tran vdout0_157ck1690 FIND v(dout0_157) AT=850.025n

.meas tran vdout0_158ck1690 FIND v(dout0_158) AT=850.025n

.meas tran vdout0_159ck1690 FIND v(dout0_159) AT=850.025n

.meas tran vdout0_160ck1690 FIND v(dout0_160) AT=850.025n

.meas tran vdout0_161ck1690 FIND v(dout0_161) AT=850.025n

.meas tran vdout0_162ck1690 FIND v(dout0_162) AT=850.025n

.meas tran vdout0_163ck1690 FIND v(dout0_163) AT=850.025n

.meas tran vdout0_164ck1690 FIND v(dout0_164) AT=850.025n

.meas tran vdout0_165ck1690 FIND v(dout0_165) AT=850.025n

.meas tran vdout0_166ck1690 FIND v(dout0_166) AT=850.025n

.meas tran vdout0_167ck1690 FIND v(dout0_167) AT=850.025n

.meas tran vdout0_168ck1690 FIND v(dout0_168) AT=850.025n

.meas tran vdout0_169ck1690 FIND v(dout0_169) AT=850.025n

.meas tran vdout0_170ck1690 FIND v(dout0_170) AT=850.025n

.meas tran vdout0_171ck1690 FIND v(dout0_171) AT=850.025n

.meas tran vdout0_172ck1690 FIND v(dout0_172) AT=850.025n

.meas tran vdout0_173ck1690 FIND v(dout0_173) AT=850.025n

.meas tran vdout0_174ck1690 FIND v(dout0_174) AT=850.025n

.meas tran vdout0_175ck1690 FIND v(dout0_175) AT=850.025n

.meas tran vdout0_176ck1690 FIND v(dout0_176) AT=850.025n

.meas tran vdout0_177ck1690 FIND v(dout0_177) AT=850.025n

.meas tran vdout0_178ck1690 FIND v(dout0_178) AT=850.025n

.meas tran vdout0_179ck1690 FIND v(dout0_179) AT=850.025n

.meas tran vdout0_180ck1690 FIND v(dout0_180) AT=850.025n

.meas tran vdout0_181ck1690 FIND v(dout0_181) AT=850.025n

.meas tran vdout0_182ck1690 FIND v(dout0_182) AT=850.025n

.meas tran vdout0_183ck1690 FIND v(dout0_183) AT=850.025n

.meas tran vdout0_184ck1690 FIND v(dout0_184) AT=850.025n

.meas tran vdout0_185ck1690 FIND v(dout0_185) AT=850.025n

.meas tran vdout0_186ck1690 FIND v(dout0_186) AT=850.025n

.meas tran vdout0_187ck1690 FIND v(dout0_187) AT=850.025n

.meas tran vdout0_188ck1690 FIND v(dout0_188) AT=850.025n

.meas tran vdout0_189ck1690 FIND v(dout0_189) AT=850.025n

.meas tran vdout0_190ck1690 FIND v(dout0_190) AT=850.025n

.meas tran vdout0_191ck1690 FIND v(dout0_191) AT=850.025n

.meas tran vdout0_192ck1690 FIND v(dout0_192) AT=850.025n

.meas tran vdout0_193ck1690 FIND v(dout0_193) AT=850.025n

.meas tran vdout0_194ck1690 FIND v(dout0_194) AT=850.025n

.meas tran vdout0_195ck1690 FIND v(dout0_195) AT=850.025n

.meas tran vdout0_196ck1690 FIND v(dout0_196) AT=850.025n

.meas tran vdout0_197ck1690 FIND v(dout0_197) AT=850.025n

.meas tran vdout0_198ck1690 FIND v(dout0_198) AT=850.025n

.meas tran vdout0_199ck1690 FIND v(dout0_199) AT=850.025n

.meas tran vdout0_200ck1690 FIND v(dout0_200) AT=850.025n

.meas tran vdout0_201ck1690 FIND v(dout0_201) AT=850.025n

.meas tran vdout0_202ck1690 FIND v(dout0_202) AT=850.025n

.meas tran vdout0_203ck1690 FIND v(dout0_203) AT=850.025n

.meas tran vdout0_204ck1690 FIND v(dout0_204) AT=850.025n

.meas tran vdout0_205ck1690 FIND v(dout0_205) AT=850.025n

.meas tran vdout0_206ck1690 FIND v(dout0_206) AT=850.025n

.meas tran vdout0_207ck1690 FIND v(dout0_207) AT=850.025n

.meas tran vdout0_208ck1690 FIND v(dout0_208) AT=850.025n

.meas tran vdout0_209ck1690 FIND v(dout0_209) AT=850.025n

.meas tran vdout0_210ck1690 FIND v(dout0_210) AT=850.025n

.meas tran vdout0_211ck1690 FIND v(dout0_211) AT=850.025n

.meas tran vdout0_212ck1690 FIND v(dout0_212) AT=850.025n

.meas tran vdout0_213ck1690 FIND v(dout0_213) AT=850.025n

.meas tran vdout0_214ck1690 FIND v(dout0_214) AT=850.025n

.meas tran vdout0_215ck1690 FIND v(dout0_215) AT=850.025n

.meas tran vdout0_216ck1690 FIND v(dout0_216) AT=850.025n

.meas tran vdout0_217ck1690 FIND v(dout0_217) AT=850.025n

.meas tran vdout0_218ck1690 FIND v(dout0_218) AT=850.025n

.meas tran vdout0_219ck1690 FIND v(dout0_219) AT=850.025n

.meas tran vdout0_220ck1690 FIND v(dout0_220) AT=850.025n

.meas tran vdout0_221ck1690 FIND v(dout0_221) AT=850.025n

.meas tran vdout0_222ck1690 FIND v(dout0_222) AT=850.025n

.meas tran vdout0_223ck1690 FIND v(dout0_223) AT=850.025n

.meas tran vdout0_224ck1690 FIND v(dout0_224) AT=850.025n

.meas tran vdout0_225ck1690 FIND v(dout0_225) AT=850.025n

.meas tran vdout0_226ck1690 FIND v(dout0_226) AT=850.025n

.meas tran vdout0_227ck1690 FIND v(dout0_227) AT=850.025n

.meas tran vdout0_228ck1690 FIND v(dout0_228) AT=850.025n

.meas tran vdout0_229ck1690 FIND v(dout0_229) AT=850.025n

.meas tran vdout0_230ck1690 FIND v(dout0_230) AT=850.025n

.meas tran vdout0_231ck1690 FIND v(dout0_231) AT=850.025n

.meas tran vdout0_232ck1690 FIND v(dout0_232) AT=850.025n

.meas tran vdout0_233ck1690 FIND v(dout0_233) AT=850.025n

.meas tran vdout0_234ck1690 FIND v(dout0_234) AT=850.025n

.meas tran vdout0_235ck1690 FIND v(dout0_235) AT=850.025n

.meas tran vdout0_236ck1690 FIND v(dout0_236) AT=850.025n

.meas tran vdout0_237ck1690 FIND v(dout0_237) AT=850.025n

.meas tran vdout0_238ck1690 FIND v(dout0_238) AT=850.025n

.meas tran vdout0_239ck1690 FIND v(dout0_239) AT=850.025n

.meas tran vdout0_240ck1690 FIND v(dout0_240) AT=850.025n

.meas tran vdout0_241ck1690 FIND v(dout0_241) AT=850.025n

.meas tran vdout0_242ck1690 FIND v(dout0_242) AT=850.025n

.meas tran vdout0_243ck1690 FIND v(dout0_243) AT=850.025n

.meas tran vdout0_244ck1690 FIND v(dout0_244) AT=850.025n

.meas tran vdout0_245ck1690 FIND v(dout0_245) AT=850.025n

.meas tran vdout0_246ck1690 FIND v(dout0_246) AT=850.025n

.meas tran vdout0_247ck1690 FIND v(dout0_247) AT=850.025n

.meas tran vdout0_248ck1690 FIND v(dout0_248) AT=850.025n

.meas tran vdout0_249ck1690 FIND v(dout0_249) AT=850.025n

.meas tran vdout0_250ck1690 FIND v(dout0_250) AT=850.025n

.meas tran vdout0_251ck1690 FIND v(dout0_251) AT=850.025n

.meas tran vdout0_252ck1690 FIND v(dout0_252) AT=850.025n

.meas tran vdout0_253ck1690 FIND v(dout0_253) AT=850.025n

.meas tran vdout0_254ck1690 FIND v(dout0_254) AT=850.025n

.meas tran vdout0_255ck1690 FIND v(dout0_255) AT=850.025n

.meas tran vdout0_0ck1710 FIND v(dout0_0) AT=860.025n

.meas tran vdout0_1ck1710 FIND v(dout0_1) AT=860.025n

.meas tran vdout0_2ck1710 FIND v(dout0_2) AT=860.025n

.meas tran vdout0_3ck1710 FIND v(dout0_3) AT=860.025n

.meas tran vdout0_4ck1710 FIND v(dout0_4) AT=860.025n

.meas tran vdout0_5ck1710 FIND v(dout0_5) AT=860.025n

.meas tran vdout0_6ck1710 FIND v(dout0_6) AT=860.025n

.meas tran vdout0_7ck1710 FIND v(dout0_7) AT=860.025n

.meas tran vdout0_8ck1710 FIND v(dout0_8) AT=860.025n

.meas tran vdout0_9ck1710 FIND v(dout0_9) AT=860.025n

.meas tran vdout0_10ck1710 FIND v(dout0_10) AT=860.025n

.meas tran vdout0_11ck1710 FIND v(dout0_11) AT=860.025n

.meas tran vdout0_12ck1710 FIND v(dout0_12) AT=860.025n

.meas tran vdout0_13ck1710 FIND v(dout0_13) AT=860.025n

.meas tran vdout0_14ck1710 FIND v(dout0_14) AT=860.025n

.meas tran vdout0_15ck1710 FIND v(dout0_15) AT=860.025n

.meas tran vdout0_16ck1710 FIND v(dout0_16) AT=860.025n

.meas tran vdout0_17ck1710 FIND v(dout0_17) AT=860.025n

.meas tran vdout0_18ck1710 FIND v(dout0_18) AT=860.025n

.meas tran vdout0_19ck1710 FIND v(dout0_19) AT=860.025n

.meas tran vdout0_20ck1710 FIND v(dout0_20) AT=860.025n

.meas tran vdout0_21ck1710 FIND v(dout0_21) AT=860.025n

.meas tran vdout0_22ck1710 FIND v(dout0_22) AT=860.025n

.meas tran vdout0_23ck1710 FIND v(dout0_23) AT=860.025n

.meas tran vdout0_24ck1710 FIND v(dout0_24) AT=860.025n

.meas tran vdout0_25ck1710 FIND v(dout0_25) AT=860.025n

.meas tran vdout0_26ck1710 FIND v(dout0_26) AT=860.025n

.meas tran vdout0_27ck1710 FIND v(dout0_27) AT=860.025n

.meas tran vdout0_28ck1710 FIND v(dout0_28) AT=860.025n

.meas tran vdout0_29ck1710 FIND v(dout0_29) AT=860.025n

.meas tran vdout0_30ck1710 FIND v(dout0_30) AT=860.025n

.meas tran vdout0_31ck1710 FIND v(dout0_31) AT=860.025n

.meas tran vdout0_32ck1710 FIND v(dout0_32) AT=860.025n

.meas tran vdout0_33ck1710 FIND v(dout0_33) AT=860.025n

.meas tran vdout0_34ck1710 FIND v(dout0_34) AT=860.025n

.meas tran vdout0_35ck1710 FIND v(dout0_35) AT=860.025n

.meas tran vdout0_36ck1710 FIND v(dout0_36) AT=860.025n

.meas tran vdout0_37ck1710 FIND v(dout0_37) AT=860.025n

.meas tran vdout0_38ck1710 FIND v(dout0_38) AT=860.025n

.meas tran vdout0_39ck1710 FIND v(dout0_39) AT=860.025n

.meas tran vdout0_40ck1710 FIND v(dout0_40) AT=860.025n

.meas tran vdout0_41ck1710 FIND v(dout0_41) AT=860.025n

.meas tran vdout0_42ck1710 FIND v(dout0_42) AT=860.025n

.meas tran vdout0_43ck1710 FIND v(dout0_43) AT=860.025n

.meas tran vdout0_44ck1710 FIND v(dout0_44) AT=860.025n

.meas tran vdout0_45ck1710 FIND v(dout0_45) AT=860.025n

.meas tran vdout0_46ck1710 FIND v(dout0_46) AT=860.025n

.meas tran vdout0_47ck1710 FIND v(dout0_47) AT=860.025n

.meas tran vdout0_48ck1710 FIND v(dout0_48) AT=860.025n

.meas tran vdout0_49ck1710 FIND v(dout0_49) AT=860.025n

.meas tran vdout0_50ck1710 FIND v(dout0_50) AT=860.025n

.meas tran vdout0_51ck1710 FIND v(dout0_51) AT=860.025n

.meas tran vdout0_52ck1710 FIND v(dout0_52) AT=860.025n

.meas tran vdout0_53ck1710 FIND v(dout0_53) AT=860.025n

.meas tran vdout0_54ck1710 FIND v(dout0_54) AT=860.025n

.meas tran vdout0_55ck1710 FIND v(dout0_55) AT=860.025n

.meas tran vdout0_56ck1710 FIND v(dout0_56) AT=860.025n

.meas tran vdout0_57ck1710 FIND v(dout0_57) AT=860.025n

.meas tran vdout0_58ck1710 FIND v(dout0_58) AT=860.025n

.meas tran vdout0_59ck1710 FIND v(dout0_59) AT=860.025n

.meas tran vdout0_60ck1710 FIND v(dout0_60) AT=860.025n

.meas tran vdout0_61ck1710 FIND v(dout0_61) AT=860.025n

.meas tran vdout0_62ck1710 FIND v(dout0_62) AT=860.025n

.meas tran vdout0_63ck1710 FIND v(dout0_63) AT=860.025n

.meas tran vdout0_64ck1710 FIND v(dout0_64) AT=860.025n

.meas tran vdout0_65ck1710 FIND v(dout0_65) AT=860.025n

.meas tran vdout0_66ck1710 FIND v(dout0_66) AT=860.025n

.meas tran vdout0_67ck1710 FIND v(dout0_67) AT=860.025n

.meas tran vdout0_68ck1710 FIND v(dout0_68) AT=860.025n

.meas tran vdout0_69ck1710 FIND v(dout0_69) AT=860.025n

.meas tran vdout0_70ck1710 FIND v(dout0_70) AT=860.025n

.meas tran vdout0_71ck1710 FIND v(dout0_71) AT=860.025n

.meas tran vdout0_72ck1710 FIND v(dout0_72) AT=860.025n

.meas tran vdout0_73ck1710 FIND v(dout0_73) AT=860.025n

.meas tran vdout0_74ck1710 FIND v(dout0_74) AT=860.025n

.meas tran vdout0_75ck1710 FIND v(dout0_75) AT=860.025n

.meas tran vdout0_76ck1710 FIND v(dout0_76) AT=860.025n

.meas tran vdout0_77ck1710 FIND v(dout0_77) AT=860.025n

.meas tran vdout0_78ck1710 FIND v(dout0_78) AT=860.025n

.meas tran vdout0_79ck1710 FIND v(dout0_79) AT=860.025n

.meas tran vdout0_80ck1710 FIND v(dout0_80) AT=860.025n

.meas tran vdout0_81ck1710 FIND v(dout0_81) AT=860.025n

.meas tran vdout0_82ck1710 FIND v(dout0_82) AT=860.025n

.meas tran vdout0_83ck1710 FIND v(dout0_83) AT=860.025n

.meas tran vdout0_84ck1710 FIND v(dout0_84) AT=860.025n

.meas tran vdout0_85ck1710 FIND v(dout0_85) AT=860.025n

.meas tran vdout0_86ck1710 FIND v(dout0_86) AT=860.025n

.meas tran vdout0_87ck1710 FIND v(dout0_87) AT=860.025n

.meas tran vdout0_88ck1710 FIND v(dout0_88) AT=860.025n

.meas tran vdout0_89ck1710 FIND v(dout0_89) AT=860.025n

.meas tran vdout0_90ck1710 FIND v(dout0_90) AT=860.025n

.meas tran vdout0_91ck1710 FIND v(dout0_91) AT=860.025n

.meas tran vdout0_92ck1710 FIND v(dout0_92) AT=860.025n

.meas tran vdout0_93ck1710 FIND v(dout0_93) AT=860.025n

.meas tran vdout0_94ck1710 FIND v(dout0_94) AT=860.025n

.meas tran vdout0_95ck1710 FIND v(dout0_95) AT=860.025n

.meas tran vdout0_96ck1710 FIND v(dout0_96) AT=860.025n

.meas tran vdout0_97ck1710 FIND v(dout0_97) AT=860.025n

.meas tran vdout0_98ck1710 FIND v(dout0_98) AT=860.025n

.meas tran vdout0_99ck1710 FIND v(dout0_99) AT=860.025n

.meas tran vdout0_100ck1710 FIND v(dout0_100) AT=860.025n

.meas tran vdout0_101ck1710 FIND v(dout0_101) AT=860.025n

.meas tran vdout0_102ck1710 FIND v(dout0_102) AT=860.025n

.meas tran vdout0_103ck1710 FIND v(dout0_103) AT=860.025n

.meas tran vdout0_104ck1710 FIND v(dout0_104) AT=860.025n

.meas tran vdout0_105ck1710 FIND v(dout0_105) AT=860.025n

.meas tran vdout0_106ck1710 FIND v(dout0_106) AT=860.025n

.meas tran vdout0_107ck1710 FIND v(dout0_107) AT=860.025n

.meas tran vdout0_108ck1710 FIND v(dout0_108) AT=860.025n

.meas tran vdout0_109ck1710 FIND v(dout0_109) AT=860.025n

.meas tran vdout0_110ck1710 FIND v(dout0_110) AT=860.025n

.meas tran vdout0_111ck1710 FIND v(dout0_111) AT=860.025n

.meas tran vdout0_112ck1710 FIND v(dout0_112) AT=860.025n

.meas tran vdout0_113ck1710 FIND v(dout0_113) AT=860.025n

.meas tran vdout0_114ck1710 FIND v(dout0_114) AT=860.025n

.meas tran vdout0_115ck1710 FIND v(dout0_115) AT=860.025n

.meas tran vdout0_116ck1710 FIND v(dout0_116) AT=860.025n

.meas tran vdout0_117ck1710 FIND v(dout0_117) AT=860.025n

.meas tran vdout0_118ck1710 FIND v(dout0_118) AT=860.025n

.meas tran vdout0_119ck1710 FIND v(dout0_119) AT=860.025n

.meas tran vdout0_120ck1710 FIND v(dout0_120) AT=860.025n

.meas tran vdout0_121ck1710 FIND v(dout0_121) AT=860.025n

.meas tran vdout0_122ck1710 FIND v(dout0_122) AT=860.025n

.meas tran vdout0_123ck1710 FIND v(dout0_123) AT=860.025n

.meas tran vdout0_124ck1710 FIND v(dout0_124) AT=860.025n

.meas tran vdout0_125ck1710 FIND v(dout0_125) AT=860.025n

.meas tran vdout0_126ck1710 FIND v(dout0_126) AT=860.025n

.meas tran vdout0_127ck1710 FIND v(dout0_127) AT=860.025n

.meas tran vdout0_128ck1710 FIND v(dout0_128) AT=860.025n

.meas tran vdout0_129ck1710 FIND v(dout0_129) AT=860.025n

.meas tran vdout0_130ck1710 FIND v(dout0_130) AT=860.025n

.meas tran vdout0_131ck1710 FIND v(dout0_131) AT=860.025n

.meas tran vdout0_132ck1710 FIND v(dout0_132) AT=860.025n

.meas tran vdout0_133ck1710 FIND v(dout0_133) AT=860.025n

.meas tran vdout0_134ck1710 FIND v(dout0_134) AT=860.025n

.meas tran vdout0_135ck1710 FIND v(dout0_135) AT=860.025n

.meas tran vdout0_136ck1710 FIND v(dout0_136) AT=860.025n

.meas tran vdout0_137ck1710 FIND v(dout0_137) AT=860.025n

.meas tran vdout0_138ck1710 FIND v(dout0_138) AT=860.025n

.meas tran vdout0_139ck1710 FIND v(dout0_139) AT=860.025n

.meas tran vdout0_140ck1710 FIND v(dout0_140) AT=860.025n

.meas tran vdout0_141ck1710 FIND v(dout0_141) AT=860.025n

.meas tran vdout0_142ck1710 FIND v(dout0_142) AT=860.025n

.meas tran vdout0_143ck1710 FIND v(dout0_143) AT=860.025n

.meas tran vdout0_144ck1710 FIND v(dout0_144) AT=860.025n

.meas tran vdout0_145ck1710 FIND v(dout0_145) AT=860.025n

.meas tran vdout0_146ck1710 FIND v(dout0_146) AT=860.025n

.meas tran vdout0_147ck1710 FIND v(dout0_147) AT=860.025n

.meas tran vdout0_148ck1710 FIND v(dout0_148) AT=860.025n

.meas tran vdout0_149ck1710 FIND v(dout0_149) AT=860.025n

.meas tran vdout0_150ck1710 FIND v(dout0_150) AT=860.025n

.meas tran vdout0_151ck1710 FIND v(dout0_151) AT=860.025n

.meas tran vdout0_152ck1710 FIND v(dout0_152) AT=860.025n

.meas tran vdout0_153ck1710 FIND v(dout0_153) AT=860.025n

.meas tran vdout0_154ck1710 FIND v(dout0_154) AT=860.025n

.meas tran vdout0_155ck1710 FIND v(dout0_155) AT=860.025n

.meas tran vdout0_156ck1710 FIND v(dout0_156) AT=860.025n

.meas tran vdout0_157ck1710 FIND v(dout0_157) AT=860.025n

.meas tran vdout0_158ck1710 FIND v(dout0_158) AT=860.025n

.meas tran vdout0_159ck1710 FIND v(dout0_159) AT=860.025n

.meas tran vdout0_160ck1710 FIND v(dout0_160) AT=860.025n

.meas tran vdout0_161ck1710 FIND v(dout0_161) AT=860.025n

.meas tran vdout0_162ck1710 FIND v(dout0_162) AT=860.025n

.meas tran vdout0_163ck1710 FIND v(dout0_163) AT=860.025n

.meas tran vdout0_164ck1710 FIND v(dout0_164) AT=860.025n

.meas tran vdout0_165ck1710 FIND v(dout0_165) AT=860.025n

.meas tran vdout0_166ck1710 FIND v(dout0_166) AT=860.025n

.meas tran vdout0_167ck1710 FIND v(dout0_167) AT=860.025n

.meas tran vdout0_168ck1710 FIND v(dout0_168) AT=860.025n

.meas tran vdout0_169ck1710 FIND v(dout0_169) AT=860.025n

.meas tran vdout0_170ck1710 FIND v(dout0_170) AT=860.025n

.meas tran vdout0_171ck1710 FIND v(dout0_171) AT=860.025n

.meas tran vdout0_172ck1710 FIND v(dout0_172) AT=860.025n

.meas tran vdout0_173ck1710 FIND v(dout0_173) AT=860.025n

.meas tran vdout0_174ck1710 FIND v(dout0_174) AT=860.025n

.meas tran vdout0_175ck1710 FIND v(dout0_175) AT=860.025n

.meas tran vdout0_176ck1710 FIND v(dout0_176) AT=860.025n

.meas tran vdout0_177ck1710 FIND v(dout0_177) AT=860.025n

.meas tran vdout0_178ck1710 FIND v(dout0_178) AT=860.025n

.meas tran vdout0_179ck1710 FIND v(dout0_179) AT=860.025n

.meas tran vdout0_180ck1710 FIND v(dout0_180) AT=860.025n

.meas tran vdout0_181ck1710 FIND v(dout0_181) AT=860.025n

.meas tran vdout0_182ck1710 FIND v(dout0_182) AT=860.025n

.meas tran vdout0_183ck1710 FIND v(dout0_183) AT=860.025n

.meas tran vdout0_184ck1710 FIND v(dout0_184) AT=860.025n

.meas tran vdout0_185ck1710 FIND v(dout0_185) AT=860.025n

.meas tran vdout0_186ck1710 FIND v(dout0_186) AT=860.025n

.meas tran vdout0_187ck1710 FIND v(dout0_187) AT=860.025n

.meas tran vdout0_188ck1710 FIND v(dout0_188) AT=860.025n

.meas tran vdout0_189ck1710 FIND v(dout0_189) AT=860.025n

.meas tran vdout0_190ck1710 FIND v(dout0_190) AT=860.025n

.meas tran vdout0_191ck1710 FIND v(dout0_191) AT=860.025n

.meas tran vdout0_192ck1710 FIND v(dout0_192) AT=860.025n

.meas tran vdout0_193ck1710 FIND v(dout0_193) AT=860.025n

.meas tran vdout0_194ck1710 FIND v(dout0_194) AT=860.025n

.meas tran vdout0_195ck1710 FIND v(dout0_195) AT=860.025n

.meas tran vdout0_196ck1710 FIND v(dout0_196) AT=860.025n

.meas tran vdout0_197ck1710 FIND v(dout0_197) AT=860.025n

.meas tran vdout0_198ck1710 FIND v(dout0_198) AT=860.025n

.meas tran vdout0_199ck1710 FIND v(dout0_199) AT=860.025n

.meas tran vdout0_200ck1710 FIND v(dout0_200) AT=860.025n

.meas tran vdout0_201ck1710 FIND v(dout0_201) AT=860.025n

.meas tran vdout0_202ck1710 FIND v(dout0_202) AT=860.025n

.meas tran vdout0_203ck1710 FIND v(dout0_203) AT=860.025n

.meas tran vdout0_204ck1710 FIND v(dout0_204) AT=860.025n

.meas tran vdout0_205ck1710 FIND v(dout0_205) AT=860.025n

.meas tran vdout0_206ck1710 FIND v(dout0_206) AT=860.025n

.meas tran vdout0_207ck1710 FIND v(dout0_207) AT=860.025n

.meas tran vdout0_208ck1710 FIND v(dout0_208) AT=860.025n

.meas tran vdout0_209ck1710 FIND v(dout0_209) AT=860.025n

.meas tran vdout0_210ck1710 FIND v(dout0_210) AT=860.025n

.meas tran vdout0_211ck1710 FIND v(dout0_211) AT=860.025n

.meas tran vdout0_212ck1710 FIND v(dout0_212) AT=860.025n

.meas tran vdout0_213ck1710 FIND v(dout0_213) AT=860.025n

.meas tran vdout0_214ck1710 FIND v(dout0_214) AT=860.025n

.meas tran vdout0_215ck1710 FIND v(dout0_215) AT=860.025n

.meas tran vdout0_216ck1710 FIND v(dout0_216) AT=860.025n

.meas tran vdout0_217ck1710 FIND v(dout0_217) AT=860.025n

.meas tran vdout0_218ck1710 FIND v(dout0_218) AT=860.025n

.meas tran vdout0_219ck1710 FIND v(dout0_219) AT=860.025n

.meas tran vdout0_220ck1710 FIND v(dout0_220) AT=860.025n

.meas tran vdout0_221ck1710 FIND v(dout0_221) AT=860.025n

.meas tran vdout0_222ck1710 FIND v(dout0_222) AT=860.025n

.meas tran vdout0_223ck1710 FIND v(dout0_223) AT=860.025n

.meas tran vdout0_224ck1710 FIND v(dout0_224) AT=860.025n

.meas tran vdout0_225ck1710 FIND v(dout0_225) AT=860.025n

.meas tran vdout0_226ck1710 FIND v(dout0_226) AT=860.025n

.meas tran vdout0_227ck1710 FIND v(dout0_227) AT=860.025n

.meas tran vdout0_228ck1710 FIND v(dout0_228) AT=860.025n

.meas tran vdout0_229ck1710 FIND v(dout0_229) AT=860.025n

.meas tran vdout0_230ck1710 FIND v(dout0_230) AT=860.025n

.meas tran vdout0_231ck1710 FIND v(dout0_231) AT=860.025n

.meas tran vdout0_232ck1710 FIND v(dout0_232) AT=860.025n

.meas tran vdout0_233ck1710 FIND v(dout0_233) AT=860.025n

.meas tran vdout0_234ck1710 FIND v(dout0_234) AT=860.025n

.meas tran vdout0_235ck1710 FIND v(dout0_235) AT=860.025n

.meas tran vdout0_236ck1710 FIND v(dout0_236) AT=860.025n

.meas tran vdout0_237ck1710 FIND v(dout0_237) AT=860.025n

.meas tran vdout0_238ck1710 FIND v(dout0_238) AT=860.025n

.meas tran vdout0_239ck1710 FIND v(dout0_239) AT=860.025n

.meas tran vdout0_240ck1710 FIND v(dout0_240) AT=860.025n

.meas tran vdout0_241ck1710 FIND v(dout0_241) AT=860.025n

.meas tran vdout0_242ck1710 FIND v(dout0_242) AT=860.025n

.meas tran vdout0_243ck1710 FIND v(dout0_243) AT=860.025n

.meas tran vdout0_244ck1710 FIND v(dout0_244) AT=860.025n

.meas tran vdout0_245ck1710 FIND v(dout0_245) AT=860.025n

.meas tran vdout0_246ck1710 FIND v(dout0_246) AT=860.025n

.meas tran vdout0_247ck1710 FIND v(dout0_247) AT=860.025n

.meas tran vdout0_248ck1710 FIND v(dout0_248) AT=860.025n

.meas tran vdout0_249ck1710 FIND v(dout0_249) AT=860.025n

.meas tran vdout0_250ck1710 FIND v(dout0_250) AT=860.025n

.meas tran vdout0_251ck1710 FIND v(dout0_251) AT=860.025n

.meas tran vdout0_252ck1710 FIND v(dout0_252) AT=860.025n

.meas tran vdout0_253ck1710 FIND v(dout0_253) AT=860.025n

.meas tran vdout0_254ck1710 FIND v(dout0_254) AT=860.025n

.meas tran vdout0_255ck1710 FIND v(dout0_255) AT=860.025n

.meas tran vdout0_0ck1730 FIND v(dout0_0) AT=870.025n

.meas tran vdout0_1ck1730 FIND v(dout0_1) AT=870.025n

.meas tran vdout0_2ck1730 FIND v(dout0_2) AT=870.025n

.meas tran vdout0_3ck1730 FIND v(dout0_3) AT=870.025n

.meas tran vdout0_4ck1730 FIND v(dout0_4) AT=870.025n

.meas tran vdout0_5ck1730 FIND v(dout0_5) AT=870.025n

.meas tran vdout0_6ck1730 FIND v(dout0_6) AT=870.025n

.meas tran vdout0_7ck1730 FIND v(dout0_7) AT=870.025n

.meas tran vdout0_8ck1730 FIND v(dout0_8) AT=870.025n

.meas tran vdout0_9ck1730 FIND v(dout0_9) AT=870.025n

.meas tran vdout0_10ck1730 FIND v(dout0_10) AT=870.025n

.meas tran vdout0_11ck1730 FIND v(dout0_11) AT=870.025n

.meas tran vdout0_12ck1730 FIND v(dout0_12) AT=870.025n

.meas tran vdout0_13ck1730 FIND v(dout0_13) AT=870.025n

.meas tran vdout0_14ck1730 FIND v(dout0_14) AT=870.025n

.meas tran vdout0_15ck1730 FIND v(dout0_15) AT=870.025n

.meas tran vdout0_16ck1730 FIND v(dout0_16) AT=870.025n

.meas tran vdout0_17ck1730 FIND v(dout0_17) AT=870.025n

.meas tran vdout0_18ck1730 FIND v(dout0_18) AT=870.025n

.meas tran vdout0_19ck1730 FIND v(dout0_19) AT=870.025n

.meas tran vdout0_20ck1730 FIND v(dout0_20) AT=870.025n

.meas tran vdout0_21ck1730 FIND v(dout0_21) AT=870.025n

.meas tran vdout0_22ck1730 FIND v(dout0_22) AT=870.025n

.meas tran vdout0_23ck1730 FIND v(dout0_23) AT=870.025n

.meas tran vdout0_24ck1730 FIND v(dout0_24) AT=870.025n

.meas tran vdout0_25ck1730 FIND v(dout0_25) AT=870.025n

.meas tran vdout0_26ck1730 FIND v(dout0_26) AT=870.025n

.meas tran vdout0_27ck1730 FIND v(dout0_27) AT=870.025n

.meas tran vdout0_28ck1730 FIND v(dout0_28) AT=870.025n

.meas tran vdout0_29ck1730 FIND v(dout0_29) AT=870.025n

.meas tran vdout0_30ck1730 FIND v(dout0_30) AT=870.025n

.meas tran vdout0_31ck1730 FIND v(dout0_31) AT=870.025n

.meas tran vdout0_32ck1730 FIND v(dout0_32) AT=870.025n

.meas tran vdout0_33ck1730 FIND v(dout0_33) AT=870.025n

.meas tran vdout0_34ck1730 FIND v(dout0_34) AT=870.025n

.meas tran vdout0_35ck1730 FIND v(dout0_35) AT=870.025n

.meas tran vdout0_36ck1730 FIND v(dout0_36) AT=870.025n

.meas tran vdout0_37ck1730 FIND v(dout0_37) AT=870.025n

.meas tran vdout0_38ck1730 FIND v(dout0_38) AT=870.025n

.meas tran vdout0_39ck1730 FIND v(dout0_39) AT=870.025n

.meas tran vdout0_40ck1730 FIND v(dout0_40) AT=870.025n

.meas tran vdout0_41ck1730 FIND v(dout0_41) AT=870.025n

.meas tran vdout0_42ck1730 FIND v(dout0_42) AT=870.025n

.meas tran vdout0_43ck1730 FIND v(dout0_43) AT=870.025n

.meas tran vdout0_44ck1730 FIND v(dout0_44) AT=870.025n

.meas tran vdout0_45ck1730 FIND v(dout0_45) AT=870.025n

.meas tran vdout0_46ck1730 FIND v(dout0_46) AT=870.025n

.meas tran vdout0_47ck1730 FIND v(dout0_47) AT=870.025n

.meas tran vdout0_48ck1730 FIND v(dout0_48) AT=870.025n

.meas tran vdout0_49ck1730 FIND v(dout0_49) AT=870.025n

.meas tran vdout0_50ck1730 FIND v(dout0_50) AT=870.025n

.meas tran vdout0_51ck1730 FIND v(dout0_51) AT=870.025n

.meas tran vdout0_52ck1730 FIND v(dout0_52) AT=870.025n

.meas tran vdout0_53ck1730 FIND v(dout0_53) AT=870.025n

.meas tran vdout0_54ck1730 FIND v(dout0_54) AT=870.025n

.meas tran vdout0_55ck1730 FIND v(dout0_55) AT=870.025n

.meas tran vdout0_56ck1730 FIND v(dout0_56) AT=870.025n

.meas tran vdout0_57ck1730 FIND v(dout0_57) AT=870.025n

.meas tran vdout0_58ck1730 FIND v(dout0_58) AT=870.025n

.meas tran vdout0_59ck1730 FIND v(dout0_59) AT=870.025n

.meas tran vdout0_60ck1730 FIND v(dout0_60) AT=870.025n

.meas tran vdout0_61ck1730 FIND v(dout0_61) AT=870.025n

.meas tran vdout0_62ck1730 FIND v(dout0_62) AT=870.025n

.meas tran vdout0_63ck1730 FIND v(dout0_63) AT=870.025n

.meas tran vdout0_64ck1730 FIND v(dout0_64) AT=870.025n

.meas tran vdout0_65ck1730 FIND v(dout0_65) AT=870.025n

.meas tran vdout0_66ck1730 FIND v(dout0_66) AT=870.025n

.meas tran vdout0_67ck1730 FIND v(dout0_67) AT=870.025n

.meas tran vdout0_68ck1730 FIND v(dout0_68) AT=870.025n

.meas tran vdout0_69ck1730 FIND v(dout0_69) AT=870.025n

.meas tran vdout0_70ck1730 FIND v(dout0_70) AT=870.025n

.meas tran vdout0_71ck1730 FIND v(dout0_71) AT=870.025n

.meas tran vdout0_72ck1730 FIND v(dout0_72) AT=870.025n

.meas tran vdout0_73ck1730 FIND v(dout0_73) AT=870.025n

.meas tran vdout0_74ck1730 FIND v(dout0_74) AT=870.025n

.meas tran vdout0_75ck1730 FIND v(dout0_75) AT=870.025n

.meas tran vdout0_76ck1730 FIND v(dout0_76) AT=870.025n

.meas tran vdout0_77ck1730 FIND v(dout0_77) AT=870.025n

.meas tran vdout0_78ck1730 FIND v(dout0_78) AT=870.025n

.meas tran vdout0_79ck1730 FIND v(dout0_79) AT=870.025n

.meas tran vdout0_80ck1730 FIND v(dout0_80) AT=870.025n

.meas tran vdout0_81ck1730 FIND v(dout0_81) AT=870.025n

.meas tran vdout0_82ck1730 FIND v(dout0_82) AT=870.025n

.meas tran vdout0_83ck1730 FIND v(dout0_83) AT=870.025n

.meas tran vdout0_84ck1730 FIND v(dout0_84) AT=870.025n

.meas tran vdout0_85ck1730 FIND v(dout0_85) AT=870.025n

.meas tran vdout0_86ck1730 FIND v(dout0_86) AT=870.025n

.meas tran vdout0_87ck1730 FIND v(dout0_87) AT=870.025n

.meas tran vdout0_88ck1730 FIND v(dout0_88) AT=870.025n

.meas tran vdout0_89ck1730 FIND v(dout0_89) AT=870.025n

.meas tran vdout0_90ck1730 FIND v(dout0_90) AT=870.025n

.meas tran vdout0_91ck1730 FIND v(dout0_91) AT=870.025n

.meas tran vdout0_92ck1730 FIND v(dout0_92) AT=870.025n

.meas tran vdout0_93ck1730 FIND v(dout0_93) AT=870.025n

.meas tran vdout0_94ck1730 FIND v(dout0_94) AT=870.025n

.meas tran vdout0_95ck1730 FIND v(dout0_95) AT=870.025n

.meas tran vdout0_96ck1730 FIND v(dout0_96) AT=870.025n

.meas tran vdout0_97ck1730 FIND v(dout0_97) AT=870.025n

.meas tran vdout0_98ck1730 FIND v(dout0_98) AT=870.025n

.meas tran vdout0_99ck1730 FIND v(dout0_99) AT=870.025n

.meas tran vdout0_100ck1730 FIND v(dout0_100) AT=870.025n

.meas tran vdout0_101ck1730 FIND v(dout0_101) AT=870.025n

.meas tran vdout0_102ck1730 FIND v(dout0_102) AT=870.025n

.meas tran vdout0_103ck1730 FIND v(dout0_103) AT=870.025n

.meas tran vdout0_104ck1730 FIND v(dout0_104) AT=870.025n

.meas tran vdout0_105ck1730 FIND v(dout0_105) AT=870.025n

.meas tran vdout0_106ck1730 FIND v(dout0_106) AT=870.025n

.meas tran vdout0_107ck1730 FIND v(dout0_107) AT=870.025n

.meas tran vdout0_108ck1730 FIND v(dout0_108) AT=870.025n

.meas tran vdout0_109ck1730 FIND v(dout0_109) AT=870.025n

.meas tran vdout0_110ck1730 FIND v(dout0_110) AT=870.025n

.meas tran vdout0_111ck1730 FIND v(dout0_111) AT=870.025n

.meas tran vdout0_112ck1730 FIND v(dout0_112) AT=870.025n

.meas tran vdout0_113ck1730 FIND v(dout0_113) AT=870.025n

.meas tran vdout0_114ck1730 FIND v(dout0_114) AT=870.025n

.meas tran vdout0_115ck1730 FIND v(dout0_115) AT=870.025n

.meas tran vdout0_116ck1730 FIND v(dout0_116) AT=870.025n

.meas tran vdout0_117ck1730 FIND v(dout0_117) AT=870.025n

.meas tran vdout0_118ck1730 FIND v(dout0_118) AT=870.025n

.meas tran vdout0_119ck1730 FIND v(dout0_119) AT=870.025n

.meas tran vdout0_120ck1730 FIND v(dout0_120) AT=870.025n

.meas tran vdout0_121ck1730 FIND v(dout0_121) AT=870.025n

.meas tran vdout0_122ck1730 FIND v(dout0_122) AT=870.025n

.meas tran vdout0_123ck1730 FIND v(dout0_123) AT=870.025n

.meas tran vdout0_124ck1730 FIND v(dout0_124) AT=870.025n

.meas tran vdout0_125ck1730 FIND v(dout0_125) AT=870.025n

.meas tran vdout0_126ck1730 FIND v(dout0_126) AT=870.025n

.meas tran vdout0_127ck1730 FIND v(dout0_127) AT=870.025n

.meas tran vdout0_128ck1730 FIND v(dout0_128) AT=870.025n

.meas tran vdout0_129ck1730 FIND v(dout0_129) AT=870.025n

.meas tran vdout0_130ck1730 FIND v(dout0_130) AT=870.025n

.meas tran vdout0_131ck1730 FIND v(dout0_131) AT=870.025n

.meas tran vdout0_132ck1730 FIND v(dout0_132) AT=870.025n

.meas tran vdout0_133ck1730 FIND v(dout0_133) AT=870.025n

.meas tran vdout0_134ck1730 FIND v(dout0_134) AT=870.025n

.meas tran vdout0_135ck1730 FIND v(dout0_135) AT=870.025n

.meas tran vdout0_136ck1730 FIND v(dout0_136) AT=870.025n

.meas tran vdout0_137ck1730 FIND v(dout0_137) AT=870.025n

.meas tran vdout0_138ck1730 FIND v(dout0_138) AT=870.025n

.meas tran vdout0_139ck1730 FIND v(dout0_139) AT=870.025n

.meas tran vdout0_140ck1730 FIND v(dout0_140) AT=870.025n

.meas tran vdout0_141ck1730 FIND v(dout0_141) AT=870.025n

.meas tran vdout0_142ck1730 FIND v(dout0_142) AT=870.025n

.meas tran vdout0_143ck1730 FIND v(dout0_143) AT=870.025n

.meas tran vdout0_144ck1730 FIND v(dout0_144) AT=870.025n

.meas tran vdout0_145ck1730 FIND v(dout0_145) AT=870.025n

.meas tran vdout0_146ck1730 FIND v(dout0_146) AT=870.025n

.meas tran vdout0_147ck1730 FIND v(dout0_147) AT=870.025n

.meas tran vdout0_148ck1730 FIND v(dout0_148) AT=870.025n

.meas tran vdout0_149ck1730 FIND v(dout0_149) AT=870.025n

.meas tran vdout0_150ck1730 FIND v(dout0_150) AT=870.025n

.meas tran vdout0_151ck1730 FIND v(dout0_151) AT=870.025n

.meas tran vdout0_152ck1730 FIND v(dout0_152) AT=870.025n

.meas tran vdout0_153ck1730 FIND v(dout0_153) AT=870.025n

.meas tran vdout0_154ck1730 FIND v(dout0_154) AT=870.025n

.meas tran vdout0_155ck1730 FIND v(dout0_155) AT=870.025n

.meas tran vdout0_156ck1730 FIND v(dout0_156) AT=870.025n

.meas tran vdout0_157ck1730 FIND v(dout0_157) AT=870.025n

.meas tran vdout0_158ck1730 FIND v(dout0_158) AT=870.025n

.meas tran vdout0_159ck1730 FIND v(dout0_159) AT=870.025n

.meas tran vdout0_160ck1730 FIND v(dout0_160) AT=870.025n

.meas tran vdout0_161ck1730 FIND v(dout0_161) AT=870.025n

.meas tran vdout0_162ck1730 FIND v(dout0_162) AT=870.025n

.meas tran vdout0_163ck1730 FIND v(dout0_163) AT=870.025n

.meas tran vdout0_164ck1730 FIND v(dout0_164) AT=870.025n

.meas tran vdout0_165ck1730 FIND v(dout0_165) AT=870.025n

.meas tran vdout0_166ck1730 FIND v(dout0_166) AT=870.025n

.meas tran vdout0_167ck1730 FIND v(dout0_167) AT=870.025n

.meas tran vdout0_168ck1730 FIND v(dout0_168) AT=870.025n

.meas tran vdout0_169ck1730 FIND v(dout0_169) AT=870.025n

.meas tran vdout0_170ck1730 FIND v(dout0_170) AT=870.025n

.meas tran vdout0_171ck1730 FIND v(dout0_171) AT=870.025n

.meas tran vdout0_172ck1730 FIND v(dout0_172) AT=870.025n

.meas tran vdout0_173ck1730 FIND v(dout0_173) AT=870.025n

.meas tran vdout0_174ck1730 FIND v(dout0_174) AT=870.025n

.meas tran vdout0_175ck1730 FIND v(dout0_175) AT=870.025n

.meas tran vdout0_176ck1730 FIND v(dout0_176) AT=870.025n

.meas tran vdout0_177ck1730 FIND v(dout0_177) AT=870.025n

.meas tran vdout0_178ck1730 FIND v(dout0_178) AT=870.025n

.meas tran vdout0_179ck1730 FIND v(dout0_179) AT=870.025n

.meas tran vdout0_180ck1730 FIND v(dout0_180) AT=870.025n

.meas tran vdout0_181ck1730 FIND v(dout0_181) AT=870.025n

.meas tran vdout0_182ck1730 FIND v(dout0_182) AT=870.025n

.meas tran vdout0_183ck1730 FIND v(dout0_183) AT=870.025n

.meas tran vdout0_184ck1730 FIND v(dout0_184) AT=870.025n

.meas tran vdout0_185ck1730 FIND v(dout0_185) AT=870.025n

.meas tran vdout0_186ck1730 FIND v(dout0_186) AT=870.025n

.meas tran vdout0_187ck1730 FIND v(dout0_187) AT=870.025n

.meas tran vdout0_188ck1730 FIND v(dout0_188) AT=870.025n

.meas tran vdout0_189ck1730 FIND v(dout0_189) AT=870.025n

.meas tran vdout0_190ck1730 FIND v(dout0_190) AT=870.025n

.meas tran vdout0_191ck1730 FIND v(dout0_191) AT=870.025n

.meas tran vdout0_192ck1730 FIND v(dout0_192) AT=870.025n

.meas tran vdout0_193ck1730 FIND v(dout0_193) AT=870.025n

.meas tran vdout0_194ck1730 FIND v(dout0_194) AT=870.025n

.meas tran vdout0_195ck1730 FIND v(dout0_195) AT=870.025n

.meas tran vdout0_196ck1730 FIND v(dout0_196) AT=870.025n

.meas tran vdout0_197ck1730 FIND v(dout0_197) AT=870.025n

.meas tran vdout0_198ck1730 FIND v(dout0_198) AT=870.025n

.meas tran vdout0_199ck1730 FIND v(dout0_199) AT=870.025n

.meas tran vdout0_200ck1730 FIND v(dout0_200) AT=870.025n

.meas tran vdout0_201ck1730 FIND v(dout0_201) AT=870.025n

.meas tran vdout0_202ck1730 FIND v(dout0_202) AT=870.025n

.meas tran vdout0_203ck1730 FIND v(dout0_203) AT=870.025n

.meas tran vdout0_204ck1730 FIND v(dout0_204) AT=870.025n

.meas tran vdout0_205ck1730 FIND v(dout0_205) AT=870.025n

.meas tran vdout0_206ck1730 FIND v(dout0_206) AT=870.025n

.meas tran vdout0_207ck1730 FIND v(dout0_207) AT=870.025n

.meas tran vdout0_208ck1730 FIND v(dout0_208) AT=870.025n

.meas tran vdout0_209ck1730 FIND v(dout0_209) AT=870.025n

.meas tran vdout0_210ck1730 FIND v(dout0_210) AT=870.025n

.meas tran vdout0_211ck1730 FIND v(dout0_211) AT=870.025n

.meas tran vdout0_212ck1730 FIND v(dout0_212) AT=870.025n

.meas tran vdout0_213ck1730 FIND v(dout0_213) AT=870.025n

.meas tran vdout0_214ck1730 FIND v(dout0_214) AT=870.025n

.meas tran vdout0_215ck1730 FIND v(dout0_215) AT=870.025n

.meas tran vdout0_216ck1730 FIND v(dout0_216) AT=870.025n

.meas tran vdout0_217ck1730 FIND v(dout0_217) AT=870.025n

.meas tran vdout0_218ck1730 FIND v(dout0_218) AT=870.025n

.meas tran vdout0_219ck1730 FIND v(dout0_219) AT=870.025n

.meas tran vdout0_220ck1730 FIND v(dout0_220) AT=870.025n

.meas tran vdout0_221ck1730 FIND v(dout0_221) AT=870.025n

.meas tran vdout0_222ck1730 FIND v(dout0_222) AT=870.025n

.meas tran vdout0_223ck1730 FIND v(dout0_223) AT=870.025n

.meas tran vdout0_224ck1730 FIND v(dout0_224) AT=870.025n

.meas tran vdout0_225ck1730 FIND v(dout0_225) AT=870.025n

.meas tran vdout0_226ck1730 FIND v(dout0_226) AT=870.025n

.meas tran vdout0_227ck1730 FIND v(dout0_227) AT=870.025n

.meas tran vdout0_228ck1730 FIND v(dout0_228) AT=870.025n

.meas tran vdout0_229ck1730 FIND v(dout0_229) AT=870.025n

.meas tran vdout0_230ck1730 FIND v(dout0_230) AT=870.025n

.meas tran vdout0_231ck1730 FIND v(dout0_231) AT=870.025n

.meas tran vdout0_232ck1730 FIND v(dout0_232) AT=870.025n

.meas tran vdout0_233ck1730 FIND v(dout0_233) AT=870.025n

.meas tran vdout0_234ck1730 FIND v(dout0_234) AT=870.025n

.meas tran vdout0_235ck1730 FIND v(dout0_235) AT=870.025n

.meas tran vdout0_236ck1730 FIND v(dout0_236) AT=870.025n

.meas tran vdout0_237ck1730 FIND v(dout0_237) AT=870.025n

.meas tran vdout0_238ck1730 FIND v(dout0_238) AT=870.025n

.meas tran vdout0_239ck1730 FIND v(dout0_239) AT=870.025n

.meas tran vdout0_240ck1730 FIND v(dout0_240) AT=870.025n

.meas tran vdout0_241ck1730 FIND v(dout0_241) AT=870.025n

.meas tran vdout0_242ck1730 FIND v(dout0_242) AT=870.025n

.meas tran vdout0_243ck1730 FIND v(dout0_243) AT=870.025n

.meas tran vdout0_244ck1730 FIND v(dout0_244) AT=870.025n

.meas tran vdout0_245ck1730 FIND v(dout0_245) AT=870.025n

.meas tran vdout0_246ck1730 FIND v(dout0_246) AT=870.025n

.meas tran vdout0_247ck1730 FIND v(dout0_247) AT=870.025n

.meas tran vdout0_248ck1730 FIND v(dout0_248) AT=870.025n

.meas tran vdout0_249ck1730 FIND v(dout0_249) AT=870.025n

.meas tran vdout0_250ck1730 FIND v(dout0_250) AT=870.025n

.meas tran vdout0_251ck1730 FIND v(dout0_251) AT=870.025n

.meas tran vdout0_252ck1730 FIND v(dout0_252) AT=870.025n

.meas tran vdout0_253ck1730 FIND v(dout0_253) AT=870.025n

.meas tran vdout0_254ck1730 FIND v(dout0_254) AT=870.025n

.meas tran vdout0_255ck1730 FIND v(dout0_255) AT=870.025n

.meas tran vdout0_0ck1750 FIND v(dout0_0) AT=880.025n

.meas tran vdout0_1ck1750 FIND v(dout0_1) AT=880.025n

.meas tran vdout0_2ck1750 FIND v(dout0_2) AT=880.025n

.meas tran vdout0_3ck1750 FIND v(dout0_3) AT=880.025n

.meas tran vdout0_4ck1750 FIND v(dout0_4) AT=880.025n

.meas tran vdout0_5ck1750 FIND v(dout0_5) AT=880.025n

.meas tran vdout0_6ck1750 FIND v(dout0_6) AT=880.025n

.meas tran vdout0_7ck1750 FIND v(dout0_7) AT=880.025n

.meas tran vdout0_8ck1750 FIND v(dout0_8) AT=880.025n

.meas tran vdout0_9ck1750 FIND v(dout0_9) AT=880.025n

.meas tran vdout0_10ck1750 FIND v(dout0_10) AT=880.025n

.meas tran vdout0_11ck1750 FIND v(dout0_11) AT=880.025n

.meas tran vdout0_12ck1750 FIND v(dout0_12) AT=880.025n

.meas tran vdout0_13ck1750 FIND v(dout0_13) AT=880.025n

.meas tran vdout0_14ck1750 FIND v(dout0_14) AT=880.025n

.meas tran vdout0_15ck1750 FIND v(dout0_15) AT=880.025n

.meas tran vdout0_16ck1750 FIND v(dout0_16) AT=880.025n

.meas tran vdout0_17ck1750 FIND v(dout0_17) AT=880.025n

.meas tran vdout0_18ck1750 FIND v(dout0_18) AT=880.025n

.meas tran vdout0_19ck1750 FIND v(dout0_19) AT=880.025n

.meas tran vdout0_20ck1750 FIND v(dout0_20) AT=880.025n

.meas tran vdout0_21ck1750 FIND v(dout0_21) AT=880.025n

.meas tran vdout0_22ck1750 FIND v(dout0_22) AT=880.025n

.meas tran vdout0_23ck1750 FIND v(dout0_23) AT=880.025n

.meas tran vdout0_24ck1750 FIND v(dout0_24) AT=880.025n

.meas tran vdout0_25ck1750 FIND v(dout0_25) AT=880.025n

.meas tran vdout0_26ck1750 FIND v(dout0_26) AT=880.025n

.meas tran vdout0_27ck1750 FIND v(dout0_27) AT=880.025n

.meas tran vdout0_28ck1750 FIND v(dout0_28) AT=880.025n

.meas tran vdout0_29ck1750 FIND v(dout0_29) AT=880.025n

.meas tran vdout0_30ck1750 FIND v(dout0_30) AT=880.025n

.meas tran vdout0_31ck1750 FIND v(dout0_31) AT=880.025n

.meas tran vdout0_32ck1750 FIND v(dout0_32) AT=880.025n

.meas tran vdout0_33ck1750 FIND v(dout0_33) AT=880.025n

.meas tran vdout0_34ck1750 FIND v(dout0_34) AT=880.025n

.meas tran vdout0_35ck1750 FIND v(dout0_35) AT=880.025n

.meas tran vdout0_36ck1750 FIND v(dout0_36) AT=880.025n

.meas tran vdout0_37ck1750 FIND v(dout0_37) AT=880.025n

.meas tran vdout0_38ck1750 FIND v(dout0_38) AT=880.025n

.meas tran vdout0_39ck1750 FIND v(dout0_39) AT=880.025n

.meas tran vdout0_40ck1750 FIND v(dout0_40) AT=880.025n

.meas tran vdout0_41ck1750 FIND v(dout0_41) AT=880.025n

.meas tran vdout0_42ck1750 FIND v(dout0_42) AT=880.025n

.meas tran vdout0_43ck1750 FIND v(dout0_43) AT=880.025n

.meas tran vdout0_44ck1750 FIND v(dout0_44) AT=880.025n

.meas tran vdout0_45ck1750 FIND v(dout0_45) AT=880.025n

.meas tran vdout0_46ck1750 FIND v(dout0_46) AT=880.025n

.meas tran vdout0_47ck1750 FIND v(dout0_47) AT=880.025n

.meas tran vdout0_48ck1750 FIND v(dout0_48) AT=880.025n

.meas tran vdout0_49ck1750 FIND v(dout0_49) AT=880.025n

.meas tran vdout0_50ck1750 FIND v(dout0_50) AT=880.025n

.meas tran vdout0_51ck1750 FIND v(dout0_51) AT=880.025n

.meas tran vdout0_52ck1750 FIND v(dout0_52) AT=880.025n

.meas tran vdout0_53ck1750 FIND v(dout0_53) AT=880.025n

.meas tran vdout0_54ck1750 FIND v(dout0_54) AT=880.025n

.meas tran vdout0_55ck1750 FIND v(dout0_55) AT=880.025n

.meas tran vdout0_56ck1750 FIND v(dout0_56) AT=880.025n

.meas tran vdout0_57ck1750 FIND v(dout0_57) AT=880.025n

.meas tran vdout0_58ck1750 FIND v(dout0_58) AT=880.025n

.meas tran vdout0_59ck1750 FIND v(dout0_59) AT=880.025n

.meas tran vdout0_60ck1750 FIND v(dout0_60) AT=880.025n

.meas tran vdout0_61ck1750 FIND v(dout0_61) AT=880.025n

.meas tran vdout0_62ck1750 FIND v(dout0_62) AT=880.025n

.meas tran vdout0_63ck1750 FIND v(dout0_63) AT=880.025n

.meas tran vdout0_64ck1750 FIND v(dout0_64) AT=880.025n

.meas tran vdout0_65ck1750 FIND v(dout0_65) AT=880.025n

.meas tran vdout0_66ck1750 FIND v(dout0_66) AT=880.025n

.meas tran vdout0_67ck1750 FIND v(dout0_67) AT=880.025n

.meas tran vdout0_68ck1750 FIND v(dout0_68) AT=880.025n

.meas tran vdout0_69ck1750 FIND v(dout0_69) AT=880.025n

.meas tran vdout0_70ck1750 FIND v(dout0_70) AT=880.025n

.meas tran vdout0_71ck1750 FIND v(dout0_71) AT=880.025n

.meas tran vdout0_72ck1750 FIND v(dout0_72) AT=880.025n

.meas tran vdout0_73ck1750 FIND v(dout0_73) AT=880.025n

.meas tran vdout0_74ck1750 FIND v(dout0_74) AT=880.025n

.meas tran vdout0_75ck1750 FIND v(dout0_75) AT=880.025n

.meas tran vdout0_76ck1750 FIND v(dout0_76) AT=880.025n

.meas tran vdout0_77ck1750 FIND v(dout0_77) AT=880.025n

.meas tran vdout0_78ck1750 FIND v(dout0_78) AT=880.025n

.meas tran vdout0_79ck1750 FIND v(dout0_79) AT=880.025n

.meas tran vdout0_80ck1750 FIND v(dout0_80) AT=880.025n

.meas tran vdout0_81ck1750 FIND v(dout0_81) AT=880.025n

.meas tran vdout0_82ck1750 FIND v(dout0_82) AT=880.025n

.meas tran vdout0_83ck1750 FIND v(dout0_83) AT=880.025n

.meas tran vdout0_84ck1750 FIND v(dout0_84) AT=880.025n

.meas tran vdout0_85ck1750 FIND v(dout0_85) AT=880.025n

.meas tran vdout0_86ck1750 FIND v(dout0_86) AT=880.025n

.meas tran vdout0_87ck1750 FIND v(dout0_87) AT=880.025n

.meas tran vdout0_88ck1750 FIND v(dout0_88) AT=880.025n

.meas tran vdout0_89ck1750 FIND v(dout0_89) AT=880.025n

.meas tran vdout0_90ck1750 FIND v(dout0_90) AT=880.025n

.meas tran vdout0_91ck1750 FIND v(dout0_91) AT=880.025n

.meas tran vdout0_92ck1750 FIND v(dout0_92) AT=880.025n

.meas tran vdout0_93ck1750 FIND v(dout0_93) AT=880.025n

.meas tran vdout0_94ck1750 FIND v(dout0_94) AT=880.025n

.meas tran vdout0_95ck1750 FIND v(dout0_95) AT=880.025n

.meas tran vdout0_96ck1750 FIND v(dout0_96) AT=880.025n

.meas tran vdout0_97ck1750 FIND v(dout0_97) AT=880.025n

.meas tran vdout0_98ck1750 FIND v(dout0_98) AT=880.025n

.meas tran vdout0_99ck1750 FIND v(dout0_99) AT=880.025n

.meas tran vdout0_100ck1750 FIND v(dout0_100) AT=880.025n

.meas tran vdout0_101ck1750 FIND v(dout0_101) AT=880.025n

.meas tran vdout0_102ck1750 FIND v(dout0_102) AT=880.025n

.meas tran vdout0_103ck1750 FIND v(dout0_103) AT=880.025n

.meas tran vdout0_104ck1750 FIND v(dout0_104) AT=880.025n

.meas tran vdout0_105ck1750 FIND v(dout0_105) AT=880.025n

.meas tran vdout0_106ck1750 FIND v(dout0_106) AT=880.025n

.meas tran vdout0_107ck1750 FIND v(dout0_107) AT=880.025n

.meas tran vdout0_108ck1750 FIND v(dout0_108) AT=880.025n

.meas tran vdout0_109ck1750 FIND v(dout0_109) AT=880.025n

.meas tran vdout0_110ck1750 FIND v(dout0_110) AT=880.025n

.meas tran vdout0_111ck1750 FIND v(dout0_111) AT=880.025n

.meas tran vdout0_112ck1750 FIND v(dout0_112) AT=880.025n

.meas tran vdout0_113ck1750 FIND v(dout0_113) AT=880.025n

.meas tran vdout0_114ck1750 FIND v(dout0_114) AT=880.025n

.meas tran vdout0_115ck1750 FIND v(dout0_115) AT=880.025n

.meas tran vdout0_116ck1750 FIND v(dout0_116) AT=880.025n

.meas tran vdout0_117ck1750 FIND v(dout0_117) AT=880.025n

.meas tran vdout0_118ck1750 FIND v(dout0_118) AT=880.025n

.meas tran vdout0_119ck1750 FIND v(dout0_119) AT=880.025n

.meas tran vdout0_120ck1750 FIND v(dout0_120) AT=880.025n

.meas tran vdout0_121ck1750 FIND v(dout0_121) AT=880.025n

.meas tran vdout0_122ck1750 FIND v(dout0_122) AT=880.025n

.meas tran vdout0_123ck1750 FIND v(dout0_123) AT=880.025n

.meas tran vdout0_124ck1750 FIND v(dout0_124) AT=880.025n

.meas tran vdout0_125ck1750 FIND v(dout0_125) AT=880.025n

.meas tran vdout0_126ck1750 FIND v(dout0_126) AT=880.025n

.meas tran vdout0_127ck1750 FIND v(dout0_127) AT=880.025n

.meas tran vdout0_128ck1750 FIND v(dout0_128) AT=880.025n

.meas tran vdout0_129ck1750 FIND v(dout0_129) AT=880.025n

.meas tran vdout0_130ck1750 FIND v(dout0_130) AT=880.025n

.meas tran vdout0_131ck1750 FIND v(dout0_131) AT=880.025n

.meas tran vdout0_132ck1750 FIND v(dout0_132) AT=880.025n

.meas tran vdout0_133ck1750 FIND v(dout0_133) AT=880.025n

.meas tran vdout0_134ck1750 FIND v(dout0_134) AT=880.025n

.meas tran vdout0_135ck1750 FIND v(dout0_135) AT=880.025n

.meas tran vdout0_136ck1750 FIND v(dout0_136) AT=880.025n

.meas tran vdout0_137ck1750 FIND v(dout0_137) AT=880.025n

.meas tran vdout0_138ck1750 FIND v(dout0_138) AT=880.025n

.meas tran vdout0_139ck1750 FIND v(dout0_139) AT=880.025n

.meas tran vdout0_140ck1750 FIND v(dout0_140) AT=880.025n

.meas tran vdout0_141ck1750 FIND v(dout0_141) AT=880.025n

.meas tran vdout0_142ck1750 FIND v(dout0_142) AT=880.025n

.meas tran vdout0_143ck1750 FIND v(dout0_143) AT=880.025n

.meas tran vdout0_144ck1750 FIND v(dout0_144) AT=880.025n

.meas tran vdout0_145ck1750 FIND v(dout0_145) AT=880.025n

.meas tran vdout0_146ck1750 FIND v(dout0_146) AT=880.025n

.meas tran vdout0_147ck1750 FIND v(dout0_147) AT=880.025n

.meas tran vdout0_148ck1750 FIND v(dout0_148) AT=880.025n

.meas tran vdout0_149ck1750 FIND v(dout0_149) AT=880.025n

.meas tran vdout0_150ck1750 FIND v(dout0_150) AT=880.025n

.meas tran vdout0_151ck1750 FIND v(dout0_151) AT=880.025n

.meas tran vdout0_152ck1750 FIND v(dout0_152) AT=880.025n

.meas tran vdout0_153ck1750 FIND v(dout0_153) AT=880.025n

.meas tran vdout0_154ck1750 FIND v(dout0_154) AT=880.025n

.meas tran vdout0_155ck1750 FIND v(dout0_155) AT=880.025n

.meas tran vdout0_156ck1750 FIND v(dout0_156) AT=880.025n

.meas tran vdout0_157ck1750 FIND v(dout0_157) AT=880.025n

.meas tran vdout0_158ck1750 FIND v(dout0_158) AT=880.025n

.meas tran vdout0_159ck1750 FIND v(dout0_159) AT=880.025n

.meas tran vdout0_160ck1750 FIND v(dout0_160) AT=880.025n

.meas tran vdout0_161ck1750 FIND v(dout0_161) AT=880.025n

.meas tran vdout0_162ck1750 FIND v(dout0_162) AT=880.025n

.meas tran vdout0_163ck1750 FIND v(dout0_163) AT=880.025n

.meas tran vdout0_164ck1750 FIND v(dout0_164) AT=880.025n

.meas tran vdout0_165ck1750 FIND v(dout0_165) AT=880.025n

.meas tran vdout0_166ck1750 FIND v(dout0_166) AT=880.025n

.meas tran vdout0_167ck1750 FIND v(dout0_167) AT=880.025n

.meas tran vdout0_168ck1750 FIND v(dout0_168) AT=880.025n

.meas tran vdout0_169ck1750 FIND v(dout0_169) AT=880.025n

.meas tran vdout0_170ck1750 FIND v(dout0_170) AT=880.025n

.meas tran vdout0_171ck1750 FIND v(dout0_171) AT=880.025n

.meas tran vdout0_172ck1750 FIND v(dout0_172) AT=880.025n

.meas tran vdout0_173ck1750 FIND v(dout0_173) AT=880.025n

.meas tran vdout0_174ck1750 FIND v(dout0_174) AT=880.025n

.meas tran vdout0_175ck1750 FIND v(dout0_175) AT=880.025n

.meas tran vdout0_176ck1750 FIND v(dout0_176) AT=880.025n

.meas tran vdout0_177ck1750 FIND v(dout0_177) AT=880.025n

.meas tran vdout0_178ck1750 FIND v(dout0_178) AT=880.025n

.meas tran vdout0_179ck1750 FIND v(dout0_179) AT=880.025n

.meas tran vdout0_180ck1750 FIND v(dout0_180) AT=880.025n

.meas tran vdout0_181ck1750 FIND v(dout0_181) AT=880.025n

.meas tran vdout0_182ck1750 FIND v(dout0_182) AT=880.025n

.meas tran vdout0_183ck1750 FIND v(dout0_183) AT=880.025n

.meas tran vdout0_184ck1750 FIND v(dout0_184) AT=880.025n

.meas tran vdout0_185ck1750 FIND v(dout0_185) AT=880.025n

.meas tran vdout0_186ck1750 FIND v(dout0_186) AT=880.025n

.meas tran vdout0_187ck1750 FIND v(dout0_187) AT=880.025n

.meas tran vdout0_188ck1750 FIND v(dout0_188) AT=880.025n

.meas tran vdout0_189ck1750 FIND v(dout0_189) AT=880.025n

.meas tran vdout0_190ck1750 FIND v(dout0_190) AT=880.025n

.meas tran vdout0_191ck1750 FIND v(dout0_191) AT=880.025n

.meas tran vdout0_192ck1750 FIND v(dout0_192) AT=880.025n

.meas tran vdout0_193ck1750 FIND v(dout0_193) AT=880.025n

.meas tran vdout0_194ck1750 FIND v(dout0_194) AT=880.025n

.meas tran vdout0_195ck1750 FIND v(dout0_195) AT=880.025n

.meas tran vdout0_196ck1750 FIND v(dout0_196) AT=880.025n

.meas tran vdout0_197ck1750 FIND v(dout0_197) AT=880.025n

.meas tran vdout0_198ck1750 FIND v(dout0_198) AT=880.025n

.meas tran vdout0_199ck1750 FIND v(dout0_199) AT=880.025n

.meas tran vdout0_200ck1750 FIND v(dout0_200) AT=880.025n

.meas tran vdout0_201ck1750 FIND v(dout0_201) AT=880.025n

.meas tran vdout0_202ck1750 FIND v(dout0_202) AT=880.025n

.meas tran vdout0_203ck1750 FIND v(dout0_203) AT=880.025n

.meas tran vdout0_204ck1750 FIND v(dout0_204) AT=880.025n

.meas tran vdout0_205ck1750 FIND v(dout0_205) AT=880.025n

.meas tran vdout0_206ck1750 FIND v(dout0_206) AT=880.025n

.meas tran vdout0_207ck1750 FIND v(dout0_207) AT=880.025n

.meas tran vdout0_208ck1750 FIND v(dout0_208) AT=880.025n

.meas tran vdout0_209ck1750 FIND v(dout0_209) AT=880.025n

.meas tran vdout0_210ck1750 FIND v(dout0_210) AT=880.025n

.meas tran vdout0_211ck1750 FIND v(dout0_211) AT=880.025n

.meas tran vdout0_212ck1750 FIND v(dout0_212) AT=880.025n

.meas tran vdout0_213ck1750 FIND v(dout0_213) AT=880.025n

.meas tran vdout0_214ck1750 FIND v(dout0_214) AT=880.025n

.meas tran vdout0_215ck1750 FIND v(dout0_215) AT=880.025n

.meas tran vdout0_216ck1750 FIND v(dout0_216) AT=880.025n

.meas tran vdout0_217ck1750 FIND v(dout0_217) AT=880.025n

.meas tran vdout0_218ck1750 FIND v(dout0_218) AT=880.025n

.meas tran vdout0_219ck1750 FIND v(dout0_219) AT=880.025n

.meas tran vdout0_220ck1750 FIND v(dout0_220) AT=880.025n

.meas tran vdout0_221ck1750 FIND v(dout0_221) AT=880.025n

.meas tran vdout0_222ck1750 FIND v(dout0_222) AT=880.025n

.meas tran vdout0_223ck1750 FIND v(dout0_223) AT=880.025n

.meas tran vdout0_224ck1750 FIND v(dout0_224) AT=880.025n

.meas tran vdout0_225ck1750 FIND v(dout0_225) AT=880.025n

.meas tran vdout0_226ck1750 FIND v(dout0_226) AT=880.025n

.meas tran vdout0_227ck1750 FIND v(dout0_227) AT=880.025n

.meas tran vdout0_228ck1750 FIND v(dout0_228) AT=880.025n

.meas tran vdout0_229ck1750 FIND v(dout0_229) AT=880.025n

.meas tran vdout0_230ck1750 FIND v(dout0_230) AT=880.025n

.meas tran vdout0_231ck1750 FIND v(dout0_231) AT=880.025n

.meas tran vdout0_232ck1750 FIND v(dout0_232) AT=880.025n

.meas tran vdout0_233ck1750 FIND v(dout0_233) AT=880.025n

.meas tran vdout0_234ck1750 FIND v(dout0_234) AT=880.025n

.meas tran vdout0_235ck1750 FIND v(dout0_235) AT=880.025n

.meas tran vdout0_236ck1750 FIND v(dout0_236) AT=880.025n

.meas tran vdout0_237ck1750 FIND v(dout0_237) AT=880.025n

.meas tran vdout0_238ck1750 FIND v(dout0_238) AT=880.025n

.meas tran vdout0_239ck1750 FIND v(dout0_239) AT=880.025n

.meas tran vdout0_240ck1750 FIND v(dout0_240) AT=880.025n

.meas tran vdout0_241ck1750 FIND v(dout0_241) AT=880.025n

.meas tran vdout0_242ck1750 FIND v(dout0_242) AT=880.025n

.meas tran vdout0_243ck1750 FIND v(dout0_243) AT=880.025n

.meas tran vdout0_244ck1750 FIND v(dout0_244) AT=880.025n

.meas tran vdout0_245ck1750 FIND v(dout0_245) AT=880.025n

.meas tran vdout0_246ck1750 FIND v(dout0_246) AT=880.025n

.meas tran vdout0_247ck1750 FIND v(dout0_247) AT=880.025n

.meas tran vdout0_248ck1750 FIND v(dout0_248) AT=880.025n

.meas tran vdout0_249ck1750 FIND v(dout0_249) AT=880.025n

.meas tran vdout0_250ck1750 FIND v(dout0_250) AT=880.025n

.meas tran vdout0_251ck1750 FIND v(dout0_251) AT=880.025n

.meas tran vdout0_252ck1750 FIND v(dout0_252) AT=880.025n

.meas tran vdout0_253ck1750 FIND v(dout0_253) AT=880.025n

.meas tran vdout0_254ck1750 FIND v(dout0_254) AT=880.025n

.meas tran vdout0_255ck1750 FIND v(dout0_255) AT=880.025n

.meas tran vdout0_0ck1760 FIND v(dout0_0) AT=885.025n

.meas tran vdout0_1ck1760 FIND v(dout0_1) AT=885.025n

.meas tran vdout0_2ck1760 FIND v(dout0_2) AT=885.025n

.meas tran vdout0_3ck1760 FIND v(dout0_3) AT=885.025n

.meas tran vdout0_4ck1760 FIND v(dout0_4) AT=885.025n

.meas tran vdout0_5ck1760 FIND v(dout0_5) AT=885.025n

.meas tran vdout0_6ck1760 FIND v(dout0_6) AT=885.025n

.meas tran vdout0_7ck1760 FIND v(dout0_7) AT=885.025n

.meas tran vdout0_8ck1760 FIND v(dout0_8) AT=885.025n

.meas tran vdout0_9ck1760 FIND v(dout0_9) AT=885.025n

.meas tran vdout0_10ck1760 FIND v(dout0_10) AT=885.025n

.meas tran vdout0_11ck1760 FIND v(dout0_11) AT=885.025n

.meas tran vdout0_12ck1760 FIND v(dout0_12) AT=885.025n

.meas tran vdout0_13ck1760 FIND v(dout0_13) AT=885.025n

.meas tran vdout0_14ck1760 FIND v(dout0_14) AT=885.025n

.meas tran vdout0_15ck1760 FIND v(dout0_15) AT=885.025n

.meas tran vdout0_16ck1760 FIND v(dout0_16) AT=885.025n

.meas tran vdout0_17ck1760 FIND v(dout0_17) AT=885.025n

.meas tran vdout0_18ck1760 FIND v(dout0_18) AT=885.025n

.meas tran vdout0_19ck1760 FIND v(dout0_19) AT=885.025n

.meas tran vdout0_20ck1760 FIND v(dout0_20) AT=885.025n

.meas tran vdout0_21ck1760 FIND v(dout0_21) AT=885.025n

.meas tran vdout0_22ck1760 FIND v(dout0_22) AT=885.025n

.meas tran vdout0_23ck1760 FIND v(dout0_23) AT=885.025n

.meas tran vdout0_24ck1760 FIND v(dout0_24) AT=885.025n

.meas tran vdout0_25ck1760 FIND v(dout0_25) AT=885.025n

.meas tran vdout0_26ck1760 FIND v(dout0_26) AT=885.025n

.meas tran vdout0_27ck1760 FIND v(dout0_27) AT=885.025n

.meas tran vdout0_28ck1760 FIND v(dout0_28) AT=885.025n

.meas tran vdout0_29ck1760 FIND v(dout0_29) AT=885.025n

.meas tran vdout0_30ck1760 FIND v(dout0_30) AT=885.025n

.meas tran vdout0_31ck1760 FIND v(dout0_31) AT=885.025n

.meas tran vdout0_32ck1760 FIND v(dout0_32) AT=885.025n

.meas tran vdout0_33ck1760 FIND v(dout0_33) AT=885.025n

.meas tran vdout0_34ck1760 FIND v(dout0_34) AT=885.025n

.meas tran vdout0_35ck1760 FIND v(dout0_35) AT=885.025n

.meas tran vdout0_36ck1760 FIND v(dout0_36) AT=885.025n

.meas tran vdout0_37ck1760 FIND v(dout0_37) AT=885.025n

.meas tran vdout0_38ck1760 FIND v(dout0_38) AT=885.025n

.meas tran vdout0_39ck1760 FIND v(dout0_39) AT=885.025n

.meas tran vdout0_40ck1760 FIND v(dout0_40) AT=885.025n

.meas tran vdout0_41ck1760 FIND v(dout0_41) AT=885.025n

.meas tran vdout0_42ck1760 FIND v(dout0_42) AT=885.025n

.meas tran vdout0_43ck1760 FIND v(dout0_43) AT=885.025n

.meas tran vdout0_44ck1760 FIND v(dout0_44) AT=885.025n

.meas tran vdout0_45ck1760 FIND v(dout0_45) AT=885.025n

.meas tran vdout0_46ck1760 FIND v(dout0_46) AT=885.025n

.meas tran vdout0_47ck1760 FIND v(dout0_47) AT=885.025n

.meas tran vdout0_48ck1760 FIND v(dout0_48) AT=885.025n

.meas tran vdout0_49ck1760 FIND v(dout0_49) AT=885.025n

.meas tran vdout0_50ck1760 FIND v(dout0_50) AT=885.025n

.meas tran vdout0_51ck1760 FIND v(dout0_51) AT=885.025n

.meas tran vdout0_52ck1760 FIND v(dout0_52) AT=885.025n

.meas tran vdout0_53ck1760 FIND v(dout0_53) AT=885.025n

.meas tran vdout0_54ck1760 FIND v(dout0_54) AT=885.025n

.meas tran vdout0_55ck1760 FIND v(dout0_55) AT=885.025n

.meas tran vdout0_56ck1760 FIND v(dout0_56) AT=885.025n

.meas tran vdout0_57ck1760 FIND v(dout0_57) AT=885.025n

.meas tran vdout0_58ck1760 FIND v(dout0_58) AT=885.025n

.meas tran vdout0_59ck1760 FIND v(dout0_59) AT=885.025n

.meas tran vdout0_60ck1760 FIND v(dout0_60) AT=885.025n

.meas tran vdout0_61ck1760 FIND v(dout0_61) AT=885.025n

.meas tran vdout0_62ck1760 FIND v(dout0_62) AT=885.025n

.meas tran vdout0_63ck1760 FIND v(dout0_63) AT=885.025n

.meas tran vdout0_64ck1760 FIND v(dout0_64) AT=885.025n

.meas tran vdout0_65ck1760 FIND v(dout0_65) AT=885.025n

.meas tran vdout0_66ck1760 FIND v(dout0_66) AT=885.025n

.meas tran vdout0_67ck1760 FIND v(dout0_67) AT=885.025n

.meas tran vdout0_68ck1760 FIND v(dout0_68) AT=885.025n

.meas tran vdout0_69ck1760 FIND v(dout0_69) AT=885.025n

.meas tran vdout0_70ck1760 FIND v(dout0_70) AT=885.025n

.meas tran vdout0_71ck1760 FIND v(dout0_71) AT=885.025n

.meas tran vdout0_72ck1760 FIND v(dout0_72) AT=885.025n

.meas tran vdout0_73ck1760 FIND v(dout0_73) AT=885.025n

.meas tran vdout0_74ck1760 FIND v(dout0_74) AT=885.025n

.meas tran vdout0_75ck1760 FIND v(dout0_75) AT=885.025n

.meas tran vdout0_76ck1760 FIND v(dout0_76) AT=885.025n

.meas tran vdout0_77ck1760 FIND v(dout0_77) AT=885.025n

.meas tran vdout0_78ck1760 FIND v(dout0_78) AT=885.025n

.meas tran vdout0_79ck1760 FIND v(dout0_79) AT=885.025n

.meas tran vdout0_80ck1760 FIND v(dout0_80) AT=885.025n

.meas tran vdout0_81ck1760 FIND v(dout0_81) AT=885.025n

.meas tran vdout0_82ck1760 FIND v(dout0_82) AT=885.025n

.meas tran vdout0_83ck1760 FIND v(dout0_83) AT=885.025n

.meas tran vdout0_84ck1760 FIND v(dout0_84) AT=885.025n

.meas tran vdout0_85ck1760 FIND v(dout0_85) AT=885.025n

.meas tran vdout0_86ck1760 FIND v(dout0_86) AT=885.025n

.meas tran vdout0_87ck1760 FIND v(dout0_87) AT=885.025n

.meas tran vdout0_88ck1760 FIND v(dout0_88) AT=885.025n

.meas tran vdout0_89ck1760 FIND v(dout0_89) AT=885.025n

.meas tran vdout0_90ck1760 FIND v(dout0_90) AT=885.025n

.meas tran vdout0_91ck1760 FIND v(dout0_91) AT=885.025n

.meas tran vdout0_92ck1760 FIND v(dout0_92) AT=885.025n

.meas tran vdout0_93ck1760 FIND v(dout0_93) AT=885.025n

.meas tran vdout0_94ck1760 FIND v(dout0_94) AT=885.025n

.meas tran vdout0_95ck1760 FIND v(dout0_95) AT=885.025n

.meas tran vdout0_96ck1760 FIND v(dout0_96) AT=885.025n

.meas tran vdout0_97ck1760 FIND v(dout0_97) AT=885.025n

.meas tran vdout0_98ck1760 FIND v(dout0_98) AT=885.025n

.meas tran vdout0_99ck1760 FIND v(dout0_99) AT=885.025n

.meas tran vdout0_100ck1760 FIND v(dout0_100) AT=885.025n

.meas tran vdout0_101ck1760 FIND v(dout0_101) AT=885.025n

.meas tran vdout0_102ck1760 FIND v(dout0_102) AT=885.025n

.meas tran vdout0_103ck1760 FIND v(dout0_103) AT=885.025n

.meas tran vdout0_104ck1760 FIND v(dout0_104) AT=885.025n

.meas tran vdout0_105ck1760 FIND v(dout0_105) AT=885.025n

.meas tran vdout0_106ck1760 FIND v(dout0_106) AT=885.025n

.meas tran vdout0_107ck1760 FIND v(dout0_107) AT=885.025n

.meas tran vdout0_108ck1760 FIND v(dout0_108) AT=885.025n

.meas tran vdout0_109ck1760 FIND v(dout0_109) AT=885.025n

.meas tran vdout0_110ck1760 FIND v(dout0_110) AT=885.025n

.meas tran vdout0_111ck1760 FIND v(dout0_111) AT=885.025n

.meas tran vdout0_112ck1760 FIND v(dout0_112) AT=885.025n

.meas tran vdout0_113ck1760 FIND v(dout0_113) AT=885.025n

.meas tran vdout0_114ck1760 FIND v(dout0_114) AT=885.025n

.meas tran vdout0_115ck1760 FIND v(dout0_115) AT=885.025n

.meas tran vdout0_116ck1760 FIND v(dout0_116) AT=885.025n

.meas tran vdout0_117ck1760 FIND v(dout0_117) AT=885.025n

.meas tran vdout0_118ck1760 FIND v(dout0_118) AT=885.025n

.meas tran vdout0_119ck1760 FIND v(dout0_119) AT=885.025n

.meas tran vdout0_120ck1760 FIND v(dout0_120) AT=885.025n

.meas tran vdout0_121ck1760 FIND v(dout0_121) AT=885.025n

.meas tran vdout0_122ck1760 FIND v(dout0_122) AT=885.025n

.meas tran vdout0_123ck1760 FIND v(dout0_123) AT=885.025n

.meas tran vdout0_124ck1760 FIND v(dout0_124) AT=885.025n

.meas tran vdout0_125ck1760 FIND v(dout0_125) AT=885.025n

.meas tran vdout0_126ck1760 FIND v(dout0_126) AT=885.025n

.meas tran vdout0_127ck1760 FIND v(dout0_127) AT=885.025n

.meas tran vdout0_128ck1760 FIND v(dout0_128) AT=885.025n

.meas tran vdout0_129ck1760 FIND v(dout0_129) AT=885.025n

.meas tran vdout0_130ck1760 FIND v(dout0_130) AT=885.025n

.meas tran vdout0_131ck1760 FIND v(dout0_131) AT=885.025n

.meas tran vdout0_132ck1760 FIND v(dout0_132) AT=885.025n

.meas tran vdout0_133ck1760 FIND v(dout0_133) AT=885.025n

.meas tran vdout0_134ck1760 FIND v(dout0_134) AT=885.025n

.meas tran vdout0_135ck1760 FIND v(dout0_135) AT=885.025n

.meas tran vdout0_136ck1760 FIND v(dout0_136) AT=885.025n

.meas tran vdout0_137ck1760 FIND v(dout0_137) AT=885.025n

.meas tran vdout0_138ck1760 FIND v(dout0_138) AT=885.025n

.meas tran vdout0_139ck1760 FIND v(dout0_139) AT=885.025n

.meas tran vdout0_140ck1760 FIND v(dout0_140) AT=885.025n

.meas tran vdout0_141ck1760 FIND v(dout0_141) AT=885.025n

.meas tran vdout0_142ck1760 FIND v(dout0_142) AT=885.025n

.meas tran vdout0_143ck1760 FIND v(dout0_143) AT=885.025n

.meas tran vdout0_144ck1760 FIND v(dout0_144) AT=885.025n

.meas tran vdout0_145ck1760 FIND v(dout0_145) AT=885.025n

.meas tran vdout0_146ck1760 FIND v(dout0_146) AT=885.025n

.meas tran vdout0_147ck1760 FIND v(dout0_147) AT=885.025n

.meas tran vdout0_148ck1760 FIND v(dout0_148) AT=885.025n

.meas tran vdout0_149ck1760 FIND v(dout0_149) AT=885.025n

.meas tran vdout0_150ck1760 FIND v(dout0_150) AT=885.025n

.meas tran vdout0_151ck1760 FIND v(dout0_151) AT=885.025n

.meas tran vdout0_152ck1760 FIND v(dout0_152) AT=885.025n

.meas tran vdout0_153ck1760 FIND v(dout0_153) AT=885.025n

.meas tran vdout0_154ck1760 FIND v(dout0_154) AT=885.025n

.meas tran vdout0_155ck1760 FIND v(dout0_155) AT=885.025n

.meas tran vdout0_156ck1760 FIND v(dout0_156) AT=885.025n

.meas tran vdout0_157ck1760 FIND v(dout0_157) AT=885.025n

.meas tran vdout0_158ck1760 FIND v(dout0_158) AT=885.025n

.meas tran vdout0_159ck1760 FIND v(dout0_159) AT=885.025n

.meas tran vdout0_160ck1760 FIND v(dout0_160) AT=885.025n

.meas tran vdout0_161ck1760 FIND v(dout0_161) AT=885.025n

.meas tran vdout0_162ck1760 FIND v(dout0_162) AT=885.025n

.meas tran vdout0_163ck1760 FIND v(dout0_163) AT=885.025n

.meas tran vdout0_164ck1760 FIND v(dout0_164) AT=885.025n

.meas tran vdout0_165ck1760 FIND v(dout0_165) AT=885.025n

.meas tran vdout0_166ck1760 FIND v(dout0_166) AT=885.025n

.meas tran vdout0_167ck1760 FIND v(dout0_167) AT=885.025n

.meas tran vdout0_168ck1760 FIND v(dout0_168) AT=885.025n

.meas tran vdout0_169ck1760 FIND v(dout0_169) AT=885.025n

.meas tran vdout0_170ck1760 FIND v(dout0_170) AT=885.025n

.meas tran vdout0_171ck1760 FIND v(dout0_171) AT=885.025n

.meas tran vdout0_172ck1760 FIND v(dout0_172) AT=885.025n

.meas tran vdout0_173ck1760 FIND v(dout0_173) AT=885.025n

.meas tran vdout0_174ck1760 FIND v(dout0_174) AT=885.025n

.meas tran vdout0_175ck1760 FIND v(dout0_175) AT=885.025n

.meas tran vdout0_176ck1760 FIND v(dout0_176) AT=885.025n

.meas tran vdout0_177ck1760 FIND v(dout0_177) AT=885.025n

.meas tran vdout0_178ck1760 FIND v(dout0_178) AT=885.025n

.meas tran vdout0_179ck1760 FIND v(dout0_179) AT=885.025n

.meas tran vdout0_180ck1760 FIND v(dout0_180) AT=885.025n

.meas tran vdout0_181ck1760 FIND v(dout0_181) AT=885.025n

.meas tran vdout0_182ck1760 FIND v(dout0_182) AT=885.025n

.meas tran vdout0_183ck1760 FIND v(dout0_183) AT=885.025n

.meas tran vdout0_184ck1760 FIND v(dout0_184) AT=885.025n

.meas tran vdout0_185ck1760 FIND v(dout0_185) AT=885.025n

.meas tran vdout0_186ck1760 FIND v(dout0_186) AT=885.025n

.meas tran vdout0_187ck1760 FIND v(dout0_187) AT=885.025n

.meas tran vdout0_188ck1760 FIND v(dout0_188) AT=885.025n

.meas tran vdout0_189ck1760 FIND v(dout0_189) AT=885.025n

.meas tran vdout0_190ck1760 FIND v(dout0_190) AT=885.025n

.meas tran vdout0_191ck1760 FIND v(dout0_191) AT=885.025n

.meas tran vdout0_192ck1760 FIND v(dout0_192) AT=885.025n

.meas tran vdout0_193ck1760 FIND v(dout0_193) AT=885.025n

.meas tran vdout0_194ck1760 FIND v(dout0_194) AT=885.025n

.meas tran vdout0_195ck1760 FIND v(dout0_195) AT=885.025n

.meas tran vdout0_196ck1760 FIND v(dout0_196) AT=885.025n

.meas tran vdout0_197ck1760 FIND v(dout0_197) AT=885.025n

.meas tran vdout0_198ck1760 FIND v(dout0_198) AT=885.025n

.meas tran vdout0_199ck1760 FIND v(dout0_199) AT=885.025n

.meas tran vdout0_200ck1760 FIND v(dout0_200) AT=885.025n

.meas tran vdout0_201ck1760 FIND v(dout0_201) AT=885.025n

.meas tran vdout0_202ck1760 FIND v(dout0_202) AT=885.025n

.meas tran vdout0_203ck1760 FIND v(dout0_203) AT=885.025n

.meas tran vdout0_204ck1760 FIND v(dout0_204) AT=885.025n

.meas tran vdout0_205ck1760 FIND v(dout0_205) AT=885.025n

.meas tran vdout0_206ck1760 FIND v(dout0_206) AT=885.025n

.meas tran vdout0_207ck1760 FIND v(dout0_207) AT=885.025n

.meas tran vdout0_208ck1760 FIND v(dout0_208) AT=885.025n

.meas tran vdout0_209ck1760 FIND v(dout0_209) AT=885.025n

.meas tran vdout0_210ck1760 FIND v(dout0_210) AT=885.025n

.meas tran vdout0_211ck1760 FIND v(dout0_211) AT=885.025n

.meas tran vdout0_212ck1760 FIND v(dout0_212) AT=885.025n

.meas tran vdout0_213ck1760 FIND v(dout0_213) AT=885.025n

.meas tran vdout0_214ck1760 FIND v(dout0_214) AT=885.025n

.meas tran vdout0_215ck1760 FIND v(dout0_215) AT=885.025n

.meas tran vdout0_216ck1760 FIND v(dout0_216) AT=885.025n

.meas tran vdout0_217ck1760 FIND v(dout0_217) AT=885.025n

.meas tran vdout0_218ck1760 FIND v(dout0_218) AT=885.025n

.meas tran vdout0_219ck1760 FIND v(dout0_219) AT=885.025n

.meas tran vdout0_220ck1760 FIND v(dout0_220) AT=885.025n

.meas tran vdout0_221ck1760 FIND v(dout0_221) AT=885.025n

.meas tran vdout0_222ck1760 FIND v(dout0_222) AT=885.025n

.meas tran vdout0_223ck1760 FIND v(dout0_223) AT=885.025n

.meas tran vdout0_224ck1760 FIND v(dout0_224) AT=885.025n

.meas tran vdout0_225ck1760 FIND v(dout0_225) AT=885.025n

.meas tran vdout0_226ck1760 FIND v(dout0_226) AT=885.025n

.meas tran vdout0_227ck1760 FIND v(dout0_227) AT=885.025n

.meas tran vdout0_228ck1760 FIND v(dout0_228) AT=885.025n

.meas tran vdout0_229ck1760 FIND v(dout0_229) AT=885.025n

.meas tran vdout0_230ck1760 FIND v(dout0_230) AT=885.025n

.meas tran vdout0_231ck1760 FIND v(dout0_231) AT=885.025n

.meas tran vdout0_232ck1760 FIND v(dout0_232) AT=885.025n

.meas tran vdout0_233ck1760 FIND v(dout0_233) AT=885.025n

.meas tran vdout0_234ck1760 FIND v(dout0_234) AT=885.025n

.meas tran vdout0_235ck1760 FIND v(dout0_235) AT=885.025n

.meas tran vdout0_236ck1760 FIND v(dout0_236) AT=885.025n

.meas tran vdout0_237ck1760 FIND v(dout0_237) AT=885.025n

.meas tran vdout0_238ck1760 FIND v(dout0_238) AT=885.025n

.meas tran vdout0_239ck1760 FIND v(dout0_239) AT=885.025n

.meas tran vdout0_240ck1760 FIND v(dout0_240) AT=885.025n

.meas tran vdout0_241ck1760 FIND v(dout0_241) AT=885.025n

.meas tran vdout0_242ck1760 FIND v(dout0_242) AT=885.025n

.meas tran vdout0_243ck1760 FIND v(dout0_243) AT=885.025n

.meas tran vdout0_244ck1760 FIND v(dout0_244) AT=885.025n

.meas tran vdout0_245ck1760 FIND v(dout0_245) AT=885.025n

.meas tran vdout0_246ck1760 FIND v(dout0_246) AT=885.025n

.meas tran vdout0_247ck1760 FIND v(dout0_247) AT=885.025n

.meas tran vdout0_248ck1760 FIND v(dout0_248) AT=885.025n

.meas tran vdout0_249ck1760 FIND v(dout0_249) AT=885.025n

.meas tran vdout0_250ck1760 FIND v(dout0_250) AT=885.025n

.meas tran vdout0_251ck1760 FIND v(dout0_251) AT=885.025n

.meas tran vdout0_252ck1760 FIND v(dout0_252) AT=885.025n

.meas tran vdout0_253ck1760 FIND v(dout0_253) AT=885.025n

.meas tran vdout0_254ck1760 FIND v(dout0_254) AT=885.025n

.meas tran vdout0_255ck1760 FIND v(dout0_255) AT=885.025n

.meas tran vdout0_0ck1770 FIND v(dout0_0) AT=890.025n

.meas tran vdout0_1ck1770 FIND v(dout0_1) AT=890.025n

.meas tran vdout0_2ck1770 FIND v(dout0_2) AT=890.025n

.meas tran vdout0_3ck1770 FIND v(dout0_3) AT=890.025n

.meas tran vdout0_4ck1770 FIND v(dout0_4) AT=890.025n

.meas tran vdout0_5ck1770 FIND v(dout0_5) AT=890.025n

.meas tran vdout0_6ck1770 FIND v(dout0_6) AT=890.025n

.meas tran vdout0_7ck1770 FIND v(dout0_7) AT=890.025n

.meas tran vdout0_8ck1770 FIND v(dout0_8) AT=890.025n

.meas tran vdout0_9ck1770 FIND v(dout0_9) AT=890.025n

.meas tran vdout0_10ck1770 FIND v(dout0_10) AT=890.025n

.meas tran vdout0_11ck1770 FIND v(dout0_11) AT=890.025n

.meas tran vdout0_12ck1770 FIND v(dout0_12) AT=890.025n

.meas tran vdout0_13ck1770 FIND v(dout0_13) AT=890.025n

.meas tran vdout0_14ck1770 FIND v(dout0_14) AT=890.025n

.meas tran vdout0_15ck1770 FIND v(dout0_15) AT=890.025n

.meas tran vdout0_16ck1770 FIND v(dout0_16) AT=890.025n

.meas tran vdout0_17ck1770 FIND v(dout0_17) AT=890.025n

.meas tran vdout0_18ck1770 FIND v(dout0_18) AT=890.025n

.meas tran vdout0_19ck1770 FIND v(dout0_19) AT=890.025n

.meas tran vdout0_20ck1770 FIND v(dout0_20) AT=890.025n

.meas tran vdout0_21ck1770 FIND v(dout0_21) AT=890.025n

.meas tran vdout0_22ck1770 FIND v(dout0_22) AT=890.025n

.meas tran vdout0_23ck1770 FIND v(dout0_23) AT=890.025n

.meas tran vdout0_24ck1770 FIND v(dout0_24) AT=890.025n

.meas tran vdout0_25ck1770 FIND v(dout0_25) AT=890.025n

.meas tran vdout0_26ck1770 FIND v(dout0_26) AT=890.025n

.meas tran vdout0_27ck1770 FIND v(dout0_27) AT=890.025n

.meas tran vdout0_28ck1770 FIND v(dout0_28) AT=890.025n

.meas tran vdout0_29ck1770 FIND v(dout0_29) AT=890.025n

.meas tran vdout0_30ck1770 FIND v(dout0_30) AT=890.025n

.meas tran vdout0_31ck1770 FIND v(dout0_31) AT=890.025n

.meas tran vdout0_32ck1770 FIND v(dout0_32) AT=890.025n

.meas tran vdout0_33ck1770 FIND v(dout0_33) AT=890.025n

.meas tran vdout0_34ck1770 FIND v(dout0_34) AT=890.025n

.meas tran vdout0_35ck1770 FIND v(dout0_35) AT=890.025n

.meas tran vdout0_36ck1770 FIND v(dout0_36) AT=890.025n

.meas tran vdout0_37ck1770 FIND v(dout0_37) AT=890.025n

.meas tran vdout0_38ck1770 FIND v(dout0_38) AT=890.025n

.meas tran vdout0_39ck1770 FIND v(dout0_39) AT=890.025n

.meas tran vdout0_40ck1770 FIND v(dout0_40) AT=890.025n

.meas tran vdout0_41ck1770 FIND v(dout0_41) AT=890.025n

.meas tran vdout0_42ck1770 FIND v(dout0_42) AT=890.025n

.meas tran vdout0_43ck1770 FIND v(dout0_43) AT=890.025n

.meas tran vdout0_44ck1770 FIND v(dout0_44) AT=890.025n

.meas tran vdout0_45ck1770 FIND v(dout0_45) AT=890.025n

.meas tran vdout0_46ck1770 FIND v(dout0_46) AT=890.025n

.meas tran vdout0_47ck1770 FIND v(dout0_47) AT=890.025n

.meas tran vdout0_48ck1770 FIND v(dout0_48) AT=890.025n

.meas tran vdout0_49ck1770 FIND v(dout0_49) AT=890.025n

.meas tran vdout0_50ck1770 FIND v(dout0_50) AT=890.025n

.meas tran vdout0_51ck1770 FIND v(dout0_51) AT=890.025n

.meas tran vdout0_52ck1770 FIND v(dout0_52) AT=890.025n

.meas tran vdout0_53ck1770 FIND v(dout0_53) AT=890.025n

.meas tran vdout0_54ck1770 FIND v(dout0_54) AT=890.025n

.meas tran vdout0_55ck1770 FIND v(dout0_55) AT=890.025n

.meas tran vdout0_56ck1770 FIND v(dout0_56) AT=890.025n

.meas tran vdout0_57ck1770 FIND v(dout0_57) AT=890.025n

.meas tran vdout0_58ck1770 FIND v(dout0_58) AT=890.025n

.meas tran vdout0_59ck1770 FIND v(dout0_59) AT=890.025n

.meas tran vdout0_60ck1770 FIND v(dout0_60) AT=890.025n

.meas tran vdout0_61ck1770 FIND v(dout0_61) AT=890.025n

.meas tran vdout0_62ck1770 FIND v(dout0_62) AT=890.025n

.meas tran vdout0_63ck1770 FIND v(dout0_63) AT=890.025n

.meas tran vdout0_64ck1770 FIND v(dout0_64) AT=890.025n

.meas tran vdout0_65ck1770 FIND v(dout0_65) AT=890.025n

.meas tran vdout0_66ck1770 FIND v(dout0_66) AT=890.025n

.meas tran vdout0_67ck1770 FIND v(dout0_67) AT=890.025n

.meas tran vdout0_68ck1770 FIND v(dout0_68) AT=890.025n

.meas tran vdout0_69ck1770 FIND v(dout0_69) AT=890.025n

.meas tran vdout0_70ck1770 FIND v(dout0_70) AT=890.025n

.meas tran vdout0_71ck1770 FIND v(dout0_71) AT=890.025n

.meas tran vdout0_72ck1770 FIND v(dout0_72) AT=890.025n

.meas tran vdout0_73ck1770 FIND v(dout0_73) AT=890.025n

.meas tran vdout0_74ck1770 FIND v(dout0_74) AT=890.025n

.meas tran vdout0_75ck1770 FIND v(dout0_75) AT=890.025n

.meas tran vdout0_76ck1770 FIND v(dout0_76) AT=890.025n

.meas tran vdout0_77ck1770 FIND v(dout0_77) AT=890.025n

.meas tran vdout0_78ck1770 FIND v(dout0_78) AT=890.025n

.meas tran vdout0_79ck1770 FIND v(dout0_79) AT=890.025n

.meas tran vdout0_80ck1770 FIND v(dout0_80) AT=890.025n

.meas tran vdout0_81ck1770 FIND v(dout0_81) AT=890.025n

.meas tran vdout0_82ck1770 FIND v(dout0_82) AT=890.025n

.meas tran vdout0_83ck1770 FIND v(dout0_83) AT=890.025n

.meas tran vdout0_84ck1770 FIND v(dout0_84) AT=890.025n

.meas tran vdout0_85ck1770 FIND v(dout0_85) AT=890.025n

.meas tran vdout0_86ck1770 FIND v(dout0_86) AT=890.025n

.meas tran vdout0_87ck1770 FIND v(dout0_87) AT=890.025n

.meas tran vdout0_88ck1770 FIND v(dout0_88) AT=890.025n

.meas tran vdout0_89ck1770 FIND v(dout0_89) AT=890.025n

.meas tran vdout0_90ck1770 FIND v(dout0_90) AT=890.025n

.meas tran vdout0_91ck1770 FIND v(dout0_91) AT=890.025n

.meas tran vdout0_92ck1770 FIND v(dout0_92) AT=890.025n

.meas tran vdout0_93ck1770 FIND v(dout0_93) AT=890.025n

.meas tran vdout0_94ck1770 FIND v(dout0_94) AT=890.025n

.meas tran vdout0_95ck1770 FIND v(dout0_95) AT=890.025n

.meas tran vdout0_96ck1770 FIND v(dout0_96) AT=890.025n

.meas tran vdout0_97ck1770 FIND v(dout0_97) AT=890.025n

.meas tran vdout0_98ck1770 FIND v(dout0_98) AT=890.025n

.meas tran vdout0_99ck1770 FIND v(dout0_99) AT=890.025n

.meas tran vdout0_100ck1770 FIND v(dout0_100) AT=890.025n

.meas tran vdout0_101ck1770 FIND v(dout0_101) AT=890.025n

.meas tran vdout0_102ck1770 FIND v(dout0_102) AT=890.025n

.meas tran vdout0_103ck1770 FIND v(dout0_103) AT=890.025n

.meas tran vdout0_104ck1770 FIND v(dout0_104) AT=890.025n

.meas tran vdout0_105ck1770 FIND v(dout0_105) AT=890.025n

.meas tran vdout0_106ck1770 FIND v(dout0_106) AT=890.025n

.meas tran vdout0_107ck1770 FIND v(dout0_107) AT=890.025n

.meas tran vdout0_108ck1770 FIND v(dout0_108) AT=890.025n

.meas tran vdout0_109ck1770 FIND v(dout0_109) AT=890.025n

.meas tran vdout0_110ck1770 FIND v(dout0_110) AT=890.025n

.meas tran vdout0_111ck1770 FIND v(dout0_111) AT=890.025n

.meas tran vdout0_112ck1770 FIND v(dout0_112) AT=890.025n

.meas tran vdout0_113ck1770 FIND v(dout0_113) AT=890.025n

.meas tran vdout0_114ck1770 FIND v(dout0_114) AT=890.025n

.meas tran vdout0_115ck1770 FIND v(dout0_115) AT=890.025n

.meas tran vdout0_116ck1770 FIND v(dout0_116) AT=890.025n

.meas tran vdout0_117ck1770 FIND v(dout0_117) AT=890.025n

.meas tran vdout0_118ck1770 FIND v(dout0_118) AT=890.025n

.meas tran vdout0_119ck1770 FIND v(dout0_119) AT=890.025n

.meas tran vdout0_120ck1770 FIND v(dout0_120) AT=890.025n

.meas tran vdout0_121ck1770 FIND v(dout0_121) AT=890.025n

.meas tran vdout0_122ck1770 FIND v(dout0_122) AT=890.025n

.meas tran vdout0_123ck1770 FIND v(dout0_123) AT=890.025n

.meas tran vdout0_124ck1770 FIND v(dout0_124) AT=890.025n

.meas tran vdout0_125ck1770 FIND v(dout0_125) AT=890.025n

.meas tran vdout0_126ck1770 FIND v(dout0_126) AT=890.025n

.meas tran vdout0_127ck1770 FIND v(dout0_127) AT=890.025n

.meas tran vdout0_128ck1770 FIND v(dout0_128) AT=890.025n

.meas tran vdout0_129ck1770 FIND v(dout0_129) AT=890.025n

.meas tran vdout0_130ck1770 FIND v(dout0_130) AT=890.025n

.meas tran vdout0_131ck1770 FIND v(dout0_131) AT=890.025n

.meas tran vdout0_132ck1770 FIND v(dout0_132) AT=890.025n

.meas tran vdout0_133ck1770 FIND v(dout0_133) AT=890.025n

.meas tran vdout0_134ck1770 FIND v(dout0_134) AT=890.025n

.meas tran vdout0_135ck1770 FIND v(dout0_135) AT=890.025n

.meas tran vdout0_136ck1770 FIND v(dout0_136) AT=890.025n

.meas tran vdout0_137ck1770 FIND v(dout0_137) AT=890.025n

.meas tran vdout0_138ck1770 FIND v(dout0_138) AT=890.025n

.meas tran vdout0_139ck1770 FIND v(dout0_139) AT=890.025n

.meas tran vdout0_140ck1770 FIND v(dout0_140) AT=890.025n

.meas tran vdout0_141ck1770 FIND v(dout0_141) AT=890.025n

.meas tran vdout0_142ck1770 FIND v(dout0_142) AT=890.025n

.meas tran vdout0_143ck1770 FIND v(dout0_143) AT=890.025n

.meas tran vdout0_144ck1770 FIND v(dout0_144) AT=890.025n

.meas tran vdout0_145ck1770 FIND v(dout0_145) AT=890.025n

.meas tran vdout0_146ck1770 FIND v(dout0_146) AT=890.025n

.meas tran vdout0_147ck1770 FIND v(dout0_147) AT=890.025n

.meas tran vdout0_148ck1770 FIND v(dout0_148) AT=890.025n

.meas tran vdout0_149ck1770 FIND v(dout0_149) AT=890.025n

.meas tran vdout0_150ck1770 FIND v(dout0_150) AT=890.025n

.meas tran vdout0_151ck1770 FIND v(dout0_151) AT=890.025n

.meas tran vdout0_152ck1770 FIND v(dout0_152) AT=890.025n

.meas tran vdout0_153ck1770 FIND v(dout0_153) AT=890.025n

.meas tran vdout0_154ck1770 FIND v(dout0_154) AT=890.025n

.meas tran vdout0_155ck1770 FIND v(dout0_155) AT=890.025n

.meas tran vdout0_156ck1770 FIND v(dout0_156) AT=890.025n

.meas tran vdout0_157ck1770 FIND v(dout0_157) AT=890.025n

.meas tran vdout0_158ck1770 FIND v(dout0_158) AT=890.025n

.meas tran vdout0_159ck1770 FIND v(dout0_159) AT=890.025n

.meas tran vdout0_160ck1770 FIND v(dout0_160) AT=890.025n

.meas tran vdout0_161ck1770 FIND v(dout0_161) AT=890.025n

.meas tran vdout0_162ck1770 FIND v(dout0_162) AT=890.025n

.meas tran vdout0_163ck1770 FIND v(dout0_163) AT=890.025n

.meas tran vdout0_164ck1770 FIND v(dout0_164) AT=890.025n

.meas tran vdout0_165ck1770 FIND v(dout0_165) AT=890.025n

.meas tran vdout0_166ck1770 FIND v(dout0_166) AT=890.025n

.meas tran vdout0_167ck1770 FIND v(dout0_167) AT=890.025n

.meas tran vdout0_168ck1770 FIND v(dout0_168) AT=890.025n

.meas tran vdout0_169ck1770 FIND v(dout0_169) AT=890.025n

.meas tran vdout0_170ck1770 FIND v(dout0_170) AT=890.025n

.meas tran vdout0_171ck1770 FIND v(dout0_171) AT=890.025n

.meas tran vdout0_172ck1770 FIND v(dout0_172) AT=890.025n

.meas tran vdout0_173ck1770 FIND v(dout0_173) AT=890.025n

.meas tran vdout0_174ck1770 FIND v(dout0_174) AT=890.025n

.meas tran vdout0_175ck1770 FIND v(dout0_175) AT=890.025n

.meas tran vdout0_176ck1770 FIND v(dout0_176) AT=890.025n

.meas tran vdout0_177ck1770 FIND v(dout0_177) AT=890.025n

.meas tran vdout0_178ck1770 FIND v(dout0_178) AT=890.025n

.meas tran vdout0_179ck1770 FIND v(dout0_179) AT=890.025n

.meas tran vdout0_180ck1770 FIND v(dout0_180) AT=890.025n

.meas tran vdout0_181ck1770 FIND v(dout0_181) AT=890.025n

.meas tran vdout0_182ck1770 FIND v(dout0_182) AT=890.025n

.meas tran vdout0_183ck1770 FIND v(dout0_183) AT=890.025n

.meas tran vdout0_184ck1770 FIND v(dout0_184) AT=890.025n

.meas tran vdout0_185ck1770 FIND v(dout0_185) AT=890.025n

.meas tran vdout0_186ck1770 FIND v(dout0_186) AT=890.025n

.meas tran vdout0_187ck1770 FIND v(dout0_187) AT=890.025n

.meas tran vdout0_188ck1770 FIND v(dout0_188) AT=890.025n

.meas tran vdout0_189ck1770 FIND v(dout0_189) AT=890.025n

.meas tran vdout0_190ck1770 FIND v(dout0_190) AT=890.025n

.meas tran vdout0_191ck1770 FIND v(dout0_191) AT=890.025n

.meas tran vdout0_192ck1770 FIND v(dout0_192) AT=890.025n

.meas tran vdout0_193ck1770 FIND v(dout0_193) AT=890.025n

.meas tran vdout0_194ck1770 FIND v(dout0_194) AT=890.025n

.meas tran vdout0_195ck1770 FIND v(dout0_195) AT=890.025n

.meas tran vdout0_196ck1770 FIND v(dout0_196) AT=890.025n

.meas tran vdout0_197ck1770 FIND v(dout0_197) AT=890.025n

.meas tran vdout0_198ck1770 FIND v(dout0_198) AT=890.025n

.meas tran vdout0_199ck1770 FIND v(dout0_199) AT=890.025n

.meas tran vdout0_200ck1770 FIND v(dout0_200) AT=890.025n

.meas tran vdout0_201ck1770 FIND v(dout0_201) AT=890.025n

.meas tran vdout0_202ck1770 FIND v(dout0_202) AT=890.025n

.meas tran vdout0_203ck1770 FIND v(dout0_203) AT=890.025n

.meas tran vdout0_204ck1770 FIND v(dout0_204) AT=890.025n

.meas tran vdout0_205ck1770 FIND v(dout0_205) AT=890.025n

.meas tran vdout0_206ck1770 FIND v(dout0_206) AT=890.025n

.meas tran vdout0_207ck1770 FIND v(dout0_207) AT=890.025n

.meas tran vdout0_208ck1770 FIND v(dout0_208) AT=890.025n

.meas tran vdout0_209ck1770 FIND v(dout0_209) AT=890.025n

.meas tran vdout0_210ck1770 FIND v(dout0_210) AT=890.025n

.meas tran vdout0_211ck1770 FIND v(dout0_211) AT=890.025n

.meas tran vdout0_212ck1770 FIND v(dout0_212) AT=890.025n

.meas tran vdout0_213ck1770 FIND v(dout0_213) AT=890.025n

.meas tran vdout0_214ck1770 FIND v(dout0_214) AT=890.025n

.meas tran vdout0_215ck1770 FIND v(dout0_215) AT=890.025n

.meas tran vdout0_216ck1770 FIND v(dout0_216) AT=890.025n

.meas tran vdout0_217ck1770 FIND v(dout0_217) AT=890.025n

.meas tran vdout0_218ck1770 FIND v(dout0_218) AT=890.025n

.meas tran vdout0_219ck1770 FIND v(dout0_219) AT=890.025n

.meas tran vdout0_220ck1770 FIND v(dout0_220) AT=890.025n

.meas tran vdout0_221ck1770 FIND v(dout0_221) AT=890.025n

.meas tran vdout0_222ck1770 FIND v(dout0_222) AT=890.025n

.meas tran vdout0_223ck1770 FIND v(dout0_223) AT=890.025n

.meas tran vdout0_224ck1770 FIND v(dout0_224) AT=890.025n

.meas tran vdout0_225ck1770 FIND v(dout0_225) AT=890.025n

.meas tran vdout0_226ck1770 FIND v(dout0_226) AT=890.025n

.meas tran vdout0_227ck1770 FIND v(dout0_227) AT=890.025n

.meas tran vdout0_228ck1770 FIND v(dout0_228) AT=890.025n

.meas tran vdout0_229ck1770 FIND v(dout0_229) AT=890.025n

.meas tran vdout0_230ck1770 FIND v(dout0_230) AT=890.025n

.meas tran vdout0_231ck1770 FIND v(dout0_231) AT=890.025n

.meas tran vdout0_232ck1770 FIND v(dout0_232) AT=890.025n

.meas tran vdout0_233ck1770 FIND v(dout0_233) AT=890.025n

.meas tran vdout0_234ck1770 FIND v(dout0_234) AT=890.025n

.meas tran vdout0_235ck1770 FIND v(dout0_235) AT=890.025n

.meas tran vdout0_236ck1770 FIND v(dout0_236) AT=890.025n

.meas tran vdout0_237ck1770 FIND v(dout0_237) AT=890.025n

.meas tran vdout0_238ck1770 FIND v(dout0_238) AT=890.025n

.meas tran vdout0_239ck1770 FIND v(dout0_239) AT=890.025n

.meas tran vdout0_240ck1770 FIND v(dout0_240) AT=890.025n

.meas tran vdout0_241ck1770 FIND v(dout0_241) AT=890.025n

.meas tran vdout0_242ck1770 FIND v(dout0_242) AT=890.025n

.meas tran vdout0_243ck1770 FIND v(dout0_243) AT=890.025n

.meas tran vdout0_244ck1770 FIND v(dout0_244) AT=890.025n

.meas tran vdout0_245ck1770 FIND v(dout0_245) AT=890.025n

.meas tran vdout0_246ck1770 FIND v(dout0_246) AT=890.025n

.meas tran vdout0_247ck1770 FIND v(dout0_247) AT=890.025n

.meas tran vdout0_248ck1770 FIND v(dout0_248) AT=890.025n

.meas tran vdout0_249ck1770 FIND v(dout0_249) AT=890.025n

.meas tran vdout0_250ck1770 FIND v(dout0_250) AT=890.025n

.meas tran vdout0_251ck1770 FIND v(dout0_251) AT=890.025n

.meas tran vdout0_252ck1770 FIND v(dout0_252) AT=890.025n

.meas tran vdout0_253ck1770 FIND v(dout0_253) AT=890.025n

.meas tran vdout0_254ck1770 FIND v(dout0_254) AT=890.025n

.meas tran vdout0_255ck1770 FIND v(dout0_255) AT=890.025n

.meas tran vdout0_0ck1790 FIND v(dout0_0) AT=900.025n

.meas tran vdout0_1ck1790 FIND v(dout0_1) AT=900.025n

.meas tran vdout0_2ck1790 FIND v(dout0_2) AT=900.025n

.meas tran vdout0_3ck1790 FIND v(dout0_3) AT=900.025n

.meas tran vdout0_4ck1790 FIND v(dout0_4) AT=900.025n

.meas tran vdout0_5ck1790 FIND v(dout0_5) AT=900.025n

.meas tran vdout0_6ck1790 FIND v(dout0_6) AT=900.025n

.meas tran vdout0_7ck1790 FIND v(dout0_7) AT=900.025n

.meas tran vdout0_8ck1790 FIND v(dout0_8) AT=900.025n

.meas tran vdout0_9ck1790 FIND v(dout0_9) AT=900.025n

.meas tran vdout0_10ck1790 FIND v(dout0_10) AT=900.025n

.meas tran vdout0_11ck1790 FIND v(dout0_11) AT=900.025n

.meas tran vdout0_12ck1790 FIND v(dout0_12) AT=900.025n

.meas tran vdout0_13ck1790 FIND v(dout0_13) AT=900.025n

.meas tran vdout0_14ck1790 FIND v(dout0_14) AT=900.025n

.meas tran vdout0_15ck1790 FIND v(dout0_15) AT=900.025n

.meas tran vdout0_16ck1790 FIND v(dout0_16) AT=900.025n

.meas tran vdout0_17ck1790 FIND v(dout0_17) AT=900.025n

.meas tran vdout0_18ck1790 FIND v(dout0_18) AT=900.025n

.meas tran vdout0_19ck1790 FIND v(dout0_19) AT=900.025n

.meas tran vdout0_20ck1790 FIND v(dout0_20) AT=900.025n

.meas tran vdout0_21ck1790 FIND v(dout0_21) AT=900.025n

.meas tran vdout0_22ck1790 FIND v(dout0_22) AT=900.025n

.meas tran vdout0_23ck1790 FIND v(dout0_23) AT=900.025n

.meas tran vdout0_24ck1790 FIND v(dout0_24) AT=900.025n

.meas tran vdout0_25ck1790 FIND v(dout0_25) AT=900.025n

.meas tran vdout0_26ck1790 FIND v(dout0_26) AT=900.025n

.meas tran vdout0_27ck1790 FIND v(dout0_27) AT=900.025n

.meas tran vdout0_28ck1790 FIND v(dout0_28) AT=900.025n

.meas tran vdout0_29ck1790 FIND v(dout0_29) AT=900.025n

.meas tran vdout0_30ck1790 FIND v(dout0_30) AT=900.025n

.meas tran vdout0_31ck1790 FIND v(dout0_31) AT=900.025n

.meas tran vdout0_32ck1790 FIND v(dout0_32) AT=900.025n

.meas tran vdout0_33ck1790 FIND v(dout0_33) AT=900.025n

.meas tran vdout0_34ck1790 FIND v(dout0_34) AT=900.025n

.meas tran vdout0_35ck1790 FIND v(dout0_35) AT=900.025n

.meas tran vdout0_36ck1790 FIND v(dout0_36) AT=900.025n

.meas tran vdout0_37ck1790 FIND v(dout0_37) AT=900.025n

.meas tran vdout0_38ck1790 FIND v(dout0_38) AT=900.025n

.meas tran vdout0_39ck1790 FIND v(dout0_39) AT=900.025n

.meas tran vdout0_40ck1790 FIND v(dout0_40) AT=900.025n

.meas tran vdout0_41ck1790 FIND v(dout0_41) AT=900.025n

.meas tran vdout0_42ck1790 FIND v(dout0_42) AT=900.025n

.meas tran vdout0_43ck1790 FIND v(dout0_43) AT=900.025n

.meas tran vdout0_44ck1790 FIND v(dout0_44) AT=900.025n

.meas tran vdout0_45ck1790 FIND v(dout0_45) AT=900.025n

.meas tran vdout0_46ck1790 FIND v(dout0_46) AT=900.025n

.meas tran vdout0_47ck1790 FIND v(dout0_47) AT=900.025n

.meas tran vdout0_48ck1790 FIND v(dout0_48) AT=900.025n

.meas tran vdout0_49ck1790 FIND v(dout0_49) AT=900.025n

.meas tran vdout0_50ck1790 FIND v(dout0_50) AT=900.025n

.meas tran vdout0_51ck1790 FIND v(dout0_51) AT=900.025n

.meas tran vdout0_52ck1790 FIND v(dout0_52) AT=900.025n

.meas tran vdout0_53ck1790 FIND v(dout0_53) AT=900.025n

.meas tran vdout0_54ck1790 FIND v(dout0_54) AT=900.025n

.meas tran vdout0_55ck1790 FIND v(dout0_55) AT=900.025n

.meas tran vdout0_56ck1790 FIND v(dout0_56) AT=900.025n

.meas tran vdout0_57ck1790 FIND v(dout0_57) AT=900.025n

.meas tran vdout0_58ck1790 FIND v(dout0_58) AT=900.025n

.meas tran vdout0_59ck1790 FIND v(dout0_59) AT=900.025n

.meas tran vdout0_60ck1790 FIND v(dout0_60) AT=900.025n

.meas tran vdout0_61ck1790 FIND v(dout0_61) AT=900.025n

.meas tran vdout0_62ck1790 FIND v(dout0_62) AT=900.025n

.meas tran vdout0_63ck1790 FIND v(dout0_63) AT=900.025n

.meas tran vdout0_64ck1790 FIND v(dout0_64) AT=900.025n

.meas tran vdout0_65ck1790 FIND v(dout0_65) AT=900.025n

.meas tran vdout0_66ck1790 FIND v(dout0_66) AT=900.025n

.meas tran vdout0_67ck1790 FIND v(dout0_67) AT=900.025n

.meas tran vdout0_68ck1790 FIND v(dout0_68) AT=900.025n

.meas tran vdout0_69ck1790 FIND v(dout0_69) AT=900.025n

.meas tran vdout0_70ck1790 FIND v(dout0_70) AT=900.025n

.meas tran vdout0_71ck1790 FIND v(dout0_71) AT=900.025n

.meas tran vdout0_72ck1790 FIND v(dout0_72) AT=900.025n

.meas tran vdout0_73ck1790 FIND v(dout0_73) AT=900.025n

.meas tran vdout0_74ck1790 FIND v(dout0_74) AT=900.025n

.meas tran vdout0_75ck1790 FIND v(dout0_75) AT=900.025n

.meas tran vdout0_76ck1790 FIND v(dout0_76) AT=900.025n

.meas tran vdout0_77ck1790 FIND v(dout0_77) AT=900.025n

.meas tran vdout0_78ck1790 FIND v(dout0_78) AT=900.025n

.meas tran vdout0_79ck1790 FIND v(dout0_79) AT=900.025n

.meas tran vdout0_80ck1790 FIND v(dout0_80) AT=900.025n

.meas tran vdout0_81ck1790 FIND v(dout0_81) AT=900.025n

.meas tran vdout0_82ck1790 FIND v(dout0_82) AT=900.025n

.meas tran vdout0_83ck1790 FIND v(dout0_83) AT=900.025n

.meas tran vdout0_84ck1790 FIND v(dout0_84) AT=900.025n

.meas tran vdout0_85ck1790 FIND v(dout0_85) AT=900.025n

.meas tran vdout0_86ck1790 FIND v(dout0_86) AT=900.025n

.meas tran vdout0_87ck1790 FIND v(dout0_87) AT=900.025n

.meas tran vdout0_88ck1790 FIND v(dout0_88) AT=900.025n

.meas tran vdout0_89ck1790 FIND v(dout0_89) AT=900.025n

.meas tran vdout0_90ck1790 FIND v(dout0_90) AT=900.025n

.meas tran vdout0_91ck1790 FIND v(dout0_91) AT=900.025n

.meas tran vdout0_92ck1790 FIND v(dout0_92) AT=900.025n

.meas tran vdout0_93ck1790 FIND v(dout0_93) AT=900.025n

.meas tran vdout0_94ck1790 FIND v(dout0_94) AT=900.025n

.meas tran vdout0_95ck1790 FIND v(dout0_95) AT=900.025n

.meas tran vdout0_96ck1790 FIND v(dout0_96) AT=900.025n

.meas tran vdout0_97ck1790 FIND v(dout0_97) AT=900.025n

.meas tran vdout0_98ck1790 FIND v(dout0_98) AT=900.025n

.meas tran vdout0_99ck1790 FIND v(dout0_99) AT=900.025n

.meas tran vdout0_100ck1790 FIND v(dout0_100) AT=900.025n

.meas tran vdout0_101ck1790 FIND v(dout0_101) AT=900.025n

.meas tran vdout0_102ck1790 FIND v(dout0_102) AT=900.025n

.meas tran vdout0_103ck1790 FIND v(dout0_103) AT=900.025n

.meas tran vdout0_104ck1790 FIND v(dout0_104) AT=900.025n

.meas tran vdout0_105ck1790 FIND v(dout0_105) AT=900.025n

.meas tran vdout0_106ck1790 FIND v(dout0_106) AT=900.025n

.meas tran vdout0_107ck1790 FIND v(dout0_107) AT=900.025n

.meas tran vdout0_108ck1790 FIND v(dout0_108) AT=900.025n

.meas tran vdout0_109ck1790 FIND v(dout0_109) AT=900.025n

.meas tran vdout0_110ck1790 FIND v(dout0_110) AT=900.025n

.meas tran vdout0_111ck1790 FIND v(dout0_111) AT=900.025n

.meas tran vdout0_112ck1790 FIND v(dout0_112) AT=900.025n

.meas tran vdout0_113ck1790 FIND v(dout0_113) AT=900.025n

.meas tran vdout0_114ck1790 FIND v(dout0_114) AT=900.025n

.meas tran vdout0_115ck1790 FIND v(dout0_115) AT=900.025n

.meas tran vdout0_116ck1790 FIND v(dout0_116) AT=900.025n

.meas tran vdout0_117ck1790 FIND v(dout0_117) AT=900.025n

.meas tran vdout0_118ck1790 FIND v(dout0_118) AT=900.025n

.meas tran vdout0_119ck1790 FIND v(dout0_119) AT=900.025n

.meas tran vdout0_120ck1790 FIND v(dout0_120) AT=900.025n

.meas tran vdout0_121ck1790 FIND v(dout0_121) AT=900.025n

.meas tran vdout0_122ck1790 FIND v(dout0_122) AT=900.025n

.meas tran vdout0_123ck1790 FIND v(dout0_123) AT=900.025n

.meas tran vdout0_124ck1790 FIND v(dout0_124) AT=900.025n

.meas tran vdout0_125ck1790 FIND v(dout0_125) AT=900.025n

.meas tran vdout0_126ck1790 FIND v(dout0_126) AT=900.025n

.meas tran vdout0_127ck1790 FIND v(dout0_127) AT=900.025n

.meas tran vdout0_128ck1790 FIND v(dout0_128) AT=900.025n

.meas tran vdout0_129ck1790 FIND v(dout0_129) AT=900.025n

.meas tran vdout0_130ck1790 FIND v(dout0_130) AT=900.025n

.meas tran vdout0_131ck1790 FIND v(dout0_131) AT=900.025n

.meas tran vdout0_132ck1790 FIND v(dout0_132) AT=900.025n

.meas tran vdout0_133ck1790 FIND v(dout0_133) AT=900.025n

.meas tran vdout0_134ck1790 FIND v(dout0_134) AT=900.025n

.meas tran vdout0_135ck1790 FIND v(dout0_135) AT=900.025n

.meas tran vdout0_136ck1790 FIND v(dout0_136) AT=900.025n

.meas tran vdout0_137ck1790 FIND v(dout0_137) AT=900.025n

.meas tran vdout0_138ck1790 FIND v(dout0_138) AT=900.025n

.meas tran vdout0_139ck1790 FIND v(dout0_139) AT=900.025n

.meas tran vdout0_140ck1790 FIND v(dout0_140) AT=900.025n

.meas tran vdout0_141ck1790 FIND v(dout0_141) AT=900.025n

.meas tran vdout0_142ck1790 FIND v(dout0_142) AT=900.025n

.meas tran vdout0_143ck1790 FIND v(dout0_143) AT=900.025n

.meas tran vdout0_144ck1790 FIND v(dout0_144) AT=900.025n

.meas tran vdout0_145ck1790 FIND v(dout0_145) AT=900.025n

.meas tran vdout0_146ck1790 FIND v(dout0_146) AT=900.025n

.meas tran vdout0_147ck1790 FIND v(dout0_147) AT=900.025n

.meas tran vdout0_148ck1790 FIND v(dout0_148) AT=900.025n

.meas tran vdout0_149ck1790 FIND v(dout0_149) AT=900.025n

.meas tran vdout0_150ck1790 FIND v(dout0_150) AT=900.025n

.meas tran vdout0_151ck1790 FIND v(dout0_151) AT=900.025n

.meas tran vdout0_152ck1790 FIND v(dout0_152) AT=900.025n

.meas tran vdout0_153ck1790 FIND v(dout0_153) AT=900.025n

.meas tran vdout0_154ck1790 FIND v(dout0_154) AT=900.025n

.meas tran vdout0_155ck1790 FIND v(dout0_155) AT=900.025n

.meas tran vdout0_156ck1790 FIND v(dout0_156) AT=900.025n

.meas tran vdout0_157ck1790 FIND v(dout0_157) AT=900.025n

.meas tran vdout0_158ck1790 FIND v(dout0_158) AT=900.025n

.meas tran vdout0_159ck1790 FIND v(dout0_159) AT=900.025n

.meas tran vdout0_160ck1790 FIND v(dout0_160) AT=900.025n

.meas tran vdout0_161ck1790 FIND v(dout0_161) AT=900.025n

.meas tran vdout0_162ck1790 FIND v(dout0_162) AT=900.025n

.meas tran vdout0_163ck1790 FIND v(dout0_163) AT=900.025n

.meas tran vdout0_164ck1790 FIND v(dout0_164) AT=900.025n

.meas tran vdout0_165ck1790 FIND v(dout0_165) AT=900.025n

.meas tran vdout0_166ck1790 FIND v(dout0_166) AT=900.025n

.meas tran vdout0_167ck1790 FIND v(dout0_167) AT=900.025n

.meas tran vdout0_168ck1790 FIND v(dout0_168) AT=900.025n

.meas tran vdout0_169ck1790 FIND v(dout0_169) AT=900.025n

.meas tran vdout0_170ck1790 FIND v(dout0_170) AT=900.025n

.meas tran vdout0_171ck1790 FIND v(dout0_171) AT=900.025n

.meas tran vdout0_172ck1790 FIND v(dout0_172) AT=900.025n

.meas tran vdout0_173ck1790 FIND v(dout0_173) AT=900.025n

.meas tran vdout0_174ck1790 FIND v(dout0_174) AT=900.025n

.meas tran vdout0_175ck1790 FIND v(dout0_175) AT=900.025n

.meas tran vdout0_176ck1790 FIND v(dout0_176) AT=900.025n

.meas tran vdout0_177ck1790 FIND v(dout0_177) AT=900.025n

.meas tran vdout0_178ck1790 FIND v(dout0_178) AT=900.025n

.meas tran vdout0_179ck1790 FIND v(dout0_179) AT=900.025n

.meas tran vdout0_180ck1790 FIND v(dout0_180) AT=900.025n

.meas tran vdout0_181ck1790 FIND v(dout0_181) AT=900.025n

.meas tran vdout0_182ck1790 FIND v(dout0_182) AT=900.025n

.meas tran vdout0_183ck1790 FIND v(dout0_183) AT=900.025n

.meas tran vdout0_184ck1790 FIND v(dout0_184) AT=900.025n

.meas tran vdout0_185ck1790 FIND v(dout0_185) AT=900.025n

.meas tran vdout0_186ck1790 FIND v(dout0_186) AT=900.025n

.meas tran vdout0_187ck1790 FIND v(dout0_187) AT=900.025n

.meas tran vdout0_188ck1790 FIND v(dout0_188) AT=900.025n

.meas tran vdout0_189ck1790 FIND v(dout0_189) AT=900.025n

.meas tran vdout0_190ck1790 FIND v(dout0_190) AT=900.025n

.meas tran vdout0_191ck1790 FIND v(dout0_191) AT=900.025n

.meas tran vdout0_192ck1790 FIND v(dout0_192) AT=900.025n

.meas tran vdout0_193ck1790 FIND v(dout0_193) AT=900.025n

.meas tran vdout0_194ck1790 FIND v(dout0_194) AT=900.025n

.meas tran vdout0_195ck1790 FIND v(dout0_195) AT=900.025n

.meas tran vdout0_196ck1790 FIND v(dout0_196) AT=900.025n

.meas tran vdout0_197ck1790 FIND v(dout0_197) AT=900.025n

.meas tran vdout0_198ck1790 FIND v(dout0_198) AT=900.025n

.meas tran vdout0_199ck1790 FIND v(dout0_199) AT=900.025n

.meas tran vdout0_200ck1790 FIND v(dout0_200) AT=900.025n

.meas tran vdout0_201ck1790 FIND v(dout0_201) AT=900.025n

.meas tran vdout0_202ck1790 FIND v(dout0_202) AT=900.025n

.meas tran vdout0_203ck1790 FIND v(dout0_203) AT=900.025n

.meas tran vdout0_204ck1790 FIND v(dout0_204) AT=900.025n

.meas tran vdout0_205ck1790 FIND v(dout0_205) AT=900.025n

.meas tran vdout0_206ck1790 FIND v(dout0_206) AT=900.025n

.meas tran vdout0_207ck1790 FIND v(dout0_207) AT=900.025n

.meas tran vdout0_208ck1790 FIND v(dout0_208) AT=900.025n

.meas tran vdout0_209ck1790 FIND v(dout0_209) AT=900.025n

.meas tran vdout0_210ck1790 FIND v(dout0_210) AT=900.025n

.meas tran vdout0_211ck1790 FIND v(dout0_211) AT=900.025n

.meas tran vdout0_212ck1790 FIND v(dout0_212) AT=900.025n

.meas tran vdout0_213ck1790 FIND v(dout0_213) AT=900.025n

.meas tran vdout0_214ck1790 FIND v(dout0_214) AT=900.025n

.meas tran vdout0_215ck1790 FIND v(dout0_215) AT=900.025n

.meas tran vdout0_216ck1790 FIND v(dout0_216) AT=900.025n

.meas tran vdout0_217ck1790 FIND v(dout0_217) AT=900.025n

.meas tran vdout0_218ck1790 FIND v(dout0_218) AT=900.025n

.meas tran vdout0_219ck1790 FIND v(dout0_219) AT=900.025n

.meas tran vdout0_220ck1790 FIND v(dout0_220) AT=900.025n

.meas tran vdout0_221ck1790 FIND v(dout0_221) AT=900.025n

.meas tran vdout0_222ck1790 FIND v(dout0_222) AT=900.025n

.meas tran vdout0_223ck1790 FIND v(dout0_223) AT=900.025n

.meas tran vdout0_224ck1790 FIND v(dout0_224) AT=900.025n

.meas tran vdout0_225ck1790 FIND v(dout0_225) AT=900.025n

.meas tran vdout0_226ck1790 FIND v(dout0_226) AT=900.025n

.meas tran vdout0_227ck1790 FIND v(dout0_227) AT=900.025n

.meas tran vdout0_228ck1790 FIND v(dout0_228) AT=900.025n

.meas tran vdout0_229ck1790 FIND v(dout0_229) AT=900.025n

.meas tran vdout0_230ck1790 FIND v(dout0_230) AT=900.025n

.meas tran vdout0_231ck1790 FIND v(dout0_231) AT=900.025n

.meas tran vdout0_232ck1790 FIND v(dout0_232) AT=900.025n

.meas tran vdout0_233ck1790 FIND v(dout0_233) AT=900.025n

.meas tran vdout0_234ck1790 FIND v(dout0_234) AT=900.025n

.meas tran vdout0_235ck1790 FIND v(dout0_235) AT=900.025n

.meas tran vdout0_236ck1790 FIND v(dout0_236) AT=900.025n

.meas tran vdout0_237ck1790 FIND v(dout0_237) AT=900.025n

.meas tran vdout0_238ck1790 FIND v(dout0_238) AT=900.025n

.meas tran vdout0_239ck1790 FIND v(dout0_239) AT=900.025n

.meas tran vdout0_240ck1790 FIND v(dout0_240) AT=900.025n

.meas tran vdout0_241ck1790 FIND v(dout0_241) AT=900.025n

.meas tran vdout0_242ck1790 FIND v(dout0_242) AT=900.025n

.meas tran vdout0_243ck1790 FIND v(dout0_243) AT=900.025n

.meas tran vdout0_244ck1790 FIND v(dout0_244) AT=900.025n

.meas tran vdout0_245ck1790 FIND v(dout0_245) AT=900.025n

.meas tran vdout0_246ck1790 FIND v(dout0_246) AT=900.025n

.meas tran vdout0_247ck1790 FIND v(dout0_247) AT=900.025n

.meas tran vdout0_248ck1790 FIND v(dout0_248) AT=900.025n

.meas tran vdout0_249ck1790 FIND v(dout0_249) AT=900.025n

.meas tran vdout0_250ck1790 FIND v(dout0_250) AT=900.025n

.meas tran vdout0_251ck1790 FIND v(dout0_251) AT=900.025n

.meas tran vdout0_252ck1790 FIND v(dout0_252) AT=900.025n

.meas tran vdout0_253ck1790 FIND v(dout0_253) AT=900.025n

.meas tran vdout0_254ck1790 FIND v(dout0_254) AT=900.025n

.meas tran vdout0_255ck1790 FIND v(dout0_255) AT=900.025n

.meas tran vdout0_0ck1850 FIND v(dout0_0) AT=930.025n

.meas tran vdout0_1ck1850 FIND v(dout0_1) AT=930.025n

.meas tran vdout0_2ck1850 FIND v(dout0_2) AT=930.025n

.meas tran vdout0_3ck1850 FIND v(dout0_3) AT=930.025n

.meas tran vdout0_4ck1850 FIND v(dout0_4) AT=930.025n

.meas tran vdout0_5ck1850 FIND v(dout0_5) AT=930.025n

.meas tran vdout0_6ck1850 FIND v(dout0_6) AT=930.025n

.meas tran vdout0_7ck1850 FIND v(dout0_7) AT=930.025n

.meas tran vdout0_8ck1850 FIND v(dout0_8) AT=930.025n

.meas tran vdout0_9ck1850 FIND v(dout0_9) AT=930.025n

.meas tran vdout0_10ck1850 FIND v(dout0_10) AT=930.025n

.meas tran vdout0_11ck1850 FIND v(dout0_11) AT=930.025n

.meas tran vdout0_12ck1850 FIND v(dout0_12) AT=930.025n

.meas tran vdout0_13ck1850 FIND v(dout0_13) AT=930.025n

.meas tran vdout0_14ck1850 FIND v(dout0_14) AT=930.025n

.meas tran vdout0_15ck1850 FIND v(dout0_15) AT=930.025n

.meas tran vdout0_16ck1850 FIND v(dout0_16) AT=930.025n

.meas tran vdout0_17ck1850 FIND v(dout0_17) AT=930.025n

.meas tran vdout0_18ck1850 FIND v(dout0_18) AT=930.025n

.meas tran vdout0_19ck1850 FIND v(dout0_19) AT=930.025n

.meas tran vdout0_20ck1850 FIND v(dout0_20) AT=930.025n

.meas tran vdout0_21ck1850 FIND v(dout0_21) AT=930.025n

.meas tran vdout0_22ck1850 FIND v(dout0_22) AT=930.025n

.meas tran vdout0_23ck1850 FIND v(dout0_23) AT=930.025n

.meas tran vdout0_24ck1850 FIND v(dout0_24) AT=930.025n

.meas tran vdout0_25ck1850 FIND v(dout0_25) AT=930.025n

.meas tran vdout0_26ck1850 FIND v(dout0_26) AT=930.025n

.meas tran vdout0_27ck1850 FIND v(dout0_27) AT=930.025n

.meas tran vdout0_28ck1850 FIND v(dout0_28) AT=930.025n

.meas tran vdout0_29ck1850 FIND v(dout0_29) AT=930.025n

.meas tran vdout0_30ck1850 FIND v(dout0_30) AT=930.025n

.meas tran vdout0_31ck1850 FIND v(dout0_31) AT=930.025n

.meas tran vdout0_32ck1850 FIND v(dout0_32) AT=930.025n

.meas tran vdout0_33ck1850 FIND v(dout0_33) AT=930.025n

.meas tran vdout0_34ck1850 FIND v(dout0_34) AT=930.025n

.meas tran vdout0_35ck1850 FIND v(dout0_35) AT=930.025n

.meas tran vdout0_36ck1850 FIND v(dout0_36) AT=930.025n

.meas tran vdout0_37ck1850 FIND v(dout0_37) AT=930.025n

.meas tran vdout0_38ck1850 FIND v(dout0_38) AT=930.025n

.meas tran vdout0_39ck1850 FIND v(dout0_39) AT=930.025n

.meas tran vdout0_40ck1850 FIND v(dout0_40) AT=930.025n

.meas tran vdout0_41ck1850 FIND v(dout0_41) AT=930.025n

.meas tran vdout0_42ck1850 FIND v(dout0_42) AT=930.025n

.meas tran vdout0_43ck1850 FIND v(dout0_43) AT=930.025n

.meas tran vdout0_44ck1850 FIND v(dout0_44) AT=930.025n

.meas tran vdout0_45ck1850 FIND v(dout0_45) AT=930.025n

.meas tran vdout0_46ck1850 FIND v(dout0_46) AT=930.025n

.meas tran vdout0_47ck1850 FIND v(dout0_47) AT=930.025n

.meas tran vdout0_48ck1850 FIND v(dout0_48) AT=930.025n

.meas tran vdout0_49ck1850 FIND v(dout0_49) AT=930.025n

.meas tran vdout0_50ck1850 FIND v(dout0_50) AT=930.025n

.meas tran vdout0_51ck1850 FIND v(dout0_51) AT=930.025n

.meas tran vdout0_52ck1850 FIND v(dout0_52) AT=930.025n

.meas tran vdout0_53ck1850 FIND v(dout0_53) AT=930.025n

.meas tran vdout0_54ck1850 FIND v(dout0_54) AT=930.025n

.meas tran vdout0_55ck1850 FIND v(dout0_55) AT=930.025n

.meas tran vdout0_56ck1850 FIND v(dout0_56) AT=930.025n

.meas tran vdout0_57ck1850 FIND v(dout0_57) AT=930.025n

.meas tran vdout0_58ck1850 FIND v(dout0_58) AT=930.025n

.meas tran vdout0_59ck1850 FIND v(dout0_59) AT=930.025n

.meas tran vdout0_60ck1850 FIND v(dout0_60) AT=930.025n

.meas tran vdout0_61ck1850 FIND v(dout0_61) AT=930.025n

.meas tran vdout0_62ck1850 FIND v(dout0_62) AT=930.025n

.meas tran vdout0_63ck1850 FIND v(dout0_63) AT=930.025n

.meas tran vdout0_64ck1850 FIND v(dout0_64) AT=930.025n

.meas tran vdout0_65ck1850 FIND v(dout0_65) AT=930.025n

.meas tran vdout0_66ck1850 FIND v(dout0_66) AT=930.025n

.meas tran vdout0_67ck1850 FIND v(dout0_67) AT=930.025n

.meas tran vdout0_68ck1850 FIND v(dout0_68) AT=930.025n

.meas tran vdout0_69ck1850 FIND v(dout0_69) AT=930.025n

.meas tran vdout0_70ck1850 FIND v(dout0_70) AT=930.025n

.meas tran vdout0_71ck1850 FIND v(dout0_71) AT=930.025n

.meas tran vdout0_72ck1850 FIND v(dout0_72) AT=930.025n

.meas tran vdout0_73ck1850 FIND v(dout0_73) AT=930.025n

.meas tran vdout0_74ck1850 FIND v(dout0_74) AT=930.025n

.meas tran vdout0_75ck1850 FIND v(dout0_75) AT=930.025n

.meas tran vdout0_76ck1850 FIND v(dout0_76) AT=930.025n

.meas tran vdout0_77ck1850 FIND v(dout0_77) AT=930.025n

.meas tran vdout0_78ck1850 FIND v(dout0_78) AT=930.025n

.meas tran vdout0_79ck1850 FIND v(dout0_79) AT=930.025n

.meas tran vdout0_80ck1850 FIND v(dout0_80) AT=930.025n

.meas tran vdout0_81ck1850 FIND v(dout0_81) AT=930.025n

.meas tran vdout0_82ck1850 FIND v(dout0_82) AT=930.025n

.meas tran vdout0_83ck1850 FIND v(dout0_83) AT=930.025n

.meas tran vdout0_84ck1850 FIND v(dout0_84) AT=930.025n

.meas tran vdout0_85ck1850 FIND v(dout0_85) AT=930.025n

.meas tran vdout0_86ck1850 FIND v(dout0_86) AT=930.025n

.meas tran vdout0_87ck1850 FIND v(dout0_87) AT=930.025n

.meas tran vdout0_88ck1850 FIND v(dout0_88) AT=930.025n

.meas tran vdout0_89ck1850 FIND v(dout0_89) AT=930.025n

.meas tran vdout0_90ck1850 FIND v(dout0_90) AT=930.025n

.meas tran vdout0_91ck1850 FIND v(dout0_91) AT=930.025n

.meas tran vdout0_92ck1850 FIND v(dout0_92) AT=930.025n

.meas tran vdout0_93ck1850 FIND v(dout0_93) AT=930.025n

.meas tran vdout0_94ck1850 FIND v(dout0_94) AT=930.025n

.meas tran vdout0_95ck1850 FIND v(dout0_95) AT=930.025n

.meas tran vdout0_96ck1850 FIND v(dout0_96) AT=930.025n

.meas tran vdout0_97ck1850 FIND v(dout0_97) AT=930.025n

.meas tran vdout0_98ck1850 FIND v(dout0_98) AT=930.025n

.meas tran vdout0_99ck1850 FIND v(dout0_99) AT=930.025n

.meas tran vdout0_100ck1850 FIND v(dout0_100) AT=930.025n

.meas tran vdout0_101ck1850 FIND v(dout0_101) AT=930.025n

.meas tran vdout0_102ck1850 FIND v(dout0_102) AT=930.025n

.meas tran vdout0_103ck1850 FIND v(dout0_103) AT=930.025n

.meas tran vdout0_104ck1850 FIND v(dout0_104) AT=930.025n

.meas tran vdout0_105ck1850 FIND v(dout0_105) AT=930.025n

.meas tran vdout0_106ck1850 FIND v(dout0_106) AT=930.025n

.meas tran vdout0_107ck1850 FIND v(dout0_107) AT=930.025n

.meas tran vdout0_108ck1850 FIND v(dout0_108) AT=930.025n

.meas tran vdout0_109ck1850 FIND v(dout0_109) AT=930.025n

.meas tran vdout0_110ck1850 FIND v(dout0_110) AT=930.025n

.meas tran vdout0_111ck1850 FIND v(dout0_111) AT=930.025n

.meas tran vdout0_112ck1850 FIND v(dout0_112) AT=930.025n

.meas tran vdout0_113ck1850 FIND v(dout0_113) AT=930.025n

.meas tran vdout0_114ck1850 FIND v(dout0_114) AT=930.025n

.meas tran vdout0_115ck1850 FIND v(dout0_115) AT=930.025n

.meas tran vdout0_116ck1850 FIND v(dout0_116) AT=930.025n

.meas tran vdout0_117ck1850 FIND v(dout0_117) AT=930.025n

.meas tran vdout0_118ck1850 FIND v(dout0_118) AT=930.025n

.meas tran vdout0_119ck1850 FIND v(dout0_119) AT=930.025n

.meas tran vdout0_120ck1850 FIND v(dout0_120) AT=930.025n

.meas tran vdout0_121ck1850 FIND v(dout0_121) AT=930.025n

.meas tran vdout0_122ck1850 FIND v(dout0_122) AT=930.025n

.meas tran vdout0_123ck1850 FIND v(dout0_123) AT=930.025n

.meas tran vdout0_124ck1850 FIND v(dout0_124) AT=930.025n

.meas tran vdout0_125ck1850 FIND v(dout0_125) AT=930.025n

.meas tran vdout0_126ck1850 FIND v(dout0_126) AT=930.025n

.meas tran vdout0_127ck1850 FIND v(dout0_127) AT=930.025n

.meas tran vdout0_128ck1850 FIND v(dout0_128) AT=930.025n

.meas tran vdout0_129ck1850 FIND v(dout0_129) AT=930.025n

.meas tran vdout0_130ck1850 FIND v(dout0_130) AT=930.025n

.meas tran vdout0_131ck1850 FIND v(dout0_131) AT=930.025n

.meas tran vdout0_132ck1850 FIND v(dout0_132) AT=930.025n

.meas tran vdout0_133ck1850 FIND v(dout0_133) AT=930.025n

.meas tran vdout0_134ck1850 FIND v(dout0_134) AT=930.025n

.meas tran vdout0_135ck1850 FIND v(dout0_135) AT=930.025n

.meas tran vdout0_136ck1850 FIND v(dout0_136) AT=930.025n

.meas tran vdout0_137ck1850 FIND v(dout0_137) AT=930.025n

.meas tran vdout0_138ck1850 FIND v(dout0_138) AT=930.025n

.meas tran vdout0_139ck1850 FIND v(dout0_139) AT=930.025n

.meas tran vdout0_140ck1850 FIND v(dout0_140) AT=930.025n

.meas tran vdout0_141ck1850 FIND v(dout0_141) AT=930.025n

.meas tran vdout0_142ck1850 FIND v(dout0_142) AT=930.025n

.meas tran vdout0_143ck1850 FIND v(dout0_143) AT=930.025n

.meas tran vdout0_144ck1850 FIND v(dout0_144) AT=930.025n

.meas tran vdout0_145ck1850 FIND v(dout0_145) AT=930.025n

.meas tran vdout0_146ck1850 FIND v(dout0_146) AT=930.025n

.meas tran vdout0_147ck1850 FIND v(dout0_147) AT=930.025n

.meas tran vdout0_148ck1850 FIND v(dout0_148) AT=930.025n

.meas tran vdout0_149ck1850 FIND v(dout0_149) AT=930.025n

.meas tran vdout0_150ck1850 FIND v(dout0_150) AT=930.025n

.meas tran vdout0_151ck1850 FIND v(dout0_151) AT=930.025n

.meas tran vdout0_152ck1850 FIND v(dout0_152) AT=930.025n

.meas tran vdout0_153ck1850 FIND v(dout0_153) AT=930.025n

.meas tran vdout0_154ck1850 FIND v(dout0_154) AT=930.025n

.meas tran vdout0_155ck1850 FIND v(dout0_155) AT=930.025n

.meas tran vdout0_156ck1850 FIND v(dout0_156) AT=930.025n

.meas tran vdout0_157ck1850 FIND v(dout0_157) AT=930.025n

.meas tran vdout0_158ck1850 FIND v(dout0_158) AT=930.025n

.meas tran vdout0_159ck1850 FIND v(dout0_159) AT=930.025n

.meas tran vdout0_160ck1850 FIND v(dout0_160) AT=930.025n

.meas tran vdout0_161ck1850 FIND v(dout0_161) AT=930.025n

.meas tran vdout0_162ck1850 FIND v(dout0_162) AT=930.025n

.meas tran vdout0_163ck1850 FIND v(dout0_163) AT=930.025n

.meas tran vdout0_164ck1850 FIND v(dout0_164) AT=930.025n

.meas tran vdout0_165ck1850 FIND v(dout0_165) AT=930.025n

.meas tran vdout0_166ck1850 FIND v(dout0_166) AT=930.025n

.meas tran vdout0_167ck1850 FIND v(dout0_167) AT=930.025n

.meas tran vdout0_168ck1850 FIND v(dout0_168) AT=930.025n

.meas tran vdout0_169ck1850 FIND v(dout0_169) AT=930.025n

.meas tran vdout0_170ck1850 FIND v(dout0_170) AT=930.025n

.meas tran vdout0_171ck1850 FIND v(dout0_171) AT=930.025n

.meas tran vdout0_172ck1850 FIND v(dout0_172) AT=930.025n

.meas tran vdout0_173ck1850 FIND v(dout0_173) AT=930.025n

.meas tran vdout0_174ck1850 FIND v(dout0_174) AT=930.025n

.meas tran vdout0_175ck1850 FIND v(dout0_175) AT=930.025n

.meas tran vdout0_176ck1850 FIND v(dout0_176) AT=930.025n

.meas tran vdout0_177ck1850 FIND v(dout0_177) AT=930.025n

.meas tran vdout0_178ck1850 FIND v(dout0_178) AT=930.025n

.meas tran vdout0_179ck1850 FIND v(dout0_179) AT=930.025n

.meas tran vdout0_180ck1850 FIND v(dout0_180) AT=930.025n

.meas tran vdout0_181ck1850 FIND v(dout0_181) AT=930.025n

.meas tran vdout0_182ck1850 FIND v(dout0_182) AT=930.025n

.meas tran vdout0_183ck1850 FIND v(dout0_183) AT=930.025n

.meas tran vdout0_184ck1850 FIND v(dout0_184) AT=930.025n

.meas tran vdout0_185ck1850 FIND v(dout0_185) AT=930.025n

.meas tran vdout0_186ck1850 FIND v(dout0_186) AT=930.025n

.meas tran vdout0_187ck1850 FIND v(dout0_187) AT=930.025n

.meas tran vdout0_188ck1850 FIND v(dout0_188) AT=930.025n

.meas tran vdout0_189ck1850 FIND v(dout0_189) AT=930.025n

.meas tran vdout0_190ck1850 FIND v(dout0_190) AT=930.025n

.meas tran vdout0_191ck1850 FIND v(dout0_191) AT=930.025n

.meas tran vdout0_192ck1850 FIND v(dout0_192) AT=930.025n

.meas tran vdout0_193ck1850 FIND v(dout0_193) AT=930.025n

.meas tran vdout0_194ck1850 FIND v(dout0_194) AT=930.025n

.meas tran vdout0_195ck1850 FIND v(dout0_195) AT=930.025n

.meas tran vdout0_196ck1850 FIND v(dout0_196) AT=930.025n

.meas tran vdout0_197ck1850 FIND v(dout0_197) AT=930.025n

.meas tran vdout0_198ck1850 FIND v(dout0_198) AT=930.025n

.meas tran vdout0_199ck1850 FIND v(dout0_199) AT=930.025n

.meas tran vdout0_200ck1850 FIND v(dout0_200) AT=930.025n

.meas tran vdout0_201ck1850 FIND v(dout0_201) AT=930.025n

.meas tran vdout0_202ck1850 FIND v(dout0_202) AT=930.025n

.meas tran vdout0_203ck1850 FIND v(dout0_203) AT=930.025n

.meas tran vdout0_204ck1850 FIND v(dout0_204) AT=930.025n

.meas tran vdout0_205ck1850 FIND v(dout0_205) AT=930.025n

.meas tran vdout0_206ck1850 FIND v(dout0_206) AT=930.025n

.meas tran vdout0_207ck1850 FIND v(dout0_207) AT=930.025n

.meas tran vdout0_208ck1850 FIND v(dout0_208) AT=930.025n

.meas tran vdout0_209ck1850 FIND v(dout0_209) AT=930.025n

.meas tran vdout0_210ck1850 FIND v(dout0_210) AT=930.025n

.meas tran vdout0_211ck1850 FIND v(dout0_211) AT=930.025n

.meas tran vdout0_212ck1850 FIND v(dout0_212) AT=930.025n

.meas tran vdout0_213ck1850 FIND v(dout0_213) AT=930.025n

.meas tran vdout0_214ck1850 FIND v(dout0_214) AT=930.025n

.meas tran vdout0_215ck1850 FIND v(dout0_215) AT=930.025n

.meas tran vdout0_216ck1850 FIND v(dout0_216) AT=930.025n

.meas tran vdout0_217ck1850 FIND v(dout0_217) AT=930.025n

.meas tran vdout0_218ck1850 FIND v(dout0_218) AT=930.025n

.meas tran vdout0_219ck1850 FIND v(dout0_219) AT=930.025n

.meas tran vdout0_220ck1850 FIND v(dout0_220) AT=930.025n

.meas tran vdout0_221ck1850 FIND v(dout0_221) AT=930.025n

.meas tran vdout0_222ck1850 FIND v(dout0_222) AT=930.025n

.meas tran vdout0_223ck1850 FIND v(dout0_223) AT=930.025n

.meas tran vdout0_224ck1850 FIND v(dout0_224) AT=930.025n

.meas tran vdout0_225ck1850 FIND v(dout0_225) AT=930.025n

.meas tran vdout0_226ck1850 FIND v(dout0_226) AT=930.025n

.meas tran vdout0_227ck1850 FIND v(dout0_227) AT=930.025n

.meas tran vdout0_228ck1850 FIND v(dout0_228) AT=930.025n

.meas tran vdout0_229ck1850 FIND v(dout0_229) AT=930.025n

.meas tran vdout0_230ck1850 FIND v(dout0_230) AT=930.025n

.meas tran vdout0_231ck1850 FIND v(dout0_231) AT=930.025n

.meas tran vdout0_232ck1850 FIND v(dout0_232) AT=930.025n

.meas tran vdout0_233ck1850 FIND v(dout0_233) AT=930.025n

.meas tran vdout0_234ck1850 FIND v(dout0_234) AT=930.025n

.meas tran vdout0_235ck1850 FIND v(dout0_235) AT=930.025n

.meas tran vdout0_236ck1850 FIND v(dout0_236) AT=930.025n

.meas tran vdout0_237ck1850 FIND v(dout0_237) AT=930.025n

.meas tran vdout0_238ck1850 FIND v(dout0_238) AT=930.025n

.meas tran vdout0_239ck1850 FIND v(dout0_239) AT=930.025n

.meas tran vdout0_240ck1850 FIND v(dout0_240) AT=930.025n

.meas tran vdout0_241ck1850 FIND v(dout0_241) AT=930.025n

.meas tran vdout0_242ck1850 FIND v(dout0_242) AT=930.025n

.meas tran vdout0_243ck1850 FIND v(dout0_243) AT=930.025n

.meas tran vdout0_244ck1850 FIND v(dout0_244) AT=930.025n

.meas tran vdout0_245ck1850 FIND v(dout0_245) AT=930.025n

.meas tran vdout0_246ck1850 FIND v(dout0_246) AT=930.025n

.meas tran vdout0_247ck1850 FIND v(dout0_247) AT=930.025n

.meas tran vdout0_248ck1850 FIND v(dout0_248) AT=930.025n

.meas tran vdout0_249ck1850 FIND v(dout0_249) AT=930.025n

.meas tran vdout0_250ck1850 FIND v(dout0_250) AT=930.025n

.meas tran vdout0_251ck1850 FIND v(dout0_251) AT=930.025n

.meas tran vdout0_252ck1850 FIND v(dout0_252) AT=930.025n

.meas tran vdout0_253ck1850 FIND v(dout0_253) AT=930.025n

.meas tran vdout0_254ck1850 FIND v(dout0_254) AT=930.025n

.meas tran vdout0_255ck1850 FIND v(dout0_255) AT=930.025n

.meas tran vdout0_0ck1920 FIND v(dout0_0) AT=965.025n

.meas tran vdout0_1ck1920 FIND v(dout0_1) AT=965.025n

.meas tran vdout0_2ck1920 FIND v(dout0_2) AT=965.025n

.meas tran vdout0_3ck1920 FIND v(dout0_3) AT=965.025n

.meas tran vdout0_4ck1920 FIND v(dout0_4) AT=965.025n

.meas tran vdout0_5ck1920 FIND v(dout0_5) AT=965.025n

.meas tran vdout0_6ck1920 FIND v(dout0_6) AT=965.025n

.meas tran vdout0_7ck1920 FIND v(dout0_7) AT=965.025n

.meas tran vdout0_8ck1920 FIND v(dout0_8) AT=965.025n

.meas tran vdout0_9ck1920 FIND v(dout0_9) AT=965.025n

.meas tran vdout0_10ck1920 FIND v(dout0_10) AT=965.025n

.meas tran vdout0_11ck1920 FIND v(dout0_11) AT=965.025n

.meas tran vdout0_12ck1920 FIND v(dout0_12) AT=965.025n

.meas tran vdout0_13ck1920 FIND v(dout0_13) AT=965.025n

.meas tran vdout0_14ck1920 FIND v(dout0_14) AT=965.025n

.meas tran vdout0_15ck1920 FIND v(dout0_15) AT=965.025n

.meas tran vdout0_16ck1920 FIND v(dout0_16) AT=965.025n

.meas tran vdout0_17ck1920 FIND v(dout0_17) AT=965.025n

.meas tran vdout0_18ck1920 FIND v(dout0_18) AT=965.025n

.meas tran vdout0_19ck1920 FIND v(dout0_19) AT=965.025n

.meas tran vdout0_20ck1920 FIND v(dout0_20) AT=965.025n

.meas tran vdout0_21ck1920 FIND v(dout0_21) AT=965.025n

.meas tran vdout0_22ck1920 FIND v(dout0_22) AT=965.025n

.meas tran vdout0_23ck1920 FIND v(dout0_23) AT=965.025n

.meas tran vdout0_24ck1920 FIND v(dout0_24) AT=965.025n

.meas tran vdout0_25ck1920 FIND v(dout0_25) AT=965.025n

.meas tran vdout0_26ck1920 FIND v(dout0_26) AT=965.025n

.meas tran vdout0_27ck1920 FIND v(dout0_27) AT=965.025n

.meas tran vdout0_28ck1920 FIND v(dout0_28) AT=965.025n

.meas tran vdout0_29ck1920 FIND v(dout0_29) AT=965.025n

.meas tran vdout0_30ck1920 FIND v(dout0_30) AT=965.025n

.meas tran vdout0_31ck1920 FIND v(dout0_31) AT=965.025n

.meas tran vdout0_32ck1920 FIND v(dout0_32) AT=965.025n

.meas tran vdout0_33ck1920 FIND v(dout0_33) AT=965.025n

.meas tran vdout0_34ck1920 FIND v(dout0_34) AT=965.025n

.meas tran vdout0_35ck1920 FIND v(dout0_35) AT=965.025n

.meas tran vdout0_36ck1920 FIND v(dout0_36) AT=965.025n

.meas tran vdout0_37ck1920 FIND v(dout0_37) AT=965.025n

.meas tran vdout0_38ck1920 FIND v(dout0_38) AT=965.025n

.meas tran vdout0_39ck1920 FIND v(dout0_39) AT=965.025n

.meas tran vdout0_40ck1920 FIND v(dout0_40) AT=965.025n

.meas tran vdout0_41ck1920 FIND v(dout0_41) AT=965.025n

.meas tran vdout0_42ck1920 FIND v(dout0_42) AT=965.025n

.meas tran vdout0_43ck1920 FIND v(dout0_43) AT=965.025n

.meas tran vdout0_44ck1920 FIND v(dout0_44) AT=965.025n

.meas tran vdout0_45ck1920 FIND v(dout0_45) AT=965.025n

.meas tran vdout0_46ck1920 FIND v(dout0_46) AT=965.025n

.meas tran vdout0_47ck1920 FIND v(dout0_47) AT=965.025n

.meas tran vdout0_48ck1920 FIND v(dout0_48) AT=965.025n

.meas tran vdout0_49ck1920 FIND v(dout0_49) AT=965.025n

.meas tran vdout0_50ck1920 FIND v(dout0_50) AT=965.025n

.meas tran vdout0_51ck1920 FIND v(dout0_51) AT=965.025n

.meas tran vdout0_52ck1920 FIND v(dout0_52) AT=965.025n

.meas tran vdout0_53ck1920 FIND v(dout0_53) AT=965.025n

.meas tran vdout0_54ck1920 FIND v(dout0_54) AT=965.025n

.meas tran vdout0_55ck1920 FIND v(dout0_55) AT=965.025n

.meas tran vdout0_56ck1920 FIND v(dout0_56) AT=965.025n

.meas tran vdout0_57ck1920 FIND v(dout0_57) AT=965.025n

.meas tran vdout0_58ck1920 FIND v(dout0_58) AT=965.025n

.meas tran vdout0_59ck1920 FIND v(dout0_59) AT=965.025n

.meas tran vdout0_60ck1920 FIND v(dout0_60) AT=965.025n

.meas tran vdout0_61ck1920 FIND v(dout0_61) AT=965.025n

.meas tran vdout0_62ck1920 FIND v(dout0_62) AT=965.025n

.meas tran vdout0_63ck1920 FIND v(dout0_63) AT=965.025n

.meas tran vdout0_64ck1920 FIND v(dout0_64) AT=965.025n

.meas tran vdout0_65ck1920 FIND v(dout0_65) AT=965.025n

.meas tran vdout0_66ck1920 FIND v(dout0_66) AT=965.025n

.meas tran vdout0_67ck1920 FIND v(dout0_67) AT=965.025n

.meas tran vdout0_68ck1920 FIND v(dout0_68) AT=965.025n

.meas tran vdout0_69ck1920 FIND v(dout0_69) AT=965.025n

.meas tran vdout0_70ck1920 FIND v(dout0_70) AT=965.025n

.meas tran vdout0_71ck1920 FIND v(dout0_71) AT=965.025n

.meas tran vdout0_72ck1920 FIND v(dout0_72) AT=965.025n

.meas tran vdout0_73ck1920 FIND v(dout0_73) AT=965.025n

.meas tran vdout0_74ck1920 FIND v(dout0_74) AT=965.025n

.meas tran vdout0_75ck1920 FIND v(dout0_75) AT=965.025n

.meas tran vdout0_76ck1920 FIND v(dout0_76) AT=965.025n

.meas tran vdout0_77ck1920 FIND v(dout0_77) AT=965.025n

.meas tran vdout0_78ck1920 FIND v(dout0_78) AT=965.025n

.meas tran vdout0_79ck1920 FIND v(dout0_79) AT=965.025n

.meas tran vdout0_80ck1920 FIND v(dout0_80) AT=965.025n

.meas tran vdout0_81ck1920 FIND v(dout0_81) AT=965.025n

.meas tran vdout0_82ck1920 FIND v(dout0_82) AT=965.025n

.meas tran vdout0_83ck1920 FIND v(dout0_83) AT=965.025n

.meas tran vdout0_84ck1920 FIND v(dout0_84) AT=965.025n

.meas tran vdout0_85ck1920 FIND v(dout0_85) AT=965.025n

.meas tran vdout0_86ck1920 FIND v(dout0_86) AT=965.025n

.meas tran vdout0_87ck1920 FIND v(dout0_87) AT=965.025n

.meas tran vdout0_88ck1920 FIND v(dout0_88) AT=965.025n

.meas tran vdout0_89ck1920 FIND v(dout0_89) AT=965.025n

.meas tran vdout0_90ck1920 FIND v(dout0_90) AT=965.025n

.meas tran vdout0_91ck1920 FIND v(dout0_91) AT=965.025n

.meas tran vdout0_92ck1920 FIND v(dout0_92) AT=965.025n

.meas tran vdout0_93ck1920 FIND v(dout0_93) AT=965.025n

.meas tran vdout0_94ck1920 FIND v(dout0_94) AT=965.025n

.meas tran vdout0_95ck1920 FIND v(dout0_95) AT=965.025n

.meas tran vdout0_96ck1920 FIND v(dout0_96) AT=965.025n

.meas tran vdout0_97ck1920 FIND v(dout0_97) AT=965.025n

.meas tran vdout0_98ck1920 FIND v(dout0_98) AT=965.025n

.meas tran vdout0_99ck1920 FIND v(dout0_99) AT=965.025n

.meas tran vdout0_100ck1920 FIND v(dout0_100) AT=965.025n

.meas tran vdout0_101ck1920 FIND v(dout0_101) AT=965.025n

.meas tran vdout0_102ck1920 FIND v(dout0_102) AT=965.025n

.meas tran vdout0_103ck1920 FIND v(dout0_103) AT=965.025n

.meas tran vdout0_104ck1920 FIND v(dout0_104) AT=965.025n

.meas tran vdout0_105ck1920 FIND v(dout0_105) AT=965.025n

.meas tran vdout0_106ck1920 FIND v(dout0_106) AT=965.025n

.meas tran vdout0_107ck1920 FIND v(dout0_107) AT=965.025n

.meas tran vdout0_108ck1920 FIND v(dout0_108) AT=965.025n

.meas tran vdout0_109ck1920 FIND v(dout0_109) AT=965.025n

.meas tran vdout0_110ck1920 FIND v(dout0_110) AT=965.025n

.meas tran vdout0_111ck1920 FIND v(dout0_111) AT=965.025n

.meas tran vdout0_112ck1920 FIND v(dout0_112) AT=965.025n

.meas tran vdout0_113ck1920 FIND v(dout0_113) AT=965.025n

.meas tran vdout0_114ck1920 FIND v(dout0_114) AT=965.025n

.meas tran vdout0_115ck1920 FIND v(dout0_115) AT=965.025n

.meas tran vdout0_116ck1920 FIND v(dout0_116) AT=965.025n

.meas tran vdout0_117ck1920 FIND v(dout0_117) AT=965.025n

.meas tran vdout0_118ck1920 FIND v(dout0_118) AT=965.025n

.meas tran vdout0_119ck1920 FIND v(dout0_119) AT=965.025n

.meas tran vdout0_120ck1920 FIND v(dout0_120) AT=965.025n

.meas tran vdout0_121ck1920 FIND v(dout0_121) AT=965.025n

.meas tran vdout0_122ck1920 FIND v(dout0_122) AT=965.025n

.meas tran vdout0_123ck1920 FIND v(dout0_123) AT=965.025n

.meas tran vdout0_124ck1920 FIND v(dout0_124) AT=965.025n

.meas tran vdout0_125ck1920 FIND v(dout0_125) AT=965.025n

.meas tran vdout0_126ck1920 FIND v(dout0_126) AT=965.025n

.meas tran vdout0_127ck1920 FIND v(dout0_127) AT=965.025n

.meas tran vdout0_128ck1920 FIND v(dout0_128) AT=965.025n

.meas tran vdout0_129ck1920 FIND v(dout0_129) AT=965.025n

.meas tran vdout0_130ck1920 FIND v(dout0_130) AT=965.025n

.meas tran vdout0_131ck1920 FIND v(dout0_131) AT=965.025n

.meas tran vdout0_132ck1920 FIND v(dout0_132) AT=965.025n

.meas tran vdout0_133ck1920 FIND v(dout0_133) AT=965.025n

.meas tran vdout0_134ck1920 FIND v(dout0_134) AT=965.025n

.meas tran vdout0_135ck1920 FIND v(dout0_135) AT=965.025n

.meas tran vdout0_136ck1920 FIND v(dout0_136) AT=965.025n

.meas tran vdout0_137ck1920 FIND v(dout0_137) AT=965.025n

.meas tran vdout0_138ck1920 FIND v(dout0_138) AT=965.025n

.meas tran vdout0_139ck1920 FIND v(dout0_139) AT=965.025n

.meas tran vdout0_140ck1920 FIND v(dout0_140) AT=965.025n

.meas tran vdout0_141ck1920 FIND v(dout0_141) AT=965.025n

.meas tran vdout0_142ck1920 FIND v(dout0_142) AT=965.025n

.meas tran vdout0_143ck1920 FIND v(dout0_143) AT=965.025n

.meas tran vdout0_144ck1920 FIND v(dout0_144) AT=965.025n

.meas tran vdout0_145ck1920 FIND v(dout0_145) AT=965.025n

.meas tran vdout0_146ck1920 FIND v(dout0_146) AT=965.025n

.meas tran vdout0_147ck1920 FIND v(dout0_147) AT=965.025n

.meas tran vdout0_148ck1920 FIND v(dout0_148) AT=965.025n

.meas tran vdout0_149ck1920 FIND v(dout0_149) AT=965.025n

.meas tran vdout0_150ck1920 FIND v(dout0_150) AT=965.025n

.meas tran vdout0_151ck1920 FIND v(dout0_151) AT=965.025n

.meas tran vdout0_152ck1920 FIND v(dout0_152) AT=965.025n

.meas tran vdout0_153ck1920 FIND v(dout0_153) AT=965.025n

.meas tran vdout0_154ck1920 FIND v(dout0_154) AT=965.025n

.meas tran vdout0_155ck1920 FIND v(dout0_155) AT=965.025n

.meas tran vdout0_156ck1920 FIND v(dout0_156) AT=965.025n

.meas tran vdout0_157ck1920 FIND v(dout0_157) AT=965.025n

.meas tran vdout0_158ck1920 FIND v(dout0_158) AT=965.025n

.meas tran vdout0_159ck1920 FIND v(dout0_159) AT=965.025n

.meas tran vdout0_160ck1920 FIND v(dout0_160) AT=965.025n

.meas tran vdout0_161ck1920 FIND v(dout0_161) AT=965.025n

.meas tran vdout0_162ck1920 FIND v(dout0_162) AT=965.025n

.meas tran vdout0_163ck1920 FIND v(dout0_163) AT=965.025n

.meas tran vdout0_164ck1920 FIND v(dout0_164) AT=965.025n

.meas tran vdout0_165ck1920 FIND v(dout0_165) AT=965.025n

.meas tran vdout0_166ck1920 FIND v(dout0_166) AT=965.025n

.meas tran vdout0_167ck1920 FIND v(dout0_167) AT=965.025n

.meas tran vdout0_168ck1920 FIND v(dout0_168) AT=965.025n

.meas tran vdout0_169ck1920 FIND v(dout0_169) AT=965.025n

.meas tran vdout0_170ck1920 FIND v(dout0_170) AT=965.025n

.meas tran vdout0_171ck1920 FIND v(dout0_171) AT=965.025n

.meas tran vdout0_172ck1920 FIND v(dout0_172) AT=965.025n

.meas tran vdout0_173ck1920 FIND v(dout0_173) AT=965.025n

.meas tran vdout0_174ck1920 FIND v(dout0_174) AT=965.025n

.meas tran vdout0_175ck1920 FIND v(dout0_175) AT=965.025n

.meas tran vdout0_176ck1920 FIND v(dout0_176) AT=965.025n

.meas tran vdout0_177ck1920 FIND v(dout0_177) AT=965.025n

.meas tran vdout0_178ck1920 FIND v(dout0_178) AT=965.025n

.meas tran vdout0_179ck1920 FIND v(dout0_179) AT=965.025n

.meas tran vdout0_180ck1920 FIND v(dout0_180) AT=965.025n

.meas tran vdout0_181ck1920 FIND v(dout0_181) AT=965.025n

.meas tran vdout0_182ck1920 FIND v(dout0_182) AT=965.025n

.meas tran vdout0_183ck1920 FIND v(dout0_183) AT=965.025n

.meas tran vdout0_184ck1920 FIND v(dout0_184) AT=965.025n

.meas tran vdout0_185ck1920 FIND v(dout0_185) AT=965.025n

.meas tran vdout0_186ck1920 FIND v(dout0_186) AT=965.025n

.meas tran vdout0_187ck1920 FIND v(dout0_187) AT=965.025n

.meas tran vdout0_188ck1920 FIND v(dout0_188) AT=965.025n

.meas tran vdout0_189ck1920 FIND v(dout0_189) AT=965.025n

.meas tran vdout0_190ck1920 FIND v(dout0_190) AT=965.025n

.meas tran vdout0_191ck1920 FIND v(dout0_191) AT=965.025n

.meas tran vdout0_192ck1920 FIND v(dout0_192) AT=965.025n

.meas tran vdout0_193ck1920 FIND v(dout0_193) AT=965.025n

.meas tran vdout0_194ck1920 FIND v(dout0_194) AT=965.025n

.meas tran vdout0_195ck1920 FIND v(dout0_195) AT=965.025n

.meas tran vdout0_196ck1920 FIND v(dout0_196) AT=965.025n

.meas tran vdout0_197ck1920 FIND v(dout0_197) AT=965.025n

.meas tran vdout0_198ck1920 FIND v(dout0_198) AT=965.025n

.meas tran vdout0_199ck1920 FIND v(dout0_199) AT=965.025n

.meas tran vdout0_200ck1920 FIND v(dout0_200) AT=965.025n

.meas tran vdout0_201ck1920 FIND v(dout0_201) AT=965.025n

.meas tran vdout0_202ck1920 FIND v(dout0_202) AT=965.025n

.meas tran vdout0_203ck1920 FIND v(dout0_203) AT=965.025n

.meas tran vdout0_204ck1920 FIND v(dout0_204) AT=965.025n

.meas tran vdout0_205ck1920 FIND v(dout0_205) AT=965.025n

.meas tran vdout0_206ck1920 FIND v(dout0_206) AT=965.025n

.meas tran vdout0_207ck1920 FIND v(dout0_207) AT=965.025n

.meas tran vdout0_208ck1920 FIND v(dout0_208) AT=965.025n

.meas tran vdout0_209ck1920 FIND v(dout0_209) AT=965.025n

.meas tran vdout0_210ck1920 FIND v(dout0_210) AT=965.025n

.meas tran vdout0_211ck1920 FIND v(dout0_211) AT=965.025n

.meas tran vdout0_212ck1920 FIND v(dout0_212) AT=965.025n

.meas tran vdout0_213ck1920 FIND v(dout0_213) AT=965.025n

.meas tran vdout0_214ck1920 FIND v(dout0_214) AT=965.025n

.meas tran vdout0_215ck1920 FIND v(dout0_215) AT=965.025n

.meas tran vdout0_216ck1920 FIND v(dout0_216) AT=965.025n

.meas tran vdout0_217ck1920 FIND v(dout0_217) AT=965.025n

.meas tran vdout0_218ck1920 FIND v(dout0_218) AT=965.025n

.meas tran vdout0_219ck1920 FIND v(dout0_219) AT=965.025n

.meas tran vdout0_220ck1920 FIND v(dout0_220) AT=965.025n

.meas tran vdout0_221ck1920 FIND v(dout0_221) AT=965.025n

.meas tran vdout0_222ck1920 FIND v(dout0_222) AT=965.025n

.meas tran vdout0_223ck1920 FIND v(dout0_223) AT=965.025n

.meas tran vdout0_224ck1920 FIND v(dout0_224) AT=965.025n

.meas tran vdout0_225ck1920 FIND v(dout0_225) AT=965.025n

.meas tran vdout0_226ck1920 FIND v(dout0_226) AT=965.025n

.meas tran vdout0_227ck1920 FIND v(dout0_227) AT=965.025n

.meas tran vdout0_228ck1920 FIND v(dout0_228) AT=965.025n

.meas tran vdout0_229ck1920 FIND v(dout0_229) AT=965.025n

.meas tran vdout0_230ck1920 FIND v(dout0_230) AT=965.025n

.meas tran vdout0_231ck1920 FIND v(dout0_231) AT=965.025n

.meas tran vdout0_232ck1920 FIND v(dout0_232) AT=965.025n

.meas tran vdout0_233ck1920 FIND v(dout0_233) AT=965.025n

.meas tran vdout0_234ck1920 FIND v(dout0_234) AT=965.025n

.meas tran vdout0_235ck1920 FIND v(dout0_235) AT=965.025n

.meas tran vdout0_236ck1920 FIND v(dout0_236) AT=965.025n

.meas tran vdout0_237ck1920 FIND v(dout0_237) AT=965.025n

.meas tran vdout0_238ck1920 FIND v(dout0_238) AT=965.025n

.meas tran vdout0_239ck1920 FIND v(dout0_239) AT=965.025n

.meas tran vdout0_240ck1920 FIND v(dout0_240) AT=965.025n

.meas tran vdout0_241ck1920 FIND v(dout0_241) AT=965.025n

.meas tran vdout0_242ck1920 FIND v(dout0_242) AT=965.025n

.meas tran vdout0_243ck1920 FIND v(dout0_243) AT=965.025n

.meas tran vdout0_244ck1920 FIND v(dout0_244) AT=965.025n

.meas tran vdout0_245ck1920 FIND v(dout0_245) AT=965.025n

.meas tran vdout0_246ck1920 FIND v(dout0_246) AT=965.025n

.meas tran vdout0_247ck1920 FIND v(dout0_247) AT=965.025n

.meas tran vdout0_248ck1920 FIND v(dout0_248) AT=965.025n

.meas tran vdout0_249ck1920 FIND v(dout0_249) AT=965.025n

.meas tran vdout0_250ck1920 FIND v(dout0_250) AT=965.025n

.meas tran vdout0_251ck1920 FIND v(dout0_251) AT=965.025n

.meas tran vdout0_252ck1920 FIND v(dout0_252) AT=965.025n

.meas tran vdout0_253ck1920 FIND v(dout0_253) AT=965.025n

.meas tran vdout0_254ck1920 FIND v(dout0_254) AT=965.025n

.meas tran vdout0_255ck1920 FIND v(dout0_255) AT=965.025n

.meas tran vdout0_0ck1970 FIND v(dout0_0) AT=990.025n

.meas tran vdout0_1ck1970 FIND v(dout0_1) AT=990.025n

.meas tran vdout0_2ck1970 FIND v(dout0_2) AT=990.025n

.meas tran vdout0_3ck1970 FIND v(dout0_3) AT=990.025n

.meas tran vdout0_4ck1970 FIND v(dout0_4) AT=990.025n

.meas tran vdout0_5ck1970 FIND v(dout0_5) AT=990.025n

.meas tran vdout0_6ck1970 FIND v(dout0_6) AT=990.025n

.meas tran vdout0_7ck1970 FIND v(dout0_7) AT=990.025n

.meas tran vdout0_8ck1970 FIND v(dout0_8) AT=990.025n

.meas tran vdout0_9ck1970 FIND v(dout0_9) AT=990.025n

.meas tran vdout0_10ck1970 FIND v(dout0_10) AT=990.025n

.meas tran vdout0_11ck1970 FIND v(dout0_11) AT=990.025n

.meas tran vdout0_12ck1970 FIND v(dout0_12) AT=990.025n

.meas tran vdout0_13ck1970 FIND v(dout0_13) AT=990.025n

.meas tran vdout0_14ck1970 FIND v(dout0_14) AT=990.025n

.meas tran vdout0_15ck1970 FIND v(dout0_15) AT=990.025n

.meas tran vdout0_16ck1970 FIND v(dout0_16) AT=990.025n

.meas tran vdout0_17ck1970 FIND v(dout0_17) AT=990.025n

.meas tran vdout0_18ck1970 FIND v(dout0_18) AT=990.025n

.meas tran vdout0_19ck1970 FIND v(dout0_19) AT=990.025n

.meas tran vdout0_20ck1970 FIND v(dout0_20) AT=990.025n

.meas tran vdout0_21ck1970 FIND v(dout0_21) AT=990.025n

.meas tran vdout0_22ck1970 FIND v(dout0_22) AT=990.025n

.meas tran vdout0_23ck1970 FIND v(dout0_23) AT=990.025n

.meas tran vdout0_24ck1970 FIND v(dout0_24) AT=990.025n

.meas tran vdout0_25ck1970 FIND v(dout0_25) AT=990.025n

.meas tran vdout0_26ck1970 FIND v(dout0_26) AT=990.025n

.meas tran vdout0_27ck1970 FIND v(dout0_27) AT=990.025n

.meas tran vdout0_28ck1970 FIND v(dout0_28) AT=990.025n

.meas tran vdout0_29ck1970 FIND v(dout0_29) AT=990.025n

.meas tran vdout0_30ck1970 FIND v(dout0_30) AT=990.025n

.meas tran vdout0_31ck1970 FIND v(dout0_31) AT=990.025n

.meas tran vdout0_32ck1970 FIND v(dout0_32) AT=990.025n

.meas tran vdout0_33ck1970 FIND v(dout0_33) AT=990.025n

.meas tran vdout0_34ck1970 FIND v(dout0_34) AT=990.025n

.meas tran vdout0_35ck1970 FIND v(dout0_35) AT=990.025n

.meas tran vdout0_36ck1970 FIND v(dout0_36) AT=990.025n

.meas tran vdout0_37ck1970 FIND v(dout0_37) AT=990.025n

.meas tran vdout0_38ck1970 FIND v(dout0_38) AT=990.025n

.meas tran vdout0_39ck1970 FIND v(dout0_39) AT=990.025n

.meas tran vdout0_40ck1970 FIND v(dout0_40) AT=990.025n

.meas tran vdout0_41ck1970 FIND v(dout0_41) AT=990.025n

.meas tran vdout0_42ck1970 FIND v(dout0_42) AT=990.025n

.meas tran vdout0_43ck1970 FIND v(dout0_43) AT=990.025n

.meas tran vdout0_44ck1970 FIND v(dout0_44) AT=990.025n

.meas tran vdout0_45ck1970 FIND v(dout0_45) AT=990.025n

.meas tran vdout0_46ck1970 FIND v(dout0_46) AT=990.025n

.meas tran vdout0_47ck1970 FIND v(dout0_47) AT=990.025n

.meas tran vdout0_48ck1970 FIND v(dout0_48) AT=990.025n

.meas tran vdout0_49ck1970 FIND v(dout0_49) AT=990.025n

.meas tran vdout0_50ck1970 FIND v(dout0_50) AT=990.025n

.meas tran vdout0_51ck1970 FIND v(dout0_51) AT=990.025n

.meas tran vdout0_52ck1970 FIND v(dout0_52) AT=990.025n

.meas tran vdout0_53ck1970 FIND v(dout0_53) AT=990.025n

.meas tran vdout0_54ck1970 FIND v(dout0_54) AT=990.025n

.meas tran vdout0_55ck1970 FIND v(dout0_55) AT=990.025n

.meas tran vdout0_56ck1970 FIND v(dout0_56) AT=990.025n

.meas tran vdout0_57ck1970 FIND v(dout0_57) AT=990.025n

.meas tran vdout0_58ck1970 FIND v(dout0_58) AT=990.025n

.meas tran vdout0_59ck1970 FIND v(dout0_59) AT=990.025n

.meas tran vdout0_60ck1970 FIND v(dout0_60) AT=990.025n

.meas tran vdout0_61ck1970 FIND v(dout0_61) AT=990.025n

.meas tran vdout0_62ck1970 FIND v(dout0_62) AT=990.025n

.meas tran vdout0_63ck1970 FIND v(dout0_63) AT=990.025n

.meas tran vdout0_64ck1970 FIND v(dout0_64) AT=990.025n

.meas tran vdout0_65ck1970 FIND v(dout0_65) AT=990.025n

.meas tran vdout0_66ck1970 FIND v(dout0_66) AT=990.025n

.meas tran vdout0_67ck1970 FIND v(dout0_67) AT=990.025n

.meas tran vdout0_68ck1970 FIND v(dout0_68) AT=990.025n

.meas tran vdout0_69ck1970 FIND v(dout0_69) AT=990.025n

.meas tran vdout0_70ck1970 FIND v(dout0_70) AT=990.025n

.meas tran vdout0_71ck1970 FIND v(dout0_71) AT=990.025n

.meas tran vdout0_72ck1970 FIND v(dout0_72) AT=990.025n

.meas tran vdout0_73ck1970 FIND v(dout0_73) AT=990.025n

.meas tran vdout0_74ck1970 FIND v(dout0_74) AT=990.025n

.meas tran vdout0_75ck1970 FIND v(dout0_75) AT=990.025n

.meas tran vdout0_76ck1970 FIND v(dout0_76) AT=990.025n

.meas tran vdout0_77ck1970 FIND v(dout0_77) AT=990.025n

.meas tran vdout0_78ck1970 FIND v(dout0_78) AT=990.025n

.meas tran vdout0_79ck1970 FIND v(dout0_79) AT=990.025n

.meas tran vdout0_80ck1970 FIND v(dout0_80) AT=990.025n

.meas tran vdout0_81ck1970 FIND v(dout0_81) AT=990.025n

.meas tran vdout0_82ck1970 FIND v(dout0_82) AT=990.025n

.meas tran vdout0_83ck1970 FIND v(dout0_83) AT=990.025n

.meas tran vdout0_84ck1970 FIND v(dout0_84) AT=990.025n

.meas tran vdout0_85ck1970 FIND v(dout0_85) AT=990.025n

.meas tran vdout0_86ck1970 FIND v(dout0_86) AT=990.025n

.meas tran vdout0_87ck1970 FIND v(dout0_87) AT=990.025n

.meas tran vdout0_88ck1970 FIND v(dout0_88) AT=990.025n

.meas tran vdout0_89ck1970 FIND v(dout0_89) AT=990.025n

.meas tran vdout0_90ck1970 FIND v(dout0_90) AT=990.025n

.meas tran vdout0_91ck1970 FIND v(dout0_91) AT=990.025n

.meas tran vdout0_92ck1970 FIND v(dout0_92) AT=990.025n

.meas tran vdout0_93ck1970 FIND v(dout0_93) AT=990.025n

.meas tran vdout0_94ck1970 FIND v(dout0_94) AT=990.025n

.meas tran vdout0_95ck1970 FIND v(dout0_95) AT=990.025n

.meas tran vdout0_96ck1970 FIND v(dout0_96) AT=990.025n

.meas tran vdout0_97ck1970 FIND v(dout0_97) AT=990.025n

.meas tran vdout0_98ck1970 FIND v(dout0_98) AT=990.025n

.meas tran vdout0_99ck1970 FIND v(dout0_99) AT=990.025n

.meas tran vdout0_100ck1970 FIND v(dout0_100) AT=990.025n

.meas tran vdout0_101ck1970 FIND v(dout0_101) AT=990.025n

.meas tran vdout0_102ck1970 FIND v(dout0_102) AT=990.025n

.meas tran vdout0_103ck1970 FIND v(dout0_103) AT=990.025n

.meas tran vdout0_104ck1970 FIND v(dout0_104) AT=990.025n

.meas tran vdout0_105ck1970 FIND v(dout0_105) AT=990.025n

.meas tran vdout0_106ck1970 FIND v(dout0_106) AT=990.025n

.meas tran vdout0_107ck1970 FIND v(dout0_107) AT=990.025n

.meas tran vdout0_108ck1970 FIND v(dout0_108) AT=990.025n

.meas tran vdout0_109ck1970 FIND v(dout0_109) AT=990.025n

.meas tran vdout0_110ck1970 FIND v(dout0_110) AT=990.025n

.meas tran vdout0_111ck1970 FIND v(dout0_111) AT=990.025n

.meas tran vdout0_112ck1970 FIND v(dout0_112) AT=990.025n

.meas tran vdout0_113ck1970 FIND v(dout0_113) AT=990.025n

.meas tran vdout0_114ck1970 FIND v(dout0_114) AT=990.025n

.meas tran vdout0_115ck1970 FIND v(dout0_115) AT=990.025n

.meas tran vdout0_116ck1970 FIND v(dout0_116) AT=990.025n

.meas tran vdout0_117ck1970 FIND v(dout0_117) AT=990.025n

.meas tran vdout0_118ck1970 FIND v(dout0_118) AT=990.025n

.meas tran vdout0_119ck1970 FIND v(dout0_119) AT=990.025n

.meas tran vdout0_120ck1970 FIND v(dout0_120) AT=990.025n

.meas tran vdout0_121ck1970 FIND v(dout0_121) AT=990.025n

.meas tran vdout0_122ck1970 FIND v(dout0_122) AT=990.025n

.meas tran vdout0_123ck1970 FIND v(dout0_123) AT=990.025n

.meas tran vdout0_124ck1970 FIND v(dout0_124) AT=990.025n

.meas tran vdout0_125ck1970 FIND v(dout0_125) AT=990.025n

.meas tran vdout0_126ck1970 FIND v(dout0_126) AT=990.025n

.meas tran vdout0_127ck1970 FIND v(dout0_127) AT=990.025n

.meas tran vdout0_128ck1970 FIND v(dout0_128) AT=990.025n

.meas tran vdout0_129ck1970 FIND v(dout0_129) AT=990.025n

.meas tran vdout0_130ck1970 FIND v(dout0_130) AT=990.025n

.meas tran vdout0_131ck1970 FIND v(dout0_131) AT=990.025n

.meas tran vdout0_132ck1970 FIND v(dout0_132) AT=990.025n

.meas tran vdout0_133ck1970 FIND v(dout0_133) AT=990.025n

.meas tran vdout0_134ck1970 FIND v(dout0_134) AT=990.025n

.meas tran vdout0_135ck1970 FIND v(dout0_135) AT=990.025n

.meas tran vdout0_136ck1970 FIND v(dout0_136) AT=990.025n

.meas tran vdout0_137ck1970 FIND v(dout0_137) AT=990.025n

.meas tran vdout0_138ck1970 FIND v(dout0_138) AT=990.025n

.meas tran vdout0_139ck1970 FIND v(dout0_139) AT=990.025n

.meas tran vdout0_140ck1970 FIND v(dout0_140) AT=990.025n

.meas tran vdout0_141ck1970 FIND v(dout0_141) AT=990.025n

.meas tran vdout0_142ck1970 FIND v(dout0_142) AT=990.025n

.meas tran vdout0_143ck1970 FIND v(dout0_143) AT=990.025n

.meas tran vdout0_144ck1970 FIND v(dout0_144) AT=990.025n

.meas tran vdout0_145ck1970 FIND v(dout0_145) AT=990.025n

.meas tran vdout0_146ck1970 FIND v(dout0_146) AT=990.025n

.meas tran vdout0_147ck1970 FIND v(dout0_147) AT=990.025n

.meas tran vdout0_148ck1970 FIND v(dout0_148) AT=990.025n

.meas tran vdout0_149ck1970 FIND v(dout0_149) AT=990.025n

.meas tran vdout0_150ck1970 FIND v(dout0_150) AT=990.025n

.meas tran vdout0_151ck1970 FIND v(dout0_151) AT=990.025n

.meas tran vdout0_152ck1970 FIND v(dout0_152) AT=990.025n

.meas tran vdout0_153ck1970 FIND v(dout0_153) AT=990.025n

.meas tran vdout0_154ck1970 FIND v(dout0_154) AT=990.025n

.meas tran vdout0_155ck1970 FIND v(dout0_155) AT=990.025n

.meas tran vdout0_156ck1970 FIND v(dout0_156) AT=990.025n

.meas tran vdout0_157ck1970 FIND v(dout0_157) AT=990.025n

.meas tran vdout0_158ck1970 FIND v(dout0_158) AT=990.025n

.meas tran vdout0_159ck1970 FIND v(dout0_159) AT=990.025n

.meas tran vdout0_160ck1970 FIND v(dout0_160) AT=990.025n

.meas tran vdout0_161ck1970 FIND v(dout0_161) AT=990.025n

.meas tran vdout0_162ck1970 FIND v(dout0_162) AT=990.025n

.meas tran vdout0_163ck1970 FIND v(dout0_163) AT=990.025n

.meas tran vdout0_164ck1970 FIND v(dout0_164) AT=990.025n

.meas tran vdout0_165ck1970 FIND v(dout0_165) AT=990.025n

.meas tran vdout0_166ck1970 FIND v(dout0_166) AT=990.025n

.meas tran vdout0_167ck1970 FIND v(dout0_167) AT=990.025n

.meas tran vdout0_168ck1970 FIND v(dout0_168) AT=990.025n

.meas tran vdout0_169ck1970 FIND v(dout0_169) AT=990.025n

.meas tran vdout0_170ck1970 FIND v(dout0_170) AT=990.025n

.meas tran vdout0_171ck1970 FIND v(dout0_171) AT=990.025n

.meas tran vdout0_172ck1970 FIND v(dout0_172) AT=990.025n

.meas tran vdout0_173ck1970 FIND v(dout0_173) AT=990.025n

.meas tran vdout0_174ck1970 FIND v(dout0_174) AT=990.025n

.meas tran vdout0_175ck1970 FIND v(dout0_175) AT=990.025n

.meas tran vdout0_176ck1970 FIND v(dout0_176) AT=990.025n

.meas tran vdout0_177ck1970 FIND v(dout0_177) AT=990.025n

.meas tran vdout0_178ck1970 FIND v(dout0_178) AT=990.025n

.meas tran vdout0_179ck1970 FIND v(dout0_179) AT=990.025n

.meas tran vdout0_180ck1970 FIND v(dout0_180) AT=990.025n

.meas tran vdout0_181ck1970 FIND v(dout0_181) AT=990.025n

.meas tran vdout0_182ck1970 FIND v(dout0_182) AT=990.025n

.meas tran vdout0_183ck1970 FIND v(dout0_183) AT=990.025n

.meas tran vdout0_184ck1970 FIND v(dout0_184) AT=990.025n

.meas tran vdout0_185ck1970 FIND v(dout0_185) AT=990.025n

.meas tran vdout0_186ck1970 FIND v(dout0_186) AT=990.025n

.meas tran vdout0_187ck1970 FIND v(dout0_187) AT=990.025n

.meas tran vdout0_188ck1970 FIND v(dout0_188) AT=990.025n

.meas tran vdout0_189ck1970 FIND v(dout0_189) AT=990.025n

.meas tran vdout0_190ck1970 FIND v(dout0_190) AT=990.025n

.meas tran vdout0_191ck1970 FIND v(dout0_191) AT=990.025n

.meas tran vdout0_192ck1970 FIND v(dout0_192) AT=990.025n

.meas tran vdout0_193ck1970 FIND v(dout0_193) AT=990.025n

.meas tran vdout0_194ck1970 FIND v(dout0_194) AT=990.025n

.meas tran vdout0_195ck1970 FIND v(dout0_195) AT=990.025n

.meas tran vdout0_196ck1970 FIND v(dout0_196) AT=990.025n

.meas tran vdout0_197ck1970 FIND v(dout0_197) AT=990.025n

.meas tran vdout0_198ck1970 FIND v(dout0_198) AT=990.025n

.meas tran vdout0_199ck1970 FIND v(dout0_199) AT=990.025n

.meas tran vdout0_200ck1970 FIND v(dout0_200) AT=990.025n

.meas tran vdout0_201ck1970 FIND v(dout0_201) AT=990.025n

.meas tran vdout0_202ck1970 FIND v(dout0_202) AT=990.025n

.meas tran vdout0_203ck1970 FIND v(dout0_203) AT=990.025n

.meas tran vdout0_204ck1970 FIND v(dout0_204) AT=990.025n

.meas tran vdout0_205ck1970 FIND v(dout0_205) AT=990.025n

.meas tran vdout0_206ck1970 FIND v(dout0_206) AT=990.025n

.meas tran vdout0_207ck1970 FIND v(dout0_207) AT=990.025n

.meas tran vdout0_208ck1970 FIND v(dout0_208) AT=990.025n

.meas tran vdout0_209ck1970 FIND v(dout0_209) AT=990.025n

.meas tran vdout0_210ck1970 FIND v(dout0_210) AT=990.025n

.meas tran vdout0_211ck1970 FIND v(dout0_211) AT=990.025n

.meas tran vdout0_212ck1970 FIND v(dout0_212) AT=990.025n

.meas tran vdout0_213ck1970 FIND v(dout0_213) AT=990.025n

.meas tran vdout0_214ck1970 FIND v(dout0_214) AT=990.025n

.meas tran vdout0_215ck1970 FIND v(dout0_215) AT=990.025n

.meas tran vdout0_216ck1970 FIND v(dout0_216) AT=990.025n

.meas tran vdout0_217ck1970 FIND v(dout0_217) AT=990.025n

.meas tran vdout0_218ck1970 FIND v(dout0_218) AT=990.025n

.meas tran vdout0_219ck1970 FIND v(dout0_219) AT=990.025n

.meas tran vdout0_220ck1970 FIND v(dout0_220) AT=990.025n

.meas tran vdout0_221ck1970 FIND v(dout0_221) AT=990.025n

.meas tran vdout0_222ck1970 FIND v(dout0_222) AT=990.025n

.meas tran vdout0_223ck1970 FIND v(dout0_223) AT=990.025n

.meas tran vdout0_224ck1970 FIND v(dout0_224) AT=990.025n

.meas tran vdout0_225ck1970 FIND v(dout0_225) AT=990.025n

.meas tran vdout0_226ck1970 FIND v(dout0_226) AT=990.025n

.meas tran vdout0_227ck1970 FIND v(dout0_227) AT=990.025n

.meas tran vdout0_228ck1970 FIND v(dout0_228) AT=990.025n

.meas tran vdout0_229ck1970 FIND v(dout0_229) AT=990.025n

.meas tran vdout0_230ck1970 FIND v(dout0_230) AT=990.025n

.meas tran vdout0_231ck1970 FIND v(dout0_231) AT=990.025n

.meas tran vdout0_232ck1970 FIND v(dout0_232) AT=990.025n

.meas tran vdout0_233ck1970 FIND v(dout0_233) AT=990.025n

.meas tran vdout0_234ck1970 FIND v(dout0_234) AT=990.025n

.meas tran vdout0_235ck1970 FIND v(dout0_235) AT=990.025n

.meas tran vdout0_236ck1970 FIND v(dout0_236) AT=990.025n

.meas tran vdout0_237ck1970 FIND v(dout0_237) AT=990.025n

.meas tran vdout0_238ck1970 FIND v(dout0_238) AT=990.025n

.meas tran vdout0_239ck1970 FIND v(dout0_239) AT=990.025n

.meas tran vdout0_240ck1970 FIND v(dout0_240) AT=990.025n

.meas tran vdout0_241ck1970 FIND v(dout0_241) AT=990.025n

.meas tran vdout0_242ck1970 FIND v(dout0_242) AT=990.025n

.meas tran vdout0_243ck1970 FIND v(dout0_243) AT=990.025n

.meas tran vdout0_244ck1970 FIND v(dout0_244) AT=990.025n

.meas tran vdout0_245ck1970 FIND v(dout0_245) AT=990.025n

.meas tran vdout0_246ck1970 FIND v(dout0_246) AT=990.025n

.meas tran vdout0_247ck1970 FIND v(dout0_247) AT=990.025n

.meas tran vdout0_248ck1970 FIND v(dout0_248) AT=990.025n

.meas tran vdout0_249ck1970 FIND v(dout0_249) AT=990.025n

.meas tran vdout0_250ck1970 FIND v(dout0_250) AT=990.025n

.meas tran vdout0_251ck1970 FIND v(dout0_251) AT=990.025n

.meas tran vdout0_252ck1970 FIND v(dout0_252) AT=990.025n

.meas tran vdout0_253ck1970 FIND v(dout0_253) AT=990.025n

.meas tran vdout0_254ck1970 FIND v(dout0_254) AT=990.025n

.meas tran vdout0_255ck1970 FIND v(dout0_255) AT=990.025n

.meas tran vdout0_0ck1990 FIND v(dout0_0) AT=1000.025n

.meas tran vdout0_1ck1990 FIND v(dout0_1) AT=1000.025n

.meas tran vdout0_2ck1990 FIND v(dout0_2) AT=1000.025n

.meas tran vdout0_3ck1990 FIND v(dout0_3) AT=1000.025n

.meas tran vdout0_4ck1990 FIND v(dout0_4) AT=1000.025n

.meas tran vdout0_5ck1990 FIND v(dout0_5) AT=1000.025n

.meas tran vdout0_6ck1990 FIND v(dout0_6) AT=1000.025n

.meas tran vdout0_7ck1990 FIND v(dout0_7) AT=1000.025n

.meas tran vdout0_8ck1990 FIND v(dout0_8) AT=1000.025n

.meas tran vdout0_9ck1990 FIND v(dout0_9) AT=1000.025n

.meas tran vdout0_10ck1990 FIND v(dout0_10) AT=1000.025n

.meas tran vdout0_11ck1990 FIND v(dout0_11) AT=1000.025n

.meas tran vdout0_12ck1990 FIND v(dout0_12) AT=1000.025n

.meas tran vdout0_13ck1990 FIND v(dout0_13) AT=1000.025n

.meas tran vdout0_14ck1990 FIND v(dout0_14) AT=1000.025n

.meas tran vdout0_15ck1990 FIND v(dout0_15) AT=1000.025n

.meas tran vdout0_16ck1990 FIND v(dout0_16) AT=1000.025n

.meas tran vdout0_17ck1990 FIND v(dout0_17) AT=1000.025n

.meas tran vdout0_18ck1990 FIND v(dout0_18) AT=1000.025n

.meas tran vdout0_19ck1990 FIND v(dout0_19) AT=1000.025n

.meas tran vdout0_20ck1990 FIND v(dout0_20) AT=1000.025n

.meas tran vdout0_21ck1990 FIND v(dout0_21) AT=1000.025n

.meas tran vdout0_22ck1990 FIND v(dout0_22) AT=1000.025n

.meas tran vdout0_23ck1990 FIND v(dout0_23) AT=1000.025n

.meas tran vdout0_24ck1990 FIND v(dout0_24) AT=1000.025n

.meas tran vdout0_25ck1990 FIND v(dout0_25) AT=1000.025n

.meas tran vdout0_26ck1990 FIND v(dout0_26) AT=1000.025n

.meas tran vdout0_27ck1990 FIND v(dout0_27) AT=1000.025n

.meas tran vdout0_28ck1990 FIND v(dout0_28) AT=1000.025n

.meas tran vdout0_29ck1990 FIND v(dout0_29) AT=1000.025n

.meas tran vdout0_30ck1990 FIND v(dout0_30) AT=1000.025n

.meas tran vdout0_31ck1990 FIND v(dout0_31) AT=1000.025n

.meas tran vdout0_32ck1990 FIND v(dout0_32) AT=1000.025n

.meas tran vdout0_33ck1990 FIND v(dout0_33) AT=1000.025n

.meas tran vdout0_34ck1990 FIND v(dout0_34) AT=1000.025n

.meas tran vdout0_35ck1990 FIND v(dout0_35) AT=1000.025n

.meas tran vdout0_36ck1990 FIND v(dout0_36) AT=1000.025n

.meas tran vdout0_37ck1990 FIND v(dout0_37) AT=1000.025n

.meas tran vdout0_38ck1990 FIND v(dout0_38) AT=1000.025n

.meas tran vdout0_39ck1990 FIND v(dout0_39) AT=1000.025n

.meas tran vdout0_40ck1990 FIND v(dout0_40) AT=1000.025n

.meas tran vdout0_41ck1990 FIND v(dout0_41) AT=1000.025n

.meas tran vdout0_42ck1990 FIND v(dout0_42) AT=1000.025n

.meas tran vdout0_43ck1990 FIND v(dout0_43) AT=1000.025n

.meas tran vdout0_44ck1990 FIND v(dout0_44) AT=1000.025n

.meas tran vdout0_45ck1990 FIND v(dout0_45) AT=1000.025n

.meas tran vdout0_46ck1990 FIND v(dout0_46) AT=1000.025n

.meas tran vdout0_47ck1990 FIND v(dout0_47) AT=1000.025n

.meas tran vdout0_48ck1990 FIND v(dout0_48) AT=1000.025n

.meas tran vdout0_49ck1990 FIND v(dout0_49) AT=1000.025n

.meas tran vdout0_50ck1990 FIND v(dout0_50) AT=1000.025n

.meas tran vdout0_51ck1990 FIND v(dout0_51) AT=1000.025n

.meas tran vdout0_52ck1990 FIND v(dout0_52) AT=1000.025n

.meas tran vdout0_53ck1990 FIND v(dout0_53) AT=1000.025n

.meas tran vdout0_54ck1990 FIND v(dout0_54) AT=1000.025n

.meas tran vdout0_55ck1990 FIND v(dout0_55) AT=1000.025n

.meas tran vdout0_56ck1990 FIND v(dout0_56) AT=1000.025n

.meas tran vdout0_57ck1990 FIND v(dout0_57) AT=1000.025n

.meas tran vdout0_58ck1990 FIND v(dout0_58) AT=1000.025n

.meas tran vdout0_59ck1990 FIND v(dout0_59) AT=1000.025n

.meas tran vdout0_60ck1990 FIND v(dout0_60) AT=1000.025n

.meas tran vdout0_61ck1990 FIND v(dout0_61) AT=1000.025n

.meas tran vdout0_62ck1990 FIND v(dout0_62) AT=1000.025n

.meas tran vdout0_63ck1990 FIND v(dout0_63) AT=1000.025n

.meas tran vdout0_64ck1990 FIND v(dout0_64) AT=1000.025n

.meas tran vdout0_65ck1990 FIND v(dout0_65) AT=1000.025n

.meas tran vdout0_66ck1990 FIND v(dout0_66) AT=1000.025n

.meas tran vdout0_67ck1990 FIND v(dout0_67) AT=1000.025n

.meas tran vdout0_68ck1990 FIND v(dout0_68) AT=1000.025n

.meas tran vdout0_69ck1990 FIND v(dout0_69) AT=1000.025n

.meas tran vdout0_70ck1990 FIND v(dout0_70) AT=1000.025n

.meas tran vdout0_71ck1990 FIND v(dout0_71) AT=1000.025n

.meas tran vdout0_72ck1990 FIND v(dout0_72) AT=1000.025n

.meas tran vdout0_73ck1990 FIND v(dout0_73) AT=1000.025n

.meas tran vdout0_74ck1990 FIND v(dout0_74) AT=1000.025n

.meas tran vdout0_75ck1990 FIND v(dout0_75) AT=1000.025n

.meas tran vdout0_76ck1990 FIND v(dout0_76) AT=1000.025n

.meas tran vdout0_77ck1990 FIND v(dout0_77) AT=1000.025n

.meas tran vdout0_78ck1990 FIND v(dout0_78) AT=1000.025n

.meas tran vdout0_79ck1990 FIND v(dout0_79) AT=1000.025n

.meas tran vdout0_80ck1990 FIND v(dout0_80) AT=1000.025n

.meas tran vdout0_81ck1990 FIND v(dout0_81) AT=1000.025n

.meas tran vdout0_82ck1990 FIND v(dout0_82) AT=1000.025n

.meas tran vdout0_83ck1990 FIND v(dout0_83) AT=1000.025n

.meas tran vdout0_84ck1990 FIND v(dout0_84) AT=1000.025n

.meas tran vdout0_85ck1990 FIND v(dout0_85) AT=1000.025n

.meas tran vdout0_86ck1990 FIND v(dout0_86) AT=1000.025n

.meas tran vdout0_87ck1990 FIND v(dout0_87) AT=1000.025n

.meas tran vdout0_88ck1990 FIND v(dout0_88) AT=1000.025n

.meas tran vdout0_89ck1990 FIND v(dout0_89) AT=1000.025n

.meas tran vdout0_90ck1990 FIND v(dout0_90) AT=1000.025n

.meas tran vdout0_91ck1990 FIND v(dout0_91) AT=1000.025n

.meas tran vdout0_92ck1990 FIND v(dout0_92) AT=1000.025n

.meas tran vdout0_93ck1990 FIND v(dout0_93) AT=1000.025n

.meas tran vdout0_94ck1990 FIND v(dout0_94) AT=1000.025n

.meas tran vdout0_95ck1990 FIND v(dout0_95) AT=1000.025n

.meas tran vdout0_96ck1990 FIND v(dout0_96) AT=1000.025n

.meas tran vdout0_97ck1990 FIND v(dout0_97) AT=1000.025n

.meas tran vdout0_98ck1990 FIND v(dout0_98) AT=1000.025n

.meas tran vdout0_99ck1990 FIND v(dout0_99) AT=1000.025n

.meas tran vdout0_100ck1990 FIND v(dout0_100) AT=1000.025n

.meas tran vdout0_101ck1990 FIND v(dout0_101) AT=1000.025n

.meas tran vdout0_102ck1990 FIND v(dout0_102) AT=1000.025n

.meas tran vdout0_103ck1990 FIND v(dout0_103) AT=1000.025n

.meas tran vdout0_104ck1990 FIND v(dout0_104) AT=1000.025n

.meas tran vdout0_105ck1990 FIND v(dout0_105) AT=1000.025n

.meas tran vdout0_106ck1990 FIND v(dout0_106) AT=1000.025n

.meas tran vdout0_107ck1990 FIND v(dout0_107) AT=1000.025n

.meas tran vdout0_108ck1990 FIND v(dout0_108) AT=1000.025n

.meas tran vdout0_109ck1990 FIND v(dout0_109) AT=1000.025n

.meas tran vdout0_110ck1990 FIND v(dout0_110) AT=1000.025n

.meas tran vdout0_111ck1990 FIND v(dout0_111) AT=1000.025n

.meas tran vdout0_112ck1990 FIND v(dout0_112) AT=1000.025n

.meas tran vdout0_113ck1990 FIND v(dout0_113) AT=1000.025n

.meas tran vdout0_114ck1990 FIND v(dout0_114) AT=1000.025n

.meas tran vdout0_115ck1990 FIND v(dout0_115) AT=1000.025n

.meas tran vdout0_116ck1990 FIND v(dout0_116) AT=1000.025n

.meas tran vdout0_117ck1990 FIND v(dout0_117) AT=1000.025n

.meas tran vdout0_118ck1990 FIND v(dout0_118) AT=1000.025n

.meas tran vdout0_119ck1990 FIND v(dout0_119) AT=1000.025n

.meas tran vdout0_120ck1990 FIND v(dout0_120) AT=1000.025n

.meas tran vdout0_121ck1990 FIND v(dout0_121) AT=1000.025n

.meas tran vdout0_122ck1990 FIND v(dout0_122) AT=1000.025n

.meas tran vdout0_123ck1990 FIND v(dout0_123) AT=1000.025n

.meas tran vdout0_124ck1990 FIND v(dout0_124) AT=1000.025n

.meas tran vdout0_125ck1990 FIND v(dout0_125) AT=1000.025n

.meas tran vdout0_126ck1990 FIND v(dout0_126) AT=1000.025n

.meas tran vdout0_127ck1990 FIND v(dout0_127) AT=1000.025n

.meas tran vdout0_128ck1990 FIND v(dout0_128) AT=1000.025n

.meas tran vdout0_129ck1990 FIND v(dout0_129) AT=1000.025n

.meas tran vdout0_130ck1990 FIND v(dout0_130) AT=1000.025n

.meas tran vdout0_131ck1990 FIND v(dout0_131) AT=1000.025n

.meas tran vdout0_132ck1990 FIND v(dout0_132) AT=1000.025n

.meas tran vdout0_133ck1990 FIND v(dout0_133) AT=1000.025n

.meas tran vdout0_134ck1990 FIND v(dout0_134) AT=1000.025n

.meas tran vdout0_135ck1990 FIND v(dout0_135) AT=1000.025n

.meas tran vdout0_136ck1990 FIND v(dout0_136) AT=1000.025n

.meas tran vdout0_137ck1990 FIND v(dout0_137) AT=1000.025n

.meas tran vdout0_138ck1990 FIND v(dout0_138) AT=1000.025n

.meas tran vdout0_139ck1990 FIND v(dout0_139) AT=1000.025n

.meas tran vdout0_140ck1990 FIND v(dout0_140) AT=1000.025n

.meas tran vdout0_141ck1990 FIND v(dout0_141) AT=1000.025n

.meas tran vdout0_142ck1990 FIND v(dout0_142) AT=1000.025n

.meas tran vdout0_143ck1990 FIND v(dout0_143) AT=1000.025n

.meas tran vdout0_144ck1990 FIND v(dout0_144) AT=1000.025n

.meas tran vdout0_145ck1990 FIND v(dout0_145) AT=1000.025n

.meas tran vdout0_146ck1990 FIND v(dout0_146) AT=1000.025n

.meas tran vdout0_147ck1990 FIND v(dout0_147) AT=1000.025n

.meas tran vdout0_148ck1990 FIND v(dout0_148) AT=1000.025n

.meas tran vdout0_149ck1990 FIND v(dout0_149) AT=1000.025n

.meas tran vdout0_150ck1990 FIND v(dout0_150) AT=1000.025n

.meas tran vdout0_151ck1990 FIND v(dout0_151) AT=1000.025n

.meas tran vdout0_152ck1990 FIND v(dout0_152) AT=1000.025n

.meas tran vdout0_153ck1990 FIND v(dout0_153) AT=1000.025n

.meas tran vdout0_154ck1990 FIND v(dout0_154) AT=1000.025n

.meas tran vdout0_155ck1990 FIND v(dout0_155) AT=1000.025n

.meas tran vdout0_156ck1990 FIND v(dout0_156) AT=1000.025n

.meas tran vdout0_157ck1990 FIND v(dout0_157) AT=1000.025n

.meas tran vdout0_158ck1990 FIND v(dout0_158) AT=1000.025n

.meas tran vdout0_159ck1990 FIND v(dout0_159) AT=1000.025n

.meas tran vdout0_160ck1990 FIND v(dout0_160) AT=1000.025n

.meas tran vdout0_161ck1990 FIND v(dout0_161) AT=1000.025n

.meas tran vdout0_162ck1990 FIND v(dout0_162) AT=1000.025n

.meas tran vdout0_163ck1990 FIND v(dout0_163) AT=1000.025n

.meas tran vdout0_164ck1990 FIND v(dout0_164) AT=1000.025n

.meas tran vdout0_165ck1990 FIND v(dout0_165) AT=1000.025n

.meas tran vdout0_166ck1990 FIND v(dout0_166) AT=1000.025n

.meas tran vdout0_167ck1990 FIND v(dout0_167) AT=1000.025n

.meas tran vdout0_168ck1990 FIND v(dout0_168) AT=1000.025n

.meas tran vdout0_169ck1990 FIND v(dout0_169) AT=1000.025n

.meas tran vdout0_170ck1990 FIND v(dout0_170) AT=1000.025n

.meas tran vdout0_171ck1990 FIND v(dout0_171) AT=1000.025n

.meas tran vdout0_172ck1990 FIND v(dout0_172) AT=1000.025n

.meas tran vdout0_173ck1990 FIND v(dout0_173) AT=1000.025n

.meas tran vdout0_174ck1990 FIND v(dout0_174) AT=1000.025n

.meas tran vdout0_175ck1990 FIND v(dout0_175) AT=1000.025n

.meas tran vdout0_176ck1990 FIND v(dout0_176) AT=1000.025n

.meas tran vdout0_177ck1990 FIND v(dout0_177) AT=1000.025n

.meas tran vdout0_178ck1990 FIND v(dout0_178) AT=1000.025n

.meas tran vdout0_179ck1990 FIND v(dout0_179) AT=1000.025n

.meas tran vdout0_180ck1990 FIND v(dout0_180) AT=1000.025n

.meas tran vdout0_181ck1990 FIND v(dout0_181) AT=1000.025n

.meas tran vdout0_182ck1990 FIND v(dout0_182) AT=1000.025n

.meas tran vdout0_183ck1990 FIND v(dout0_183) AT=1000.025n

.meas tran vdout0_184ck1990 FIND v(dout0_184) AT=1000.025n

.meas tran vdout0_185ck1990 FIND v(dout0_185) AT=1000.025n

.meas tran vdout0_186ck1990 FIND v(dout0_186) AT=1000.025n

.meas tran vdout0_187ck1990 FIND v(dout0_187) AT=1000.025n

.meas tran vdout0_188ck1990 FIND v(dout0_188) AT=1000.025n

.meas tran vdout0_189ck1990 FIND v(dout0_189) AT=1000.025n

.meas tran vdout0_190ck1990 FIND v(dout0_190) AT=1000.025n

.meas tran vdout0_191ck1990 FIND v(dout0_191) AT=1000.025n

.meas tran vdout0_192ck1990 FIND v(dout0_192) AT=1000.025n

.meas tran vdout0_193ck1990 FIND v(dout0_193) AT=1000.025n

.meas tran vdout0_194ck1990 FIND v(dout0_194) AT=1000.025n

.meas tran vdout0_195ck1990 FIND v(dout0_195) AT=1000.025n

.meas tran vdout0_196ck1990 FIND v(dout0_196) AT=1000.025n

.meas tran vdout0_197ck1990 FIND v(dout0_197) AT=1000.025n

.meas tran vdout0_198ck1990 FIND v(dout0_198) AT=1000.025n

.meas tran vdout0_199ck1990 FIND v(dout0_199) AT=1000.025n

.meas tran vdout0_200ck1990 FIND v(dout0_200) AT=1000.025n

.meas tran vdout0_201ck1990 FIND v(dout0_201) AT=1000.025n

.meas tran vdout0_202ck1990 FIND v(dout0_202) AT=1000.025n

.meas tran vdout0_203ck1990 FIND v(dout0_203) AT=1000.025n

.meas tran vdout0_204ck1990 FIND v(dout0_204) AT=1000.025n

.meas tran vdout0_205ck1990 FIND v(dout0_205) AT=1000.025n

.meas tran vdout0_206ck1990 FIND v(dout0_206) AT=1000.025n

.meas tran vdout0_207ck1990 FIND v(dout0_207) AT=1000.025n

.meas tran vdout0_208ck1990 FIND v(dout0_208) AT=1000.025n

.meas tran vdout0_209ck1990 FIND v(dout0_209) AT=1000.025n

.meas tran vdout0_210ck1990 FIND v(dout0_210) AT=1000.025n

.meas tran vdout0_211ck1990 FIND v(dout0_211) AT=1000.025n

.meas tran vdout0_212ck1990 FIND v(dout0_212) AT=1000.025n

.meas tran vdout0_213ck1990 FIND v(dout0_213) AT=1000.025n

.meas tran vdout0_214ck1990 FIND v(dout0_214) AT=1000.025n

.meas tran vdout0_215ck1990 FIND v(dout0_215) AT=1000.025n

.meas tran vdout0_216ck1990 FIND v(dout0_216) AT=1000.025n

.meas tran vdout0_217ck1990 FIND v(dout0_217) AT=1000.025n

.meas tran vdout0_218ck1990 FIND v(dout0_218) AT=1000.025n

.meas tran vdout0_219ck1990 FIND v(dout0_219) AT=1000.025n

.meas tran vdout0_220ck1990 FIND v(dout0_220) AT=1000.025n

.meas tran vdout0_221ck1990 FIND v(dout0_221) AT=1000.025n

.meas tran vdout0_222ck1990 FIND v(dout0_222) AT=1000.025n

.meas tran vdout0_223ck1990 FIND v(dout0_223) AT=1000.025n

.meas tran vdout0_224ck1990 FIND v(dout0_224) AT=1000.025n

.meas tran vdout0_225ck1990 FIND v(dout0_225) AT=1000.025n

.meas tran vdout0_226ck1990 FIND v(dout0_226) AT=1000.025n

.meas tran vdout0_227ck1990 FIND v(dout0_227) AT=1000.025n

.meas tran vdout0_228ck1990 FIND v(dout0_228) AT=1000.025n

.meas tran vdout0_229ck1990 FIND v(dout0_229) AT=1000.025n

.meas tran vdout0_230ck1990 FIND v(dout0_230) AT=1000.025n

.meas tran vdout0_231ck1990 FIND v(dout0_231) AT=1000.025n

.meas tran vdout0_232ck1990 FIND v(dout0_232) AT=1000.025n

.meas tran vdout0_233ck1990 FIND v(dout0_233) AT=1000.025n

.meas tran vdout0_234ck1990 FIND v(dout0_234) AT=1000.025n

.meas tran vdout0_235ck1990 FIND v(dout0_235) AT=1000.025n

.meas tran vdout0_236ck1990 FIND v(dout0_236) AT=1000.025n

.meas tran vdout0_237ck1990 FIND v(dout0_237) AT=1000.025n

.meas tran vdout0_238ck1990 FIND v(dout0_238) AT=1000.025n

.meas tran vdout0_239ck1990 FIND v(dout0_239) AT=1000.025n

.meas tran vdout0_240ck1990 FIND v(dout0_240) AT=1000.025n

.meas tran vdout0_241ck1990 FIND v(dout0_241) AT=1000.025n

.meas tran vdout0_242ck1990 FIND v(dout0_242) AT=1000.025n

.meas tran vdout0_243ck1990 FIND v(dout0_243) AT=1000.025n

.meas tran vdout0_244ck1990 FIND v(dout0_244) AT=1000.025n

.meas tran vdout0_245ck1990 FIND v(dout0_245) AT=1000.025n

.meas tran vdout0_246ck1990 FIND v(dout0_246) AT=1000.025n

.meas tran vdout0_247ck1990 FIND v(dout0_247) AT=1000.025n

.meas tran vdout0_248ck1990 FIND v(dout0_248) AT=1000.025n

.meas tran vdout0_249ck1990 FIND v(dout0_249) AT=1000.025n

.meas tran vdout0_250ck1990 FIND v(dout0_250) AT=1000.025n

.meas tran vdout0_251ck1990 FIND v(dout0_251) AT=1000.025n

.meas tran vdout0_252ck1990 FIND v(dout0_252) AT=1000.025n

.meas tran vdout0_253ck1990 FIND v(dout0_253) AT=1000.025n

.meas tran vdout0_254ck1990 FIND v(dout0_254) AT=1000.025n

.meas tran vdout0_255ck1990 FIND v(dout0_255) AT=1000.025n

.meas tran vdout0_0ck2000 FIND v(dout0_0) AT=1005.025n

.meas tran vdout0_1ck2000 FIND v(dout0_1) AT=1005.025n

.meas tran vdout0_2ck2000 FIND v(dout0_2) AT=1005.025n

.meas tran vdout0_3ck2000 FIND v(dout0_3) AT=1005.025n

.meas tran vdout0_4ck2000 FIND v(dout0_4) AT=1005.025n

.meas tran vdout0_5ck2000 FIND v(dout0_5) AT=1005.025n

.meas tran vdout0_6ck2000 FIND v(dout0_6) AT=1005.025n

.meas tran vdout0_7ck2000 FIND v(dout0_7) AT=1005.025n

.meas tran vdout0_8ck2000 FIND v(dout0_8) AT=1005.025n

.meas tran vdout0_9ck2000 FIND v(dout0_9) AT=1005.025n

.meas tran vdout0_10ck2000 FIND v(dout0_10) AT=1005.025n

.meas tran vdout0_11ck2000 FIND v(dout0_11) AT=1005.025n

.meas tran vdout0_12ck2000 FIND v(dout0_12) AT=1005.025n

.meas tran vdout0_13ck2000 FIND v(dout0_13) AT=1005.025n

.meas tran vdout0_14ck2000 FIND v(dout0_14) AT=1005.025n

.meas tran vdout0_15ck2000 FIND v(dout0_15) AT=1005.025n

.meas tran vdout0_16ck2000 FIND v(dout0_16) AT=1005.025n

.meas tran vdout0_17ck2000 FIND v(dout0_17) AT=1005.025n

.meas tran vdout0_18ck2000 FIND v(dout0_18) AT=1005.025n

.meas tran vdout0_19ck2000 FIND v(dout0_19) AT=1005.025n

.meas tran vdout0_20ck2000 FIND v(dout0_20) AT=1005.025n

.meas tran vdout0_21ck2000 FIND v(dout0_21) AT=1005.025n

.meas tran vdout0_22ck2000 FIND v(dout0_22) AT=1005.025n

.meas tran vdout0_23ck2000 FIND v(dout0_23) AT=1005.025n

.meas tran vdout0_24ck2000 FIND v(dout0_24) AT=1005.025n

.meas tran vdout0_25ck2000 FIND v(dout0_25) AT=1005.025n

.meas tran vdout0_26ck2000 FIND v(dout0_26) AT=1005.025n

.meas tran vdout0_27ck2000 FIND v(dout0_27) AT=1005.025n

.meas tran vdout0_28ck2000 FIND v(dout0_28) AT=1005.025n

.meas tran vdout0_29ck2000 FIND v(dout0_29) AT=1005.025n

.meas tran vdout0_30ck2000 FIND v(dout0_30) AT=1005.025n

.meas tran vdout0_31ck2000 FIND v(dout0_31) AT=1005.025n

.meas tran vdout0_32ck2000 FIND v(dout0_32) AT=1005.025n

.meas tran vdout0_33ck2000 FIND v(dout0_33) AT=1005.025n

.meas tran vdout0_34ck2000 FIND v(dout0_34) AT=1005.025n

.meas tran vdout0_35ck2000 FIND v(dout0_35) AT=1005.025n

.meas tran vdout0_36ck2000 FIND v(dout0_36) AT=1005.025n

.meas tran vdout0_37ck2000 FIND v(dout0_37) AT=1005.025n

.meas tran vdout0_38ck2000 FIND v(dout0_38) AT=1005.025n

.meas tran vdout0_39ck2000 FIND v(dout0_39) AT=1005.025n

.meas tran vdout0_40ck2000 FIND v(dout0_40) AT=1005.025n

.meas tran vdout0_41ck2000 FIND v(dout0_41) AT=1005.025n

.meas tran vdout0_42ck2000 FIND v(dout0_42) AT=1005.025n

.meas tran vdout0_43ck2000 FIND v(dout0_43) AT=1005.025n

.meas tran vdout0_44ck2000 FIND v(dout0_44) AT=1005.025n

.meas tran vdout0_45ck2000 FIND v(dout0_45) AT=1005.025n

.meas tran vdout0_46ck2000 FIND v(dout0_46) AT=1005.025n

.meas tran vdout0_47ck2000 FIND v(dout0_47) AT=1005.025n

.meas tran vdout0_48ck2000 FIND v(dout0_48) AT=1005.025n

.meas tran vdout0_49ck2000 FIND v(dout0_49) AT=1005.025n

.meas tran vdout0_50ck2000 FIND v(dout0_50) AT=1005.025n

.meas tran vdout0_51ck2000 FIND v(dout0_51) AT=1005.025n

.meas tran vdout0_52ck2000 FIND v(dout0_52) AT=1005.025n

.meas tran vdout0_53ck2000 FIND v(dout0_53) AT=1005.025n

.meas tran vdout0_54ck2000 FIND v(dout0_54) AT=1005.025n

.meas tran vdout0_55ck2000 FIND v(dout0_55) AT=1005.025n

.meas tran vdout0_56ck2000 FIND v(dout0_56) AT=1005.025n

.meas tran vdout0_57ck2000 FIND v(dout0_57) AT=1005.025n

.meas tran vdout0_58ck2000 FIND v(dout0_58) AT=1005.025n

.meas tran vdout0_59ck2000 FIND v(dout0_59) AT=1005.025n

.meas tran vdout0_60ck2000 FIND v(dout0_60) AT=1005.025n

.meas tran vdout0_61ck2000 FIND v(dout0_61) AT=1005.025n

.meas tran vdout0_62ck2000 FIND v(dout0_62) AT=1005.025n

.meas tran vdout0_63ck2000 FIND v(dout0_63) AT=1005.025n

.meas tran vdout0_64ck2000 FIND v(dout0_64) AT=1005.025n

.meas tran vdout0_65ck2000 FIND v(dout0_65) AT=1005.025n

.meas tran vdout0_66ck2000 FIND v(dout0_66) AT=1005.025n

.meas tran vdout0_67ck2000 FIND v(dout0_67) AT=1005.025n

.meas tran vdout0_68ck2000 FIND v(dout0_68) AT=1005.025n

.meas tran vdout0_69ck2000 FIND v(dout0_69) AT=1005.025n

.meas tran vdout0_70ck2000 FIND v(dout0_70) AT=1005.025n

.meas tran vdout0_71ck2000 FIND v(dout0_71) AT=1005.025n

.meas tran vdout0_72ck2000 FIND v(dout0_72) AT=1005.025n

.meas tran vdout0_73ck2000 FIND v(dout0_73) AT=1005.025n

.meas tran vdout0_74ck2000 FIND v(dout0_74) AT=1005.025n

.meas tran vdout0_75ck2000 FIND v(dout0_75) AT=1005.025n

.meas tran vdout0_76ck2000 FIND v(dout0_76) AT=1005.025n

.meas tran vdout0_77ck2000 FIND v(dout0_77) AT=1005.025n

.meas tran vdout0_78ck2000 FIND v(dout0_78) AT=1005.025n

.meas tran vdout0_79ck2000 FIND v(dout0_79) AT=1005.025n

.meas tran vdout0_80ck2000 FIND v(dout0_80) AT=1005.025n

.meas tran vdout0_81ck2000 FIND v(dout0_81) AT=1005.025n

.meas tran vdout0_82ck2000 FIND v(dout0_82) AT=1005.025n

.meas tran vdout0_83ck2000 FIND v(dout0_83) AT=1005.025n

.meas tran vdout0_84ck2000 FIND v(dout0_84) AT=1005.025n

.meas tran vdout0_85ck2000 FIND v(dout0_85) AT=1005.025n

.meas tran vdout0_86ck2000 FIND v(dout0_86) AT=1005.025n

.meas tran vdout0_87ck2000 FIND v(dout0_87) AT=1005.025n

.meas tran vdout0_88ck2000 FIND v(dout0_88) AT=1005.025n

.meas tran vdout0_89ck2000 FIND v(dout0_89) AT=1005.025n

.meas tran vdout0_90ck2000 FIND v(dout0_90) AT=1005.025n

.meas tran vdout0_91ck2000 FIND v(dout0_91) AT=1005.025n

.meas tran vdout0_92ck2000 FIND v(dout0_92) AT=1005.025n

.meas tran vdout0_93ck2000 FIND v(dout0_93) AT=1005.025n

.meas tran vdout0_94ck2000 FIND v(dout0_94) AT=1005.025n

.meas tran vdout0_95ck2000 FIND v(dout0_95) AT=1005.025n

.meas tran vdout0_96ck2000 FIND v(dout0_96) AT=1005.025n

.meas tran vdout0_97ck2000 FIND v(dout0_97) AT=1005.025n

.meas tran vdout0_98ck2000 FIND v(dout0_98) AT=1005.025n

.meas tran vdout0_99ck2000 FIND v(dout0_99) AT=1005.025n

.meas tran vdout0_100ck2000 FIND v(dout0_100) AT=1005.025n

.meas tran vdout0_101ck2000 FIND v(dout0_101) AT=1005.025n

.meas tran vdout0_102ck2000 FIND v(dout0_102) AT=1005.025n

.meas tran vdout0_103ck2000 FIND v(dout0_103) AT=1005.025n

.meas tran vdout0_104ck2000 FIND v(dout0_104) AT=1005.025n

.meas tran vdout0_105ck2000 FIND v(dout0_105) AT=1005.025n

.meas tran vdout0_106ck2000 FIND v(dout0_106) AT=1005.025n

.meas tran vdout0_107ck2000 FIND v(dout0_107) AT=1005.025n

.meas tran vdout0_108ck2000 FIND v(dout0_108) AT=1005.025n

.meas tran vdout0_109ck2000 FIND v(dout0_109) AT=1005.025n

.meas tran vdout0_110ck2000 FIND v(dout0_110) AT=1005.025n

.meas tran vdout0_111ck2000 FIND v(dout0_111) AT=1005.025n

.meas tran vdout0_112ck2000 FIND v(dout0_112) AT=1005.025n

.meas tran vdout0_113ck2000 FIND v(dout0_113) AT=1005.025n

.meas tran vdout0_114ck2000 FIND v(dout0_114) AT=1005.025n

.meas tran vdout0_115ck2000 FIND v(dout0_115) AT=1005.025n

.meas tran vdout0_116ck2000 FIND v(dout0_116) AT=1005.025n

.meas tran vdout0_117ck2000 FIND v(dout0_117) AT=1005.025n

.meas tran vdout0_118ck2000 FIND v(dout0_118) AT=1005.025n

.meas tran vdout0_119ck2000 FIND v(dout0_119) AT=1005.025n

.meas tran vdout0_120ck2000 FIND v(dout0_120) AT=1005.025n

.meas tran vdout0_121ck2000 FIND v(dout0_121) AT=1005.025n

.meas tran vdout0_122ck2000 FIND v(dout0_122) AT=1005.025n

.meas tran vdout0_123ck2000 FIND v(dout0_123) AT=1005.025n

.meas tran vdout0_124ck2000 FIND v(dout0_124) AT=1005.025n

.meas tran vdout0_125ck2000 FIND v(dout0_125) AT=1005.025n

.meas tran vdout0_126ck2000 FIND v(dout0_126) AT=1005.025n

.meas tran vdout0_127ck2000 FIND v(dout0_127) AT=1005.025n

.meas tran vdout0_128ck2000 FIND v(dout0_128) AT=1005.025n

.meas tran vdout0_129ck2000 FIND v(dout0_129) AT=1005.025n

.meas tran vdout0_130ck2000 FIND v(dout0_130) AT=1005.025n

.meas tran vdout0_131ck2000 FIND v(dout0_131) AT=1005.025n

.meas tran vdout0_132ck2000 FIND v(dout0_132) AT=1005.025n

.meas tran vdout0_133ck2000 FIND v(dout0_133) AT=1005.025n

.meas tran vdout0_134ck2000 FIND v(dout0_134) AT=1005.025n

.meas tran vdout0_135ck2000 FIND v(dout0_135) AT=1005.025n

.meas tran vdout0_136ck2000 FIND v(dout0_136) AT=1005.025n

.meas tran vdout0_137ck2000 FIND v(dout0_137) AT=1005.025n

.meas tran vdout0_138ck2000 FIND v(dout0_138) AT=1005.025n

.meas tran vdout0_139ck2000 FIND v(dout0_139) AT=1005.025n

.meas tran vdout0_140ck2000 FIND v(dout0_140) AT=1005.025n

.meas tran vdout0_141ck2000 FIND v(dout0_141) AT=1005.025n

.meas tran vdout0_142ck2000 FIND v(dout0_142) AT=1005.025n

.meas tran vdout0_143ck2000 FIND v(dout0_143) AT=1005.025n

.meas tran vdout0_144ck2000 FIND v(dout0_144) AT=1005.025n

.meas tran vdout0_145ck2000 FIND v(dout0_145) AT=1005.025n

.meas tran vdout0_146ck2000 FIND v(dout0_146) AT=1005.025n

.meas tran vdout0_147ck2000 FIND v(dout0_147) AT=1005.025n

.meas tran vdout0_148ck2000 FIND v(dout0_148) AT=1005.025n

.meas tran vdout0_149ck2000 FIND v(dout0_149) AT=1005.025n

.meas tran vdout0_150ck2000 FIND v(dout0_150) AT=1005.025n

.meas tran vdout0_151ck2000 FIND v(dout0_151) AT=1005.025n

.meas tran vdout0_152ck2000 FIND v(dout0_152) AT=1005.025n

.meas tran vdout0_153ck2000 FIND v(dout0_153) AT=1005.025n

.meas tran vdout0_154ck2000 FIND v(dout0_154) AT=1005.025n

.meas tran vdout0_155ck2000 FIND v(dout0_155) AT=1005.025n

.meas tran vdout0_156ck2000 FIND v(dout0_156) AT=1005.025n

.meas tran vdout0_157ck2000 FIND v(dout0_157) AT=1005.025n

.meas tran vdout0_158ck2000 FIND v(dout0_158) AT=1005.025n

.meas tran vdout0_159ck2000 FIND v(dout0_159) AT=1005.025n

.meas tran vdout0_160ck2000 FIND v(dout0_160) AT=1005.025n

.meas tran vdout0_161ck2000 FIND v(dout0_161) AT=1005.025n

.meas tran vdout0_162ck2000 FIND v(dout0_162) AT=1005.025n

.meas tran vdout0_163ck2000 FIND v(dout0_163) AT=1005.025n

.meas tran vdout0_164ck2000 FIND v(dout0_164) AT=1005.025n

.meas tran vdout0_165ck2000 FIND v(dout0_165) AT=1005.025n

.meas tran vdout0_166ck2000 FIND v(dout0_166) AT=1005.025n

.meas tran vdout0_167ck2000 FIND v(dout0_167) AT=1005.025n

.meas tran vdout0_168ck2000 FIND v(dout0_168) AT=1005.025n

.meas tran vdout0_169ck2000 FIND v(dout0_169) AT=1005.025n

.meas tran vdout0_170ck2000 FIND v(dout0_170) AT=1005.025n

.meas tran vdout0_171ck2000 FIND v(dout0_171) AT=1005.025n

.meas tran vdout0_172ck2000 FIND v(dout0_172) AT=1005.025n

.meas tran vdout0_173ck2000 FIND v(dout0_173) AT=1005.025n

.meas tran vdout0_174ck2000 FIND v(dout0_174) AT=1005.025n

.meas tran vdout0_175ck2000 FIND v(dout0_175) AT=1005.025n

.meas tran vdout0_176ck2000 FIND v(dout0_176) AT=1005.025n

.meas tran vdout0_177ck2000 FIND v(dout0_177) AT=1005.025n

.meas tran vdout0_178ck2000 FIND v(dout0_178) AT=1005.025n

.meas tran vdout0_179ck2000 FIND v(dout0_179) AT=1005.025n

.meas tran vdout0_180ck2000 FIND v(dout0_180) AT=1005.025n

.meas tran vdout0_181ck2000 FIND v(dout0_181) AT=1005.025n

.meas tran vdout0_182ck2000 FIND v(dout0_182) AT=1005.025n

.meas tran vdout0_183ck2000 FIND v(dout0_183) AT=1005.025n

.meas tran vdout0_184ck2000 FIND v(dout0_184) AT=1005.025n

.meas tran vdout0_185ck2000 FIND v(dout0_185) AT=1005.025n

.meas tran vdout0_186ck2000 FIND v(dout0_186) AT=1005.025n

.meas tran vdout0_187ck2000 FIND v(dout0_187) AT=1005.025n

.meas tran vdout0_188ck2000 FIND v(dout0_188) AT=1005.025n

.meas tran vdout0_189ck2000 FIND v(dout0_189) AT=1005.025n

.meas tran vdout0_190ck2000 FIND v(dout0_190) AT=1005.025n

.meas tran vdout0_191ck2000 FIND v(dout0_191) AT=1005.025n

.meas tran vdout0_192ck2000 FIND v(dout0_192) AT=1005.025n

.meas tran vdout0_193ck2000 FIND v(dout0_193) AT=1005.025n

.meas tran vdout0_194ck2000 FIND v(dout0_194) AT=1005.025n

.meas tran vdout0_195ck2000 FIND v(dout0_195) AT=1005.025n

.meas tran vdout0_196ck2000 FIND v(dout0_196) AT=1005.025n

.meas tran vdout0_197ck2000 FIND v(dout0_197) AT=1005.025n

.meas tran vdout0_198ck2000 FIND v(dout0_198) AT=1005.025n

.meas tran vdout0_199ck2000 FIND v(dout0_199) AT=1005.025n

.meas tran vdout0_200ck2000 FIND v(dout0_200) AT=1005.025n

.meas tran vdout0_201ck2000 FIND v(dout0_201) AT=1005.025n

.meas tran vdout0_202ck2000 FIND v(dout0_202) AT=1005.025n

.meas tran vdout0_203ck2000 FIND v(dout0_203) AT=1005.025n

.meas tran vdout0_204ck2000 FIND v(dout0_204) AT=1005.025n

.meas tran vdout0_205ck2000 FIND v(dout0_205) AT=1005.025n

.meas tran vdout0_206ck2000 FIND v(dout0_206) AT=1005.025n

.meas tran vdout0_207ck2000 FIND v(dout0_207) AT=1005.025n

.meas tran vdout0_208ck2000 FIND v(dout0_208) AT=1005.025n

.meas tran vdout0_209ck2000 FIND v(dout0_209) AT=1005.025n

.meas tran vdout0_210ck2000 FIND v(dout0_210) AT=1005.025n

.meas tran vdout0_211ck2000 FIND v(dout0_211) AT=1005.025n

.meas tran vdout0_212ck2000 FIND v(dout0_212) AT=1005.025n

.meas tran vdout0_213ck2000 FIND v(dout0_213) AT=1005.025n

.meas tran vdout0_214ck2000 FIND v(dout0_214) AT=1005.025n

.meas tran vdout0_215ck2000 FIND v(dout0_215) AT=1005.025n

.meas tran vdout0_216ck2000 FIND v(dout0_216) AT=1005.025n

.meas tran vdout0_217ck2000 FIND v(dout0_217) AT=1005.025n

.meas tran vdout0_218ck2000 FIND v(dout0_218) AT=1005.025n

.meas tran vdout0_219ck2000 FIND v(dout0_219) AT=1005.025n

.meas tran vdout0_220ck2000 FIND v(dout0_220) AT=1005.025n

.meas tran vdout0_221ck2000 FIND v(dout0_221) AT=1005.025n

.meas tran vdout0_222ck2000 FIND v(dout0_222) AT=1005.025n

.meas tran vdout0_223ck2000 FIND v(dout0_223) AT=1005.025n

.meas tran vdout0_224ck2000 FIND v(dout0_224) AT=1005.025n

.meas tran vdout0_225ck2000 FIND v(dout0_225) AT=1005.025n

.meas tran vdout0_226ck2000 FIND v(dout0_226) AT=1005.025n

.meas tran vdout0_227ck2000 FIND v(dout0_227) AT=1005.025n

.meas tran vdout0_228ck2000 FIND v(dout0_228) AT=1005.025n

.meas tran vdout0_229ck2000 FIND v(dout0_229) AT=1005.025n

.meas tran vdout0_230ck2000 FIND v(dout0_230) AT=1005.025n

.meas tran vdout0_231ck2000 FIND v(dout0_231) AT=1005.025n

.meas tran vdout0_232ck2000 FIND v(dout0_232) AT=1005.025n

.meas tran vdout0_233ck2000 FIND v(dout0_233) AT=1005.025n

.meas tran vdout0_234ck2000 FIND v(dout0_234) AT=1005.025n

.meas tran vdout0_235ck2000 FIND v(dout0_235) AT=1005.025n

.meas tran vdout0_236ck2000 FIND v(dout0_236) AT=1005.025n

.meas tran vdout0_237ck2000 FIND v(dout0_237) AT=1005.025n

.meas tran vdout0_238ck2000 FIND v(dout0_238) AT=1005.025n

.meas tran vdout0_239ck2000 FIND v(dout0_239) AT=1005.025n

.meas tran vdout0_240ck2000 FIND v(dout0_240) AT=1005.025n

.meas tran vdout0_241ck2000 FIND v(dout0_241) AT=1005.025n

.meas tran vdout0_242ck2000 FIND v(dout0_242) AT=1005.025n

.meas tran vdout0_243ck2000 FIND v(dout0_243) AT=1005.025n

.meas tran vdout0_244ck2000 FIND v(dout0_244) AT=1005.025n

.meas tran vdout0_245ck2000 FIND v(dout0_245) AT=1005.025n

.meas tran vdout0_246ck2000 FIND v(dout0_246) AT=1005.025n

.meas tran vdout0_247ck2000 FIND v(dout0_247) AT=1005.025n

.meas tran vdout0_248ck2000 FIND v(dout0_248) AT=1005.025n

.meas tran vdout0_249ck2000 FIND v(dout0_249) AT=1005.025n

.meas tran vdout0_250ck2000 FIND v(dout0_250) AT=1005.025n

.meas tran vdout0_251ck2000 FIND v(dout0_251) AT=1005.025n

.meas tran vdout0_252ck2000 FIND v(dout0_252) AT=1005.025n

.meas tran vdout0_253ck2000 FIND v(dout0_253) AT=1005.025n

.meas tran vdout0_254ck2000 FIND v(dout0_254) AT=1005.025n

.meas tran vdout0_255ck2000 FIND v(dout0_255) AT=1005.025n

.meas tran vdout0_0ck2040 FIND v(dout0_0) AT=1025.025n

.meas tran vdout0_1ck2040 FIND v(dout0_1) AT=1025.025n

.meas tran vdout0_2ck2040 FIND v(dout0_2) AT=1025.025n

.meas tran vdout0_3ck2040 FIND v(dout0_3) AT=1025.025n

.meas tran vdout0_4ck2040 FIND v(dout0_4) AT=1025.025n

.meas tran vdout0_5ck2040 FIND v(dout0_5) AT=1025.025n

.meas tran vdout0_6ck2040 FIND v(dout0_6) AT=1025.025n

.meas tran vdout0_7ck2040 FIND v(dout0_7) AT=1025.025n

.meas tran vdout0_8ck2040 FIND v(dout0_8) AT=1025.025n

.meas tran vdout0_9ck2040 FIND v(dout0_9) AT=1025.025n

.meas tran vdout0_10ck2040 FIND v(dout0_10) AT=1025.025n

.meas tran vdout0_11ck2040 FIND v(dout0_11) AT=1025.025n

.meas tran vdout0_12ck2040 FIND v(dout0_12) AT=1025.025n

.meas tran vdout0_13ck2040 FIND v(dout0_13) AT=1025.025n

.meas tran vdout0_14ck2040 FIND v(dout0_14) AT=1025.025n

.meas tran vdout0_15ck2040 FIND v(dout0_15) AT=1025.025n

.meas tran vdout0_16ck2040 FIND v(dout0_16) AT=1025.025n

.meas tran vdout0_17ck2040 FIND v(dout0_17) AT=1025.025n

.meas tran vdout0_18ck2040 FIND v(dout0_18) AT=1025.025n

.meas tran vdout0_19ck2040 FIND v(dout0_19) AT=1025.025n

.meas tran vdout0_20ck2040 FIND v(dout0_20) AT=1025.025n

.meas tran vdout0_21ck2040 FIND v(dout0_21) AT=1025.025n

.meas tran vdout0_22ck2040 FIND v(dout0_22) AT=1025.025n

.meas tran vdout0_23ck2040 FIND v(dout0_23) AT=1025.025n

.meas tran vdout0_24ck2040 FIND v(dout0_24) AT=1025.025n

.meas tran vdout0_25ck2040 FIND v(dout0_25) AT=1025.025n

.meas tran vdout0_26ck2040 FIND v(dout0_26) AT=1025.025n

.meas tran vdout0_27ck2040 FIND v(dout0_27) AT=1025.025n

.meas tran vdout0_28ck2040 FIND v(dout0_28) AT=1025.025n

.meas tran vdout0_29ck2040 FIND v(dout0_29) AT=1025.025n

.meas tran vdout0_30ck2040 FIND v(dout0_30) AT=1025.025n

.meas tran vdout0_31ck2040 FIND v(dout0_31) AT=1025.025n

.meas tran vdout0_32ck2040 FIND v(dout0_32) AT=1025.025n

.meas tran vdout0_33ck2040 FIND v(dout0_33) AT=1025.025n

.meas tran vdout0_34ck2040 FIND v(dout0_34) AT=1025.025n

.meas tran vdout0_35ck2040 FIND v(dout0_35) AT=1025.025n

.meas tran vdout0_36ck2040 FIND v(dout0_36) AT=1025.025n

.meas tran vdout0_37ck2040 FIND v(dout0_37) AT=1025.025n

.meas tran vdout0_38ck2040 FIND v(dout0_38) AT=1025.025n

.meas tran vdout0_39ck2040 FIND v(dout0_39) AT=1025.025n

.meas tran vdout0_40ck2040 FIND v(dout0_40) AT=1025.025n

.meas tran vdout0_41ck2040 FIND v(dout0_41) AT=1025.025n

.meas tran vdout0_42ck2040 FIND v(dout0_42) AT=1025.025n

.meas tran vdout0_43ck2040 FIND v(dout0_43) AT=1025.025n

.meas tran vdout0_44ck2040 FIND v(dout0_44) AT=1025.025n

.meas tran vdout0_45ck2040 FIND v(dout0_45) AT=1025.025n

.meas tran vdout0_46ck2040 FIND v(dout0_46) AT=1025.025n

.meas tran vdout0_47ck2040 FIND v(dout0_47) AT=1025.025n

.meas tran vdout0_48ck2040 FIND v(dout0_48) AT=1025.025n

.meas tran vdout0_49ck2040 FIND v(dout0_49) AT=1025.025n

.meas tran vdout0_50ck2040 FIND v(dout0_50) AT=1025.025n

.meas tran vdout0_51ck2040 FIND v(dout0_51) AT=1025.025n

.meas tran vdout0_52ck2040 FIND v(dout0_52) AT=1025.025n

.meas tran vdout0_53ck2040 FIND v(dout0_53) AT=1025.025n

.meas tran vdout0_54ck2040 FIND v(dout0_54) AT=1025.025n

.meas tran vdout0_55ck2040 FIND v(dout0_55) AT=1025.025n

.meas tran vdout0_56ck2040 FIND v(dout0_56) AT=1025.025n

.meas tran vdout0_57ck2040 FIND v(dout0_57) AT=1025.025n

.meas tran vdout0_58ck2040 FIND v(dout0_58) AT=1025.025n

.meas tran vdout0_59ck2040 FIND v(dout0_59) AT=1025.025n

.meas tran vdout0_60ck2040 FIND v(dout0_60) AT=1025.025n

.meas tran vdout0_61ck2040 FIND v(dout0_61) AT=1025.025n

.meas tran vdout0_62ck2040 FIND v(dout0_62) AT=1025.025n

.meas tran vdout0_63ck2040 FIND v(dout0_63) AT=1025.025n

.meas tran vdout0_64ck2040 FIND v(dout0_64) AT=1025.025n

.meas tran vdout0_65ck2040 FIND v(dout0_65) AT=1025.025n

.meas tran vdout0_66ck2040 FIND v(dout0_66) AT=1025.025n

.meas tran vdout0_67ck2040 FIND v(dout0_67) AT=1025.025n

.meas tran vdout0_68ck2040 FIND v(dout0_68) AT=1025.025n

.meas tran vdout0_69ck2040 FIND v(dout0_69) AT=1025.025n

.meas tran vdout0_70ck2040 FIND v(dout0_70) AT=1025.025n

.meas tran vdout0_71ck2040 FIND v(dout0_71) AT=1025.025n

.meas tran vdout0_72ck2040 FIND v(dout0_72) AT=1025.025n

.meas tran vdout0_73ck2040 FIND v(dout0_73) AT=1025.025n

.meas tran vdout0_74ck2040 FIND v(dout0_74) AT=1025.025n

.meas tran vdout0_75ck2040 FIND v(dout0_75) AT=1025.025n

.meas tran vdout0_76ck2040 FIND v(dout0_76) AT=1025.025n

.meas tran vdout0_77ck2040 FIND v(dout0_77) AT=1025.025n

.meas tran vdout0_78ck2040 FIND v(dout0_78) AT=1025.025n

.meas tran vdout0_79ck2040 FIND v(dout0_79) AT=1025.025n

.meas tran vdout0_80ck2040 FIND v(dout0_80) AT=1025.025n

.meas tran vdout0_81ck2040 FIND v(dout0_81) AT=1025.025n

.meas tran vdout0_82ck2040 FIND v(dout0_82) AT=1025.025n

.meas tran vdout0_83ck2040 FIND v(dout0_83) AT=1025.025n

.meas tran vdout0_84ck2040 FIND v(dout0_84) AT=1025.025n

.meas tran vdout0_85ck2040 FIND v(dout0_85) AT=1025.025n

.meas tran vdout0_86ck2040 FIND v(dout0_86) AT=1025.025n

.meas tran vdout0_87ck2040 FIND v(dout0_87) AT=1025.025n

.meas tran vdout0_88ck2040 FIND v(dout0_88) AT=1025.025n

.meas tran vdout0_89ck2040 FIND v(dout0_89) AT=1025.025n

.meas tran vdout0_90ck2040 FIND v(dout0_90) AT=1025.025n

.meas tran vdout0_91ck2040 FIND v(dout0_91) AT=1025.025n

.meas tran vdout0_92ck2040 FIND v(dout0_92) AT=1025.025n

.meas tran vdout0_93ck2040 FIND v(dout0_93) AT=1025.025n

.meas tran vdout0_94ck2040 FIND v(dout0_94) AT=1025.025n

.meas tran vdout0_95ck2040 FIND v(dout0_95) AT=1025.025n

.meas tran vdout0_96ck2040 FIND v(dout0_96) AT=1025.025n

.meas tran vdout0_97ck2040 FIND v(dout0_97) AT=1025.025n

.meas tran vdout0_98ck2040 FIND v(dout0_98) AT=1025.025n

.meas tran vdout0_99ck2040 FIND v(dout0_99) AT=1025.025n

.meas tran vdout0_100ck2040 FIND v(dout0_100) AT=1025.025n

.meas tran vdout0_101ck2040 FIND v(dout0_101) AT=1025.025n

.meas tran vdout0_102ck2040 FIND v(dout0_102) AT=1025.025n

.meas tran vdout0_103ck2040 FIND v(dout0_103) AT=1025.025n

.meas tran vdout0_104ck2040 FIND v(dout0_104) AT=1025.025n

.meas tran vdout0_105ck2040 FIND v(dout0_105) AT=1025.025n

.meas tran vdout0_106ck2040 FIND v(dout0_106) AT=1025.025n

.meas tran vdout0_107ck2040 FIND v(dout0_107) AT=1025.025n

.meas tran vdout0_108ck2040 FIND v(dout0_108) AT=1025.025n

.meas tran vdout0_109ck2040 FIND v(dout0_109) AT=1025.025n

.meas tran vdout0_110ck2040 FIND v(dout0_110) AT=1025.025n

.meas tran vdout0_111ck2040 FIND v(dout0_111) AT=1025.025n

.meas tran vdout0_112ck2040 FIND v(dout0_112) AT=1025.025n

.meas tran vdout0_113ck2040 FIND v(dout0_113) AT=1025.025n

.meas tran vdout0_114ck2040 FIND v(dout0_114) AT=1025.025n

.meas tran vdout0_115ck2040 FIND v(dout0_115) AT=1025.025n

.meas tran vdout0_116ck2040 FIND v(dout0_116) AT=1025.025n

.meas tran vdout0_117ck2040 FIND v(dout0_117) AT=1025.025n

.meas tran vdout0_118ck2040 FIND v(dout0_118) AT=1025.025n

.meas tran vdout0_119ck2040 FIND v(dout0_119) AT=1025.025n

.meas tran vdout0_120ck2040 FIND v(dout0_120) AT=1025.025n

.meas tran vdout0_121ck2040 FIND v(dout0_121) AT=1025.025n

.meas tran vdout0_122ck2040 FIND v(dout0_122) AT=1025.025n

.meas tran vdout0_123ck2040 FIND v(dout0_123) AT=1025.025n

.meas tran vdout0_124ck2040 FIND v(dout0_124) AT=1025.025n

.meas tran vdout0_125ck2040 FIND v(dout0_125) AT=1025.025n

.meas tran vdout0_126ck2040 FIND v(dout0_126) AT=1025.025n

.meas tran vdout0_127ck2040 FIND v(dout0_127) AT=1025.025n

.meas tran vdout0_128ck2040 FIND v(dout0_128) AT=1025.025n

.meas tran vdout0_129ck2040 FIND v(dout0_129) AT=1025.025n

.meas tran vdout0_130ck2040 FIND v(dout0_130) AT=1025.025n

.meas tran vdout0_131ck2040 FIND v(dout0_131) AT=1025.025n

.meas tran vdout0_132ck2040 FIND v(dout0_132) AT=1025.025n

.meas tran vdout0_133ck2040 FIND v(dout0_133) AT=1025.025n

.meas tran vdout0_134ck2040 FIND v(dout0_134) AT=1025.025n

.meas tran vdout0_135ck2040 FIND v(dout0_135) AT=1025.025n

.meas tran vdout0_136ck2040 FIND v(dout0_136) AT=1025.025n

.meas tran vdout0_137ck2040 FIND v(dout0_137) AT=1025.025n

.meas tran vdout0_138ck2040 FIND v(dout0_138) AT=1025.025n

.meas tran vdout0_139ck2040 FIND v(dout0_139) AT=1025.025n

.meas tran vdout0_140ck2040 FIND v(dout0_140) AT=1025.025n

.meas tran vdout0_141ck2040 FIND v(dout0_141) AT=1025.025n

.meas tran vdout0_142ck2040 FIND v(dout0_142) AT=1025.025n

.meas tran vdout0_143ck2040 FIND v(dout0_143) AT=1025.025n

.meas tran vdout0_144ck2040 FIND v(dout0_144) AT=1025.025n

.meas tran vdout0_145ck2040 FIND v(dout0_145) AT=1025.025n

.meas tran vdout0_146ck2040 FIND v(dout0_146) AT=1025.025n

.meas tran vdout0_147ck2040 FIND v(dout0_147) AT=1025.025n

.meas tran vdout0_148ck2040 FIND v(dout0_148) AT=1025.025n

.meas tran vdout0_149ck2040 FIND v(dout0_149) AT=1025.025n

.meas tran vdout0_150ck2040 FIND v(dout0_150) AT=1025.025n

.meas tran vdout0_151ck2040 FIND v(dout0_151) AT=1025.025n

.meas tran vdout0_152ck2040 FIND v(dout0_152) AT=1025.025n

.meas tran vdout0_153ck2040 FIND v(dout0_153) AT=1025.025n

.meas tran vdout0_154ck2040 FIND v(dout0_154) AT=1025.025n

.meas tran vdout0_155ck2040 FIND v(dout0_155) AT=1025.025n

.meas tran vdout0_156ck2040 FIND v(dout0_156) AT=1025.025n

.meas tran vdout0_157ck2040 FIND v(dout0_157) AT=1025.025n

.meas tran vdout0_158ck2040 FIND v(dout0_158) AT=1025.025n

.meas tran vdout0_159ck2040 FIND v(dout0_159) AT=1025.025n

.meas tran vdout0_160ck2040 FIND v(dout0_160) AT=1025.025n

.meas tran vdout0_161ck2040 FIND v(dout0_161) AT=1025.025n

.meas tran vdout0_162ck2040 FIND v(dout0_162) AT=1025.025n

.meas tran vdout0_163ck2040 FIND v(dout0_163) AT=1025.025n

.meas tran vdout0_164ck2040 FIND v(dout0_164) AT=1025.025n

.meas tran vdout0_165ck2040 FIND v(dout0_165) AT=1025.025n

.meas tran vdout0_166ck2040 FIND v(dout0_166) AT=1025.025n

.meas tran vdout0_167ck2040 FIND v(dout0_167) AT=1025.025n

.meas tran vdout0_168ck2040 FIND v(dout0_168) AT=1025.025n

.meas tran vdout0_169ck2040 FIND v(dout0_169) AT=1025.025n

.meas tran vdout0_170ck2040 FIND v(dout0_170) AT=1025.025n

.meas tran vdout0_171ck2040 FIND v(dout0_171) AT=1025.025n

.meas tran vdout0_172ck2040 FIND v(dout0_172) AT=1025.025n

.meas tran vdout0_173ck2040 FIND v(dout0_173) AT=1025.025n

.meas tran vdout0_174ck2040 FIND v(dout0_174) AT=1025.025n

.meas tran vdout0_175ck2040 FIND v(dout0_175) AT=1025.025n

.meas tran vdout0_176ck2040 FIND v(dout0_176) AT=1025.025n

.meas tran vdout0_177ck2040 FIND v(dout0_177) AT=1025.025n

.meas tran vdout0_178ck2040 FIND v(dout0_178) AT=1025.025n

.meas tran vdout0_179ck2040 FIND v(dout0_179) AT=1025.025n

.meas tran vdout0_180ck2040 FIND v(dout0_180) AT=1025.025n

.meas tran vdout0_181ck2040 FIND v(dout0_181) AT=1025.025n

.meas tran vdout0_182ck2040 FIND v(dout0_182) AT=1025.025n

.meas tran vdout0_183ck2040 FIND v(dout0_183) AT=1025.025n

.meas tran vdout0_184ck2040 FIND v(dout0_184) AT=1025.025n

.meas tran vdout0_185ck2040 FIND v(dout0_185) AT=1025.025n

.meas tran vdout0_186ck2040 FIND v(dout0_186) AT=1025.025n

.meas tran vdout0_187ck2040 FIND v(dout0_187) AT=1025.025n

.meas tran vdout0_188ck2040 FIND v(dout0_188) AT=1025.025n

.meas tran vdout0_189ck2040 FIND v(dout0_189) AT=1025.025n

.meas tran vdout0_190ck2040 FIND v(dout0_190) AT=1025.025n

.meas tran vdout0_191ck2040 FIND v(dout0_191) AT=1025.025n

.meas tran vdout0_192ck2040 FIND v(dout0_192) AT=1025.025n

.meas tran vdout0_193ck2040 FIND v(dout0_193) AT=1025.025n

.meas tran vdout0_194ck2040 FIND v(dout0_194) AT=1025.025n

.meas tran vdout0_195ck2040 FIND v(dout0_195) AT=1025.025n

.meas tran vdout0_196ck2040 FIND v(dout0_196) AT=1025.025n

.meas tran vdout0_197ck2040 FIND v(dout0_197) AT=1025.025n

.meas tran vdout0_198ck2040 FIND v(dout0_198) AT=1025.025n

.meas tran vdout0_199ck2040 FIND v(dout0_199) AT=1025.025n

.meas tran vdout0_200ck2040 FIND v(dout0_200) AT=1025.025n

.meas tran vdout0_201ck2040 FIND v(dout0_201) AT=1025.025n

.meas tran vdout0_202ck2040 FIND v(dout0_202) AT=1025.025n

.meas tran vdout0_203ck2040 FIND v(dout0_203) AT=1025.025n

.meas tran vdout0_204ck2040 FIND v(dout0_204) AT=1025.025n

.meas tran vdout0_205ck2040 FIND v(dout0_205) AT=1025.025n

.meas tran vdout0_206ck2040 FIND v(dout0_206) AT=1025.025n

.meas tran vdout0_207ck2040 FIND v(dout0_207) AT=1025.025n

.meas tran vdout0_208ck2040 FIND v(dout0_208) AT=1025.025n

.meas tran vdout0_209ck2040 FIND v(dout0_209) AT=1025.025n

.meas tran vdout0_210ck2040 FIND v(dout0_210) AT=1025.025n

.meas tran vdout0_211ck2040 FIND v(dout0_211) AT=1025.025n

.meas tran vdout0_212ck2040 FIND v(dout0_212) AT=1025.025n

.meas tran vdout0_213ck2040 FIND v(dout0_213) AT=1025.025n

.meas tran vdout0_214ck2040 FIND v(dout0_214) AT=1025.025n

.meas tran vdout0_215ck2040 FIND v(dout0_215) AT=1025.025n

.meas tran vdout0_216ck2040 FIND v(dout0_216) AT=1025.025n

.meas tran vdout0_217ck2040 FIND v(dout0_217) AT=1025.025n

.meas tran vdout0_218ck2040 FIND v(dout0_218) AT=1025.025n

.meas tran vdout0_219ck2040 FIND v(dout0_219) AT=1025.025n

.meas tran vdout0_220ck2040 FIND v(dout0_220) AT=1025.025n

.meas tran vdout0_221ck2040 FIND v(dout0_221) AT=1025.025n

.meas tran vdout0_222ck2040 FIND v(dout0_222) AT=1025.025n

.meas tran vdout0_223ck2040 FIND v(dout0_223) AT=1025.025n

.meas tran vdout0_224ck2040 FIND v(dout0_224) AT=1025.025n

.meas tran vdout0_225ck2040 FIND v(dout0_225) AT=1025.025n

.meas tran vdout0_226ck2040 FIND v(dout0_226) AT=1025.025n

.meas tran vdout0_227ck2040 FIND v(dout0_227) AT=1025.025n

.meas tran vdout0_228ck2040 FIND v(dout0_228) AT=1025.025n

.meas tran vdout0_229ck2040 FIND v(dout0_229) AT=1025.025n

.meas tran vdout0_230ck2040 FIND v(dout0_230) AT=1025.025n

.meas tran vdout0_231ck2040 FIND v(dout0_231) AT=1025.025n

.meas tran vdout0_232ck2040 FIND v(dout0_232) AT=1025.025n

.meas tran vdout0_233ck2040 FIND v(dout0_233) AT=1025.025n

.meas tran vdout0_234ck2040 FIND v(dout0_234) AT=1025.025n

.meas tran vdout0_235ck2040 FIND v(dout0_235) AT=1025.025n

.meas tran vdout0_236ck2040 FIND v(dout0_236) AT=1025.025n

.meas tran vdout0_237ck2040 FIND v(dout0_237) AT=1025.025n

.meas tran vdout0_238ck2040 FIND v(dout0_238) AT=1025.025n

.meas tran vdout0_239ck2040 FIND v(dout0_239) AT=1025.025n

.meas tran vdout0_240ck2040 FIND v(dout0_240) AT=1025.025n

.meas tran vdout0_241ck2040 FIND v(dout0_241) AT=1025.025n

.meas tran vdout0_242ck2040 FIND v(dout0_242) AT=1025.025n

.meas tran vdout0_243ck2040 FIND v(dout0_243) AT=1025.025n

.meas tran vdout0_244ck2040 FIND v(dout0_244) AT=1025.025n

.meas tran vdout0_245ck2040 FIND v(dout0_245) AT=1025.025n

.meas tran vdout0_246ck2040 FIND v(dout0_246) AT=1025.025n

.meas tran vdout0_247ck2040 FIND v(dout0_247) AT=1025.025n

.meas tran vdout0_248ck2040 FIND v(dout0_248) AT=1025.025n

.meas tran vdout0_249ck2040 FIND v(dout0_249) AT=1025.025n

.meas tran vdout0_250ck2040 FIND v(dout0_250) AT=1025.025n

.meas tran vdout0_251ck2040 FIND v(dout0_251) AT=1025.025n

.meas tran vdout0_252ck2040 FIND v(dout0_252) AT=1025.025n

.meas tran vdout0_253ck2040 FIND v(dout0_253) AT=1025.025n

.meas tran vdout0_254ck2040 FIND v(dout0_254) AT=1025.025n

.meas tran vdout0_255ck2040 FIND v(dout0_255) AT=1025.025n

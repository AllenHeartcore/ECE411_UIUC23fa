.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_0ck50 FIND v(dout0_0) AT=30.025n

.meas tran vdout0_1ck50 FIND v(dout0_1) AT=30.025n

.meas tran vdout0_2ck50 FIND v(dout0_2) AT=30.025n

.meas tran vdout0_3ck50 FIND v(dout0_3) AT=30.025n

.meas tran vdout0_4ck50 FIND v(dout0_4) AT=30.025n

.meas tran vdout0_5ck50 FIND v(dout0_5) AT=30.025n

.meas tran vdout0_6ck50 FIND v(dout0_6) AT=30.025n

.meas tran vdout0_7ck50 FIND v(dout0_7) AT=30.025n

.meas tran vdout0_8ck50 FIND v(dout0_8) AT=30.025n

.meas tran vdout0_9ck50 FIND v(dout0_9) AT=30.025n

.meas tran vdout0_10ck50 FIND v(dout0_10) AT=30.025n

.meas tran vdout0_11ck50 FIND v(dout0_11) AT=30.025n

.meas tran vdout0_12ck50 FIND v(dout0_12) AT=30.025n

.meas tran vdout0_13ck50 FIND v(dout0_13) AT=30.025n

.meas tran vdout0_14ck50 FIND v(dout0_14) AT=30.025n

.meas tran vdout0_15ck50 FIND v(dout0_15) AT=30.025n

.meas tran vdout0_16ck50 FIND v(dout0_16) AT=30.025n

.meas tran vdout0_17ck50 FIND v(dout0_17) AT=30.025n

.meas tran vdout0_18ck50 FIND v(dout0_18) AT=30.025n

.meas tran vdout0_19ck50 FIND v(dout0_19) AT=30.025n

.meas tran vdout0_20ck50 FIND v(dout0_20) AT=30.025n

.meas tran vdout0_21ck50 FIND v(dout0_21) AT=30.025n

.meas tran vdout0_22ck50 FIND v(dout0_22) AT=30.025n

.meas tran vdout0_23ck50 FIND v(dout0_23) AT=30.025n

.meas tran vdout0_24ck50 FIND v(dout0_24) AT=30.025n

.meas tran vdout0_25ck50 FIND v(dout0_25) AT=30.025n

.meas tran vdout0_26ck50 FIND v(dout0_26) AT=30.025n

.meas tran vdout0_27ck50 FIND v(dout0_27) AT=30.025n

.meas tran vdout0_28ck50 FIND v(dout0_28) AT=30.025n

.meas tran vdout0_29ck50 FIND v(dout0_29) AT=30.025n

.meas tran vdout0_30ck50 FIND v(dout0_30) AT=30.025n

.meas tran vdout0_31ck50 FIND v(dout0_31) AT=30.025n

.meas tran vdout0_32ck50 FIND v(dout0_32) AT=30.025n

.meas tran vdout0_33ck50 FIND v(dout0_33) AT=30.025n

.meas tran vdout0_34ck50 FIND v(dout0_34) AT=30.025n

.meas tran vdout0_35ck50 FIND v(dout0_35) AT=30.025n

.meas tran vdout0_36ck50 FIND v(dout0_36) AT=30.025n

.meas tran vdout0_37ck50 FIND v(dout0_37) AT=30.025n

.meas tran vdout0_38ck50 FIND v(dout0_38) AT=30.025n

.meas tran vdout0_39ck50 FIND v(dout0_39) AT=30.025n

.meas tran vdout0_40ck50 FIND v(dout0_40) AT=30.025n

.meas tran vdout0_41ck50 FIND v(dout0_41) AT=30.025n

.meas tran vdout0_42ck50 FIND v(dout0_42) AT=30.025n

.meas tran vdout0_43ck50 FIND v(dout0_43) AT=30.025n

.meas tran vdout0_44ck50 FIND v(dout0_44) AT=30.025n

.meas tran vdout0_45ck50 FIND v(dout0_45) AT=30.025n

.meas tran vdout0_46ck50 FIND v(dout0_46) AT=30.025n

.meas tran vdout0_47ck50 FIND v(dout0_47) AT=30.025n

.meas tran vdout0_48ck50 FIND v(dout0_48) AT=30.025n

.meas tran vdout0_49ck50 FIND v(dout0_49) AT=30.025n

.meas tran vdout0_50ck50 FIND v(dout0_50) AT=30.025n

.meas tran vdout0_51ck50 FIND v(dout0_51) AT=30.025n

.meas tran vdout0_52ck50 FIND v(dout0_52) AT=30.025n

.meas tran vdout0_53ck50 FIND v(dout0_53) AT=30.025n

.meas tran vdout0_54ck50 FIND v(dout0_54) AT=30.025n

.meas tran vdout0_55ck50 FIND v(dout0_55) AT=30.025n

.meas tran vdout0_56ck50 FIND v(dout0_56) AT=30.025n

.meas tran vdout0_57ck50 FIND v(dout0_57) AT=30.025n

.meas tran vdout0_58ck50 FIND v(dout0_58) AT=30.025n

.meas tran vdout0_59ck50 FIND v(dout0_59) AT=30.025n

.meas tran vdout0_60ck50 FIND v(dout0_60) AT=30.025n

.meas tran vdout0_61ck50 FIND v(dout0_61) AT=30.025n

.meas tran vdout0_62ck50 FIND v(dout0_62) AT=30.025n

.meas tran vdout0_63ck50 FIND v(dout0_63) AT=30.025n

.meas tran vdout0_64ck50 FIND v(dout0_64) AT=30.025n

.meas tran vdout0_65ck50 FIND v(dout0_65) AT=30.025n

.meas tran vdout0_66ck50 FIND v(dout0_66) AT=30.025n

.meas tran vdout0_67ck50 FIND v(dout0_67) AT=30.025n

.meas tran vdout0_68ck50 FIND v(dout0_68) AT=30.025n

.meas tran vdout0_69ck50 FIND v(dout0_69) AT=30.025n

.meas tran vdout0_70ck50 FIND v(dout0_70) AT=30.025n

.meas tran vdout0_71ck50 FIND v(dout0_71) AT=30.025n

.meas tran vdout0_72ck50 FIND v(dout0_72) AT=30.025n

.meas tran vdout0_73ck50 FIND v(dout0_73) AT=30.025n

.meas tran vdout0_74ck50 FIND v(dout0_74) AT=30.025n

.meas tran vdout0_75ck50 FIND v(dout0_75) AT=30.025n

.meas tran vdout0_76ck50 FIND v(dout0_76) AT=30.025n

.meas tran vdout0_77ck50 FIND v(dout0_77) AT=30.025n

.meas tran vdout0_78ck50 FIND v(dout0_78) AT=30.025n

.meas tran vdout0_79ck50 FIND v(dout0_79) AT=30.025n

.meas tran vdout0_80ck50 FIND v(dout0_80) AT=30.025n

.meas tran vdout0_81ck50 FIND v(dout0_81) AT=30.025n

.meas tran vdout0_82ck50 FIND v(dout0_82) AT=30.025n

.meas tran vdout0_83ck50 FIND v(dout0_83) AT=30.025n

.meas tran vdout0_84ck50 FIND v(dout0_84) AT=30.025n

.meas tran vdout0_85ck50 FIND v(dout0_85) AT=30.025n

.meas tran vdout0_86ck50 FIND v(dout0_86) AT=30.025n

.meas tran vdout0_87ck50 FIND v(dout0_87) AT=30.025n

.meas tran vdout0_88ck50 FIND v(dout0_88) AT=30.025n

.meas tran vdout0_89ck50 FIND v(dout0_89) AT=30.025n

.meas tran vdout0_90ck50 FIND v(dout0_90) AT=30.025n

.meas tran vdout0_91ck50 FIND v(dout0_91) AT=30.025n

.meas tran vdout0_92ck50 FIND v(dout0_92) AT=30.025n

.meas tran vdout0_93ck50 FIND v(dout0_93) AT=30.025n

.meas tran vdout0_94ck50 FIND v(dout0_94) AT=30.025n

.meas tran vdout0_95ck50 FIND v(dout0_95) AT=30.025n

.meas tran vdout0_96ck50 FIND v(dout0_96) AT=30.025n

.meas tran vdout0_97ck50 FIND v(dout0_97) AT=30.025n

.meas tran vdout0_98ck50 FIND v(dout0_98) AT=30.025n

.meas tran vdout0_99ck50 FIND v(dout0_99) AT=30.025n

.meas tran vdout0_100ck50 FIND v(dout0_100) AT=30.025n

.meas tran vdout0_101ck50 FIND v(dout0_101) AT=30.025n

.meas tran vdout0_102ck50 FIND v(dout0_102) AT=30.025n

.meas tran vdout0_103ck50 FIND v(dout0_103) AT=30.025n

.meas tran vdout0_104ck50 FIND v(dout0_104) AT=30.025n

.meas tran vdout0_105ck50 FIND v(dout0_105) AT=30.025n

.meas tran vdout0_106ck50 FIND v(dout0_106) AT=30.025n

.meas tran vdout0_107ck50 FIND v(dout0_107) AT=30.025n

.meas tran vdout0_108ck50 FIND v(dout0_108) AT=30.025n

.meas tran vdout0_109ck50 FIND v(dout0_109) AT=30.025n

.meas tran vdout0_110ck50 FIND v(dout0_110) AT=30.025n

.meas tran vdout0_111ck50 FIND v(dout0_111) AT=30.025n

.meas tran vdout0_112ck50 FIND v(dout0_112) AT=30.025n

.meas tran vdout0_113ck50 FIND v(dout0_113) AT=30.025n

.meas tran vdout0_114ck50 FIND v(dout0_114) AT=30.025n

.meas tran vdout0_115ck50 FIND v(dout0_115) AT=30.025n

.meas tran vdout0_116ck50 FIND v(dout0_116) AT=30.025n

.meas tran vdout0_117ck50 FIND v(dout0_117) AT=30.025n

.meas tran vdout0_118ck50 FIND v(dout0_118) AT=30.025n

.meas tran vdout0_119ck50 FIND v(dout0_119) AT=30.025n

.meas tran vdout0_120ck50 FIND v(dout0_120) AT=30.025n

.meas tran vdout0_121ck50 FIND v(dout0_121) AT=30.025n

.meas tran vdout0_122ck50 FIND v(dout0_122) AT=30.025n

.meas tran vdout0_123ck50 FIND v(dout0_123) AT=30.025n

.meas tran vdout0_124ck50 FIND v(dout0_124) AT=30.025n

.meas tran vdout0_125ck50 FIND v(dout0_125) AT=30.025n

.meas tran vdout0_126ck50 FIND v(dout0_126) AT=30.025n

.meas tran vdout0_127ck50 FIND v(dout0_127) AT=30.025n

.meas tran vdout0_0ck80 FIND v(dout0_0) AT=45.025n

.meas tran vdout0_1ck80 FIND v(dout0_1) AT=45.025n

.meas tran vdout0_2ck80 FIND v(dout0_2) AT=45.025n

.meas tran vdout0_3ck80 FIND v(dout0_3) AT=45.025n

.meas tran vdout0_4ck80 FIND v(dout0_4) AT=45.025n

.meas tran vdout0_5ck80 FIND v(dout0_5) AT=45.025n

.meas tran vdout0_6ck80 FIND v(dout0_6) AT=45.025n

.meas tran vdout0_7ck80 FIND v(dout0_7) AT=45.025n

.meas tran vdout0_8ck80 FIND v(dout0_8) AT=45.025n

.meas tran vdout0_9ck80 FIND v(dout0_9) AT=45.025n

.meas tran vdout0_10ck80 FIND v(dout0_10) AT=45.025n

.meas tran vdout0_11ck80 FIND v(dout0_11) AT=45.025n

.meas tran vdout0_12ck80 FIND v(dout0_12) AT=45.025n

.meas tran vdout0_13ck80 FIND v(dout0_13) AT=45.025n

.meas tran vdout0_14ck80 FIND v(dout0_14) AT=45.025n

.meas tran vdout0_15ck80 FIND v(dout0_15) AT=45.025n

.meas tran vdout0_16ck80 FIND v(dout0_16) AT=45.025n

.meas tran vdout0_17ck80 FIND v(dout0_17) AT=45.025n

.meas tran vdout0_18ck80 FIND v(dout0_18) AT=45.025n

.meas tran vdout0_19ck80 FIND v(dout0_19) AT=45.025n

.meas tran vdout0_20ck80 FIND v(dout0_20) AT=45.025n

.meas tran vdout0_21ck80 FIND v(dout0_21) AT=45.025n

.meas tran vdout0_22ck80 FIND v(dout0_22) AT=45.025n

.meas tran vdout0_23ck80 FIND v(dout0_23) AT=45.025n

.meas tran vdout0_24ck80 FIND v(dout0_24) AT=45.025n

.meas tran vdout0_25ck80 FIND v(dout0_25) AT=45.025n

.meas tran vdout0_26ck80 FIND v(dout0_26) AT=45.025n

.meas tran vdout0_27ck80 FIND v(dout0_27) AT=45.025n

.meas tran vdout0_28ck80 FIND v(dout0_28) AT=45.025n

.meas tran vdout0_29ck80 FIND v(dout0_29) AT=45.025n

.meas tran vdout0_30ck80 FIND v(dout0_30) AT=45.025n

.meas tran vdout0_31ck80 FIND v(dout0_31) AT=45.025n

.meas tran vdout0_32ck80 FIND v(dout0_32) AT=45.025n

.meas tran vdout0_33ck80 FIND v(dout0_33) AT=45.025n

.meas tran vdout0_34ck80 FIND v(dout0_34) AT=45.025n

.meas tran vdout0_35ck80 FIND v(dout0_35) AT=45.025n

.meas tran vdout0_36ck80 FIND v(dout0_36) AT=45.025n

.meas tran vdout0_37ck80 FIND v(dout0_37) AT=45.025n

.meas tran vdout0_38ck80 FIND v(dout0_38) AT=45.025n

.meas tran vdout0_39ck80 FIND v(dout0_39) AT=45.025n

.meas tran vdout0_40ck80 FIND v(dout0_40) AT=45.025n

.meas tran vdout0_41ck80 FIND v(dout0_41) AT=45.025n

.meas tran vdout0_42ck80 FIND v(dout0_42) AT=45.025n

.meas tran vdout0_43ck80 FIND v(dout0_43) AT=45.025n

.meas tran vdout0_44ck80 FIND v(dout0_44) AT=45.025n

.meas tran vdout0_45ck80 FIND v(dout0_45) AT=45.025n

.meas tran vdout0_46ck80 FIND v(dout0_46) AT=45.025n

.meas tran vdout0_47ck80 FIND v(dout0_47) AT=45.025n

.meas tran vdout0_48ck80 FIND v(dout0_48) AT=45.025n

.meas tran vdout0_49ck80 FIND v(dout0_49) AT=45.025n

.meas tran vdout0_50ck80 FIND v(dout0_50) AT=45.025n

.meas tran vdout0_51ck80 FIND v(dout0_51) AT=45.025n

.meas tran vdout0_52ck80 FIND v(dout0_52) AT=45.025n

.meas tran vdout0_53ck80 FIND v(dout0_53) AT=45.025n

.meas tran vdout0_54ck80 FIND v(dout0_54) AT=45.025n

.meas tran vdout0_55ck80 FIND v(dout0_55) AT=45.025n

.meas tran vdout0_56ck80 FIND v(dout0_56) AT=45.025n

.meas tran vdout0_57ck80 FIND v(dout0_57) AT=45.025n

.meas tran vdout0_58ck80 FIND v(dout0_58) AT=45.025n

.meas tran vdout0_59ck80 FIND v(dout0_59) AT=45.025n

.meas tran vdout0_60ck80 FIND v(dout0_60) AT=45.025n

.meas tran vdout0_61ck80 FIND v(dout0_61) AT=45.025n

.meas tran vdout0_62ck80 FIND v(dout0_62) AT=45.025n

.meas tran vdout0_63ck80 FIND v(dout0_63) AT=45.025n

.meas tran vdout0_64ck80 FIND v(dout0_64) AT=45.025n

.meas tran vdout0_65ck80 FIND v(dout0_65) AT=45.025n

.meas tran vdout0_66ck80 FIND v(dout0_66) AT=45.025n

.meas tran vdout0_67ck80 FIND v(dout0_67) AT=45.025n

.meas tran vdout0_68ck80 FIND v(dout0_68) AT=45.025n

.meas tran vdout0_69ck80 FIND v(dout0_69) AT=45.025n

.meas tran vdout0_70ck80 FIND v(dout0_70) AT=45.025n

.meas tran vdout0_71ck80 FIND v(dout0_71) AT=45.025n

.meas tran vdout0_72ck80 FIND v(dout0_72) AT=45.025n

.meas tran vdout0_73ck80 FIND v(dout0_73) AT=45.025n

.meas tran vdout0_74ck80 FIND v(dout0_74) AT=45.025n

.meas tran vdout0_75ck80 FIND v(dout0_75) AT=45.025n

.meas tran vdout0_76ck80 FIND v(dout0_76) AT=45.025n

.meas tran vdout0_77ck80 FIND v(dout0_77) AT=45.025n

.meas tran vdout0_78ck80 FIND v(dout0_78) AT=45.025n

.meas tran vdout0_79ck80 FIND v(dout0_79) AT=45.025n

.meas tran vdout0_80ck80 FIND v(dout0_80) AT=45.025n

.meas tran vdout0_81ck80 FIND v(dout0_81) AT=45.025n

.meas tran vdout0_82ck80 FIND v(dout0_82) AT=45.025n

.meas tran vdout0_83ck80 FIND v(dout0_83) AT=45.025n

.meas tran vdout0_84ck80 FIND v(dout0_84) AT=45.025n

.meas tran vdout0_85ck80 FIND v(dout0_85) AT=45.025n

.meas tran vdout0_86ck80 FIND v(dout0_86) AT=45.025n

.meas tran vdout0_87ck80 FIND v(dout0_87) AT=45.025n

.meas tran vdout0_88ck80 FIND v(dout0_88) AT=45.025n

.meas tran vdout0_89ck80 FIND v(dout0_89) AT=45.025n

.meas tran vdout0_90ck80 FIND v(dout0_90) AT=45.025n

.meas tran vdout0_91ck80 FIND v(dout0_91) AT=45.025n

.meas tran vdout0_92ck80 FIND v(dout0_92) AT=45.025n

.meas tran vdout0_93ck80 FIND v(dout0_93) AT=45.025n

.meas tran vdout0_94ck80 FIND v(dout0_94) AT=45.025n

.meas tran vdout0_95ck80 FIND v(dout0_95) AT=45.025n

.meas tran vdout0_96ck80 FIND v(dout0_96) AT=45.025n

.meas tran vdout0_97ck80 FIND v(dout0_97) AT=45.025n

.meas tran vdout0_98ck80 FIND v(dout0_98) AT=45.025n

.meas tran vdout0_99ck80 FIND v(dout0_99) AT=45.025n

.meas tran vdout0_100ck80 FIND v(dout0_100) AT=45.025n

.meas tran vdout0_101ck80 FIND v(dout0_101) AT=45.025n

.meas tran vdout0_102ck80 FIND v(dout0_102) AT=45.025n

.meas tran vdout0_103ck80 FIND v(dout0_103) AT=45.025n

.meas tran vdout0_104ck80 FIND v(dout0_104) AT=45.025n

.meas tran vdout0_105ck80 FIND v(dout0_105) AT=45.025n

.meas tran vdout0_106ck80 FIND v(dout0_106) AT=45.025n

.meas tran vdout0_107ck80 FIND v(dout0_107) AT=45.025n

.meas tran vdout0_108ck80 FIND v(dout0_108) AT=45.025n

.meas tran vdout0_109ck80 FIND v(dout0_109) AT=45.025n

.meas tran vdout0_110ck80 FIND v(dout0_110) AT=45.025n

.meas tran vdout0_111ck80 FIND v(dout0_111) AT=45.025n

.meas tran vdout0_112ck80 FIND v(dout0_112) AT=45.025n

.meas tran vdout0_113ck80 FIND v(dout0_113) AT=45.025n

.meas tran vdout0_114ck80 FIND v(dout0_114) AT=45.025n

.meas tran vdout0_115ck80 FIND v(dout0_115) AT=45.025n

.meas tran vdout0_116ck80 FIND v(dout0_116) AT=45.025n

.meas tran vdout0_117ck80 FIND v(dout0_117) AT=45.025n

.meas tran vdout0_118ck80 FIND v(dout0_118) AT=45.025n

.meas tran vdout0_119ck80 FIND v(dout0_119) AT=45.025n

.meas tran vdout0_120ck80 FIND v(dout0_120) AT=45.025n

.meas tran vdout0_121ck80 FIND v(dout0_121) AT=45.025n

.meas tran vdout0_122ck80 FIND v(dout0_122) AT=45.025n

.meas tran vdout0_123ck80 FIND v(dout0_123) AT=45.025n

.meas tran vdout0_124ck80 FIND v(dout0_124) AT=45.025n

.meas tran vdout0_125ck80 FIND v(dout0_125) AT=45.025n

.meas tran vdout0_126ck80 FIND v(dout0_126) AT=45.025n

.meas tran vdout0_127ck80 FIND v(dout0_127) AT=45.025n

.meas tran vdout0_0ck90 FIND v(dout0_0) AT=50.025n

.meas tran vdout0_1ck90 FIND v(dout0_1) AT=50.025n

.meas tran vdout0_2ck90 FIND v(dout0_2) AT=50.025n

.meas tran vdout0_3ck90 FIND v(dout0_3) AT=50.025n

.meas tran vdout0_4ck90 FIND v(dout0_4) AT=50.025n

.meas tran vdout0_5ck90 FIND v(dout0_5) AT=50.025n

.meas tran vdout0_6ck90 FIND v(dout0_6) AT=50.025n

.meas tran vdout0_7ck90 FIND v(dout0_7) AT=50.025n

.meas tran vdout0_8ck90 FIND v(dout0_8) AT=50.025n

.meas tran vdout0_9ck90 FIND v(dout0_9) AT=50.025n

.meas tran vdout0_10ck90 FIND v(dout0_10) AT=50.025n

.meas tran vdout0_11ck90 FIND v(dout0_11) AT=50.025n

.meas tran vdout0_12ck90 FIND v(dout0_12) AT=50.025n

.meas tran vdout0_13ck90 FIND v(dout0_13) AT=50.025n

.meas tran vdout0_14ck90 FIND v(dout0_14) AT=50.025n

.meas tran vdout0_15ck90 FIND v(dout0_15) AT=50.025n

.meas tran vdout0_16ck90 FIND v(dout0_16) AT=50.025n

.meas tran vdout0_17ck90 FIND v(dout0_17) AT=50.025n

.meas tran vdout0_18ck90 FIND v(dout0_18) AT=50.025n

.meas tran vdout0_19ck90 FIND v(dout0_19) AT=50.025n

.meas tran vdout0_20ck90 FIND v(dout0_20) AT=50.025n

.meas tran vdout0_21ck90 FIND v(dout0_21) AT=50.025n

.meas tran vdout0_22ck90 FIND v(dout0_22) AT=50.025n

.meas tran vdout0_23ck90 FIND v(dout0_23) AT=50.025n

.meas tran vdout0_24ck90 FIND v(dout0_24) AT=50.025n

.meas tran vdout0_25ck90 FIND v(dout0_25) AT=50.025n

.meas tran vdout0_26ck90 FIND v(dout0_26) AT=50.025n

.meas tran vdout0_27ck90 FIND v(dout0_27) AT=50.025n

.meas tran vdout0_28ck90 FIND v(dout0_28) AT=50.025n

.meas tran vdout0_29ck90 FIND v(dout0_29) AT=50.025n

.meas tran vdout0_30ck90 FIND v(dout0_30) AT=50.025n

.meas tran vdout0_31ck90 FIND v(dout0_31) AT=50.025n

.meas tran vdout0_32ck90 FIND v(dout0_32) AT=50.025n

.meas tran vdout0_33ck90 FIND v(dout0_33) AT=50.025n

.meas tran vdout0_34ck90 FIND v(dout0_34) AT=50.025n

.meas tran vdout0_35ck90 FIND v(dout0_35) AT=50.025n

.meas tran vdout0_36ck90 FIND v(dout0_36) AT=50.025n

.meas tran vdout0_37ck90 FIND v(dout0_37) AT=50.025n

.meas tran vdout0_38ck90 FIND v(dout0_38) AT=50.025n

.meas tran vdout0_39ck90 FIND v(dout0_39) AT=50.025n

.meas tran vdout0_40ck90 FIND v(dout0_40) AT=50.025n

.meas tran vdout0_41ck90 FIND v(dout0_41) AT=50.025n

.meas tran vdout0_42ck90 FIND v(dout0_42) AT=50.025n

.meas tran vdout0_43ck90 FIND v(dout0_43) AT=50.025n

.meas tran vdout0_44ck90 FIND v(dout0_44) AT=50.025n

.meas tran vdout0_45ck90 FIND v(dout0_45) AT=50.025n

.meas tran vdout0_46ck90 FIND v(dout0_46) AT=50.025n

.meas tran vdout0_47ck90 FIND v(dout0_47) AT=50.025n

.meas tran vdout0_48ck90 FIND v(dout0_48) AT=50.025n

.meas tran vdout0_49ck90 FIND v(dout0_49) AT=50.025n

.meas tran vdout0_50ck90 FIND v(dout0_50) AT=50.025n

.meas tran vdout0_51ck90 FIND v(dout0_51) AT=50.025n

.meas tran vdout0_52ck90 FIND v(dout0_52) AT=50.025n

.meas tran vdout0_53ck90 FIND v(dout0_53) AT=50.025n

.meas tran vdout0_54ck90 FIND v(dout0_54) AT=50.025n

.meas tran vdout0_55ck90 FIND v(dout0_55) AT=50.025n

.meas tran vdout0_56ck90 FIND v(dout0_56) AT=50.025n

.meas tran vdout0_57ck90 FIND v(dout0_57) AT=50.025n

.meas tran vdout0_58ck90 FIND v(dout0_58) AT=50.025n

.meas tran vdout0_59ck90 FIND v(dout0_59) AT=50.025n

.meas tran vdout0_60ck90 FIND v(dout0_60) AT=50.025n

.meas tran vdout0_61ck90 FIND v(dout0_61) AT=50.025n

.meas tran vdout0_62ck90 FIND v(dout0_62) AT=50.025n

.meas tran vdout0_63ck90 FIND v(dout0_63) AT=50.025n

.meas tran vdout0_64ck90 FIND v(dout0_64) AT=50.025n

.meas tran vdout0_65ck90 FIND v(dout0_65) AT=50.025n

.meas tran vdout0_66ck90 FIND v(dout0_66) AT=50.025n

.meas tran vdout0_67ck90 FIND v(dout0_67) AT=50.025n

.meas tran vdout0_68ck90 FIND v(dout0_68) AT=50.025n

.meas tran vdout0_69ck90 FIND v(dout0_69) AT=50.025n

.meas tran vdout0_70ck90 FIND v(dout0_70) AT=50.025n

.meas tran vdout0_71ck90 FIND v(dout0_71) AT=50.025n

.meas tran vdout0_72ck90 FIND v(dout0_72) AT=50.025n

.meas tran vdout0_73ck90 FIND v(dout0_73) AT=50.025n

.meas tran vdout0_74ck90 FIND v(dout0_74) AT=50.025n

.meas tran vdout0_75ck90 FIND v(dout0_75) AT=50.025n

.meas tran vdout0_76ck90 FIND v(dout0_76) AT=50.025n

.meas tran vdout0_77ck90 FIND v(dout0_77) AT=50.025n

.meas tran vdout0_78ck90 FIND v(dout0_78) AT=50.025n

.meas tran vdout0_79ck90 FIND v(dout0_79) AT=50.025n

.meas tran vdout0_80ck90 FIND v(dout0_80) AT=50.025n

.meas tran vdout0_81ck90 FIND v(dout0_81) AT=50.025n

.meas tran vdout0_82ck90 FIND v(dout0_82) AT=50.025n

.meas tran vdout0_83ck90 FIND v(dout0_83) AT=50.025n

.meas tran vdout0_84ck90 FIND v(dout0_84) AT=50.025n

.meas tran vdout0_85ck90 FIND v(dout0_85) AT=50.025n

.meas tran vdout0_86ck90 FIND v(dout0_86) AT=50.025n

.meas tran vdout0_87ck90 FIND v(dout0_87) AT=50.025n

.meas tran vdout0_88ck90 FIND v(dout0_88) AT=50.025n

.meas tran vdout0_89ck90 FIND v(dout0_89) AT=50.025n

.meas tran vdout0_90ck90 FIND v(dout0_90) AT=50.025n

.meas tran vdout0_91ck90 FIND v(dout0_91) AT=50.025n

.meas tran vdout0_92ck90 FIND v(dout0_92) AT=50.025n

.meas tran vdout0_93ck90 FIND v(dout0_93) AT=50.025n

.meas tran vdout0_94ck90 FIND v(dout0_94) AT=50.025n

.meas tran vdout0_95ck90 FIND v(dout0_95) AT=50.025n

.meas tran vdout0_96ck90 FIND v(dout0_96) AT=50.025n

.meas tran vdout0_97ck90 FIND v(dout0_97) AT=50.025n

.meas tran vdout0_98ck90 FIND v(dout0_98) AT=50.025n

.meas tran vdout0_99ck90 FIND v(dout0_99) AT=50.025n

.meas tran vdout0_100ck90 FIND v(dout0_100) AT=50.025n

.meas tran vdout0_101ck90 FIND v(dout0_101) AT=50.025n

.meas tran vdout0_102ck90 FIND v(dout0_102) AT=50.025n

.meas tran vdout0_103ck90 FIND v(dout0_103) AT=50.025n

.meas tran vdout0_104ck90 FIND v(dout0_104) AT=50.025n

.meas tran vdout0_105ck90 FIND v(dout0_105) AT=50.025n

.meas tran vdout0_106ck90 FIND v(dout0_106) AT=50.025n

.meas tran vdout0_107ck90 FIND v(dout0_107) AT=50.025n

.meas tran vdout0_108ck90 FIND v(dout0_108) AT=50.025n

.meas tran vdout0_109ck90 FIND v(dout0_109) AT=50.025n

.meas tran vdout0_110ck90 FIND v(dout0_110) AT=50.025n

.meas tran vdout0_111ck90 FIND v(dout0_111) AT=50.025n

.meas tran vdout0_112ck90 FIND v(dout0_112) AT=50.025n

.meas tran vdout0_113ck90 FIND v(dout0_113) AT=50.025n

.meas tran vdout0_114ck90 FIND v(dout0_114) AT=50.025n

.meas tran vdout0_115ck90 FIND v(dout0_115) AT=50.025n

.meas tran vdout0_116ck90 FIND v(dout0_116) AT=50.025n

.meas tran vdout0_117ck90 FIND v(dout0_117) AT=50.025n

.meas tran vdout0_118ck90 FIND v(dout0_118) AT=50.025n

.meas tran vdout0_119ck90 FIND v(dout0_119) AT=50.025n

.meas tran vdout0_120ck90 FIND v(dout0_120) AT=50.025n

.meas tran vdout0_121ck90 FIND v(dout0_121) AT=50.025n

.meas tran vdout0_122ck90 FIND v(dout0_122) AT=50.025n

.meas tran vdout0_123ck90 FIND v(dout0_123) AT=50.025n

.meas tran vdout0_124ck90 FIND v(dout0_124) AT=50.025n

.meas tran vdout0_125ck90 FIND v(dout0_125) AT=50.025n

.meas tran vdout0_126ck90 FIND v(dout0_126) AT=50.025n

.meas tran vdout0_127ck90 FIND v(dout0_127) AT=50.025n

.meas tran vdout0_0ck100 FIND v(dout0_0) AT=55.025n

.meas tran vdout0_1ck100 FIND v(dout0_1) AT=55.025n

.meas tran vdout0_2ck100 FIND v(dout0_2) AT=55.025n

.meas tran vdout0_3ck100 FIND v(dout0_3) AT=55.025n

.meas tran vdout0_4ck100 FIND v(dout0_4) AT=55.025n

.meas tran vdout0_5ck100 FIND v(dout0_5) AT=55.025n

.meas tran vdout0_6ck100 FIND v(dout0_6) AT=55.025n

.meas tran vdout0_7ck100 FIND v(dout0_7) AT=55.025n

.meas tran vdout0_8ck100 FIND v(dout0_8) AT=55.025n

.meas tran vdout0_9ck100 FIND v(dout0_9) AT=55.025n

.meas tran vdout0_10ck100 FIND v(dout0_10) AT=55.025n

.meas tran vdout0_11ck100 FIND v(dout0_11) AT=55.025n

.meas tran vdout0_12ck100 FIND v(dout0_12) AT=55.025n

.meas tran vdout0_13ck100 FIND v(dout0_13) AT=55.025n

.meas tran vdout0_14ck100 FIND v(dout0_14) AT=55.025n

.meas tran vdout0_15ck100 FIND v(dout0_15) AT=55.025n

.meas tran vdout0_16ck100 FIND v(dout0_16) AT=55.025n

.meas tran vdout0_17ck100 FIND v(dout0_17) AT=55.025n

.meas tran vdout0_18ck100 FIND v(dout0_18) AT=55.025n

.meas tran vdout0_19ck100 FIND v(dout0_19) AT=55.025n

.meas tran vdout0_20ck100 FIND v(dout0_20) AT=55.025n

.meas tran vdout0_21ck100 FIND v(dout0_21) AT=55.025n

.meas tran vdout0_22ck100 FIND v(dout0_22) AT=55.025n

.meas tran vdout0_23ck100 FIND v(dout0_23) AT=55.025n

.meas tran vdout0_24ck100 FIND v(dout0_24) AT=55.025n

.meas tran vdout0_25ck100 FIND v(dout0_25) AT=55.025n

.meas tran vdout0_26ck100 FIND v(dout0_26) AT=55.025n

.meas tran vdout0_27ck100 FIND v(dout0_27) AT=55.025n

.meas tran vdout0_28ck100 FIND v(dout0_28) AT=55.025n

.meas tran vdout0_29ck100 FIND v(dout0_29) AT=55.025n

.meas tran vdout0_30ck100 FIND v(dout0_30) AT=55.025n

.meas tran vdout0_31ck100 FIND v(dout0_31) AT=55.025n

.meas tran vdout0_32ck100 FIND v(dout0_32) AT=55.025n

.meas tran vdout0_33ck100 FIND v(dout0_33) AT=55.025n

.meas tran vdout0_34ck100 FIND v(dout0_34) AT=55.025n

.meas tran vdout0_35ck100 FIND v(dout0_35) AT=55.025n

.meas tran vdout0_36ck100 FIND v(dout0_36) AT=55.025n

.meas tran vdout0_37ck100 FIND v(dout0_37) AT=55.025n

.meas tran vdout0_38ck100 FIND v(dout0_38) AT=55.025n

.meas tran vdout0_39ck100 FIND v(dout0_39) AT=55.025n

.meas tran vdout0_40ck100 FIND v(dout0_40) AT=55.025n

.meas tran vdout0_41ck100 FIND v(dout0_41) AT=55.025n

.meas tran vdout0_42ck100 FIND v(dout0_42) AT=55.025n

.meas tran vdout0_43ck100 FIND v(dout0_43) AT=55.025n

.meas tran vdout0_44ck100 FIND v(dout0_44) AT=55.025n

.meas tran vdout0_45ck100 FIND v(dout0_45) AT=55.025n

.meas tran vdout0_46ck100 FIND v(dout0_46) AT=55.025n

.meas tran vdout0_47ck100 FIND v(dout0_47) AT=55.025n

.meas tran vdout0_48ck100 FIND v(dout0_48) AT=55.025n

.meas tran vdout0_49ck100 FIND v(dout0_49) AT=55.025n

.meas tran vdout0_50ck100 FIND v(dout0_50) AT=55.025n

.meas tran vdout0_51ck100 FIND v(dout0_51) AT=55.025n

.meas tran vdout0_52ck100 FIND v(dout0_52) AT=55.025n

.meas tran vdout0_53ck100 FIND v(dout0_53) AT=55.025n

.meas tran vdout0_54ck100 FIND v(dout0_54) AT=55.025n

.meas tran vdout0_55ck100 FIND v(dout0_55) AT=55.025n

.meas tran vdout0_56ck100 FIND v(dout0_56) AT=55.025n

.meas tran vdout0_57ck100 FIND v(dout0_57) AT=55.025n

.meas tran vdout0_58ck100 FIND v(dout0_58) AT=55.025n

.meas tran vdout0_59ck100 FIND v(dout0_59) AT=55.025n

.meas tran vdout0_60ck100 FIND v(dout0_60) AT=55.025n

.meas tran vdout0_61ck100 FIND v(dout0_61) AT=55.025n

.meas tran vdout0_62ck100 FIND v(dout0_62) AT=55.025n

.meas tran vdout0_63ck100 FIND v(dout0_63) AT=55.025n

.meas tran vdout0_64ck100 FIND v(dout0_64) AT=55.025n

.meas tran vdout0_65ck100 FIND v(dout0_65) AT=55.025n

.meas tran vdout0_66ck100 FIND v(dout0_66) AT=55.025n

.meas tran vdout0_67ck100 FIND v(dout0_67) AT=55.025n

.meas tran vdout0_68ck100 FIND v(dout0_68) AT=55.025n

.meas tran vdout0_69ck100 FIND v(dout0_69) AT=55.025n

.meas tran vdout0_70ck100 FIND v(dout0_70) AT=55.025n

.meas tran vdout0_71ck100 FIND v(dout0_71) AT=55.025n

.meas tran vdout0_72ck100 FIND v(dout0_72) AT=55.025n

.meas tran vdout0_73ck100 FIND v(dout0_73) AT=55.025n

.meas tran vdout0_74ck100 FIND v(dout0_74) AT=55.025n

.meas tran vdout0_75ck100 FIND v(dout0_75) AT=55.025n

.meas tran vdout0_76ck100 FIND v(dout0_76) AT=55.025n

.meas tran vdout0_77ck100 FIND v(dout0_77) AT=55.025n

.meas tran vdout0_78ck100 FIND v(dout0_78) AT=55.025n

.meas tran vdout0_79ck100 FIND v(dout0_79) AT=55.025n

.meas tran vdout0_80ck100 FIND v(dout0_80) AT=55.025n

.meas tran vdout0_81ck100 FIND v(dout0_81) AT=55.025n

.meas tran vdout0_82ck100 FIND v(dout0_82) AT=55.025n

.meas tran vdout0_83ck100 FIND v(dout0_83) AT=55.025n

.meas tran vdout0_84ck100 FIND v(dout0_84) AT=55.025n

.meas tran vdout0_85ck100 FIND v(dout0_85) AT=55.025n

.meas tran vdout0_86ck100 FIND v(dout0_86) AT=55.025n

.meas tran vdout0_87ck100 FIND v(dout0_87) AT=55.025n

.meas tran vdout0_88ck100 FIND v(dout0_88) AT=55.025n

.meas tran vdout0_89ck100 FIND v(dout0_89) AT=55.025n

.meas tran vdout0_90ck100 FIND v(dout0_90) AT=55.025n

.meas tran vdout0_91ck100 FIND v(dout0_91) AT=55.025n

.meas tran vdout0_92ck100 FIND v(dout0_92) AT=55.025n

.meas tran vdout0_93ck100 FIND v(dout0_93) AT=55.025n

.meas tran vdout0_94ck100 FIND v(dout0_94) AT=55.025n

.meas tran vdout0_95ck100 FIND v(dout0_95) AT=55.025n

.meas tran vdout0_96ck100 FIND v(dout0_96) AT=55.025n

.meas tran vdout0_97ck100 FIND v(dout0_97) AT=55.025n

.meas tran vdout0_98ck100 FIND v(dout0_98) AT=55.025n

.meas tran vdout0_99ck100 FIND v(dout0_99) AT=55.025n

.meas tran vdout0_100ck100 FIND v(dout0_100) AT=55.025n

.meas tran vdout0_101ck100 FIND v(dout0_101) AT=55.025n

.meas tran vdout0_102ck100 FIND v(dout0_102) AT=55.025n

.meas tran vdout0_103ck100 FIND v(dout0_103) AT=55.025n

.meas tran vdout0_104ck100 FIND v(dout0_104) AT=55.025n

.meas tran vdout0_105ck100 FIND v(dout0_105) AT=55.025n

.meas tran vdout0_106ck100 FIND v(dout0_106) AT=55.025n

.meas tran vdout0_107ck100 FIND v(dout0_107) AT=55.025n

.meas tran vdout0_108ck100 FIND v(dout0_108) AT=55.025n

.meas tran vdout0_109ck100 FIND v(dout0_109) AT=55.025n

.meas tran vdout0_110ck100 FIND v(dout0_110) AT=55.025n

.meas tran vdout0_111ck100 FIND v(dout0_111) AT=55.025n

.meas tran vdout0_112ck100 FIND v(dout0_112) AT=55.025n

.meas tran vdout0_113ck100 FIND v(dout0_113) AT=55.025n

.meas tran vdout0_114ck100 FIND v(dout0_114) AT=55.025n

.meas tran vdout0_115ck100 FIND v(dout0_115) AT=55.025n

.meas tran vdout0_116ck100 FIND v(dout0_116) AT=55.025n

.meas tran vdout0_117ck100 FIND v(dout0_117) AT=55.025n

.meas tran vdout0_118ck100 FIND v(dout0_118) AT=55.025n

.meas tran vdout0_119ck100 FIND v(dout0_119) AT=55.025n

.meas tran vdout0_120ck100 FIND v(dout0_120) AT=55.025n

.meas tran vdout0_121ck100 FIND v(dout0_121) AT=55.025n

.meas tran vdout0_122ck100 FIND v(dout0_122) AT=55.025n

.meas tran vdout0_123ck100 FIND v(dout0_123) AT=55.025n

.meas tran vdout0_124ck100 FIND v(dout0_124) AT=55.025n

.meas tran vdout0_125ck100 FIND v(dout0_125) AT=55.025n

.meas tran vdout0_126ck100 FIND v(dout0_126) AT=55.025n

.meas tran vdout0_127ck100 FIND v(dout0_127) AT=55.025n

.meas tran vdout0_0ck120 FIND v(dout0_0) AT=65.025n

.meas tran vdout0_1ck120 FIND v(dout0_1) AT=65.025n

.meas tran vdout0_2ck120 FIND v(dout0_2) AT=65.025n

.meas tran vdout0_3ck120 FIND v(dout0_3) AT=65.025n

.meas tran vdout0_4ck120 FIND v(dout0_4) AT=65.025n

.meas tran vdout0_5ck120 FIND v(dout0_5) AT=65.025n

.meas tran vdout0_6ck120 FIND v(dout0_6) AT=65.025n

.meas tran vdout0_7ck120 FIND v(dout0_7) AT=65.025n

.meas tran vdout0_8ck120 FIND v(dout0_8) AT=65.025n

.meas tran vdout0_9ck120 FIND v(dout0_9) AT=65.025n

.meas tran vdout0_10ck120 FIND v(dout0_10) AT=65.025n

.meas tran vdout0_11ck120 FIND v(dout0_11) AT=65.025n

.meas tran vdout0_12ck120 FIND v(dout0_12) AT=65.025n

.meas tran vdout0_13ck120 FIND v(dout0_13) AT=65.025n

.meas tran vdout0_14ck120 FIND v(dout0_14) AT=65.025n

.meas tran vdout0_15ck120 FIND v(dout0_15) AT=65.025n

.meas tran vdout0_16ck120 FIND v(dout0_16) AT=65.025n

.meas tran vdout0_17ck120 FIND v(dout0_17) AT=65.025n

.meas tran vdout0_18ck120 FIND v(dout0_18) AT=65.025n

.meas tran vdout0_19ck120 FIND v(dout0_19) AT=65.025n

.meas tran vdout0_20ck120 FIND v(dout0_20) AT=65.025n

.meas tran vdout0_21ck120 FIND v(dout0_21) AT=65.025n

.meas tran vdout0_22ck120 FIND v(dout0_22) AT=65.025n

.meas tran vdout0_23ck120 FIND v(dout0_23) AT=65.025n

.meas tran vdout0_24ck120 FIND v(dout0_24) AT=65.025n

.meas tran vdout0_25ck120 FIND v(dout0_25) AT=65.025n

.meas tran vdout0_26ck120 FIND v(dout0_26) AT=65.025n

.meas tran vdout0_27ck120 FIND v(dout0_27) AT=65.025n

.meas tran vdout0_28ck120 FIND v(dout0_28) AT=65.025n

.meas tran vdout0_29ck120 FIND v(dout0_29) AT=65.025n

.meas tran vdout0_30ck120 FIND v(dout0_30) AT=65.025n

.meas tran vdout0_31ck120 FIND v(dout0_31) AT=65.025n

.meas tran vdout0_32ck120 FIND v(dout0_32) AT=65.025n

.meas tran vdout0_33ck120 FIND v(dout0_33) AT=65.025n

.meas tran vdout0_34ck120 FIND v(dout0_34) AT=65.025n

.meas tran vdout0_35ck120 FIND v(dout0_35) AT=65.025n

.meas tran vdout0_36ck120 FIND v(dout0_36) AT=65.025n

.meas tran vdout0_37ck120 FIND v(dout0_37) AT=65.025n

.meas tran vdout0_38ck120 FIND v(dout0_38) AT=65.025n

.meas tran vdout0_39ck120 FIND v(dout0_39) AT=65.025n

.meas tran vdout0_40ck120 FIND v(dout0_40) AT=65.025n

.meas tran vdout0_41ck120 FIND v(dout0_41) AT=65.025n

.meas tran vdout0_42ck120 FIND v(dout0_42) AT=65.025n

.meas tran vdout0_43ck120 FIND v(dout0_43) AT=65.025n

.meas tran vdout0_44ck120 FIND v(dout0_44) AT=65.025n

.meas tran vdout0_45ck120 FIND v(dout0_45) AT=65.025n

.meas tran vdout0_46ck120 FIND v(dout0_46) AT=65.025n

.meas tran vdout0_47ck120 FIND v(dout0_47) AT=65.025n

.meas tran vdout0_48ck120 FIND v(dout0_48) AT=65.025n

.meas tran vdout0_49ck120 FIND v(dout0_49) AT=65.025n

.meas tran vdout0_50ck120 FIND v(dout0_50) AT=65.025n

.meas tran vdout0_51ck120 FIND v(dout0_51) AT=65.025n

.meas tran vdout0_52ck120 FIND v(dout0_52) AT=65.025n

.meas tran vdout0_53ck120 FIND v(dout0_53) AT=65.025n

.meas tran vdout0_54ck120 FIND v(dout0_54) AT=65.025n

.meas tran vdout0_55ck120 FIND v(dout0_55) AT=65.025n

.meas tran vdout0_56ck120 FIND v(dout0_56) AT=65.025n

.meas tran vdout0_57ck120 FIND v(dout0_57) AT=65.025n

.meas tran vdout0_58ck120 FIND v(dout0_58) AT=65.025n

.meas tran vdout0_59ck120 FIND v(dout0_59) AT=65.025n

.meas tran vdout0_60ck120 FIND v(dout0_60) AT=65.025n

.meas tran vdout0_61ck120 FIND v(dout0_61) AT=65.025n

.meas tran vdout0_62ck120 FIND v(dout0_62) AT=65.025n

.meas tran vdout0_63ck120 FIND v(dout0_63) AT=65.025n

.meas tran vdout0_64ck120 FIND v(dout0_64) AT=65.025n

.meas tran vdout0_65ck120 FIND v(dout0_65) AT=65.025n

.meas tran vdout0_66ck120 FIND v(dout0_66) AT=65.025n

.meas tran vdout0_67ck120 FIND v(dout0_67) AT=65.025n

.meas tran vdout0_68ck120 FIND v(dout0_68) AT=65.025n

.meas tran vdout0_69ck120 FIND v(dout0_69) AT=65.025n

.meas tran vdout0_70ck120 FIND v(dout0_70) AT=65.025n

.meas tran vdout0_71ck120 FIND v(dout0_71) AT=65.025n

.meas tran vdout0_72ck120 FIND v(dout0_72) AT=65.025n

.meas tran vdout0_73ck120 FIND v(dout0_73) AT=65.025n

.meas tran vdout0_74ck120 FIND v(dout0_74) AT=65.025n

.meas tran vdout0_75ck120 FIND v(dout0_75) AT=65.025n

.meas tran vdout0_76ck120 FIND v(dout0_76) AT=65.025n

.meas tran vdout0_77ck120 FIND v(dout0_77) AT=65.025n

.meas tran vdout0_78ck120 FIND v(dout0_78) AT=65.025n

.meas tran vdout0_79ck120 FIND v(dout0_79) AT=65.025n

.meas tran vdout0_80ck120 FIND v(dout0_80) AT=65.025n

.meas tran vdout0_81ck120 FIND v(dout0_81) AT=65.025n

.meas tran vdout0_82ck120 FIND v(dout0_82) AT=65.025n

.meas tran vdout0_83ck120 FIND v(dout0_83) AT=65.025n

.meas tran vdout0_84ck120 FIND v(dout0_84) AT=65.025n

.meas tran vdout0_85ck120 FIND v(dout0_85) AT=65.025n

.meas tran vdout0_86ck120 FIND v(dout0_86) AT=65.025n

.meas tran vdout0_87ck120 FIND v(dout0_87) AT=65.025n

.meas tran vdout0_88ck120 FIND v(dout0_88) AT=65.025n

.meas tran vdout0_89ck120 FIND v(dout0_89) AT=65.025n

.meas tran vdout0_90ck120 FIND v(dout0_90) AT=65.025n

.meas tran vdout0_91ck120 FIND v(dout0_91) AT=65.025n

.meas tran vdout0_92ck120 FIND v(dout0_92) AT=65.025n

.meas tran vdout0_93ck120 FIND v(dout0_93) AT=65.025n

.meas tran vdout0_94ck120 FIND v(dout0_94) AT=65.025n

.meas tran vdout0_95ck120 FIND v(dout0_95) AT=65.025n

.meas tran vdout0_96ck120 FIND v(dout0_96) AT=65.025n

.meas tran vdout0_97ck120 FIND v(dout0_97) AT=65.025n

.meas tran vdout0_98ck120 FIND v(dout0_98) AT=65.025n

.meas tran vdout0_99ck120 FIND v(dout0_99) AT=65.025n

.meas tran vdout0_100ck120 FIND v(dout0_100) AT=65.025n

.meas tran vdout0_101ck120 FIND v(dout0_101) AT=65.025n

.meas tran vdout0_102ck120 FIND v(dout0_102) AT=65.025n

.meas tran vdout0_103ck120 FIND v(dout0_103) AT=65.025n

.meas tran vdout0_104ck120 FIND v(dout0_104) AT=65.025n

.meas tran vdout0_105ck120 FIND v(dout0_105) AT=65.025n

.meas tran vdout0_106ck120 FIND v(dout0_106) AT=65.025n

.meas tran vdout0_107ck120 FIND v(dout0_107) AT=65.025n

.meas tran vdout0_108ck120 FIND v(dout0_108) AT=65.025n

.meas tran vdout0_109ck120 FIND v(dout0_109) AT=65.025n

.meas tran vdout0_110ck120 FIND v(dout0_110) AT=65.025n

.meas tran vdout0_111ck120 FIND v(dout0_111) AT=65.025n

.meas tran vdout0_112ck120 FIND v(dout0_112) AT=65.025n

.meas tran vdout0_113ck120 FIND v(dout0_113) AT=65.025n

.meas tran vdout0_114ck120 FIND v(dout0_114) AT=65.025n

.meas tran vdout0_115ck120 FIND v(dout0_115) AT=65.025n

.meas tran vdout0_116ck120 FIND v(dout0_116) AT=65.025n

.meas tran vdout0_117ck120 FIND v(dout0_117) AT=65.025n

.meas tran vdout0_118ck120 FIND v(dout0_118) AT=65.025n

.meas tran vdout0_119ck120 FIND v(dout0_119) AT=65.025n

.meas tran vdout0_120ck120 FIND v(dout0_120) AT=65.025n

.meas tran vdout0_121ck120 FIND v(dout0_121) AT=65.025n

.meas tran vdout0_122ck120 FIND v(dout0_122) AT=65.025n

.meas tran vdout0_123ck120 FIND v(dout0_123) AT=65.025n

.meas tran vdout0_124ck120 FIND v(dout0_124) AT=65.025n

.meas tran vdout0_125ck120 FIND v(dout0_125) AT=65.025n

.meas tran vdout0_126ck120 FIND v(dout0_126) AT=65.025n

.meas tran vdout0_127ck120 FIND v(dout0_127) AT=65.025n

.meas tran vdout0_0ck140 FIND v(dout0_0) AT=75.025n

.meas tran vdout0_1ck140 FIND v(dout0_1) AT=75.025n

.meas tran vdout0_2ck140 FIND v(dout0_2) AT=75.025n

.meas tran vdout0_3ck140 FIND v(dout0_3) AT=75.025n

.meas tran vdout0_4ck140 FIND v(dout0_4) AT=75.025n

.meas tran vdout0_5ck140 FIND v(dout0_5) AT=75.025n

.meas tran vdout0_6ck140 FIND v(dout0_6) AT=75.025n

.meas tran vdout0_7ck140 FIND v(dout0_7) AT=75.025n

.meas tran vdout0_8ck140 FIND v(dout0_8) AT=75.025n

.meas tran vdout0_9ck140 FIND v(dout0_9) AT=75.025n

.meas tran vdout0_10ck140 FIND v(dout0_10) AT=75.025n

.meas tran vdout0_11ck140 FIND v(dout0_11) AT=75.025n

.meas tran vdout0_12ck140 FIND v(dout0_12) AT=75.025n

.meas tran vdout0_13ck140 FIND v(dout0_13) AT=75.025n

.meas tran vdout0_14ck140 FIND v(dout0_14) AT=75.025n

.meas tran vdout0_15ck140 FIND v(dout0_15) AT=75.025n

.meas tran vdout0_16ck140 FIND v(dout0_16) AT=75.025n

.meas tran vdout0_17ck140 FIND v(dout0_17) AT=75.025n

.meas tran vdout0_18ck140 FIND v(dout0_18) AT=75.025n

.meas tran vdout0_19ck140 FIND v(dout0_19) AT=75.025n

.meas tran vdout0_20ck140 FIND v(dout0_20) AT=75.025n

.meas tran vdout0_21ck140 FIND v(dout0_21) AT=75.025n

.meas tran vdout0_22ck140 FIND v(dout0_22) AT=75.025n

.meas tran vdout0_23ck140 FIND v(dout0_23) AT=75.025n

.meas tran vdout0_24ck140 FIND v(dout0_24) AT=75.025n

.meas tran vdout0_25ck140 FIND v(dout0_25) AT=75.025n

.meas tran vdout0_26ck140 FIND v(dout0_26) AT=75.025n

.meas tran vdout0_27ck140 FIND v(dout0_27) AT=75.025n

.meas tran vdout0_28ck140 FIND v(dout0_28) AT=75.025n

.meas tran vdout0_29ck140 FIND v(dout0_29) AT=75.025n

.meas tran vdout0_30ck140 FIND v(dout0_30) AT=75.025n

.meas tran vdout0_31ck140 FIND v(dout0_31) AT=75.025n

.meas tran vdout0_32ck140 FIND v(dout0_32) AT=75.025n

.meas tran vdout0_33ck140 FIND v(dout0_33) AT=75.025n

.meas tran vdout0_34ck140 FIND v(dout0_34) AT=75.025n

.meas tran vdout0_35ck140 FIND v(dout0_35) AT=75.025n

.meas tran vdout0_36ck140 FIND v(dout0_36) AT=75.025n

.meas tran vdout0_37ck140 FIND v(dout0_37) AT=75.025n

.meas tran vdout0_38ck140 FIND v(dout0_38) AT=75.025n

.meas tran vdout0_39ck140 FIND v(dout0_39) AT=75.025n

.meas tran vdout0_40ck140 FIND v(dout0_40) AT=75.025n

.meas tran vdout0_41ck140 FIND v(dout0_41) AT=75.025n

.meas tran vdout0_42ck140 FIND v(dout0_42) AT=75.025n

.meas tran vdout0_43ck140 FIND v(dout0_43) AT=75.025n

.meas tran vdout0_44ck140 FIND v(dout0_44) AT=75.025n

.meas tran vdout0_45ck140 FIND v(dout0_45) AT=75.025n

.meas tran vdout0_46ck140 FIND v(dout0_46) AT=75.025n

.meas tran vdout0_47ck140 FIND v(dout0_47) AT=75.025n

.meas tran vdout0_48ck140 FIND v(dout0_48) AT=75.025n

.meas tran vdout0_49ck140 FIND v(dout0_49) AT=75.025n

.meas tran vdout0_50ck140 FIND v(dout0_50) AT=75.025n

.meas tran vdout0_51ck140 FIND v(dout0_51) AT=75.025n

.meas tran vdout0_52ck140 FIND v(dout0_52) AT=75.025n

.meas tran vdout0_53ck140 FIND v(dout0_53) AT=75.025n

.meas tran vdout0_54ck140 FIND v(dout0_54) AT=75.025n

.meas tran vdout0_55ck140 FIND v(dout0_55) AT=75.025n

.meas tran vdout0_56ck140 FIND v(dout0_56) AT=75.025n

.meas tran vdout0_57ck140 FIND v(dout0_57) AT=75.025n

.meas tran vdout0_58ck140 FIND v(dout0_58) AT=75.025n

.meas tran vdout0_59ck140 FIND v(dout0_59) AT=75.025n

.meas tran vdout0_60ck140 FIND v(dout0_60) AT=75.025n

.meas tran vdout0_61ck140 FIND v(dout0_61) AT=75.025n

.meas tran vdout0_62ck140 FIND v(dout0_62) AT=75.025n

.meas tran vdout0_63ck140 FIND v(dout0_63) AT=75.025n

.meas tran vdout0_64ck140 FIND v(dout0_64) AT=75.025n

.meas tran vdout0_65ck140 FIND v(dout0_65) AT=75.025n

.meas tran vdout0_66ck140 FIND v(dout0_66) AT=75.025n

.meas tran vdout0_67ck140 FIND v(dout0_67) AT=75.025n

.meas tran vdout0_68ck140 FIND v(dout0_68) AT=75.025n

.meas tran vdout0_69ck140 FIND v(dout0_69) AT=75.025n

.meas tran vdout0_70ck140 FIND v(dout0_70) AT=75.025n

.meas tran vdout0_71ck140 FIND v(dout0_71) AT=75.025n

.meas tran vdout0_72ck140 FIND v(dout0_72) AT=75.025n

.meas tran vdout0_73ck140 FIND v(dout0_73) AT=75.025n

.meas tran vdout0_74ck140 FIND v(dout0_74) AT=75.025n

.meas tran vdout0_75ck140 FIND v(dout0_75) AT=75.025n

.meas tran vdout0_76ck140 FIND v(dout0_76) AT=75.025n

.meas tran vdout0_77ck140 FIND v(dout0_77) AT=75.025n

.meas tran vdout0_78ck140 FIND v(dout0_78) AT=75.025n

.meas tran vdout0_79ck140 FIND v(dout0_79) AT=75.025n

.meas tran vdout0_80ck140 FIND v(dout0_80) AT=75.025n

.meas tran vdout0_81ck140 FIND v(dout0_81) AT=75.025n

.meas tran vdout0_82ck140 FIND v(dout0_82) AT=75.025n

.meas tran vdout0_83ck140 FIND v(dout0_83) AT=75.025n

.meas tran vdout0_84ck140 FIND v(dout0_84) AT=75.025n

.meas tran vdout0_85ck140 FIND v(dout0_85) AT=75.025n

.meas tran vdout0_86ck140 FIND v(dout0_86) AT=75.025n

.meas tran vdout0_87ck140 FIND v(dout0_87) AT=75.025n

.meas tran vdout0_88ck140 FIND v(dout0_88) AT=75.025n

.meas tran vdout0_89ck140 FIND v(dout0_89) AT=75.025n

.meas tran vdout0_90ck140 FIND v(dout0_90) AT=75.025n

.meas tran vdout0_91ck140 FIND v(dout0_91) AT=75.025n

.meas tran vdout0_92ck140 FIND v(dout0_92) AT=75.025n

.meas tran vdout0_93ck140 FIND v(dout0_93) AT=75.025n

.meas tran vdout0_94ck140 FIND v(dout0_94) AT=75.025n

.meas tran vdout0_95ck140 FIND v(dout0_95) AT=75.025n

.meas tran vdout0_96ck140 FIND v(dout0_96) AT=75.025n

.meas tran vdout0_97ck140 FIND v(dout0_97) AT=75.025n

.meas tran vdout0_98ck140 FIND v(dout0_98) AT=75.025n

.meas tran vdout0_99ck140 FIND v(dout0_99) AT=75.025n

.meas tran vdout0_100ck140 FIND v(dout0_100) AT=75.025n

.meas tran vdout0_101ck140 FIND v(dout0_101) AT=75.025n

.meas tran vdout0_102ck140 FIND v(dout0_102) AT=75.025n

.meas tran vdout0_103ck140 FIND v(dout0_103) AT=75.025n

.meas tran vdout0_104ck140 FIND v(dout0_104) AT=75.025n

.meas tran vdout0_105ck140 FIND v(dout0_105) AT=75.025n

.meas tran vdout0_106ck140 FIND v(dout0_106) AT=75.025n

.meas tran vdout0_107ck140 FIND v(dout0_107) AT=75.025n

.meas tran vdout0_108ck140 FIND v(dout0_108) AT=75.025n

.meas tran vdout0_109ck140 FIND v(dout0_109) AT=75.025n

.meas tran vdout0_110ck140 FIND v(dout0_110) AT=75.025n

.meas tran vdout0_111ck140 FIND v(dout0_111) AT=75.025n

.meas tran vdout0_112ck140 FIND v(dout0_112) AT=75.025n

.meas tran vdout0_113ck140 FIND v(dout0_113) AT=75.025n

.meas tran vdout0_114ck140 FIND v(dout0_114) AT=75.025n

.meas tran vdout0_115ck140 FIND v(dout0_115) AT=75.025n

.meas tran vdout0_116ck140 FIND v(dout0_116) AT=75.025n

.meas tran vdout0_117ck140 FIND v(dout0_117) AT=75.025n

.meas tran vdout0_118ck140 FIND v(dout0_118) AT=75.025n

.meas tran vdout0_119ck140 FIND v(dout0_119) AT=75.025n

.meas tran vdout0_120ck140 FIND v(dout0_120) AT=75.025n

.meas tran vdout0_121ck140 FIND v(dout0_121) AT=75.025n

.meas tran vdout0_122ck140 FIND v(dout0_122) AT=75.025n

.meas tran vdout0_123ck140 FIND v(dout0_123) AT=75.025n

.meas tran vdout0_124ck140 FIND v(dout0_124) AT=75.025n

.meas tran vdout0_125ck140 FIND v(dout0_125) AT=75.025n

.meas tran vdout0_126ck140 FIND v(dout0_126) AT=75.025n

.meas tran vdout0_127ck140 FIND v(dout0_127) AT=75.025n

.meas tran vdout0_0ck150 FIND v(dout0_0) AT=80.025n

.meas tran vdout0_1ck150 FIND v(dout0_1) AT=80.025n

.meas tran vdout0_2ck150 FIND v(dout0_2) AT=80.025n

.meas tran vdout0_3ck150 FIND v(dout0_3) AT=80.025n

.meas tran vdout0_4ck150 FIND v(dout0_4) AT=80.025n

.meas tran vdout0_5ck150 FIND v(dout0_5) AT=80.025n

.meas tran vdout0_6ck150 FIND v(dout0_6) AT=80.025n

.meas tran vdout0_7ck150 FIND v(dout0_7) AT=80.025n

.meas tran vdout0_8ck150 FIND v(dout0_8) AT=80.025n

.meas tran vdout0_9ck150 FIND v(dout0_9) AT=80.025n

.meas tran vdout0_10ck150 FIND v(dout0_10) AT=80.025n

.meas tran vdout0_11ck150 FIND v(dout0_11) AT=80.025n

.meas tran vdout0_12ck150 FIND v(dout0_12) AT=80.025n

.meas tran vdout0_13ck150 FIND v(dout0_13) AT=80.025n

.meas tran vdout0_14ck150 FIND v(dout0_14) AT=80.025n

.meas tran vdout0_15ck150 FIND v(dout0_15) AT=80.025n

.meas tran vdout0_16ck150 FIND v(dout0_16) AT=80.025n

.meas tran vdout0_17ck150 FIND v(dout0_17) AT=80.025n

.meas tran vdout0_18ck150 FIND v(dout0_18) AT=80.025n

.meas tran vdout0_19ck150 FIND v(dout0_19) AT=80.025n

.meas tran vdout0_20ck150 FIND v(dout0_20) AT=80.025n

.meas tran vdout0_21ck150 FIND v(dout0_21) AT=80.025n

.meas tran vdout0_22ck150 FIND v(dout0_22) AT=80.025n

.meas tran vdout0_23ck150 FIND v(dout0_23) AT=80.025n

.meas tran vdout0_24ck150 FIND v(dout0_24) AT=80.025n

.meas tran vdout0_25ck150 FIND v(dout0_25) AT=80.025n

.meas tran vdout0_26ck150 FIND v(dout0_26) AT=80.025n

.meas tran vdout0_27ck150 FIND v(dout0_27) AT=80.025n

.meas tran vdout0_28ck150 FIND v(dout0_28) AT=80.025n

.meas tran vdout0_29ck150 FIND v(dout0_29) AT=80.025n

.meas tran vdout0_30ck150 FIND v(dout0_30) AT=80.025n

.meas tran vdout0_31ck150 FIND v(dout0_31) AT=80.025n

.meas tran vdout0_32ck150 FIND v(dout0_32) AT=80.025n

.meas tran vdout0_33ck150 FIND v(dout0_33) AT=80.025n

.meas tran vdout0_34ck150 FIND v(dout0_34) AT=80.025n

.meas tran vdout0_35ck150 FIND v(dout0_35) AT=80.025n

.meas tran vdout0_36ck150 FIND v(dout0_36) AT=80.025n

.meas tran vdout0_37ck150 FIND v(dout0_37) AT=80.025n

.meas tran vdout0_38ck150 FIND v(dout0_38) AT=80.025n

.meas tran vdout0_39ck150 FIND v(dout0_39) AT=80.025n

.meas tran vdout0_40ck150 FIND v(dout0_40) AT=80.025n

.meas tran vdout0_41ck150 FIND v(dout0_41) AT=80.025n

.meas tran vdout0_42ck150 FIND v(dout0_42) AT=80.025n

.meas tran vdout0_43ck150 FIND v(dout0_43) AT=80.025n

.meas tran vdout0_44ck150 FIND v(dout0_44) AT=80.025n

.meas tran vdout0_45ck150 FIND v(dout0_45) AT=80.025n

.meas tran vdout0_46ck150 FIND v(dout0_46) AT=80.025n

.meas tran vdout0_47ck150 FIND v(dout0_47) AT=80.025n

.meas tran vdout0_48ck150 FIND v(dout0_48) AT=80.025n

.meas tran vdout0_49ck150 FIND v(dout0_49) AT=80.025n

.meas tran vdout0_50ck150 FIND v(dout0_50) AT=80.025n

.meas tran vdout0_51ck150 FIND v(dout0_51) AT=80.025n

.meas tran vdout0_52ck150 FIND v(dout0_52) AT=80.025n

.meas tran vdout0_53ck150 FIND v(dout0_53) AT=80.025n

.meas tran vdout0_54ck150 FIND v(dout0_54) AT=80.025n

.meas tran vdout0_55ck150 FIND v(dout0_55) AT=80.025n

.meas tran vdout0_56ck150 FIND v(dout0_56) AT=80.025n

.meas tran vdout0_57ck150 FIND v(dout0_57) AT=80.025n

.meas tran vdout0_58ck150 FIND v(dout0_58) AT=80.025n

.meas tran vdout0_59ck150 FIND v(dout0_59) AT=80.025n

.meas tran vdout0_60ck150 FIND v(dout0_60) AT=80.025n

.meas tran vdout0_61ck150 FIND v(dout0_61) AT=80.025n

.meas tran vdout0_62ck150 FIND v(dout0_62) AT=80.025n

.meas tran vdout0_63ck150 FIND v(dout0_63) AT=80.025n

.meas tran vdout0_64ck150 FIND v(dout0_64) AT=80.025n

.meas tran vdout0_65ck150 FIND v(dout0_65) AT=80.025n

.meas tran vdout0_66ck150 FIND v(dout0_66) AT=80.025n

.meas tran vdout0_67ck150 FIND v(dout0_67) AT=80.025n

.meas tran vdout0_68ck150 FIND v(dout0_68) AT=80.025n

.meas tran vdout0_69ck150 FIND v(dout0_69) AT=80.025n

.meas tran vdout0_70ck150 FIND v(dout0_70) AT=80.025n

.meas tran vdout0_71ck150 FIND v(dout0_71) AT=80.025n

.meas tran vdout0_72ck150 FIND v(dout0_72) AT=80.025n

.meas tran vdout0_73ck150 FIND v(dout0_73) AT=80.025n

.meas tran vdout0_74ck150 FIND v(dout0_74) AT=80.025n

.meas tran vdout0_75ck150 FIND v(dout0_75) AT=80.025n

.meas tran vdout0_76ck150 FIND v(dout0_76) AT=80.025n

.meas tran vdout0_77ck150 FIND v(dout0_77) AT=80.025n

.meas tran vdout0_78ck150 FIND v(dout0_78) AT=80.025n

.meas tran vdout0_79ck150 FIND v(dout0_79) AT=80.025n

.meas tran vdout0_80ck150 FIND v(dout0_80) AT=80.025n

.meas tran vdout0_81ck150 FIND v(dout0_81) AT=80.025n

.meas tran vdout0_82ck150 FIND v(dout0_82) AT=80.025n

.meas tran vdout0_83ck150 FIND v(dout0_83) AT=80.025n

.meas tran vdout0_84ck150 FIND v(dout0_84) AT=80.025n

.meas tran vdout0_85ck150 FIND v(dout0_85) AT=80.025n

.meas tran vdout0_86ck150 FIND v(dout0_86) AT=80.025n

.meas tran vdout0_87ck150 FIND v(dout0_87) AT=80.025n

.meas tran vdout0_88ck150 FIND v(dout0_88) AT=80.025n

.meas tran vdout0_89ck150 FIND v(dout0_89) AT=80.025n

.meas tran vdout0_90ck150 FIND v(dout0_90) AT=80.025n

.meas tran vdout0_91ck150 FIND v(dout0_91) AT=80.025n

.meas tran vdout0_92ck150 FIND v(dout0_92) AT=80.025n

.meas tran vdout0_93ck150 FIND v(dout0_93) AT=80.025n

.meas tran vdout0_94ck150 FIND v(dout0_94) AT=80.025n

.meas tran vdout0_95ck150 FIND v(dout0_95) AT=80.025n

.meas tran vdout0_96ck150 FIND v(dout0_96) AT=80.025n

.meas tran vdout0_97ck150 FIND v(dout0_97) AT=80.025n

.meas tran vdout0_98ck150 FIND v(dout0_98) AT=80.025n

.meas tran vdout0_99ck150 FIND v(dout0_99) AT=80.025n

.meas tran vdout0_100ck150 FIND v(dout0_100) AT=80.025n

.meas tran vdout0_101ck150 FIND v(dout0_101) AT=80.025n

.meas tran vdout0_102ck150 FIND v(dout0_102) AT=80.025n

.meas tran vdout0_103ck150 FIND v(dout0_103) AT=80.025n

.meas tran vdout0_104ck150 FIND v(dout0_104) AT=80.025n

.meas tran vdout0_105ck150 FIND v(dout0_105) AT=80.025n

.meas tran vdout0_106ck150 FIND v(dout0_106) AT=80.025n

.meas tran vdout0_107ck150 FIND v(dout0_107) AT=80.025n

.meas tran vdout0_108ck150 FIND v(dout0_108) AT=80.025n

.meas tran vdout0_109ck150 FIND v(dout0_109) AT=80.025n

.meas tran vdout0_110ck150 FIND v(dout0_110) AT=80.025n

.meas tran vdout0_111ck150 FIND v(dout0_111) AT=80.025n

.meas tran vdout0_112ck150 FIND v(dout0_112) AT=80.025n

.meas tran vdout0_113ck150 FIND v(dout0_113) AT=80.025n

.meas tran vdout0_114ck150 FIND v(dout0_114) AT=80.025n

.meas tran vdout0_115ck150 FIND v(dout0_115) AT=80.025n

.meas tran vdout0_116ck150 FIND v(dout0_116) AT=80.025n

.meas tran vdout0_117ck150 FIND v(dout0_117) AT=80.025n

.meas tran vdout0_118ck150 FIND v(dout0_118) AT=80.025n

.meas tran vdout0_119ck150 FIND v(dout0_119) AT=80.025n

.meas tran vdout0_120ck150 FIND v(dout0_120) AT=80.025n

.meas tran vdout0_121ck150 FIND v(dout0_121) AT=80.025n

.meas tran vdout0_122ck150 FIND v(dout0_122) AT=80.025n

.meas tran vdout0_123ck150 FIND v(dout0_123) AT=80.025n

.meas tran vdout0_124ck150 FIND v(dout0_124) AT=80.025n

.meas tran vdout0_125ck150 FIND v(dout0_125) AT=80.025n

.meas tran vdout0_126ck150 FIND v(dout0_126) AT=80.025n

.meas tran vdout0_127ck150 FIND v(dout0_127) AT=80.025n

.meas tran vdout0_0ck160 FIND v(dout0_0) AT=85.025n

.meas tran vdout0_1ck160 FIND v(dout0_1) AT=85.025n

.meas tran vdout0_2ck160 FIND v(dout0_2) AT=85.025n

.meas tran vdout0_3ck160 FIND v(dout0_3) AT=85.025n

.meas tran vdout0_4ck160 FIND v(dout0_4) AT=85.025n

.meas tran vdout0_5ck160 FIND v(dout0_5) AT=85.025n

.meas tran vdout0_6ck160 FIND v(dout0_6) AT=85.025n

.meas tran vdout0_7ck160 FIND v(dout0_7) AT=85.025n

.meas tran vdout0_8ck160 FIND v(dout0_8) AT=85.025n

.meas tran vdout0_9ck160 FIND v(dout0_9) AT=85.025n

.meas tran vdout0_10ck160 FIND v(dout0_10) AT=85.025n

.meas tran vdout0_11ck160 FIND v(dout0_11) AT=85.025n

.meas tran vdout0_12ck160 FIND v(dout0_12) AT=85.025n

.meas tran vdout0_13ck160 FIND v(dout0_13) AT=85.025n

.meas tran vdout0_14ck160 FIND v(dout0_14) AT=85.025n

.meas tran vdout0_15ck160 FIND v(dout0_15) AT=85.025n

.meas tran vdout0_16ck160 FIND v(dout0_16) AT=85.025n

.meas tran vdout0_17ck160 FIND v(dout0_17) AT=85.025n

.meas tran vdout0_18ck160 FIND v(dout0_18) AT=85.025n

.meas tran vdout0_19ck160 FIND v(dout0_19) AT=85.025n

.meas tran vdout0_20ck160 FIND v(dout0_20) AT=85.025n

.meas tran vdout0_21ck160 FIND v(dout0_21) AT=85.025n

.meas tran vdout0_22ck160 FIND v(dout0_22) AT=85.025n

.meas tran vdout0_23ck160 FIND v(dout0_23) AT=85.025n

.meas tran vdout0_24ck160 FIND v(dout0_24) AT=85.025n

.meas tran vdout0_25ck160 FIND v(dout0_25) AT=85.025n

.meas tran vdout0_26ck160 FIND v(dout0_26) AT=85.025n

.meas tran vdout0_27ck160 FIND v(dout0_27) AT=85.025n

.meas tran vdout0_28ck160 FIND v(dout0_28) AT=85.025n

.meas tran vdout0_29ck160 FIND v(dout0_29) AT=85.025n

.meas tran vdout0_30ck160 FIND v(dout0_30) AT=85.025n

.meas tran vdout0_31ck160 FIND v(dout0_31) AT=85.025n

.meas tran vdout0_32ck160 FIND v(dout0_32) AT=85.025n

.meas tran vdout0_33ck160 FIND v(dout0_33) AT=85.025n

.meas tran vdout0_34ck160 FIND v(dout0_34) AT=85.025n

.meas tran vdout0_35ck160 FIND v(dout0_35) AT=85.025n

.meas tran vdout0_36ck160 FIND v(dout0_36) AT=85.025n

.meas tran vdout0_37ck160 FIND v(dout0_37) AT=85.025n

.meas tran vdout0_38ck160 FIND v(dout0_38) AT=85.025n

.meas tran vdout0_39ck160 FIND v(dout0_39) AT=85.025n

.meas tran vdout0_40ck160 FIND v(dout0_40) AT=85.025n

.meas tran vdout0_41ck160 FIND v(dout0_41) AT=85.025n

.meas tran vdout0_42ck160 FIND v(dout0_42) AT=85.025n

.meas tran vdout0_43ck160 FIND v(dout0_43) AT=85.025n

.meas tran vdout0_44ck160 FIND v(dout0_44) AT=85.025n

.meas tran vdout0_45ck160 FIND v(dout0_45) AT=85.025n

.meas tran vdout0_46ck160 FIND v(dout0_46) AT=85.025n

.meas tran vdout0_47ck160 FIND v(dout0_47) AT=85.025n

.meas tran vdout0_48ck160 FIND v(dout0_48) AT=85.025n

.meas tran vdout0_49ck160 FIND v(dout0_49) AT=85.025n

.meas tran vdout0_50ck160 FIND v(dout0_50) AT=85.025n

.meas tran vdout0_51ck160 FIND v(dout0_51) AT=85.025n

.meas tran vdout0_52ck160 FIND v(dout0_52) AT=85.025n

.meas tran vdout0_53ck160 FIND v(dout0_53) AT=85.025n

.meas tran vdout0_54ck160 FIND v(dout0_54) AT=85.025n

.meas tran vdout0_55ck160 FIND v(dout0_55) AT=85.025n

.meas tran vdout0_56ck160 FIND v(dout0_56) AT=85.025n

.meas tran vdout0_57ck160 FIND v(dout0_57) AT=85.025n

.meas tran vdout0_58ck160 FIND v(dout0_58) AT=85.025n

.meas tran vdout0_59ck160 FIND v(dout0_59) AT=85.025n

.meas tran vdout0_60ck160 FIND v(dout0_60) AT=85.025n

.meas tran vdout0_61ck160 FIND v(dout0_61) AT=85.025n

.meas tran vdout0_62ck160 FIND v(dout0_62) AT=85.025n

.meas tran vdout0_63ck160 FIND v(dout0_63) AT=85.025n

.meas tran vdout0_64ck160 FIND v(dout0_64) AT=85.025n

.meas tran vdout0_65ck160 FIND v(dout0_65) AT=85.025n

.meas tran vdout0_66ck160 FIND v(dout0_66) AT=85.025n

.meas tran vdout0_67ck160 FIND v(dout0_67) AT=85.025n

.meas tran vdout0_68ck160 FIND v(dout0_68) AT=85.025n

.meas tran vdout0_69ck160 FIND v(dout0_69) AT=85.025n

.meas tran vdout0_70ck160 FIND v(dout0_70) AT=85.025n

.meas tran vdout0_71ck160 FIND v(dout0_71) AT=85.025n

.meas tran vdout0_72ck160 FIND v(dout0_72) AT=85.025n

.meas tran vdout0_73ck160 FIND v(dout0_73) AT=85.025n

.meas tran vdout0_74ck160 FIND v(dout0_74) AT=85.025n

.meas tran vdout0_75ck160 FIND v(dout0_75) AT=85.025n

.meas tran vdout0_76ck160 FIND v(dout0_76) AT=85.025n

.meas tran vdout0_77ck160 FIND v(dout0_77) AT=85.025n

.meas tran vdout0_78ck160 FIND v(dout0_78) AT=85.025n

.meas tran vdout0_79ck160 FIND v(dout0_79) AT=85.025n

.meas tran vdout0_80ck160 FIND v(dout0_80) AT=85.025n

.meas tran vdout0_81ck160 FIND v(dout0_81) AT=85.025n

.meas tran vdout0_82ck160 FIND v(dout0_82) AT=85.025n

.meas tran vdout0_83ck160 FIND v(dout0_83) AT=85.025n

.meas tran vdout0_84ck160 FIND v(dout0_84) AT=85.025n

.meas tran vdout0_85ck160 FIND v(dout0_85) AT=85.025n

.meas tran vdout0_86ck160 FIND v(dout0_86) AT=85.025n

.meas tran vdout0_87ck160 FIND v(dout0_87) AT=85.025n

.meas tran vdout0_88ck160 FIND v(dout0_88) AT=85.025n

.meas tran vdout0_89ck160 FIND v(dout0_89) AT=85.025n

.meas tran vdout0_90ck160 FIND v(dout0_90) AT=85.025n

.meas tran vdout0_91ck160 FIND v(dout0_91) AT=85.025n

.meas tran vdout0_92ck160 FIND v(dout0_92) AT=85.025n

.meas tran vdout0_93ck160 FIND v(dout0_93) AT=85.025n

.meas tran vdout0_94ck160 FIND v(dout0_94) AT=85.025n

.meas tran vdout0_95ck160 FIND v(dout0_95) AT=85.025n

.meas tran vdout0_96ck160 FIND v(dout0_96) AT=85.025n

.meas tran vdout0_97ck160 FIND v(dout0_97) AT=85.025n

.meas tran vdout0_98ck160 FIND v(dout0_98) AT=85.025n

.meas tran vdout0_99ck160 FIND v(dout0_99) AT=85.025n

.meas tran vdout0_100ck160 FIND v(dout0_100) AT=85.025n

.meas tran vdout0_101ck160 FIND v(dout0_101) AT=85.025n

.meas tran vdout0_102ck160 FIND v(dout0_102) AT=85.025n

.meas tran vdout0_103ck160 FIND v(dout0_103) AT=85.025n

.meas tran vdout0_104ck160 FIND v(dout0_104) AT=85.025n

.meas tran vdout0_105ck160 FIND v(dout0_105) AT=85.025n

.meas tran vdout0_106ck160 FIND v(dout0_106) AT=85.025n

.meas tran vdout0_107ck160 FIND v(dout0_107) AT=85.025n

.meas tran vdout0_108ck160 FIND v(dout0_108) AT=85.025n

.meas tran vdout0_109ck160 FIND v(dout0_109) AT=85.025n

.meas tran vdout0_110ck160 FIND v(dout0_110) AT=85.025n

.meas tran vdout0_111ck160 FIND v(dout0_111) AT=85.025n

.meas tran vdout0_112ck160 FIND v(dout0_112) AT=85.025n

.meas tran vdout0_113ck160 FIND v(dout0_113) AT=85.025n

.meas tran vdout0_114ck160 FIND v(dout0_114) AT=85.025n

.meas tran vdout0_115ck160 FIND v(dout0_115) AT=85.025n

.meas tran vdout0_116ck160 FIND v(dout0_116) AT=85.025n

.meas tran vdout0_117ck160 FIND v(dout0_117) AT=85.025n

.meas tran vdout0_118ck160 FIND v(dout0_118) AT=85.025n

.meas tran vdout0_119ck160 FIND v(dout0_119) AT=85.025n

.meas tran vdout0_120ck160 FIND v(dout0_120) AT=85.025n

.meas tran vdout0_121ck160 FIND v(dout0_121) AT=85.025n

.meas tran vdout0_122ck160 FIND v(dout0_122) AT=85.025n

.meas tran vdout0_123ck160 FIND v(dout0_123) AT=85.025n

.meas tran vdout0_124ck160 FIND v(dout0_124) AT=85.025n

.meas tran vdout0_125ck160 FIND v(dout0_125) AT=85.025n

.meas tran vdout0_126ck160 FIND v(dout0_126) AT=85.025n

.meas tran vdout0_127ck160 FIND v(dout0_127) AT=85.025n

.meas tran vdout0_0ck170 FIND v(dout0_0) AT=90.025n

.meas tran vdout0_1ck170 FIND v(dout0_1) AT=90.025n

.meas tran vdout0_2ck170 FIND v(dout0_2) AT=90.025n

.meas tran vdout0_3ck170 FIND v(dout0_3) AT=90.025n

.meas tran vdout0_4ck170 FIND v(dout0_4) AT=90.025n

.meas tran vdout0_5ck170 FIND v(dout0_5) AT=90.025n

.meas tran vdout0_6ck170 FIND v(dout0_6) AT=90.025n

.meas tran vdout0_7ck170 FIND v(dout0_7) AT=90.025n

.meas tran vdout0_8ck170 FIND v(dout0_8) AT=90.025n

.meas tran vdout0_9ck170 FIND v(dout0_9) AT=90.025n

.meas tran vdout0_10ck170 FIND v(dout0_10) AT=90.025n

.meas tran vdout0_11ck170 FIND v(dout0_11) AT=90.025n

.meas tran vdout0_12ck170 FIND v(dout0_12) AT=90.025n

.meas tran vdout0_13ck170 FIND v(dout0_13) AT=90.025n

.meas tran vdout0_14ck170 FIND v(dout0_14) AT=90.025n

.meas tran vdout0_15ck170 FIND v(dout0_15) AT=90.025n

.meas tran vdout0_16ck170 FIND v(dout0_16) AT=90.025n

.meas tran vdout0_17ck170 FIND v(dout0_17) AT=90.025n

.meas tran vdout0_18ck170 FIND v(dout0_18) AT=90.025n

.meas tran vdout0_19ck170 FIND v(dout0_19) AT=90.025n

.meas tran vdout0_20ck170 FIND v(dout0_20) AT=90.025n

.meas tran vdout0_21ck170 FIND v(dout0_21) AT=90.025n

.meas tran vdout0_22ck170 FIND v(dout0_22) AT=90.025n

.meas tran vdout0_23ck170 FIND v(dout0_23) AT=90.025n

.meas tran vdout0_24ck170 FIND v(dout0_24) AT=90.025n

.meas tran vdout0_25ck170 FIND v(dout0_25) AT=90.025n

.meas tran vdout0_26ck170 FIND v(dout0_26) AT=90.025n

.meas tran vdout0_27ck170 FIND v(dout0_27) AT=90.025n

.meas tran vdout0_28ck170 FIND v(dout0_28) AT=90.025n

.meas tran vdout0_29ck170 FIND v(dout0_29) AT=90.025n

.meas tran vdout0_30ck170 FIND v(dout0_30) AT=90.025n

.meas tran vdout0_31ck170 FIND v(dout0_31) AT=90.025n

.meas tran vdout0_32ck170 FIND v(dout0_32) AT=90.025n

.meas tran vdout0_33ck170 FIND v(dout0_33) AT=90.025n

.meas tran vdout0_34ck170 FIND v(dout0_34) AT=90.025n

.meas tran vdout0_35ck170 FIND v(dout0_35) AT=90.025n

.meas tran vdout0_36ck170 FIND v(dout0_36) AT=90.025n

.meas tran vdout0_37ck170 FIND v(dout0_37) AT=90.025n

.meas tran vdout0_38ck170 FIND v(dout0_38) AT=90.025n

.meas tran vdout0_39ck170 FIND v(dout0_39) AT=90.025n

.meas tran vdout0_40ck170 FIND v(dout0_40) AT=90.025n

.meas tran vdout0_41ck170 FIND v(dout0_41) AT=90.025n

.meas tran vdout0_42ck170 FIND v(dout0_42) AT=90.025n

.meas tran vdout0_43ck170 FIND v(dout0_43) AT=90.025n

.meas tran vdout0_44ck170 FIND v(dout0_44) AT=90.025n

.meas tran vdout0_45ck170 FIND v(dout0_45) AT=90.025n

.meas tran vdout0_46ck170 FIND v(dout0_46) AT=90.025n

.meas tran vdout0_47ck170 FIND v(dout0_47) AT=90.025n

.meas tran vdout0_48ck170 FIND v(dout0_48) AT=90.025n

.meas tran vdout0_49ck170 FIND v(dout0_49) AT=90.025n

.meas tran vdout0_50ck170 FIND v(dout0_50) AT=90.025n

.meas tran vdout0_51ck170 FIND v(dout0_51) AT=90.025n

.meas tran vdout0_52ck170 FIND v(dout0_52) AT=90.025n

.meas tran vdout0_53ck170 FIND v(dout0_53) AT=90.025n

.meas tran vdout0_54ck170 FIND v(dout0_54) AT=90.025n

.meas tran vdout0_55ck170 FIND v(dout0_55) AT=90.025n

.meas tran vdout0_56ck170 FIND v(dout0_56) AT=90.025n

.meas tran vdout0_57ck170 FIND v(dout0_57) AT=90.025n

.meas tran vdout0_58ck170 FIND v(dout0_58) AT=90.025n

.meas tran vdout0_59ck170 FIND v(dout0_59) AT=90.025n

.meas tran vdout0_60ck170 FIND v(dout0_60) AT=90.025n

.meas tran vdout0_61ck170 FIND v(dout0_61) AT=90.025n

.meas tran vdout0_62ck170 FIND v(dout0_62) AT=90.025n

.meas tran vdout0_63ck170 FIND v(dout0_63) AT=90.025n

.meas tran vdout0_64ck170 FIND v(dout0_64) AT=90.025n

.meas tran vdout0_65ck170 FIND v(dout0_65) AT=90.025n

.meas tran vdout0_66ck170 FIND v(dout0_66) AT=90.025n

.meas tran vdout0_67ck170 FIND v(dout0_67) AT=90.025n

.meas tran vdout0_68ck170 FIND v(dout0_68) AT=90.025n

.meas tran vdout0_69ck170 FIND v(dout0_69) AT=90.025n

.meas tran vdout0_70ck170 FIND v(dout0_70) AT=90.025n

.meas tran vdout0_71ck170 FIND v(dout0_71) AT=90.025n

.meas tran vdout0_72ck170 FIND v(dout0_72) AT=90.025n

.meas tran vdout0_73ck170 FIND v(dout0_73) AT=90.025n

.meas tran vdout0_74ck170 FIND v(dout0_74) AT=90.025n

.meas tran vdout0_75ck170 FIND v(dout0_75) AT=90.025n

.meas tran vdout0_76ck170 FIND v(dout0_76) AT=90.025n

.meas tran vdout0_77ck170 FIND v(dout0_77) AT=90.025n

.meas tran vdout0_78ck170 FIND v(dout0_78) AT=90.025n

.meas tran vdout0_79ck170 FIND v(dout0_79) AT=90.025n

.meas tran vdout0_80ck170 FIND v(dout0_80) AT=90.025n

.meas tran vdout0_81ck170 FIND v(dout0_81) AT=90.025n

.meas tran vdout0_82ck170 FIND v(dout0_82) AT=90.025n

.meas tran vdout0_83ck170 FIND v(dout0_83) AT=90.025n

.meas tran vdout0_84ck170 FIND v(dout0_84) AT=90.025n

.meas tran vdout0_85ck170 FIND v(dout0_85) AT=90.025n

.meas tran vdout0_86ck170 FIND v(dout0_86) AT=90.025n

.meas tran vdout0_87ck170 FIND v(dout0_87) AT=90.025n

.meas tran vdout0_88ck170 FIND v(dout0_88) AT=90.025n

.meas tran vdout0_89ck170 FIND v(dout0_89) AT=90.025n

.meas tran vdout0_90ck170 FIND v(dout0_90) AT=90.025n

.meas tran vdout0_91ck170 FIND v(dout0_91) AT=90.025n

.meas tran vdout0_92ck170 FIND v(dout0_92) AT=90.025n

.meas tran vdout0_93ck170 FIND v(dout0_93) AT=90.025n

.meas tran vdout0_94ck170 FIND v(dout0_94) AT=90.025n

.meas tran vdout0_95ck170 FIND v(dout0_95) AT=90.025n

.meas tran vdout0_96ck170 FIND v(dout0_96) AT=90.025n

.meas tran vdout0_97ck170 FIND v(dout0_97) AT=90.025n

.meas tran vdout0_98ck170 FIND v(dout0_98) AT=90.025n

.meas tran vdout0_99ck170 FIND v(dout0_99) AT=90.025n

.meas tran vdout0_100ck170 FIND v(dout0_100) AT=90.025n

.meas tran vdout0_101ck170 FIND v(dout0_101) AT=90.025n

.meas tran vdout0_102ck170 FIND v(dout0_102) AT=90.025n

.meas tran vdout0_103ck170 FIND v(dout0_103) AT=90.025n

.meas tran vdout0_104ck170 FIND v(dout0_104) AT=90.025n

.meas tran vdout0_105ck170 FIND v(dout0_105) AT=90.025n

.meas tran vdout0_106ck170 FIND v(dout0_106) AT=90.025n

.meas tran vdout0_107ck170 FIND v(dout0_107) AT=90.025n

.meas tran vdout0_108ck170 FIND v(dout0_108) AT=90.025n

.meas tran vdout0_109ck170 FIND v(dout0_109) AT=90.025n

.meas tran vdout0_110ck170 FIND v(dout0_110) AT=90.025n

.meas tran vdout0_111ck170 FIND v(dout0_111) AT=90.025n

.meas tran vdout0_112ck170 FIND v(dout0_112) AT=90.025n

.meas tran vdout0_113ck170 FIND v(dout0_113) AT=90.025n

.meas tran vdout0_114ck170 FIND v(dout0_114) AT=90.025n

.meas tran vdout0_115ck170 FIND v(dout0_115) AT=90.025n

.meas tran vdout0_116ck170 FIND v(dout0_116) AT=90.025n

.meas tran vdout0_117ck170 FIND v(dout0_117) AT=90.025n

.meas tran vdout0_118ck170 FIND v(dout0_118) AT=90.025n

.meas tran vdout0_119ck170 FIND v(dout0_119) AT=90.025n

.meas tran vdout0_120ck170 FIND v(dout0_120) AT=90.025n

.meas tran vdout0_121ck170 FIND v(dout0_121) AT=90.025n

.meas tran vdout0_122ck170 FIND v(dout0_122) AT=90.025n

.meas tran vdout0_123ck170 FIND v(dout0_123) AT=90.025n

.meas tran vdout0_124ck170 FIND v(dout0_124) AT=90.025n

.meas tran vdout0_125ck170 FIND v(dout0_125) AT=90.025n

.meas tran vdout0_126ck170 FIND v(dout0_126) AT=90.025n

.meas tran vdout0_127ck170 FIND v(dout0_127) AT=90.025n

.meas tran vdout0_0ck180 FIND v(dout0_0) AT=95.025n

.meas tran vdout0_1ck180 FIND v(dout0_1) AT=95.025n

.meas tran vdout0_2ck180 FIND v(dout0_2) AT=95.025n

.meas tran vdout0_3ck180 FIND v(dout0_3) AT=95.025n

.meas tran vdout0_4ck180 FIND v(dout0_4) AT=95.025n

.meas tran vdout0_5ck180 FIND v(dout0_5) AT=95.025n

.meas tran vdout0_6ck180 FIND v(dout0_6) AT=95.025n

.meas tran vdout0_7ck180 FIND v(dout0_7) AT=95.025n

.meas tran vdout0_8ck180 FIND v(dout0_8) AT=95.025n

.meas tran vdout0_9ck180 FIND v(dout0_9) AT=95.025n

.meas tran vdout0_10ck180 FIND v(dout0_10) AT=95.025n

.meas tran vdout0_11ck180 FIND v(dout0_11) AT=95.025n

.meas tran vdout0_12ck180 FIND v(dout0_12) AT=95.025n

.meas tran vdout0_13ck180 FIND v(dout0_13) AT=95.025n

.meas tran vdout0_14ck180 FIND v(dout0_14) AT=95.025n

.meas tran vdout0_15ck180 FIND v(dout0_15) AT=95.025n

.meas tran vdout0_16ck180 FIND v(dout0_16) AT=95.025n

.meas tran vdout0_17ck180 FIND v(dout0_17) AT=95.025n

.meas tran vdout0_18ck180 FIND v(dout0_18) AT=95.025n

.meas tran vdout0_19ck180 FIND v(dout0_19) AT=95.025n

.meas tran vdout0_20ck180 FIND v(dout0_20) AT=95.025n

.meas tran vdout0_21ck180 FIND v(dout0_21) AT=95.025n

.meas tran vdout0_22ck180 FIND v(dout0_22) AT=95.025n

.meas tran vdout0_23ck180 FIND v(dout0_23) AT=95.025n

.meas tran vdout0_24ck180 FIND v(dout0_24) AT=95.025n

.meas tran vdout0_25ck180 FIND v(dout0_25) AT=95.025n

.meas tran vdout0_26ck180 FIND v(dout0_26) AT=95.025n

.meas tran vdout0_27ck180 FIND v(dout0_27) AT=95.025n

.meas tran vdout0_28ck180 FIND v(dout0_28) AT=95.025n

.meas tran vdout0_29ck180 FIND v(dout0_29) AT=95.025n

.meas tran vdout0_30ck180 FIND v(dout0_30) AT=95.025n

.meas tran vdout0_31ck180 FIND v(dout0_31) AT=95.025n

.meas tran vdout0_32ck180 FIND v(dout0_32) AT=95.025n

.meas tran vdout0_33ck180 FIND v(dout0_33) AT=95.025n

.meas tran vdout0_34ck180 FIND v(dout0_34) AT=95.025n

.meas tran vdout0_35ck180 FIND v(dout0_35) AT=95.025n

.meas tran vdout0_36ck180 FIND v(dout0_36) AT=95.025n

.meas tran vdout0_37ck180 FIND v(dout0_37) AT=95.025n

.meas tran vdout0_38ck180 FIND v(dout0_38) AT=95.025n

.meas tran vdout0_39ck180 FIND v(dout0_39) AT=95.025n

.meas tran vdout0_40ck180 FIND v(dout0_40) AT=95.025n

.meas tran vdout0_41ck180 FIND v(dout0_41) AT=95.025n

.meas tran vdout0_42ck180 FIND v(dout0_42) AT=95.025n

.meas tran vdout0_43ck180 FIND v(dout0_43) AT=95.025n

.meas tran vdout0_44ck180 FIND v(dout0_44) AT=95.025n

.meas tran vdout0_45ck180 FIND v(dout0_45) AT=95.025n

.meas tran vdout0_46ck180 FIND v(dout0_46) AT=95.025n

.meas tran vdout0_47ck180 FIND v(dout0_47) AT=95.025n

.meas tran vdout0_48ck180 FIND v(dout0_48) AT=95.025n

.meas tran vdout0_49ck180 FIND v(dout0_49) AT=95.025n

.meas tran vdout0_50ck180 FIND v(dout0_50) AT=95.025n

.meas tran vdout0_51ck180 FIND v(dout0_51) AT=95.025n

.meas tran vdout0_52ck180 FIND v(dout0_52) AT=95.025n

.meas tran vdout0_53ck180 FIND v(dout0_53) AT=95.025n

.meas tran vdout0_54ck180 FIND v(dout0_54) AT=95.025n

.meas tran vdout0_55ck180 FIND v(dout0_55) AT=95.025n

.meas tran vdout0_56ck180 FIND v(dout0_56) AT=95.025n

.meas tran vdout0_57ck180 FIND v(dout0_57) AT=95.025n

.meas tran vdout0_58ck180 FIND v(dout0_58) AT=95.025n

.meas tran vdout0_59ck180 FIND v(dout0_59) AT=95.025n

.meas tran vdout0_60ck180 FIND v(dout0_60) AT=95.025n

.meas tran vdout0_61ck180 FIND v(dout0_61) AT=95.025n

.meas tran vdout0_62ck180 FIND v(dout0_62) AT=95.025n

.meas tran vdout0_63ck180 FIND v(dout0_63) AT=95.025n

.meas tran vdout0_64ck180 FIND v(dout0_64) AT=95.025n

.meas tran vdout0_65ck180 FIND v(dout0_65) AT=95.025n

.meas tran vdout0_66ck180 FIND v(dout0_66) AT=95.025n

.meas tran vdout0_67ck180 FIND v(dout0_67) AT=95.025n

.meas tran vdout0_68ck180 FIND v(dout0_68) AT=95.025n

.meas tran vdout0_69ck180 FIND v(dout0_69) AT=95.025n

.meas tran vdout0_70ck180 FIND v(dout0_70) AT=95.025n

.meas tran vdout0_71ck180 FIND v(dout0_71) AT=95.025n

.meas tran vdout0_72ck180 FIND v(dout0_72) AT=95.025n

.meas tran vdout0_73ck180 FIND v(dout0_73) AT=95.025n

.meas tran vdout0_74ck180 FIND v(dout0_74) AT=95.025n

.meas tran vdout0_75ck180 FIND v(dout0_75) AT=95.025n

.meas tran vdout0_76ck180 FIND v(dout0_76) AT=95.025n

.meas tran vdout0_77ck180 FIND v(dout0_77) AT=95.025n

.meas tran vdout0_78ck180 FIND v(dout0_78) AT=95.025n

.meas tran vdout0_79ck180 FIND v(dout0_79) AT=95.025n

.meas tran vdout0_80ck180 FIND v(dout0_80) AT=95.025n

.meas tran vdout0_81ck180 FIND v(dout0_81) AT=95.025n

.meas tran vdout0_82ck180 FIND v(dout0_82) AT=95.025n

.meas tran vdout0_83ck180 FIND v(dout0_83) AT=95.025n

.meas tran vdout0_84ck180 FIND v(dout0_84) AT=95.025n

.meas tran vdout0_85ck180 FIND v(dout0_85) AT=95.025n

.meas tran vdout0_86ck180 FIND v(dout0_86) AT=95.025n

.meas tran vdout0_87ck180 FIND v(dout0_87) AT=95.025n

.meas tran vdout0_88ck180 FIND v(dout0_88) AT=95.025n

.meas tran vdout0_89ck180 FIND v(dout0_89) AT=95.025n

.meas tran vdout0_90ck180 FIND v(dout0_90) AT=95.025n

.meas tran vdout0_91ck180 FIND v(dout0_91) AT=95.025n

.meas tran vdout0_92ck180 FIND v(dout0_92) AT=95.025n

.meas tran vdout0_93ck180 FIND v(dout0_93) AT=95.025n

.meas tran vdout0_94ck180 FIND v(dout0_94) AT=95.025n

.meas tran vdout0_95ck180 FIND v(dout0_95) AT=95.025n

.meas tran vdout0_96ck180 FIND v(dout0_96) AT=95.025n

.meas tran vdout0_97ck180 FIND v(dout0_97) AT=95.025n

.meas tran vdout0_98ck180 FIND v(dout0_98) AT=95.025n

.meas tran vdout0_99ck180 FIND v(dout0_99) AT=95.025n

.meas tran vdout0_100ck180 FIND v(dout0_100) AT=95.025n

.meas tran vdout0_101ck180 FIND v(dout0_101) AT=95.025n

.meas tran vdout0_102ck180 FIND v(dout0_102) AT=95.025n

.meas tran vdout0_103ck180 FIND v(dout0_103) AT=95.025n

.meas tran vdout0_104ck180 FIND v(dout0_104) AT=95.025n

.meas tran vdout0_105ck180 FIND v(dout0_105) AT=95.025n

.meas tran vdout0_106ck180 FIND v(dout0_106) AT=95.025n

.meas tran vdout0_107ck180 FIND v(dout0_107) AT=95.025n

.meas tran vdout0_108ck180 FIND v(dout0_108) AT=95.025n

.meas tran vdout0_109ck180 FIND v(dout0_109) AT=95.025n

.meas tran vdout0_110ck180 FIND v(dout0_110) AT=95.025n

.meas tran vdout0_111ck180 FIND v(dout0_111) AT=95.025n

.meas tran vdout0_112ck180 FIND v(dout0_112) AT=95.025n

.meas tran vdout0_113ck180 FIND v(dout0_113) AT=95.025n

.meas tran vdout0_114ck180 FIND v(dout0_114) AT=95.025n

.meas tran vdout0_115ck180 FIND v(dout0_115) AT=95.025n

.meas tran vdout0_116ck180 FIND v(dout0_116) AT=95.025n

.meas tran vdout0_117ck180 FIND v(dout0_117) AT=95.025n

.meas tran vdout0_118ck180 FIND v(dout0_118) AT=95.025n

.meas tran vdout0_119ck180 FIND v(dout0_119) AT=95.025n

.meas tran vdout0_120ck180 FIND v(dout0_120) AT=95.025n

.meas tran vdout0_121ck180 FIND v(dout0_121) AT=95.025n

.meas tran vdout0_122ck180 FIND v(dout0_122) AT=95.025n

.meas tran vdout0_123ck180 FIND v(dout0_123) AT=95.025n

.meas tran vdout0_124ck180 FIND v(dout0_124) AT=95.025n

.meas tran vdout0_125ck180 FIND v(dout0_125) AT=95.025n

.meas tran vdout0_126ck180 FIND v(dout0_126) AT=95.025n

.meas tran vdout0_127ck180 FIND v(dout0_127) AT=95.025n

.meas tran vdout0_0ck200 FIND v(dout0_0) AT=105.025n

.meas tran vdout0_1ck200 FIND v(dout0_1) AT=105.025n

.meas tran vdout0_2ck200 FIND v(dout0_2) AT=105.025n

.meas tran vdout0_3ck200 FIND v(dout0_3) AT=105.025n

.meas tran vdout0_4ck200 FIND v(dout0_4) AT=105.025n

.meas tran vdout0_5ck200 FIND v(dout0_5) AT=105.025n

.meas tran vdout0_6ck200 FIND v(dout0_6) AT=105.025n

.meas tran vdout0_7ck200 FIND v(dout0_7) AT=105.025n

.meas tran vdout0_8ck200 FIND v(dout0_8) AT=105.025n

.meas tran vdout0_9ck200 FIND v(dout0_9) AT=105.025n

.meas tran vdout0_10ck200 FIND v(dout0_10) AT=105.025n

.meas tran vdout0_11ck200 FIND v(dout0_11) AT=105.025n

.meas tran vdout0_12ck200 FIND v(dout0_12) AT=105.025n

.meas tran vdout0_13ck200 FIND v(dout0_13) AT=105.025n

.meas tran vdout0_14ck200 FIND v(dout0_14) AT=105.025n

.meas tran vdout0_15ck200 FIND v(dout0_15) AT=105.025n

.meas tran vdout0_16ck200 FIND v(dout0_16) AT=105.025n

.meas tran vdout0_17ck200 FIND v(dout0_17) AT=105.025n

.meas tran vdout0_18ck200 FIND v(dout0_18) AT=105.025n

.meas tran vdout0_19ck200 FIND v(dout0_19) AT=105.025n

.meas tran vdout0_20ck200 FIND v(dout0_20) AT=105.025n

.meas tran vdout0_21ck200 FIND v(dout0_21) AT=105.025n

.meas tran vdout0_22ck200 FIND v(dout0_22) AT=105.025n

.meas tran vdout0_23ck200 FIND v(dout0_23) AT=105.025n

.meas tran vdout0_24ck200 FIND v(dout0_24) AT=105.025n

.meas tran vdout0_25ck200 FIND v(dout0_25) AT=105.025n

.meas tran vdout0_26ck200 FIND v(dout0_26) AT=105.025n

.meas tran vdout0_27ck200 FIND v(dout0_27) AT=105.025n

.meas tran vdout0_28ck200 FIND v(dout0_28) AT=105.025n

.meas tran vdout0_29ck200 FIND v(dout0_29) AT=105.025n

.meas tran vdout0_30ck200 FIND v(dout0_30) AT=105.025n

.meas tran vdout0_31ck200 FIND v(dout0_31) AT=105.025n

.meas tran vdout0_32ck200 FIND v(dout0_32) AT=105.025n

.meas tran vdout0_33ck200 FIND v(dout0_33) AT=105.025n

.meas tran vdout0_34ck200 FIND v(dout0_34) AT=105.025n

.meas tran vdout0_35ck200 FIND v(dout0_35) AT=105.025n

.meas tran vdout0_36ck200 FIND v(dout0_36) AT=105.025n

.meas tran vdout0_37ck200 FIND v(dout0_37) AT=105.025n

.meas tran vdout0_38ck200 FIND v(dout0_38) AT=105.025n

.meas tran vdout0_39ck200 FIND v(dout0_39) AT=105.025n

.meas tran vdout0_40ck200 FIND v(dout0_40) AT=105.025n

.meas tran vdout0_41ck200 FIND v(dout0_41) AT=105.025n

.meas tran vdout0_42ck200 FIND v(dout0_42) AT=105.025n

.meas tran vdout0_43ck200 FIND v(dout0_43) AT=105.025n

.meas tran vdout0_44ck200 FIND v(dout0_44) AT=105.025n

.meas tran vdout0_45ck200 FIND v(dout0_45) AT=105.025n

.meas tran vdout0_46ck200 FIND v(dout0_46) AT=105.025n

.meas tran vdout0_47ck200 FIND v(dout0_47) AT=105.025n

.meas tran vdout0_48ck200 FIND v(dout0_48) AT=105.025n

.meas tran vdout0_49ck200 FIND v(dout0_49) AT=105.025n

.meas tran vdout0_50ck200 FIND v(dout0_50) AT=105.025n

.meas tran vdout0_51ck200 FIND v(dout0_51) AT=105.025n

.meas tran vdout0_52ck200 FIND v(dout0_52) AT=105.025n

.meas tran vdout0_53ck200 FIND v(dout0_53) AT=105.025n

.meas tran vdout0_54ck200 FIND v(dout0_54) AT=105.025n

.meas tran vdout0_55ck200 FIND v(dout0_55) AT=105.025n

.meas tran vdout0_56ck200 FIND v(dout0_56) AT=105.025n

.meas tran vdout0_57ck200 FIND v(dout0_57) AT=105.025n

.meas tran vdout0_58ck200 FIND v(dout0_58) AT=105.025n

.meas tran vdout0_59ck200 FIND v(dout0_59) AT=105.025n

.meas tran vdout0_60ck200 FIND v(dout0_60) AT=105.025n

.meas tran vdout0_61ck200 FIND v(dout0_61) AT=105.025n

.meas tran vdout0_62ck200 FIND v(dout0_62) AT=105.025n

.meas tran vdout0_63ck200 FIND v(dout0_63) AT=105.025n

.meas tran vdout0_64ck200 FIND v(dout0_64) AT=105.025n

.meas tran vdout0_65ck200 FIND v(dout0_65) AT=105.025n

.meas tran vdout0_66ck200 FIND v(dout0_66) AT=105.025n

.meas tran vdout0_67ck200 FIND v(dout0_67) AT=105.025n

.meas tran vdout0_68ck200 FIND v(dout0_68) AT=105.025n

.meas tran vdout0_69ck200 FIND v(dout0_69) AT=105.025n

.meas tran vdout0_70ck200 FIND v(dout0_70) AT=105.025n

.meas tran vdout0_71ck200 FIND v(dout0_71) AT=105.025n

.meas tran vdout0_72ck200 FIND v(dout0_72) AT=105.025n

.meas tran vdout0_73ck200 FIND v(dout0_73) AT=105.025n

.meas tran vdout0_74ck200 FIND v(dout0_74) AT=105.025n

.meas tran vdout0_75ck200 FIND v(dout0_75) AT=105.025n

.meas tran vdout0_76ck200 FIND v(dout0_76) AT=105.025n

.meas tran vdout0_77ck200 FIND v(dout0_77) AT=105.025n

.meas tran vdout0_78ck200 FIND v(dout0_78) AT=105.025n

.meas tran vdout0_79ck200 FIND v(dout0_79) AT=105.025n

.meas tran vdout0_80ck200 FIND v(dout0_80) AT=105.025n

.meas tran vdout0_81ck200 FIND v(dout0_81) AT=105.025n

.meas tran vdout0_82ck200 FIND v(dout0_82) AT=105.025n

.meas tran vdout0_83ck200 FIND v(dout0_83) AT=105.025n

.meas tran vdout0_84ck200 FIND v(dout0_84) AT=105.025n

.meas tran vdout0_85ck200 FIND v(dout0_85) AT=105.025n

.meas tran vdout0_86ck200 FIND v(dout0_86) AT=105.025n

.meas tran vdout0_87ck200 FIND v(dout0_87) AT=105.025n

.meas tran vdout0_88ck200 FIND v(dout0_88) AT=105.025n

.meas tran vdout0_89ck200 FIND v(dout0_89) AT=105.025n

.meas tran vdout0_90ck200 FIND v(dout0_90) AT=105.025n

.meas tran vdout0_91ck200 FIND v(dout0_91) AT=105.025n

.meas tran vdout0_92ck200 FIND v(dout0_92) AT=105.025n

.meas tran vdout0_93ck200 FIND v(dout0_93) AT=105.025n

.meas tran vdout0_94ck200 FIND v(dout0_94) AT=105.025n

.meas tran vdout0_95ck200 FIND v(dout0_95) AT=105.025n

.meas tran vdout0_96ck200 FIND v(dout0_96) AT=105.025n

.meas tran vdout0_97ck200 FIND v(dout0_97) AT=105.025n

.meas tran vdout0_98ck200 FIND v(dout0_98) AT=105.025n

.meas tran vdout0_99ck200 FIND v(dout0_99) AT=105.025n

.meas tran vdout0_100ck200 FIND v(dout0_100) AT=105.025n

.meas tran vdout0_101ck200 FIND v(dout0_101) AT=105.025n

.meas tran vdout0_102ck200 FIND v(dout0_102) AT=105.025n

.meas tran vdout0_103ck200 FIND v(dout0_103) AT=105.025n

.meas tran vdout0_104ck200 FIND v(dout0_104) AT=105.025n

.meas tran vdout0_105ck200 FIND v(dout0_105) AT=105.025n

.meas tran vdout0_106ck200 FIND v(dout0_106) AT=105.025n

.meas tran vdout0_107ck200 FIND v(dout0_107) AT=105.025n

.meas tran vdout0_108ck200 FIND v(dout0_108) AT=105.025n

.meas tran vdout0_109ck200 FIND v(dout0_109) AT=105.025n

.meas tran vdout0_110ck200 FIND v(dout0_110) AT=105.025n

.meas tran vdout0_111ck200 FIND v(dout0_111) AT=105.025n

.meas tran vdout0_112ck200 FIND v(dout0_112) AT=105.025n

.meas tran vdout0_113ck200 FIND v(dout0_113) AT=105.025n

.meas tran vdout0_114ck200 FIND v(dout0_114) AT=105.025n

.meas tran vdout0_115ck200 FIND v(dout0_115) AT=105.025n

.meas tran vdout0_116ck200 FIND v(dout0_116) AT=105.025n

.meas tran vdout0_117ck200 FIND v(dout0_117) AT=105.025n

.meas tran vdout0_118ck200 FIND v(dout0_118) AT=105.025n

.meas tran vdout0_119ck200 FIND v(dout0_119) AT=105.025n

.meas tran vdout0_120ck200 FIND v(dout0_120) AT=105.025n

.meas tran vdout0_121ck200 FIND v(dout0_121) AT=105.025n

.meas tran vdout0_122ck200 FIND v(dout0_122) AT=105.025n

.meas tran vdout0_123ck200 FIND v(dout0_123) AT=105.025n

.meas tran vdout0_124ck200 FIND v(dout0_124) AT=105.025n

.meas tran vdout0_125ck200 FIND v(dout0_125) AT=105.025n

.meas tran vdout0_126ck200 FIND v(dout0_126) AT=105.025n

.meas tran vdout0_127ck200 FIND v(dout0_127) AT=105.025n

.meas tran vdout0_0ck210 FIND v(dout0_0) AT=110.025n

.meas tran vdout0_1ck210 FIND v(dout0_1) AT=110.025n

.meas tran vdout0_2ck210 FIND v(dout0_2) AT=110.025n

.meas tran vdout0_3ck210 FIND v(dout0_3) AT=110.025n

.meas tran vdout0_4ck210 FIND v(dout0_4) AT=110.025n

.meas tran vdout0_5ck210 FIND v(dout0_5) AT=110.025n

.meas tran vdout0_6ck210 FIND v(dout0_6) AT=110.025n

.meas tran vdout0_7ck210 FIND v(dout0_7) AT=110.025n

.meas tran vdout0_8ck210 FIND v(dout0_8) AT=110.025n

.meas tran vdout0_9ck210 FIND v(dout0_9) AT=110.025n

.meas tran vdout0_10ck210 FIND v(dout0_10) AT=110.025n

.meas tran vdout0_11ck210 FIND v(dout0_11) AT=110.025n

.meas tran vdout0_12ck210 FIND v(dout0_12) AT=110.025n

.meas tran vdout0_13ck210 FIND v(dout0_13) AT=110.025n

.meas tran vdout0_14ck210 FIND v(dout0_14) AT=110.025n

.meas tran vdout0_15ck210 FIND v(dout0_15) AT=110.025n

.meas tran vdout0_16ck210 FIND v(dout0_16) AT=110.025n

.meas tran vdout0_17ck210 FIND v(dout0_17) AT=110.025n

.meas tran vdout0_18ck210 FIND v(dout0_18) AT=110.025n

.meas tran vdout0_19ck210 FIND v(dout0_19) AT=110.025n

.meas tran vdout0_20ck210 FIND v(dout0_20) AT=110.025n

.meas tran vdout0_21ck210 FIND v(dout0_21) AT=110.025n

.meas tran vdout0_22ck210 FIND v(dout0_22) AT=110.025n

.meas tran vdout0_23ck210 FIND v(dout0_23) AT=110.025n

.meas tran vdout0_24ck210 FIND v(dout0_24) AT=110.025n

.meas tran vdout0_25ck210 FIND v(dout0_25) AT=110.025n

.meas tran vdout0_26ck210 FIND v(dout0_26) AT=110.025n

.meas tran vdout0_27ck210 FIND v(dout0_27) AT=110.025n

.meas tran vdout0_28ck210 FIND v(dout0_28) AT=110.025n

.meas tran vdout0_29ck210 FIND v(dout0_29) AT=110.025n

.meas tran vdout0_30ck210 FIND v(dout0_30) AT=110.025n

.meas tran vdout0_31ck210 FIND v(dout0_31) AT=110.025n

.meas tran vdout0_32ck210 FIND v(dout0_32) AT=110.025n

.meas tran vdout0_33ck210 FIND v(dout0_33) AT=110.025n

.meas tran vdout0_34ck210 FIND v(dout0_34) AT=110.025n

.meas tran vdout0_35ck210 FIND v(dout0_35) AT=110.025n

.meas tran vdout0_36ck210 FIND v(dout0_36) AT=110.025n

.meas tran vdout0_37ck210 FIND v(dout0_37) AT=110.025n

.meas tran vdout0_38ck210 FIND v(dout0_38) AT=110.025n

.meas tran vdout0_39ck210 FIND v(dout0_39) AT=110.025n

.meas tran vdout0_40ck210 FIND v(dout0_40) AT=110.025n

.meas tran vdout0_41ck210 FIND v(dout0_41) AT=110.025n

.meas tran vdout0_42ck210 FIND v(dout0_42) AT=110.025n

.meas tran vdout0_43ck210 FIND v(dout0_43) AT=110.025n

.meas tran vdout0_44ck210 FIND v(dout0_44) AT=110.025n

.meas tran vdout0_45ck210 FIND v(dout0_45) AT=110.025n

.meas tran vdout0_46ck210 FIND v(dout0_46) AT=110.025n

.meas tran vdout0_47ck210 FIND v(dout0_47) AT=110.025n

.meas tran vdout0_48ck210 FIND v(dout0_48) AT=110.025n

.meas tran vdout0_49ck210 FIND v(dout0_49) AT=110.025n

.meas tran vdout0_50ck210 FIND v(dout0_50) AT=110.025n

.meas tran vdout0_51ck210 FIND v(dout0_51) AT=110.025n

.meas tran vdout0_52ck210 FIND v(dout0_52) AT=110.025n

.meas tran vdout0_53ck210 FIND v(dout0_53) AT=110.025n

.meas tran vdout0_54ck210 FIND v(dout0_54) AT=110.025n

.meas tran vdout0_55ck210 FIND v(dout0_55) AT=110.025n

.meas tran vdout0_56ck210 FIND v(dout0_56) AT=110.025n

.meas tran vdout0_57ck210 FIND v(dout0_57) AT=110.025n

.meas tran vdout0_58ck210 FIND v(dout0_58) AT=110.025n

.meas tran vdout0_59ck210 FIND v(dout0_59) AT=110.025n

.meas tran vdout0_60ck210 FIND v(dout0_60) AT=110.025n

.meas tran vdout0_61ck210 FIND v(dout0_61) AT=110.025n

.meas tran vdout0_62ck210 FIND v(dout0_62) AT=110.025n

.meas tran vdout0_63ck210 FIND v(dout0_63) AT=110.025n

.meas tran vdout0_64ck210 FIND v(dout0_64) AT=110.025n

.meas tran vdout0_65ck210 FIND v(dout0_65) AT=110.025n

.meas tran vdout0_66ck210 FIND v(dout0_66) AT=110.025n

.meas tran vdout0_67ck210 FIND v(dout0_67) AT=110.025n

.meas tran vdout0_68ck210 FIND v(dout0_68) AT=110.025n

.meas tran vdout0_69ck210 FIND v(dout0_69) AT=110.025n

.meas tran vdout0_70ck210 FIND v(dout0_70) AT=110.025n

.meas tran vdout0_71ck210 FIND v(dout0_71) AT=110.025n

.meas tran vdout0_72ck210 FIND v(dout0_72) AT=110.025n

.meas tran vdout0_73ck210 FIND v(dout0_73) AT=110.025n

.meas tran vdout0_74ck210 FIND v(dout0_74) AT=110.025n

.meas tran vdout0_75ck210 FIND v(dout0_75) AT=110.025n

.meas tran vdout0_76ck210 FIND v(dout0_76) AT=110.025n

.meas tran vdout0_77ck210 FIND v(dout0_77) AT=110.025n

.meas tran vdout0_78ck210 FIND v(dout0_78) AT=110.025n

.meas tran vdout0_79ck210 FIND v(dout0_79) AT=110.025n

.meas tran vdout0_80ck210 FIND v(dout0_80) AT=110.025n

.meas tran vdout0_81ck210 FIND v(dout0_81) AT=110.025n

.meas tran vdout0_82ck210 FIND v(dout0_82) AT=110.025n

.meas tran vdout0_83ck210 FIND v(dout0_83) AT=110.025n

.meas tran vdout0_84ck210 FIND v(dout0_84) AT=110.025n

.meas tran vdout0_85ck210 FIND v(dout0_85) AT=110.025n

.meas tran vdout0_86ck210 FIND v(dout0_86) AT=110.025n

.meas tran vdout0_87ck210 FIND v(dout0_87) AT=110.025n

.meas tran vdout0_88ck210 FIND v(dout0_88) AT=110.025n

.meas tran vdout0_89ck210 FIND v(dout0_89) AT=110.025n

.meas tran vdout0_90ck210 FIND v(dout0_90) AT=110.025n

.meas tran vdout0_91ck210 FIND v(dout0_91) AT=110.025n

.meas tran vdout0_92ck210 FIND v(dout0_92) AT=110.025n

.meas tran vdout0_93ck210 FIND v(dout0_93) AT=110.025n

.meas tran vdout0_94ck210 FIND v(dout0_94) AT=110.025n

.meas tran vdout0_95ck210 FIND v(dout0_95) AT=110.025n

.meas tran vdout0_96ck210 FIND v(dout0_96) AT=110.025n

.meas tran vdout0_97ck210 FIND v(dout0_97) AT=110.025n

.meas tran vdout0_98ck210 FIND v(dout0_98) AT=110.025n

.meas tran vdout0_99ck210 FIND v(dout0_99) AT=110.025n

.meas tran vdout0_100ck210 FIND v(dout0_100) AT=110.025n

.meas tran vdout0_101ck210 FIND v(dout0_101) AT=110.025n

.meas tran vdout0_102ck210 FIND v(dout0_102) AT=110.025n

.meas tran vdout0_103ck210 FIND v(dout0_103) AT=110.025n

.meas tran vdout0_104ck210 FIND v(dout0_104) AT=110.025n

.meas tran vdout0_105ck210 FIND v(dout0_105) AT=110.025n

.meas tran vdout0_106ck210 FIND v(dout0_106) AT=110.025n

.meas tran vdout0_107ck210 FIND v(dout0_107) AT=110.025n

.meas tran vdout0_108ck210 FIND v(dout0_108) AT=110.025n

.meas tran vdout0_109ck210 FIND v(dout0_109) AT=110.025n

.meas tran vdout0_110ck210 FIND v(dout0_110) AT=110.025n

.meas tran vdout0_111ck210 FIND v(dout0_111) AT=110.025n

.meas tran vdout0_112ck210 FIND v(dout0_112) AT=110.025n

.meas tran vdout0_113ck210 FIND v(dout0_113) AT=110.025n

.meas tran vdout0_114ck210 FIND v(dout0_114) AT=110.025n

.meas tran vdout0_115ck210 FIND v(dout0_115) AT=110.025n

.meas tran vdout0_116ck210 FIND v(dout0_116) AT=110.025n

.meas tran vdout0_117ck210 FIND v(dout0_117) AT=110.025n

.meas tran vdout0_118ck210 FIND v(dout0_118) AT=110.025n

.meas tran vdout0_119ck210 FIND v(dout0_119) AT=110.025n

.meas tran vdout0_120ck210 FIND v(dout0_120) AT=110.025n

.meas tran vdout0_121ck210 FIND v(dout0_121) AT=110.025n

.meas tran vdout0_122ck210 FIND v(dout0_122) AT=110.025n

.meas tran vdout0_123ck210 FIND v(dout0_123) AT=110.025n

.meas tran vdout0_124ck210 FIND v(dout0_124) AT=110.025n

.meas tran vdout0_125ck210 FIND v(dout0_125) AT=110.025n

.meas tran vdout0_126ck210 FIND v(dout0_126) AT=110.025n

.meas tran vdout0_127ck210 FIND v(dout0_127) AT=110.025n

.meas tran vdout0_0ck220 FIND v(dout0_0) AT=115.025n

.meas tran vdout0_1ck220 FIND v(dout0_1) AT=115.025n

.meas tran vdout0_2ck220 FIND v(dout0_2) AT=115.025n

.meas tran vdout0_3ck220 FIND v(dout0_3) AT=115.025n

.meas tran vdout0_4ck220 FIND v(dout0_4) AT=115.025n

.meas tran vdout0_5ck220 FIND v(dout0_5) AT=115.025n

.meas tran vdout0_6ck220 FIND v(dout0_6) AT=115.025n

.meas tran vdout0_7ck220 FIND v(dout0_7) AT=115.025n

.meas tran vdout0_8ck220 FIND v(dout0_8) AT=115.025n

.meas tran vdout0_9ck220 FIND v(dout0_9) AT=115.025n

.meas tran vdout0_10ck220 FIND v(dout0_10) AT=115.025n

.meas tran vdout0_11ck220 FIND v(dout0_11) AT=115.025n

.meas tran vdout0_12ck220 FIND v(dout0_12) AT=115.025n

.meas tran vdout0_13ck220 FIND v(dout0_13) AT=115.025n

.meas tran vdout0_14ck220 FIND v(dout0_14) AT=115.025n

.meas tran vdout0_15ck220 FIND v(dout0_15) AT=115.025n

.meas tran vdout0_16ck220 FIND v(dout0_16) AT=115.025n

.meas tran vdout0_17ck220 FIND v(dout0_17) AT=115.025n

.meas tran vdout0_18ck220 FIND v(dout0_18) AT=115.025n

.meas tran vdout0_19ck220 FIND v(dout0_19) AT=115.025n

.meas tran vdout0_20ck220 FIND v(dout0_20) AT=115.025n

.meas tran vdout0_21ck220 FIND v(dout0_21) AT=115.025n

.meas tran vdout0_22ck220 FIND v(dout0_22) AT=115.025n

.meas tran vdout0_23ck220 FIND v(dout0_23) AT=115.025n

.meas tran vdout0_24ck220 FIND v(dout0_24) AT=115.025n

.meas tran vdout0_25ck220 FIND v(dout0_25) AT=115.025n

.meas tran vdout0_26ck220 FIND v(dout0_26) AT=115.025n

.meas tran vdout0_27ck220 FIND v(dout0_27) AT=115.025n

.meas tran vdout0_28ck220 FIND v(dout0_28) AT=115.025n

.meas tran vdout0_29ck220 FIND v(dout0_29) AT=115.025n

.meas tran vdout0_30ck220 FIND v(dout0_30) AT=115.025n

.meas tran vdout0_31ck220 FIND v(dout0_31) AT=115.025n

.meas tran vdout0_32ck220 FIND v(dout0_32) AT=115.025n

.meas tran vdout0_33ck220 FIND v(dout0_33) AT=115.025n

.meas tran vdout0_34ck220 FIND v(dout0_34) AT=115.025n

.meas tran vdout0_35ck220 FIND v(dout0_35) AT=115.025n

.meas tran vdout0_36ck220 FIND v(dout0_36) AT=115.025n

.meas tran vdout0_37ck220 FIND v(dout0_37) AT=115.025n

.meas tran vdout0_38ck220 FIND v(dout0_38) AT=115.025n

.meas tran vdout0_39ck220 FIND v(dout0_39) AT=115.025n

.meas tran vdout0_40ck220 FIND v(dout0_40) AT=115.025n

.meas tran vdout0_41ck220 FIND v(dout0_41) AT=115.025n

.meas tran vdout0_42ck220 FIND v(dout0_42) AT=115.025n

.meas tran vdout0_43ck220 FIND v(dout0_43) AT=115.025n

.meas tran vdout0_44ck220 FIND v(dout0_44) AT=115.025n

.meas tran vdout0_45ck220 FIND v(dout0_45) AT=115.025n

.meas tran vdout0_46ck220 FIND v(dout0_46) AT=115.025n

.meas tran vdout0_47ck220 FIND v(dout0_47) AT=115.025n

.meas tran vdout0_48ck220 FIND v(dout0_48) AT=115.025n

.meas tran vdout0_49ck220 FIND v(dout0_49) AT=115.025n

.meas tran vdout0_50ck220 FIND v(dout0_50) AT=115.025n

.meas tran vdout0_51ck220 FIND v(dout0_51) AT=115.025n

.meas tran vdout0_52ck220 FIND v(dout0_52) AT=115.025n

.meas tran vdout0_53ck220 FIND v(dout0_53) AT=115.025n

.meas tran vdout0_54ck220 FIND v(dout0_54) AT=115.025n

.meas tran vdout0_55ck220 FIND v(dout0_55) AT=115.025n

.meas tran vdout0_56ck220 FIND v(dout0_56) AT=115.025n

.meas tran vdout0_57ck220 FIND v(dout0_57) AT=115.025n

.meas tran vdout0_58ck220 FIND v(dout0_58) AT=115.025n

.meas tran vdout0_59ck220 FIND v(dout0_59) AT=115.025n

.meas tran vdout0_60ck220 FIND v(dout0_60) AT=115.025n

.meas tran vdout0_61ck220 FIND v(dout0_61) AT=115.025n

.meas tran vdout0_62ck220 FIND v(dout0_62) AT=115.025n

.meas tran vdout0_63ck220 FIND v(dout0_63) AT=115.025n

.meas tran vdout0_64ck220 FIND v(dout0_64) AT=115.025n

.meas tran vdout0_65ck220 FIND v(dout0_65) AT=115.025n

.meas tran vdout0_66ck220 FIND v(dout0_66) AT=115.025n

.meas tran vdout0_67ck220 FIND v(dout0_67) AT=115.025n

.meas tran vdout0_68ck220 FIND v(dout0_68) AT=115.025n

.meas tran vdout0_69ck220 FIND v(dout0_69) AT=115.025n

.meas tran vdout0_70ck220 FIND v(dout0_70) AT=115.025n

.meas tran vdout0_71ck220 FIND v(dout0_71) AT=115.025n

.meas tran vdout0_72ck220 FIND v(dout0_72) AT=115.025n

.meas tran vdout0_73ck220 FIND v(dout0_73) AT=115.025n

.meas tran vdout0_74ck220 FIND v(dout0_74) AT=115.025n

.meas tran vdout0_75ck220 FIND v(dout0_75) AT=115.025n

.meas tran vdout0_76ck220 FIND v(dout0_76) AT=115.025n

.meas tran vdout0_77ck220 FIND v(dout0_77) AT=115.025n

.meas tran vdout0_78ck220 FIND v(dout0_78) AT=115.025n

.meas tran vdout0_79ck220 FIND v(dout0_79) AT=115.025n

.meas tran vdout0_80ck220 FIND v(dout0_80) AT=115.025n

.meas tran vdout0_81ck220 FIND v(dout0_81) AT=115.025n

.meas tran vdout0_82ck220 FIND v(dout0_82) AT=115.025n

.meas tran vdout0_83ck220 FIND v(dout0_83) AT=115.025n

.meas tran vdout0_84ck220 FIND v(dout0_84) AT=115.025n

.meas tran vdout0_85ck220 FIND v(dout0_85) AT=115.025n

.meas tran vdout0_86ck220 FIND v(dout0_86) AT=115.025n

.meas tran vdout0_87ck220 FIND v(dout0_87) AT=115.025n

.meas tran vdout0_88ck220 FIND v(dout0_88) AT=115.025n

.meas tran vdout0_89ck220 FIND v(dout0_89) AT=115.025n

.meas tran vdout0_90ck220 FIND v(dout0_90) AT=115.025n

.meas tran vdout0_91ck220 FIND v(dout0_91) AT=115.025n

.meas tran vdout0_92ck220 FIND v(dout0_92) AT=115.025n

.meas tran vdout0_93ck220 FIND v(dout0_93) AT=115.025n

.meas tran vdout0_94ck220 FIND v(dout0_94) AT=115.025n

.meas tran vdout0_95ck220 FIND v(dout0_95) AT=115.025n

.meas tran vdout0_96ck220 FIND v(dout0_96) AT=115.025n

.meas tran vdout0_97ck220 FIND v(dout0_97) AT=115.025n

.meas tran vdout0_98ck220 FIND v(dout0_98) AT=115.025n

.meas tran vdout0_99ck220 FIND v(dout0_99) AT=115.025n

.meas tran vdout0_100ck220 FIND v(dout0_100) AT=115.025n

.meas tran vdout0_101ck220 FIND v(dout0_101) AT=115.025n

.meas tran vdout0_102ck220 FIND v(dout0_102) AT=115.025n

.meas tran vdout0_103ck220 FIND v(dout0_103) AT=115.025n

.meas tran vdout0_104ck220 FIND v(dout0_104) AT=115.025n

.meas tran vdout0_105ck220 FIND v(dout0_105) AT=115.025n

.meas tran vdout0_106ck220 FIND v(dout0_106) AT=115.025n

.meas tran vdout0_107ck220 FIND v(dout0_107) AT=115.025n

.meas tran vdout0_108ck220 FIND v(dout0_108) AT=115.025n

.meas tran vdout0_109ck220 FIND v(dout0_109) AT=115.025n

.meas tran vdout0_110ck220 FIND v(dout0_110) AT=115.025n

.meas tran vdout0_111ck220 FIND v(dout0_111) AT=115.025n

.meas tran vdout0_112ck220 FIND v(dout0_112) AT=115.025n

.meas tran vdout0_113ck220 FIND v(dout0_113) AT=115.025n

.meas tran vdout0_114ck220 FIND v(dout0_114) AT=115.025n

.meas tran vdout0_115ck220 FIND v(dout0_115) AT=115.025n

.meas tran vdout0_116ck220 FIND v(dout0_116) AT=115.025n

.meas tran vdout0_117ck220 FIND v(dout0_117) AT=115.025n

.meas tran vdout0_118ck220 FIND v(dout0_118) AT=115.025n

.meas tran vdout0_119ck220 FIND v(dout0_119) AT=115.025n

.meas tran vdout0_120ck220 FIND v(dout0_120) AT=115.025n

.meas tran vdout0_121ck220 FIND v(dout0_121) AT=115.025n

.meas tran vdout0_122ck220 FIND v(dout0_122) AT=115.025n

.meas tran vdout0_123ck220 FIND v(dout0_123) AT=115.025n

.meas tran vdout0_124ck220 FIND v(dout0_124) AT=115.025n

.meas tran vdout0_125ck220 FIND v(dout0_125) AT=115.025n

.meas tran vdout0_126ck220 FIND v(dout0_126) AT=115.025n

.meas tran vdout0_127ck220 FIND v(dout0_127) AT=115.025n

.meas tran vdout0_0ck250 FIND v(dout0_0) AT=130.025n

.meas tran vdout0_1ck250 FIND v(dout0_1) AT=130.025n

.meas tran vdout0_2ck250 FIND v(dout0_2) AT=130.025n

.meas tran vdout0_3ck250 FIND v(dout0_3) AT=130.025n

.meas tran vdout0_4ck250 FIND v(dout0_4) AT=130.025n

.meas tran vdout0_5ck250 FIND v(dout0_5) AT=130.025n

.meas tran vdout0_6ck250 FIND v(dout0_6) AT=130.025n

.meas tran vdout0_7ck250 FIND v(dout0_7) AT=130.025n

.meas tran vdout0_8ck250 FIND v(dout0_8) AT=130.025n

.meas tran vdout0_9ck250 FIND v(dout0_9) AT=130.025n

.meas tran vdout0_10ck250 FIND v(dout0_10) AT=130.025n

.meas tran vdout0_11ck250 FIND v(dout0_11) AT=130.025n

.meas tran vdout0_12ck250 FIND v(dout0_12) AT=130.025n

.meas tran vdout0_13ck250 FIND v(dout0_13) AT=130.025n

.meas tran vdout0_14ck250 FIND v(dout0_14) AT=130.025n

.meas tran vdout0_15ck250 FIND v(dout0_15) AT=130.025n

.meas tran vdout0_16ck250 FIND v(dout0_16) AT=130.025n

.meas tran vdout0_17ck250 FIND v(dout0_17) AT=130.025n

.meas tran vdout0_18ck250 FIND v(dout0_18) AT=130.025n

.meas tran vdout0_19ck250 FIND v(dout0_19) AT=130.025n

.meas tran vdout0_20ck250 FIND v(dout0_20) AT=130.025n

.meas tran vdout0_21ck250 FIND v(dout0_21) AT=130.025n

.meas tran vdout0_22ck250 FIND v(dout0_22) AT=130.025n

.meas tran vdout0_23ck250 FIND v(dout0_23) AT=130.025n

.meas tran vdout0_24ck250 FIND v(dout0_24) AT=130.025n

.meas tran vdout0_25ck250 FIND v(dout0_25) AT=130.025n

.meas tran vdout0_26ck250 FIND v(dout0_26) AT=130.025n

.meas tran vdout0_27ck250 FIND v(dout0_27) AT=130.025n

.meas tran vdout0_28ck250 FIND v(dout0_28) AT=130.025n

.meas tran vdout0_29ck250 FIND v(dout0_29) AT=130.025n

.meas tran vdout0_30ck250 FIND v(dout0_30) AT=130.025n

.meas tran vdout0_31ck250 FIND v(dout0_31) AT=130.025n

.meas tran vdout0_32ck250 FIND v(dout0_32) AT=130.025n

.meas tran vdout0_33ck250 FIND v(dout0_33) AT=130.025n

.meas tran vdout0_34ck250 FIND v(dout0_34) AT=130.025n

.meas tran vdout0_35ck250 FIND v(dout0_35) AT=130.025n

.meas tran vdout0_36ck250 FIND v(dout0_36) AT=130.025n

.meas tran vdout0_37ck250 FIND v(dout0_37) AT=130.025n

.meas tran vdout0_38ck250 FIND v(dout0_38) AT=130.025n

.meas tran vdout0_39ck250 FIND v(dout0_39) AT=130.025n

.meas tran vdout0_40ck250 FIND v(dout0_40) AT=130.025n

.meas tran vdout0_41ck250 FIND v(dout0_41) AT=130.025n

.meas tran vdout0_42ck250 FIND v(dout0_42) AT=130.025n

.meas tran vdout0_43ck250 FIND v(dout0_43) AT=130.025n

.meas tran vdout0_44ck250 FIND v(dout0_44) AT=130.025n

.meas tran vdout0_45ck250 FIND v(dout0_45) AT=130.025n

.meas tran vdout0_46ck250 FIND v(dout0_46) AT=130.025n

.meas tran vdout0_47ck250 FIND v(dout0_47) AT=130.025n

.meas tran vdout0_48ck250 FIND v(dout0_48) AT=130.025n

.meas tran vdout0_49ck250 FIND v(dout0_49) AT=130.025n

.meas tran vdout0_50ck250 FIND v(dout0_50) AT=130.025n

.meas tran vdout0_51ck250 FIND v(dout0_51) AT=130.025n

.meas tran vdout0_52ck250 FIND v(dout0_52) AT=130.025n

.meas tran vdout0_53ck250 FIND v(dout0_53) AT=130.025n

.meas tran vdout0_54ck250 FIND v(dout0_54) AT=130.025n

.meas tran vdout0_55ck250 FIND v(dout0_55) AT=130.025n

.meas tran vdout0_56ck250 FIND v(dout0_56) AT=130.025n

.meas tran vdout0_57ck250 FIND v(dout0_57) AT=130.025n

.meas tran vdout0_58ck250 FIND v(dout0_58) AT=130.025n

.meas tran vdout0_59ck250 FIND v(dout0_59) AT=130.025n

.meas tran vdout0_60ck250 FIND v(dout0_60) AT=130.025n

.meas tran vdout0_61ck250 FIND v(dout0_61) AT=130.025n

.meas tran vdout0_62ck250 FIND v(dout0_62) AT=130.025n

.meas tran vdout0_63ck250 FIND v(dout0_63) AT=130.025n

.meas tran vdout0_64ck250 FIND v(dout0_64) AT=130.025n

.meas tran vdout0_65ck250 FIND v(dout0_65) AT=130.025n

.meas tran vdout0_66ck250 FIND v(dout0_66) AT=130.025n

.meas tran vdout0_67ck250 FIND v(dout0_67) AT=130.025n

.meas tran vdout0_68ck250 FIND v(dout0_68) AT=130.025n

.meas tran vdout0_69ck250 FIND v(dout0_69) AT=130.025n

.meas tran vdout0_70ck250 FIND v(dout0_70) AT=130.025n

.meas tran vdout0_71ck250 FIND v(dout0_71) AT=130.025n

.meas tran vdout0_72ck250 FIND v(dout0_72) AT=130.025n

.meas tran vdout0_73ck250 FIND v(dout0_73) AT=130.025n

.meas tran vdout0_74ck250 FIND v(dout0_74) AT=130.025n

.meas tran vdout0_75ck250 FIND v(dout0_75) AT=130.025n

.meas tran vdout0_76ck250 FIND v(dout0_76) AT=130.025n

.meas tran vdout0_77ck250 FIND v(dout0_77) AT=130.025n

.meas tran vdout0_78ck250 FIND v(dout0_78) AT=130.025n

.meas tran vdout0_79ck250 FIND v(dout0_79) AT=130.025n

.meas tran vdout0_80ck250 FIND v(dout0_80) AT=130.025n

.meas tran vdout0_81ck250 FIND v(dout0_81) AT=130.025n

.meas tran vdout0_82ck250 FIND v(dout0_82) AT=130.025n

.meas tran vdout0_83ck250 FIND v(dout0_83) AT=130.025n

.meas tran vdout0_84ck250 FIND v(dout0_84) AT=130.025n

.meas tran vdout0_85ck250 FIND v(dout0_85) AT=130.025n

.meas tran vdout0_86ck250 FIND v(dout0_86) AT=130.025n

.meas tran vdout0_87ck250 FIND v(dout0_87) AT=130.025n

.meas tran vdout0_88ck250 FIND v(dout0_88) AT=130.025n

.meas tran vdout0_89ck250 FIND v(dout0_89) AT=130.025n

.meas tran vdout0_90ck250 FIND v(dout0_90) AT=130.025n

.meas tran vdout0_91ck250 FIND v(dout0_91) AT=130.025n

.meas tran vdout0_92ck250 FIND v(dout0_92) AT=130.025n

.meas tran vdout0_93ck250 FIND v(dout0_93) AT=130.025n

.meas tran vdout0_94ck250 FIND v(dout0_94) AT=130.025n

.meas tran vdout0_95ck250 FIND v(dout0_95) AT=130.025n

.meas tran vdout0_96ck250 FIND v(dout0_96) AT=130.025n

.meas tran vdout0_97ck250 FIND v(dout0_97) AT=130.025n

.meas tran vdout0_98ck250 FIND v(dout0_98) AT=130.025n

.meas tran vdout0_99ck250 FIND v(dout0_99) AT=130.025n

.meas tran vdout0_100ck250 FIND v(dout0_100) AT=130.025n

.meas tran vdout0_101ck250 FIND v(dout0_101) AT=130.025n

.meas tran vdout0_102ck250 FIND v(dout0_102) AT=130.025n

.meas tran vdout0_103ck250 FIND v(dout0_103) AT=130.025n

.meas tran vdout0_104ck250 FIND v(dout0_104) AT=130.025n

.meas tran vdout0_105ck250 FIND v(dout0_105) AT=130.025n

.meas tran vdout0_106ck250 FIND v(dout0_106) AT=130.025n

.meas tran vdout0_107ck250 FIND v(dout0_107) AT=130.025n

.meas tran vdout0_108ck250 FIND v(dout0_108) AT=130.025n

.meas tran vdout0_109ck250 FIND v(dout0_109) AT=130.025n

.meas tran vdout0_110ck250 FIND v(dout0_110) AT=130.025n

.meas tran vdout0_111ck250 FIND v(dout0_111) AT=130.025n

.meas tran vdout0_112ck250 FIND v(dout0_112) AT=130.025n

.meas tran vdout0_113ck250 FIND v(dout0_113) AT=130.025n

.meas tran vdout0_114ck250 FIND v(dout0_114) AT=130.025n

.meas tran vdout0_115ck250 FIND v(dout0_115) AT=130.025n

.meas tran vdout0_116ck250 FIND v(dout0_116) AT=130.025n

.meas tran vdout0_117ck250 FIND v(dout0_117) AT=130.025n

.meas tran vdout0_118ck250 FIND v(dout0_118) AT=130.025n

.meas tran vdout0_119ck250 FIND v(dout0_119) AT=130.025n

.meas tran vdout0_120ck250 FIND v(dout0_120) AT=130.025n

.meas tran vdout0_121ck250 FIND v(dout0_121) AT=130.025n

.meas tran vdout0_122ck250 FIND v(dout0_122) AT=130.025n

.meas tran vdout0_123ck250 FIND v(dout0_123) AT=130.025n

.meas tran vdout0_124ck250 FIND v(dout0_124) AT=130.025n

.meas tran vdout0_125ck250 FIND v(dout0_125) AT=130.025n

.meas tran vdout0_126ck250 FIND v(dout0_126) AT=130.025n

.meas tran vdout0_127ck250 FIND v(dout0_127) AT=130.025n

.meas tran vdout0_0ck260 FIND v(dout0_0) AT=135.025n

.meas tran vdout0_1ck260 FIND v(dout0_1) AT=135.025n

.meas tran vdout0_2ck260 FIND v(dout0_2) AT=135.025n

.meas tran vdout0_3ck260 FIND v(dout0_3) AT=135.025n

.meas tran vdout0_4ck260 FIND v(dout0_4) AT=135.025n

.meas tran vdout0_5ck260 FIND v(dout0_5) AT=135.025n

.meas tran vdout0_6ck260 FIND v(dout0_6) AT=135.025n

.meas tran vdout0_7ck260 FIND v(dout0_7) AT=135.025n

.meas tran vdout0_8ck260 FIND v(dout0_8) AT=135.025n

.meas tran vdout0_9ck260 FIND v(dout0_9) AT=135.025n

.meas tran vdout0_10ck260 FIND v(dout0_10) AT=135.025n

.meas tran vdout0_11ck260 FIND v(dout0_11) AT=135.025n

.meas tran vdout0_12ck260 FIND v(dout0_12) AT=135.025n

.meas tran vdout0_13ck260 FIND v(dout0_13) AT=135.025n

.meas tran vdout0_14ck260 FIND v(dout0_14) AT=135.025n

.meas tran vdout0_15ck260 FIND v(dout0_15) AT=135.025n

.meas tran vdout0_16ck260 FIND v(dout0_16) AT=135.025n

.meas tran vdout0_17ck260 FIND v(dout0_17) AT=135.025n

.meas tran vdout0_18ck260 FIND v(dout0_18) AT=135.025n

.meas tran vdout0_19ck260 FIND v(dout0_19) AT=135.025n

.meas tran vdout0_20ck260 FIND v(dout0_20) AT=135.025n

.meas tran vdout0_21ck260 FIND v(dout0_21) AT=135.025n

.meas tran vdout0_22ck260 FIND v(dout0_22) AT=135.025n

.meas tran vdout0_23ck260 FIND v(dout0_23) AT=135.025n

.meas tran vdout0_24ck260 FIND v(dout0_24) AT=135.025n

.meas tran vdout0_25ck260 FIND v(dout0_25) AT=135.025n

.meas tran vdout0_26ck260 FIND v(dout0_26) AT=135.025n

.meas tran vdout0_27ck260 FIND v(dout0_27) AT=135.025n

.meas tran vdout0_28ck260 FIND v(dout0_28) AT=135.025n

.meas tran vdout0_29ck260 FIND v(dout0_29) AT=135.025n

.meas tran vdout0_30ck260 FIND v(dout0_30) AT=135.025n

.meas tran vdout0_31ck260 FIND v(dout0_31) AT=135.025n

.meas tran vdout0_32ck260 FIND v(dout0_32) AT=135.025n

.meas tran vdout0_33ck260 FIND v(dout0_33) AT=135.025n

.meas tran vdout0_34ck260 FIND v(dout0_34) AT=135.025n

.meas tran vdout0_35ck260 FIND v(dout0_35) AT=135.025n

.meas tran vdout0_36ck260 FIND v(dout0_36) AT=135.025n

.meas tran vdout0_37ck260 FIND v(dout0_37) AT=135.025n

.meas tran vdout0_38ck260 FIND v(dout0_38) AT=135.025n

.meas tran vdout0_39ck260 FIND v(dout0_39) AT=135.025n

.meas tran vdout0_40ck260 FIND v(dout0_40) AT=135.025n

.meas tran vdout0_41ck260 FIND v(dout0_41) AT=135.025n

.meas tran vdout0_42ck260 FIND v(dout0_42) AT=135.025n

.meas tran vdout0_43ck260 FIND v(dout0_43) AT=135.025n

.meas tran vdout0_44ck260 FIND v(dout0_44) AT=135.025n

.meas tran vdout0_45ck260 FIND v(dout0_45) AT=135.025n

.meas tran vdout0_46ck260 FIND v(dout0_46) AT=135.025n

.meas tran vdout0_47ck260 FIND v(dout0_47) AT=135.025n

.meas tran vdout0_48ck260 FIND v(dout0_48) AT=135.025n

.meas tran vdout0_49ck260 FIND v(dout0_49) AT=135.025n

.meas tran vdout0_50ck260 FIND v(dout0_50) AT=135.025n

.meas tran vdout0_51ck260 FIND v(dout0_51) AT=135.025n

.meas tran vdout0_52ck260 FIND v(dout0_52) AT=135.025n

.meas tran vdout0_53ck260 FIND v(dout0_53) AT=135.025n

.meas tran vdout0_54ck260 FIND v(dout0_54) AT=135.025n

.meas tran vdout0_55ck260 FIND v(dout0_55) AT=135.025n

.meas tran vdout0_56ck260 FIND v(dout0_56) AT=135.025n

.meas tran vdout0_57ck260 FIND v(dout0_57) AT=135.025n

.meas tran vdout0_58ck260 FIND v(dout0_58) AT=135.025n

.meas tran vdout0_59ck260 FIND v(dout0_59) AT=135.025n

.meas tran vdout0_60ck260 FIND v(dout0_60) AT=135.025n

.meas tran vdout0_61ck260 FIND v(dout0_61) AT=135.025n

.meas tran vdout0_62ck260 FIND v(dout0_62) AT=135.025n

.meas tran vdout0_63ck260 FIND v(dout0_63) AT=135.025n

.meas tran vdout0_64ck260 FIND v(dout0_64) AT=135.025n

.meas tran vdout0_65ck260 FIND v(dout0_65) AT=135.025n

.meas tran vdout0_66ck260 FIND v(dout0_66) AT=135.025n

.meas tran vdout0_67ck260 FIND v(dout0_67) AT=135.025n

.meas tran vdout0_68ck260 FIND v(dout0_68) AT=135.025n

.meas tran vdout0_69ck260 FIND v(dout0_69) AT=135.025n

.meas tran vdout0_70ck260 FIND v(dout0_70) AT=135.025n

.meas tran vdout0_71ck260 FIND v(dout0_71) AT=135.025n

.meas tran vdout0_72ck260 FIND v(dout0_72) AT=135.025n

.meas tran vdout0_73ck260 FIND v(dout0_73) AT=135.025n

.meas tran vdout0_74ck260 FIND v(dout0_74) AT=135.025n

.meas tran vdout0_75ck260 FIND v(dout0_75) AT=135.025n

.meas tran vdout0_76ck260 FIND v(dout0_76) AT=135.025n

.meas tran vdout0_77ck260 FIND v(dout0_77) AT=135.025n

.meas tran vdout0_78ck260 FIND v(dout0_78) AT=135.025n

.meas tran vdout0_79ck260 FIND v(dout0_79) AT=135.025n

.meas tran vdout0_80ck260 FIND v(dout0_80) AT=135.025n

.meas tran vdout0_81ck260 FIND v(dout0_81) AT=135.025n

.meas tran vdout0_82ck260 FIND v(dout0_82) AT=135.025n

.meas tran vdout0_83ck260 FIND v(dout0_83) AT=135.025n

.meas tran vdout0_84ck260 FIND v(dout0_84) AT=135.025n

.meas tran vdout0_85ck260 FIND v(dout0_85) AT=135.025n

.meas tran vdout0_86ck260 FIND v(dout0_86) AT=135.025n

.meas tran vdout0_87ck260 FIND v(dout0_87) AT=135.025n

.meas tran vdout0_88ck260 FIND v(dout0_88) AT=135.025n

.meas tran vdout0_89ck260 FIND v(dout0_89) AT=135.025n

.meas tran vdout0_90ck260 FIND v(dout0_90) AT=135.025n

.meas tran vdout0_91ck260 FIND v(dout0_91) AT=135.025n

.meas tran vdout0_92ck260 FIND v(dout0_92) AT=135.025n

.meas tran vdout0_93ck260 FIND v(dout0_93) AT=135.025n

.meas tran vdout0_94ck260 FIND v(dout0_94) AT=135.025n

.meas tran vdout0_95ck260 FIND v(dout0_95) AT=135.025n

.meas tran vdout0_96ck260 FIND v(dout0_96) AT=135.025n

.meas tran vdout0_97ck260 FIND v(dout0_97) AT=135.025n

.meas tran vdout0_98ck260 FIND v(dout0_98) AT=135.025n

.meas tran vdout0_99ck260 FIND v(dout0_99) AT=135.025n

.meas tran vdout0_100ck260 FIND v(dout0_100) AT=135.025n

.meas tran vdout0_101ck260 FIND v(dout0_101) AT=135.025n

.meas tran vdout0_102ck260 FIND v(dout0_102) AT=135.025n

.meas tran vdout0_103ck260 FIND v(dout0_103) AT=135.025n

.meas tran vdout0_104ck260 FIND v(dout0_104) AT=135.025n

.meas tran vdout0_105ck260 FIND v(dout0_105) AT=135.025n

.meas tran vdout0_106ck260 FIND v(dout0_106) AT=135.025n

.meas tran vdout0_107ck260 FIND v(dout0_107) AT=135.025n

.meas tran vdout0_108ck260 FIND v(dout0_108) AT=135.025n

.meas tran vdout0_109ck260 FIND v(dout0_109) AT=135.025n

.meas tran vdout0_110ck260 FIND v(dout0_110) AT=135.025n

.meas tran vdout0_111ck260 FIND v(dout0_111) AT=135.025n

.meas tran vdout0_112ck260 FIND v(dout0_112) AT=135.025n

.meas tran vdout0_113ck260 FIND v(dout0_113) AT=135.025n

.meas tran vdout0_114ck260 FIND v(dout0_114) AT=135.025n

.meas tran vdout0_115ck260 FIND v(dout0_115) AT=135.025n

.meas tran vdout0_116ck260 FIND v(dout0_116) AT=135.025n

.meas tran vdout0_117ck260 FIND v(dout0_117) AT=135.025n

.meas tran vdout0_118ck260 FIND v(dout0_118) AT=135.025n

.meas tran vdout0_119ck260 FIND v(dout0_119) AT=135.025n

.meas tran vdout0_120ck260 FIND v(dout0_120) AT=135.025n

.meas tran vdout0_121ck260 FIND v(dout0_121) AT=135.025n

.meas tran vdout0_122ck260 FIND v(dout0_122) AT=135.025n

.meas tran vdout0_123ck260 FIND v(dout0_123) AT=135.025n

.meas tran vdout0_124ck260 FIND v(dout0_124) AT=135.025n

.meas tran vdout0_125ck260 FIND v(dout0_125) AT=135.025n

.meas tran vdout0_126ck260 FIND v(dout0_126) AT=135.025n

.meas tran vdout0_127ck260 FIND v(dout0_127) AT=135.025n

.meas tran vdout0_0ck270 FIND v(dout0_0) AT=140.025n

.meas tran vdout0_1ck270 FIND v(dout0_1) AT=140.025n

.meas tran vdout0_2ck270 FIND v(dout0_2) AT=140.025n

.meas tran vdout0_3ck270 FIND v(dout0_3) AT=140.025n

.meas tran vdout0_4ck270 FIND v(dout0_4) AT=140.025n

.meas tran vdout0_5ck270 FIND v(dout0_5) AT=140.025n

.meas tran vdout0_6ck270 FIND v(dout0_6) AT=140.025n

.meas tran vdout0_7ck270 FIND v(dout0_7) AT=140.025n

.meas tran vdout0_8ck270 FIND v(dout0_8) AT=140.025n

.meas tran vdout0_9ck270 FIND v(dout0_9) AT=140.025n

.meas tran vdout0_10ck270 FIND v(dout0_10) AT=140.025n

.meas tran vdout0_11ck270 FIND v(dout0_11) AT=140.025n

.meas tran vdout0_12ck270 FIND v(dout0_12) AT=140.025n

.meas tran vdout0_13ck270 FIND v(dout0_13) AT=140.025n

.meas tran vdout0_14ck270 FIND v(dout0_14) AT=140.025n

.meas tran vdout0_15ck270 FIND v(dout0_15) AT=140.025n

.meas tran vdout0_16ck270 FIND v(dout0_16) AT=140.025n

.meas tran vdout0_17ck270 FIND v(dout0_17) AT=140.025n

.meas tran vdout0_18ck270 FIND v(dout0_18) AT=140.025n

.meas tran vdout0_19ck270 FIND v(dout0_19) AT=140.025n

.meas tran vdout0_20ck270 FIND v(dout0_20) AT=140.025n

.meas tran vdout0_21ck270 FIND v(dout0_21) AT=140.025n

.meas tran vdout0_22ck270 FIND v(dout0_22) AT=140.025n

.meas tran vdout0_23ck270 FIND v(dout0_23) AT=140.025n

.meas tran vdout0_24ck270 FIND v(dout0_24) AT=140.025n

.meas tran vdout0_25ck270 FIND v(dout0_25) AT=140.025n

.meas tran vdout0_26ck270 FIND v(dout0_26) AT=140.025n

.meas tran vdout0_27ck270 FIND v(dout0_27) AT=140.025n

.meas tran vdout0_28ck270 FIND v(dout0_28) AT=140.025n

.meas tran vdout0_29ck270 FIND v(dout0_29) AT=140.025n

.meas tran vdout0_30ck270 FIND v(dout0_30) AT=140.025n

.meas tran vdout0_31ck270 FIND v(dout0_31) AT=140.025n

.meas tran vdout0_32ck270 FIND v(dout0_32) AT=140.025n

.meas tran vdout0_33ck270 FIND v(dout0_33) AT=140.025n

.meas tran vdout0_34ck270 FIND v(dout0_34) AT=140.025n

.meas tran vdout0_35ck270 FIND v(dout0_35) AT=140.025n

.meas tran vdout0_36ck270 FIND v(dout0_36) AT=140.025n

.meas tran vdout0_37ck270 FIND v(dout0_37) AT=140.025n

.meas tran vdout0_38ck270 FIND v(dout0_38) AT=140.025n

.meas tran vdout0_39ck270 FIND v(dout0_39) AT=140.025n

.meas tran vdout0_40ck270 FIND v(dout0_40) AT=140.025n

.meas tran vdout0_41ck270 FIND v(dout0_41) AT=140.025n

.meas tran vdout0_42ck270 FIND v(dout0_42) AT=140.025n

.meas tran vdout0_43ck270 FIND v(dout0_43) AT=140.025n

.meas tran vdout0_44ck270 FIND v(dout0_44) AT=140.025n

.meas tran vdout0_45ck270 FIND v(dout0_45) AT=140.025n

.meas tran vdout0_46ck270 FIND v(dout0_46) AT=140.025n

.meas tran vdout0_47ck270 FIND v(dout0_47) AT=140.025n

.meas tran vdout0_48ck270 FIND v(dout0_48) AT=140.025n

.meas tran vdout0_49ck270 FIND v(dout0_49) AT=140.025n

.meas tran vdout0_50ck270 FIND v(dout0_50) AT=140.025n

.meas tran vdout0_51ck270 FIND v(dout0_51) AT=140.025n

.meas tran vdout0_52ck270 FIND v(dout0_52) AT=140.025n

.meas tran vdout0_53ck270 FIND v(dout0_53) AT=140.025n

.meas tran vdout0_54ck270 FIND v(dout0_54) AT=140.025n

.meas tran vdout0_55ck270 FIND v(dout0_55) AT=140.025n

.meas tran vdout0_56ck270 FIND v(dout0_56) AT=140.025n

.meas tran vdout0_57ck270 FIND v(dout0_57) AT=140.025n

.meas tran vdout0_58ck270 FIND v(dout0_58) AT=140.025n

.meas tran vdout0_59ck270 FIND v(dout0_59) AT=140.025n

.meas tran vdout0_60ck270 FIND v(dout0_60) AT=140.025n

.meas tran vdout0_61ck270 FIND v(dout0_61) AT=140.025n

.meas tran vdout0_62ck270 FIND v(dout0_62) AT=140.025n

.meas tran vdout0_63ck270 FIND v(dout0_63) AT=140.025n

.meas tran vdout0_64ck270 FIND v(dout0_64) AT=140.025n

.meas tran vdout0_65ck270 FIND v(dout0_65) AT=140.025n

.meas tran vdout0_66ck270 FIND v(dout0_66) AT=140.025n

.meas tran vdout0_67ck270 FIND v(dout0_67) AT=140.025n

.meas tran vdout0_68ck270 FIND v(dout0_68) AT=140.025n

.meas tran vdout0_69ck270 FIND v(dout0_69) AT=140.025n

.meas tran vdout0_70ck270 FIND v(dout0_70) AT=140.025n

.meas tran vdout0_71ck270 FIND v(dout0_71) AT=140.025n

.meas tran vdout0_72ck270 FIND v(dout0_72) AT=140.025n

.meas tran vdout0_73ck270 FIND v(dout0_73) AT=140.025n

.meas tran vdout0_74ck270 FIND v(dout0_74) AT=140.025n

.meas tran vdout0_75ck270 FIND v(dout0_75) AT=140.025n

.meas tran vdout0_76ck270 FIND v(dout0_76) AT=140.025n

.meas tran vdout0_77ck270 FIND v(dout0_77) AT=140.025n

.meas tran vdout0_78ck270 FIND v(dout0_78) AT=140.025n

.meas tran vdout0_79ck270 FIND v(dout0_79) AT=140.025n

.meas tran vdout0_80ck270 FIND v(dout0_80) AT=140.025n

.meas tran vdout0_81ck270 FIND v(dout0_81) AT=140.025n

.meas tran vdout0_82ck270 FIND v(dout0_82) AT=140.025n

.meas tran vdout0_83ck270 FIND v(dout0_83) AT=140.025n

.meas tran vdout0_84ck270 FIND v(dout0_84) AT=140.025n

.meas tran vdout0_85ck270 FIND v(dout0_85) AT=140.025n

.meas tran vdout0_86ck270 FIND v(dout0_86) AT=140.025n

.meas tran vdout0_87ck270 FIND v(dout0_87) AT=140.025n

.meas tran vdout0_88ck270 FIND v(dout0_88) AT=140.025n

.meas tran vdout0_89ck270 FIND v(dout0_89) AT=140.025n

.meas tran vdout0_90ck270 FIND v(dout0_90) AT=140.025n

.meas tran vdout0_91ck270 FIND v(dout0_91) AT=140.025n

.meas tran vdout0_92ck270 FIND v(dout0_92) AT=140.025n

.meas tran vdout0_93ck270 FIND v(dout0_93) AT=140.025n

.meas tran vdout0_94ck270 FIND v(dout0_94) AT=140.025n

.meas tran vdout0_95ck270 FIND v(dout0_95) AT=140.025n

.meas tran vdout0_96ck270 FIND v(dout0_96) AT=140.025n

.meas tran vdout0_97ck270 FIND v(dout0_97) AT=140.025n

.meas tran vdout0_98ck270 FIND v(dout0_98) AT=140.025n

.meas tran vdout0_99ck270 FIND v(dout0_99) AT=140.025n

.meas tran vdout0_100ck270 FIND v(dout0_100) AT=140.025n

.meas tran vdout0_101ck270 FIND v(dout0_101) AT=140.025n

.meas tran vdout0_102ck270 FIND v(dout0_102) AT=140.025n

.meas tran vdout0_103ck270 FIND v(dout0_103) AT=140.025n

.meas tran vdout0_104ck270 FIND v(dout0_104) AT=140.025n

.meas tran vdout0_105ck270 FIND v(dout0_105) AT=140.025n

.meas tran vdout0_106ck270 FIND v(dout0_106) AT=140.025n

.meas tran vdout0_107ck270 FIND v(dout0_107) AT=140.025n

.meas tran vdout0_108ck270 FIND v(dout0_108) AT=140.025n

.meas tran vdout0_109ck270 FIND v(dout0_109) AT=140.025n

.meas tran vdout0_110ck270 FIND v(dout0_110) AT=140.025n

.meas tran vdout0_111ck270 FIND v(dout0_111) AT=140.025n

.meas tran vdout0_112ck270 FIND v(dout0_112) AT=140.025n

.meas tran vdout0_113ck270 FIND v(dout0_113) AT=140.025n

.meas tran vdout0_114ck270 FIND v(dout0_114) AT=140.025n

.meas tran vdout0_115ck270 FIND v(dout0_115) AT=140.025n

.meas tran vdout0_116ck270 FIND v(dout0_116) AT=140.025n

.meas tran vdout0_117ck270 FIND v(dout0_117) AT=140.025n

.meas tran vdout0_118ck270 FIND v(dout0_118) AT=140.025n

.meas tran vdout0_119ck270 FIND v(dout0_119) AT=140.025n

.meas tran vdout0_120ck270 FIND v(dout0_120) AT=140.025n

.meas tran vdout0_121ck270 FIND v(dout0_121) AT=140.025n

.meas tran vdout0_122ck270 FIND v(dout0_122) AT=140.025n

.meas tran vdout0_123ck270 FIND v(dout0_123) AT=140.025n

.meas tran vdout0_124ck270 FIND v(dout0_124) AT=140.025n

.meas tran vdout0_125ck270 FIND v(dout0_125) AT=140.025n

.meas tran vdout0_126ck270 FIND v(dout0_126) AT=140.025n

.meas tran vdout0_127ck270 FIND v(dout0_127) AT=140.025n

.meas tran vdout0_0ck280 FIND v(dout0_0) AT=145.025n

.meas tran vdout0_1ck280 FIND v(dout0_1) AT=145.025n

.meas tran vdout0_2ck280 FIND v(dout0_2) AT=145.025n

.meas tran vdout0_3ck280 FIND v(dout0_3) AT=145.025n

.meas tran vdout0_4ck280 FIND v(dout0_4) AT=145.025n

.meas tran vdout0_5ck280 FIND v(dout0_5) AT=145.025n

.meas tran vdout0_6ck280 FIND v(dout0_6) AT=145.025n

.meas tran vdout0_7ck280 FIND v(dout0_7) AT=145.025n

.meas tran vdout0_8ck280 FIND v(dout0_8) AT=145.025n

.meas tran vdout0_9ck280 FIND v(dout0_9) AT=145.025n

.meas tran vdout0_10ck280 FIND v(dout0_10) AT=145.025n

.meas tran vdout0_11ck280 FIND v(dout0_11) AT=145.025n

.meas tran vdout0_12ck280 FIND v(dout0_12) AT=145.025n

.meas tran vdout0_13ck280 FIND v(dout0_13) AT=145.025n

.meas tran vdout0_14ck280 FIND v(dout0_14) AT=145.025n

.meas tran vdout0_15ck280 FIND v(dout0_15) AT=145.025n

.meas tran vdout0_16ck280 FIND v(dout0_16) AT=145.025n

.meas tran vdout0_17ck280 FIND v(dout0_17) AT=145.025n

.meas tran vdout0_18ck280 FIND v(dout0_18) AT=145.025n

.meas tran vdout0_19ck280 FIND v(dout0_19) AT=145.025n

.meas tran vdout0_20ck280 FIND v(dout0_20) AT=145.025n

.meas tran vdout0_21ck280 FIND v(dout0_21) AT=145.025n

.meas tran vdout0_22ck280 FIND v(dout0_22) AT=145.025n

.meas tran vdout0_23ck280 FIND v(dout0_23) AT=145.025n

.meas tran vdout0_24ck280 FIND v(dout0_24) AT=145.025n

.meas tran vdout0_25ck280 FIND v(dout0_25) AT=145.025n

.meas tran vdout0_26ck280 FIND v(dout0_26) AT=145.025n

.meas tran vdout0_27ck280 FIND v(dout0_27) AT=145.025n

.meas tran vdout0_28ck280 FIND v(dout0_28) AT=145.025n

.meas tran vdout0_29ck280 FIND v(dout0_29) AT=145.025n

.meas tran vdout0_30ck280 FIND v(dout0_30) AT=145.025n

.meas tran vdout0_31ck280 FIND v(dout0_31) AT=145.025n

.meas tran vdout0_32ck280 FIND v(dout0_32) AT=145.025n

.meas tran vdout0_33ck280 FIND v(dout0_33) AT=145.025n

.meas tran vdout0_34ck280 FIND v(dout0_34) AT=145.025n

.meas tran vdout0_35ck280 FIND v(dout0_35) AT=145.025n

.meas tran vdout0_36ck280 FIND v(dout0_36) AT=145.025n

.meas tran vdout0_37ck280 FIND v(dout0_37) AT=145.025n

.meas tran vdout0_38ck280 FIND v(dout0_38) AT=145.025n

.meas tran vdout0_39ck280 FIND v(dout0_39) AT=145.025n

.meas tran vdout0_40ck280 FIND v(dout0_40) AT=145.025n

.meas tran vdout0_41ck280 FIND v(dout0_41) AT=145.025n

.meas tran vdout0_42ck280 FIND v(dout0_42) AT=145.025n

.meas tran vdout0_43ck280 FIND v(dout0_43) AT=145.025n

.meas tran vdout0_44ck280 FIND v(dout0_44) AT=145.025n

.meas tran vdout0_45ck280 FIND v(dout0_45) AT=145.025n

.meas tran vdout0_46ck280 FIND v(dout0_46) AT=145.025n

.meas tran vdout0_47ck280 FIND v(dout0_47) AT=145.025n

.meas tran vdout0_48ck280 FIND v(dout0_48) AT=145.025n

.meas tran vdout0_49ck280 FIND v(dout0_49) AT=145.025n

.meas tran vdout0_50ck280 FIND v(dout0_50) AT=145.025n

.meas tran vdout0_51ck280 FIND v(dout0_51) AT=145.025n

.meas tran vdout0_52ck280 FIND v(dout0_52) AT=145.025n

.meas tran vdout0_53ck280 FIND v(dout0_53) AT=145.025n

.meas tran vdout0_54ck280 FIND v(dout0_54) AT=145.025n

.meas tran vdout0_55ck280 FIND v(dout0_55) AT=145.025n

.meas tran vdout0_56ck280 FIND v(dout0_56) AT=145.025n

.meas tran vdout0_57ck280 FIND v(dout0_57) AT=145.025n

.meas tran vdout0_58ck280 FIND v(dout0_58) AT=145.025n

.meas tran vdout0_59ck280 FIND v(dout0_59) AT=145.025n

.meas tran vdout0_60ck280 FIND v(dout0_60) AT=145.025n

.meas tran vdout0_61ck280 FIND v(dout0_61) AT=145.025n

.meas tran vdout0_62ck280 FIND v(dout0_62) AT=145.025n

.meas tran vdout0_63ck280 FIND v(dout0_63) AT=145.025n

.meas tran vdout0_64ck280 FIND v(dout0_64) AT=145.025n

.meas tran vdout0_65ck280 FIND v(dout0_65) AT=145.025n

.meas tran vdout0_66ck280 FIND v(dout0_66) AT=145.025n

.meas tran vdout0_67ck280 FIND v(dout0_67) AT=145.025n

.meas tran vdout0_68ck280 FIND v(dout0_68) AT=145.025n

.meas tran vdout0_69ck280 FIND v(dout0_69) AT=145.025n

.meas tran vdout0_70ck280 FIND v(dout0_70) AT=145.025n

.meas tran vdout0_71ck280 FIND v(dout0_71) AT=145.025n

.meas tran vdout0_72ck280 FIND v(dout0_72) AT=145.025n

.meas tran vdout0_73ck280 FIND v(dout0_73) AT=145.025n

.meas tran vdout0_74ck280 FIND v(dout0_74) AT=145.025n

.meas tran vdout0_75ck280 FIND v(dout0_75) AT=145.025n

.meas tran vdout0_76ck280 FIND v(dout0_76) AT=145.025n

.meas tran vdout0_77ck280 FIND v(dout0_77) AT=145.025n

.meas tran vdout0_78ck280 FIND v(dout0_78) AT=145.025n

.meas tran vdout0_79ck280 FIND v(dout0_79) AT=145.025n

.meas tran vdout0_80ck280 FIND v(dout0_80) AT=145.025n

.meas tran vdout0_81ck280 FIND v(dout0_81) AT=145.025n

.meas tran vdout0_82ck280 FIND v(dout0_82) AT=145.025n

.meas tran vdout0_83ck280 FIND v(dout0_83) AT=145.025n

.meas tran vdout0_84ck280 FIND v(dout0_84) AT=145.025n

.meas tran vdout0_85ck280 FIND v(dout0_85) AT=145.025n

.meas tran vdout0_86ck280 FIND v(dout0_86) AT=145.025n

.meas tran vdout0_87ck280 FIND v(dout0_87) AT=145.025n

.meas tran vdout0_88ck280 FIND v(dout0_88) AT=145.025n

.meas tran vdout0_89ck280 FIND v(dout0_89) AT=145.025n

.meas tran vdout0_90ck280 FIND v(dout0_90) AT=145.025n

.meas tran vdout0_91ck280 FIND v(dout0_91) AT=145.025n

.meas tran vdout0_92ck280 FIND v(dout0_92) AT=145.025n

.meas tran vdout0_93ck280 FIND v(dout0_93) AT=145.025n

.meas tran vdout0_94ck280 FIND v(dout0_94) AT=145.025n

.meas tran vdout0_95ck280 FIND v(dout0_95) AT=145.025n

.meas tran vdout0_96ck280 FIND v(dout0_96) AT=145.025n

.meas tran vdout0_97ck280 FIND v(dout0_97) AT=145.025n

.meas tran vdout0_98ck280 FIND v(dout0_98) AT=145.025n

.meas tran vdout0_99ck280 FIND v(dout0_99) AT=145.025n

.meas tran vdout0_100ck280 FIND v(dout0_100) AT=145.025n

.meas tran vdout0_101ck280 FIND v(dout0_101) AT=145.025n

.meas tran vdout0_102ck280 FIND v(dout0_102) AT=145.025n

.meas tran vdout0_103ck280 FIND v(dout0_103) AT=145.025n

.meas tran vdout0_104ck280 FIND v(dout0_104) AT=145.025n

.meas tran vdout0_105ck280 FIND v(dout0_105) AT=145.025n

.meas tran vdout0_106ck280 FIND v(dout0_106) AT=145.025n

.meas tran vdout0_107ck280 FIND v(dout0_107) AT=145.025n

.meas tran vdout0_108ck280 FIND v(dout0_108) AT=145.025n

.meas tran vdout0_109ck280 FIND v(dout0_109) AT=145.025n

.meas tran vdout0_110ck280 FIND v(dout0_110) AT=145.025n

.meas tran vdout0_111ck280 FIND v(dout0_111) AT=145.025n

.meas tran vdout0_112ck280 FIND v(dout0_112) AT=145.025n

.meas tran vdout0_113ck280 FIND v(dout0_113) AT=145.025n

.meas tran vdout0_114ck280 FIND v(dout0_114) AT=145.025n

.meas tran vdout0_115ck280 FIND v(dout0_115) AT=145.025n

.meas tran vdout0_116ck280 FIND v(dout0_116) AT=145.025n

.meas tran vdout0_117ck280 FIND v(dout0_117) AT=145.025n

.meas tran vdout0_118ck280 FIND v(dout0_118) AT=145.025n

.meas tran vdout0_119ck280 FIND v(dout0_119) AT=145.025n

.meas tran vdout0_120ck280 FIND v(dout0_120) AT=145.025n

.meas tran vdout0_121ck280 FIND v(dout0_121) AT=145.025n

.meas tran vdout0_122ck280 FIND v(dout0_122) AT=145.025n

.meas tran vdout0_123ck280 FIND v(dout0_123) AT=145.025n

.meas tran vdout0_124ck280 FIND v(dout0_124) AT=145.025n

.meas tran vdout0_125ck280 FIND v(dout0_125) AT=145.025n

.meas tran vdout0_126ck280 FIND v(dout0_126) AT=145.025n

.meas tran vdout0_127ck280 FIND v(dout0_127) AT=145.025n

.meas tran vdout0_0ck310 FIND v(dout0_0) AT=160.025n

.meas tran vdout0_1ck310 FIND v(dout0_1) AT=160.025n

.meas tran vdout0_2ck310 FIND v(dout0_2) AT=160.025n

.meas tran vdout0_3ck310 FIND v(dout0_3) AT=160.025n

.meas tran vdout0_4ck310 FIND v(dout0_4) AT=160.025n

.meas tran vdout0_5ck310 FIND v(dout0_5) AT=160.025n

.meas tran vdout0_6ck310 FIND v(dout0_6) AT=160.025n

.meas tran vdout0_7ck310 FIND v(dout0_7) AT=160.025n

.meas tran vdout0_8ck310 FIND v(dout0_8) AT=160.025n

.meas tran vdout0_9ck310 FIND v(dout0_9) AT=160.025n

.meas tran vdout0_10ck310 FIND v(dout0_10) AT=160.025n

.meas tran vdout0_11ck310 FIND v(dout0_11) AT=160.025n

.meas tran vdout0_12ck310 FIND v(dout0_12) AT=160.025n

.meas tran vdout0_13ck310 FIND v(dout0_13) AT=160.025n

.meas tran vdout0_14ck310 FIND v(dout0_14) AT=160.025n

.meas tran vdout0_15ck310 FIND v(dout0_15) AT=160.025n

.meas tran vdout0_16ck310 FIND v(dout0_16) AT=160.025n

.meas tran vdout0_17ck310 FIND v(dout0_17) AT=160.025n

.meas tran vdout0_18ck310 FIND v(dout0_18) AT=160.025n

.meas tran vdout0_19ck310 FIND v(dout0_19) AT=160.025n

.meas tran vdout0_20ck310 FIND v(dout0_20) AT=160.025n

.meas tran vdout0_21ck310 FIND v(dout0_21) AT=160.025n

.meas tran vdout0_22ck310 FIND v(dout0_22) AT=160.025n

.meas tran vdout0_23ck310 FIND v(dout0_23) AT=160.025n

.meas tran vdout0_24ck310 FIND v(dout0_24) AT=160.025n

.meas tran vdout0_25ck310 FIND v(dout0_25) AT=160.025n

.meas tran vdout0_26ck310 FIND v(dout0_26) AT=160.025n

.meas tran vdout0_27ck310 FIND v(dout0_27) AT=160.025n

.meas tran vdout0_28ck310 FIND v(dout0_28) AT=160.025n

.meas tran vdout0_29ck310 FIND v(dout0_29) AT=160.025n

.meas tran vdout0_30ck310 FIND v(dout0_30) AT=160.025n

.meas tran vdout0_31ck310 FIND v(dout0_31) AT=160.025n

.meas tran vdout0_32ck310 FIND v(dout0_32) AT=160.025n

.meas tran vdout0_33ck310 FIND v(dout0_33) AT=160.025n

.meas tran vdout0_34ck310 FIND v(dout0_34) AT=160.025n

.meas tran vdout0_35ck310 FIND v(dout0_35) AT=160.025n

.meas tran vdout0_36ck310 FIND v(dout0_36) AT=160.025n

.meas tran vdout0_37ck310 FIND v(dout0_37) AT=160.025n

.meas tran vdout0_38ck310 FIND v(dout0_38) AT=160.025n

.meas tran vdout0_39ck310 FIND v(dout0_39) AT=160.025n

.meas tran vdout0_40ck310 FIND v(dout0_40) AT=160.025n

.meas tran vdout0_41ck310 FIND v(dout0_41) AT=160.025n

.meas tran vdout0_42ck310 FIND v(dout0_42) AT=160.025n

.meas tran vdout0_43ck310 FIND v(dout0_43) AT=160.025n

.meas tran vdout0_44ck310 FIND v(dout0_44) AT=160.025n

.meas tran vdout0_45ck310 FIND v(dout0_45) AT=160.025n

.meas tran vdout0_46ck310 FIND v(dout0_46) AT=160.025n

.meas tran vdout0_47ck310 FIND v(dout0_47) AT=160.025n

.meas tran vdout0_48ck310 FIND v(dout0_48) AT=160.025n

.meas tran vdout0_49ck310 FIND v(dout0_49) AT=160.025n

.meas tran vdout0_50ck310 FIND v(dout0_50) AT=160.025n

.meas tran vdout0_51ck310 FIND v(dout0_51) AT=160.025n

.meas tran vdout0_52ck310 FIND v(dout0_52) AT=160.025n

.meas tran vdout0_53ck310 FIND v(dout0_53) AT=160.025n

.meas tran vdout0_54ck310 FIND v(dout0_54) AT=160.025n

.meas tran vdout0_55ck310 FIND v(dout0_55) AT=160.025n

.meas tran vdout0_56ck310 FIND v(dout0_56) AT=160.025n

.meas tran vdout0_57ck310 FIND v(dout0_57) AT=160.025n

.meas tran vdout0_58ck310 FIND v(dout0_58) AT=160.025n

.meas tran vdout0_59ck310 FIND v(dout0_59) AT=160.025n

.meas tran vdout0_60ck310 FIND v(dout0_60) AT=160.025n

.meas tran vdout0_61ck310 FIND v(dout0_61) AT=160.025n

.meas tran vdout0_62ck310 FIND v(dout0_62) AT=160.025n

.meas tran vdout0_63ck310 FIND v(dout0_63) AT=160.025n

.meas tran vdout0_64ck310 FIND v(dout0_64) AT=160.025n

.meas tran vdout0_65ck310 FIND v(dout0_65) AT=160.025n

.meas tran vdout0_66ck310 FIND v(dout0_66) AT=160.025n

.meas tran vdout0_67ck310 FIND v(dout0_67) AT=160.025n

.meas tran vdout0_68ck310 FIND v(dout0_68) AT=160.025n

.meas tran vdout0_69ck310 FIND v(dout0_69) AT=160.025n

.meas tran vdout0_70ck310 FIND v(dout0_70) AT=160.025n

.meas tran vdout0_71ck310 FIND v(dout0_71) AT=160.025n

.meas tran vdout0_72ck310 FIND v(dout0_72) AT=160.025n

.meas tran vdout0_73ck310 FIND v(dout0_73) AT=160.025n

.meas tran vdout0_74ck310 FIND v(dout0_74) AT=160.025n

.meas tran vdout0_75ck310 FIND v(dout0_75) AT=160.025n

.meas tran vdout0_76ck310 FIND v(dout0_76) AT=160.025n

.meas tran vdout0_77ck310 FIND v(dout0_77) AT=160.025n

.meas tran vdout0_78ck310 FIND v(dout0_78) AT=160.025n

.meas tran vdout0_79ck310 FIND v(dout0_79) AT=160.025n

.meas tran vdout0_80ck310 FIND v(dout0_80) AT=160.025n

.meas tran vdout0_81ck310 FIND v(dout0_81) AT=160.025n

.meas tran vdout0_82ck310 FIND v(dout0_82) AT=160.025n

.meas tran vdout0_83ck310 FIND v(dout0_83) AT=160.025n

.meas tran vdout0_84ck310 FIND v(dout0_84) AT=160.025n

.meas tran vdout0_85ck310 FIND v(dout0_85) AT=160.025n

.meas tran vdout0_86ck310 FIND v(dout0_86) AT=160.025n

.meas tran vdout0_87ck310 FIND v(dout0_87) AT=160.025n

.meas tran vdout0_88ck310 FIND v(dout0_88) AT=160.025n

.meas tran vdout0_89ck310 FIND v(dout0_89) AT=160.025n

.meas tran vdout0_90ck310 FIND v(dout0_90) AT=160.025n

.meas tran vdout0_91ck310 FIND v(dout0_91) AT=160.025n

.meas tran vdout0_92ck310 FIND v(dout0_92) AT=160.025n

.meas tran vdout0_93ck310 FIND v(dout0_93) AT=160.025n

.meas tran vdout0_94ck310 FIND v(dout0_94) AT=160.025n

.meas tran vdout0_95ck310 FIND v(dout0_95) AT=160.025n

.meas tran vdout0_96ck310 FIND v(dout0_96) AT=160.025n

.meas tran vdout0_97ck310 FIND v(dout0_97) AT=160.025n

.meas tran vdout0_98ck310 FIND v(dout0_98) AT=160.025n

.meas tran vdout0_99ck310 FIND v(dout0_99) AT=160.025n

.meas tran vdout0_100ck310 FIND v(dout0_100) AT=160.025n

.meas tran vdout0_101ck310 FIND v(dout0_101) AT=160.025n

.meas tran vdout0_102ck310 FIND v(dout0_102) AT=160.025n

.meas tran vdout0_103ck310 FIND v(dout0_103) AT=160.025n

.meas tran vdout0_104ck310 FIND v(dout0_104) AT=160.025n

.meas tran vdout0_105ck310 FIND v(dout0_105) AT=160.025n

.meas tran vdout0_106ck310 FIND v(dout0_106) AT=160.025n

.meas tran vdout0_107ck310 FIND v(dout0_107) AT=160.025n

.meas tran vdout0_108ck310 FIND v(dout0_108) AT=160.025n

.meas tran vdout0_109ck310 FIND v(dout0_109) AT=160.025n

.meas tran vdout0_110ck310 FIND v(dout0_110) AT=160.025n

.meas tran vdout0_111ck310 FIND v(dout0_111) AT=160.025n

.meas tran vdout0_112ck310 FIND v(dout0_112) AT=160.025n

.meas tran vdout0_113ck310 FIND v(dout0_113) AT=160.025n

.meas tran vdout0_114ck310 FIND v(dout0_114) AT=160.025n

.meas tran vdout0_115ck310 FIND v(dout0_115) AT=160.025n

.meas tran vdout0_116ck310 FIND v(dout0_116) AT=160.025n

.meas tran vdout0_117ck310 FIND v(dout0_117) AT=160.025n

.meas tran vdout0_118ck310 FIND v(dout0_118) AT=160.025n

.meas tran vdout0_119ck310 FIND v(dout0_119) AT=160.025n

.meas tran vdout0_120ck310 FIND v(dout0_120) AT=160.025n

.meas tran vdout0_121ck310 FIND v(dout0_121) AT=160.025n

.meas tran vdout0_122ck310 FIND v(dout0_122) AT=160.025n

.meas tran vdout0_123ck310 FIND v(dout0_123) AT=160.025n

.meas tran vdout0_124ck310 FIND v(dout0_124) AT=160.025n

.meas tran vdout0_125ck310 FIND v(dout0_125) AT=160.025n

.meas tran vdout0_126ck310 FIND v(dout0_126) AT=160.025n

.meas tran vdout0_127ck310 FIND v(dout0_127) AT=160.025n

.meas tran vdout0_0ck360 FIND v(dout0_0) AT=185.025n

.meas tran vdout0_1ck360 FIND v(dout0_1) AT=185.025n

.meas tran vdout0_2ck360 FIND v(dout0_2) AT=185.025n

.meas tran vdout0_3ck360 FIND v(dout0_3) AT=185.025n

.meas tran vdout0_4ck360 FIND v(dout0_4) AT=185.025n

.meas tran vdout0_5ck360 FIND v(dout0_5) AT=185.025n

.meas tran vdout0_6ck360 FIND v(dout0_6) AT=185.025n

.meas tran vdout0_7ck360 FIND v(dout0_7) AT=185.025n

.meas tran vdout0_8ck360 FIND v(dout0_8) AT=185.025n

.meas tran vdout0_9ck360 FIND v(dout0_9) AT=185.025n

.meas tran vdout0_10ck360 FIND v(dout0_10) AT=185.025n

.meas tran vdout0_11ck360 FIND v(dout0_11) AT=185.025n

.meas tran vdout0_12ck360 FIND v(dout0_12) AT=185.025n

.meas tran vdout0_13ck360 FIND v(dout0_13) AT=185.025n

.meas tran vdout0_14ck360 FIND v(dout0_14) AT=185.025n

.meas tran vdout0_15ck360 FIND v(dout0_15) AT=185.025n

.meas tran vdout0_16ck360 FIND v(dout0_16) AT=185.025n

.meas tran vdout0_17ck360 FIND v(dout0_17) AT=185.025n

.meas tran vdout0_18ck360 FIND v(dout0_18) AT=185.025n

.meas tran vdout0_19ck360 FIND v(dout0_19) AT=185.025n

.meas tran vdout0_20ck360 FIND v(dout0_20) AT=185.025n

.meas tran vdout0_21ck360 FIND v(dout0_21) AT=185.025n

.meas tran vdout0_22ck360 FIND v(dout0_22) AT=185.025n

.meas tran vdout0_23ck360 FIND v(dout0_23) AT=185.025n

.meas tran vdout0_24ck360 FIND v(dout0_24) AT=185.025n

.meas tran vdout0_25ck360 FIND v(dout0_25) AT=185.025n

.meas tran vdout0_26ck360 FIND v(dout0_26) AT=185.025n

.meas tran vdout0_27ck360 FIND v(dout0_27) AT=185.025n

.meas tran vdout0_28ck360 FIND v(dout0_28) AT=185.025n

.meas tran vdout0_29ck360 FIND v(dout0_29) AT=185.025n

.meas tran vdout0_30ck360 FIND v(dout0_30) AT=185.025n

.meas tran vdout0_31ck360 FIND v(dout0_31) AT=185.025n

.meas tran vdout0_32ck360 FIND v(dout0_32) AT=185.025n

.meas tran vdout0_33ck360 FIND v(dout0_33) AT=185.025n

.meas tran vdout0_34ck360 FIND v(dout0_34) AT=185.025n

.meas tran vdout0_35ck360 FIND v(dout0_35) AT=185.025n

.meas tran vdout0_36ck360 FIND v(dout0_36) AT=185.025n

.meas tran vdout0_37ck360 FIND v(dout0_37) AT=185.025n

.meas tran vdout0_38ck360 FIND v(dout0_38) AT=185.025n

.meas tran vdout0_39ck360 FIND v(dout0_39) AT=185.025n

.meas tran vdout0_40ck360 FIND v(dout0_40) AT=185.025n

.meas tran vdout0_41ck360 FIND v(dout0_41) AT=185.025n

.meas tran vdout0_42ck360 FIND v(dout0_42) AT=185.025n

.meas tran vdout0_43ck360 FIND v(dout0_43) AT=185.025n

.meas tran vdout0_44ck360 FIND v(dout0_44) AT=185.025n

.meas tran vdout0_45ck360 FIND v(dout0_45) AT=185.025n

.meas tran vdout0_46ck360 FIND v(dout0_46) AT=185.025n

.meas tran vdout0_47ck360 FIND v(dout0_47) AT=185.025n

.meas tran vdout0_48ck360 FIND v(dout0_48) AT=185.025n

.meas tran vdout0_49ck360 FIND v(dout0_49) AT=185.025n

.meas tran vdout0_50ck360 FIND v(dout0_50) AT=185.025n

.meas tran vdout0_51ck360 FIND v(dout0_51) AT=185.025n

.meas tran vdout0_52ck360 FIND v(dout0_52) AT=185.025n

.meas tran vdout0_53ck360 FIND v(dout0_53) AT=185.025n

.meas tran vdout0_54ck360 FIND v(dout0_54) AT=185.025n

.meas tran vdout0_55ck360 FIND v(dout0_55) AT=185.025n

.meas tran vdout0_56ck360 FIND v(dout0_56) AT=185.025n

.meas tran vdout0_57ck360 FIND v(dout0_57) AT=185.025n

.meas tran vdout0_58ck360 FIND v(dout0_58) AT=185.025n

.meas tran vdout0_59ck360 FIND v(dout0_59) AT=185.025n

.meas tran vdout0_60ck360 FIND v(dout0_60) AT=185.025n

.meas tran vdout0_61ck360 FIND v(dout0_61) AT=185.025n

.meas tran vdout0_62ck360 FIND v(dout0_62) AT=185.025n

.meas tran vdout0_63ck360 FIND v(dout0_63) AT=185.025n

.meas tran vdout0_64ck360 FIND v(dout0_64) AT=185.025n

.meas tran vdout0_65ck360 FIND v(dout0_65) AT=185.025n

.meas tran vdout0_66ck360 FIND v(dout0_66) AT=185.025n

.meas tran vdout0_67ck360 FIND v(dout0_67) AT=185.025n

.meas tran vdout0_68ck360 FIND v(dout0_68) AT=185.025n

.meas tran vdout0_69ck360 FIND v(dout0_69) AT=185.025n

.meas tran vdout0_70ck360 FIND v(dout0_70) AT=185.025n

.meas tran vdout0_71ck360 FIND v(dout0_71) AT=185.025n

.meas tran vdout0_72ck360 FIND v(dout0_72) AT=185.025n

.meas tran vdout0_73ck360 FIND v(dout0_73) AT=185.025n

.meas tran vdout0_74ck360 FIND v(dout0_74) AT=185.025n

.meas tran vdout0_75ck360 FIND v(dout0_75) AT=185.025n

.meas tran vdout0_76ck360 FIND v(dout0_76) AT=185.025n

.meas tran vdout0_77ck360 FIND v(dout0_77) AT=185.025n

.meas tran vdout0_78ck360 FIND v(dout0_78) AT=185.025n

.meas tran vdout0_79ck360 FIND v(dout0_79) AT=185.025n

.meas tran vdout0_80ck360 FIND v(dout0_80) AT=185.025n

.meas tran vdout0_81ck360 FIND v(dout0_81) AT=185.025n

.meas tran vdout0_82ck360 FIND v(dout0_82) AT=185.025n

.meas tran vdout0_83ck360 FIND v(dout0_83) AT=185.025n

.meas tran vdout0_84ck360 FIND v(dout0_84) AT=185.025n

.meas tran vdout0_85ck360 FIND v(dout0_85) AT=185.025n

.meas tran vdout0_86ck360 FIND v(dout0_86) AT=185.025n

.meas tran vdout0_87ck360 FIND v(dout0_87) AT=185.025n

.meas tran vdout0_88ck360 FIND v(dout0_88) AT=185.025n

.meas tran vdout0_89ck360 FIND v(dout0_89) AT=185.025n

.meas tran vdout0_90ck360 FIND v(dout0_90) AT=185.025n

.meas tran vdout0_91ck360 FIND v(dout0_91) AT=185.025n

.meas tran vdout0_92ck360 FIND v(dout0_92) AT=185.025n

.meas tran vdout0_93ck360 FIND v(dout0_93) AT=185.025n

.meas tran vdout0_94ck360 FIND v(dout0_94) AT=185.025n

.meas tran vdout0_95ck360 FIND v(dout0_95) AT=185.025n

.meas tran vdout0_96ck360 FIND v(dout0_96) AT=185.025n

.meas tran vdout0_97ck360 FIND v(dout0_97) AT=185.025n

.meas tran vdout0_98ck360 FIND v(dout0_98) AT=185.025n

.meas tran vdout0_99ck360 FIND v(dout0_99) AT=185.025n

.meas tran vdout0_100ck360 FIND v(dout0_100) AT=185.025n

.meas tran vdout0_101ck360 FIND v(dout0_101) AT=185.025n

.meas tran vdout0_102ck360 FIND v(dout0_102) AT=185.025n

.meas tran vdout0_103ck360 FIND v(dout0_103) AT=185.025n

.meas tran vdout0_104ck360 FIND v(dout0_104) AT=185.025n

.meas tran vdout0_105ck360 FIND v(dout0_105) AT=185.025n

.meas tran vdout0_106ck360 FIND v(dout0_106) AT=185.025n

.meas tran vdout0_107ck360 FIND v(dout0_107) AT=185.025n

.meas tran vdout0_108ck360 FIND v(dout0_108) AT=185.025n

.meas tran vdout0_109ck360 FIND v(dout0_109) AT=185.025n

.meas tran vdout0_110ck360 FIND v(dout0_110) AT=185.025n

.meas tran vdout0_111ck360 FIND v(dout0_111) AT=185.025n

.meas tran vdout0_112ck360 FIND v(dout0_112) AT=185.025n

.meas tran vdout0_113ck360 FIND v(dout0_113) AT=185.025n

.meas tran vdout0_114ck360 FIND v(dout0_114) AT=185.025n

.meas tran vdout0_115ck360 FIND v(dout0_115) AT=185.025n

.meas tran vdout0_116ck360 FIND v(dout0_116) AT=185.025n

.meas tran vdout0_117ck360 FIND v(dout0_117) AT=185.025n

.meas tran vdout0_118ck360 FIND v(dout0_118) AT=185.025n

.meas tran vdout0_119ck360 FIND v(dout0_119) AT=185.025n

.meas tran vdout0_120ck360 FIND v(dout0_120) AT=185.025n

.meas tran vdout0_121ck360 FIND v(dout0_121) AT=185.025n

.meas tran vdout0_122ck360 FIND v(dout0_122) AT=185.025n

.meas tran vdout0_123ck360 FIND v(dout0_123) AT=185.025n

.meas tran vdout0_124ck360 FIND v(dout0_124) AT=185.025n

.meas tran vdout0_125ck360 FIND v(dout0_125) AT=185.025n

.meas tran vdout0_126ck360 FIND v(dout0_126) AT=185.025n

.meas tran vdout0_127ck360 FIND v(dout0_127) AT=185.025n

.meas tran vdout0_0ck410 FIND v(dout0_0) AT=210.025n

.meas tran vdout0_1ck410 FIND v(dout0_1) AT=210.025n

.meas tran vdout0_2ck410 FIND v(dout0_2) AT=210.025n

.meas tran vdout0_3ck410 FIND v(dout0_3) AT=210.025n

.meas tran vdout0_4ck410 FIND v(dout0_4) AT=210.025n

.meas tran vdout0_5ck410 FIND v(dout0_5) AT=210.025n

.meas tran vdout0_6ck410 FIND v(dout0_6) AT=210.025n

.meas tran vdout0_7ck410 FIND v(dout0_7) AT=210.025n

.meas tran vdout0_8ck410 FIND v(dout0_8) AT=210.025n

.meas tran vdout0_9ck410 FIND v(dout0_9) AT=210.025n

.meas tran vdout0_10ck410 FIND v(dout0_10) AT=210.025n

.meas tran vdout0_11ck410 FIND v(dout0_11) AT=210.025n

.meas tran vdout0_12ck410 FIND v(dout0_12) AT=210.025n

.meas tran vdout0_13ck410 FIND v(dout0_13) AT=210.025n

.meas tran vdout0_14ck410 FIND v(dout0_14) AT=210.025n

.meas tran vdout0_15ck410 FIND v(dout0_15) AT=210.025n

.meas tran vdout0_16ck410 FIND v(dout0_16) AT=210.025n

.meas tran vdout0_17ck410 FIND v(dout0_17) AT=210.025n

.meas tran vdout0_18ck410 FIND v(dout0_18) AT=210.025n

.meas tran vdout0_19ck410 FIND v(dout0_19) AT=210.025n

.meas tran vdout0_20ck410 FIND v(dout0_20) AT=210.025n

.meas tran vdout0_21ck410 FIND v(dout0_21) AT=210.025n

.meas tran vdout0_22ck410 FIND v(dout0_22) AT=210.025n

.meas tran vdout0_23ck410 FIND v(dout0_23) AT=210.025n

.meas tran vdout0_24ck410 FIND v(dout0_24) AT=210.025n

.meas tran vdout0_25ck410 FIND v(dout0_25) AT=210.025n

.meas tran vdout0_26ck410 FIND v(dout0_26) AT=210.025n

.meas tran vdout0_27ck410 FIND v(dout0_27) AT=210.025n

.meas tran vdout0_28ck410 FIND v(dout0_28) AT=210.025n

.meas tran vdout0_29ck410 FIND v(dout0_29) AT=210.025n

.meas tran vdout0_30ck410 FIND v(dout0_30) AT=210.025n

.meas tran vdout0_31ck410 FIND v(dout0_31) AT=210.025n

.meas tran vdout0_32ck410 FIND v(dout0_32) AT=210.025n

.meas tran vdout0_33ck410 FIND v(dout0_33) AT=210.025n

.meas tran vdout0_34ck410 FIND v(dout0_34) AT=210.025n

.meas tran vdout0_35ck410 FIND v(dout0_35) AT=210.025n

.meas tran vdout0_36ck410 FIND v(dout0_36) AT=210.025n

.meas tran vdout0_37ck410 FIND v(dout0_37) AT=210.025n

.meas tran vdout0_38ck410 FIND v(dout0_38) AT=210.025n

.meas tran vdout0_39ck410 FIND v(dout0_39) AT=210.025n

.meas tran vdout0_40ck410 FIND v(dout0_40) AT=210.025n

.meas tran vdout0_41ck410 FIND v(dout0_41) AT=210.025n

.meas tran vdout0_42ck410 FIND v(dout0_42) AT=210.025n

.meas tran vdout0_43ck410 FIND v(dout0_43) AT=210.025n

.meas tran vdout0_44ck410 FIND v(dout0_44) AT=210.025n

.meas tran vdout0_45ck410 FIND v(dout0_45) AT=210.025n

.meas tran vdout0_46ck410 FIND v(dout0_46) AT=210.025n

.meas tran vdout0_47ck410 FIND v(dout0_47) AT=210.025n

.meas tran vdout0_48ck410 FIND v(dout0_48) AT=210.025n

.meas tran vdout0_49ck410 FIND v(dout0_49) AT=210.025n

.meas tran vdout0_50ck410 FIND v(dout0_50) AT=210.025n

.meas tran vdout0_51ck410 FIND v(dout0_51) AT=210.025n

.meas tran vdout0_52ck410 FIND v(dout0_52) AT=210.025n

.meas tran vdout0_53ck410 FIND v(dout0_53) AT=210.025n

.meas tran vdout0_54ck410 FIND v(dout0_54) AT=210.025n

.meas tran vdout0_55ck410 FIND v(dout0_55) AT=210.025n

.meas tran vdout0_56ck410 FIND v(dout0_56) AT=210.025n

.meas tran vdout0_57ck410 FIND v(dout0_57) AT=210.025n

.meas tran vdout0_58ck410 FIND v(dout0_58) AT=210.025n

.meas tran vdout0_59ck410 FIND v(dout0_59) AT=210.025n

.meas tran vdout0_60ck410 FIND v(dout0_60) AT=210.025n

.meas tran vdout0_61ck410 FIND v(dout0_61) AT=210.025n

.meas tran vdout0_62ck410 FIND v(dout0_62) AT=210.025n

.meas tran vdout0_63ck410 FIND v(dout0_63) AT=210.025n

.meas tran vdout0_64ck410 FIND v(dout0_64) AT=210.025n

.meas tran vdout0_65ck410 FIND v(dout0_65) AT=210.025n

.meas tran vdout0_66ck410 FIND v(dout0_66) AT=210.025n

.meas tran vdout0_67ck410 FIND v(dout0_67) AT=210.025n

.meas tran vdout0_68ck410 FIND v(dout0_68) AT=210.025n

.meas tran vdout0_69ck410 FIND v(dout0_69) AT=210.025n

.meas tran vdout0_70ck410 FIND v(dout0_70) AT=210.025n

.meas tran vdout0_71ck410 FIND v(dout0_71) AT=210.025n

.meas tran vdout0_72ck410 FIND v(dout0_72) AT=210.025n

.meas tran vdout0_73ck410 FIND v(dout0_73) AT=210.025n

.meas tran vdout0_74ck410 FIND v(dout0_74) AT=210.025n

.meas tran vdout0_75ck410 FIND v(dout0_75) AT=210.025n

.meas tran vdout0_76ck410 FIND v(dout0_76) AT=210.025n

.meas tran vdout0_77ck410 FIND v(dout0_77) AT=210.025n

.meas tran vdout0_78ck410 FIND v(dout0_78) AT=210.025n

.meas tran vdout0_79ck410 FIND v(dout0_79) AT=210.025n

.meas tran vdout0_80ck410 FIND v(dout0_80) AT=210.025n

.meas tran vdout0_81ck410 FIND v(dout0_81) AT=210.025n

.meas tran vdout0_82ck410 FIND v(dout0_82) AT=210.025n

.meas tran vdout0_83ck410 FIND v(dout0_83) AT=210.025n

.meas tran vdout0_84ck410 FIND v(dout0_84) AT=210.025n

.meas tran vdout0_85ck410 FIND v(dout0_85) AT=210.025n

.meas tran vdout0_86ck410 FIND v(dout0_86) AT=210.025n

.meas tran vdout0_87ck410 FIND v(dout0_87) AT=210.025n

.meas tran vdout0_88ck410 FIND v(dout0_88) AT=210.025n

.meas tran vdout0_89ck410 FIND v(dout0_89) AT=210.025n

.meas tran vdout0_90ck410 FIND v(dout0_90) AT=210.025n

.meas tran vdout0_91ck410 FIND v(dout0_91) AT=210.025n

.meas tran vdout0_92ck410 FIND v(dout0_92) AT=210.025n

.meas tran vdout0_93ck410 FIND v(dout0_93) AT=210.025n

.meas tran vdout0_94ck410 FIND v(dout0_94) AT=210.025n

.meas tran vdout0_95ck410 FIND v(dout0_95) AT=210.025n

.meas tran vdout0_96ck410 FIND v(dout0_96) AT=210.025n

.meas tran vdout0_97ck410 FIND v(dout0_97) AT=210.025n

.meas tran vdout0_98ck410 FIND v(dout0_98) AT=210.025n

.meas tran vdout0_99ck410 FIND v(dout0_99) AT=210.025n

.meas tran vdout0_100ck410 FIND v(dout0_100) AT=210.025n

.meas tran vdout0_101ck410 FIND v(dout0_101) AT=210.025n

.meas tran vdout0_102ck410 FIND v(dout0_102) AT=210.025n

.meas tran vdout0_103ck410 FIND v(dout0_103) AT=210.025n

.meas tran vdout0_104ck410 FIND v(dout0_104) AT=210.025n

.meas tran vdout0_105ck410 FIND v(dout0_105) AT=210.025n

.meas tran vdout0_106ck410 FIND v(dout0_106) AT=210.025n

.meas tran vdout0_107ck410 FIND v(dout0_107) AT=210.025n

.meas tran vdout0_108ck410 FIND v(dout0_108) AT=210.025n

.meas tran vdout0_109ck410 FIND v(dout0_109) AT=210.025n

.meas tran vdout0_110ck410 FIND v(dout0_110) AT=210.025n

.meas tran vdout0_111ck410 FIND v(dout0_111) AT=210.025n

.meas tran vdout0_112ck410 FIND v(dout0_112) AT=210.025n

.meas tran vdout0_113ck410 FIND v(dout0_113) AT=210.025n

.meas tran vdout0_114ck410 FIND v(dout0_114) AT=210.025n

.meas tran vdout0_115ck410 FIND v(dout0_115) AT=210.025n

.meas tran vdout0_116ck410 FIND v(dout0_116) AT=210.025n

.meas tran vdout0_117ck410 FIND v(dout0_117) AT=210.025n

.meas tran vdout0_118ck410 FIND v(dout0_118) AT=210.025n

.meas tran vdout0_119ck410 FIND v(dout0_119) AT=210.025n

.meas tran vdout0_120ck410 FIND v(dout0_120) AT=210.025n

.meas tran vdout0_121ck410 FIND v(dout0_121) AT=210.025n

.meas tran vdout0_122ck410 FIND v(dout0_122) AT=210.025n

.meas tran vdout0_123ck410 FIND v(dout0_123) AT=210.025n

.meas tran vdout0_124ck410 FIND v(dout0_124) AT=210.025n

.meas tran vdout0_125ck410 FIND v(dout0_125) AT=210.025n

.meas tran vdout0_126ck410 FIND v(dout0_126) AT=210.025n

.meas tran vdout0_127ck410 FIND v(dout0_127) AT=210.025n

.meas tran vdout0_0ck440 FIND v(dout0_0) AT=225.025n

.meas tran vdout0_1ck440 FIND v(dout0_1) AT=225.025n

.meas tran vdout0_2ck440 FIND v(dout0_2) AT=225.025n

.meas tran vdout0_3ck440 FIND v(dout0_3) AT=225.025n

.meas tran vdout0_4ck440 FIND v(dout0_4) AT=225.025n

.meas tran vdout0_5ck440 FIND v(dout0_5) AT=225.025n

.meas tran vdout0_6ck440 FIND v(dout0_6) AT=225.025n

.meas tran vdout0_7ck440 FIND v(dout0_7) AT=225.025n

.meas tran vdout0_8ck440 FIND v(dout0_8) AT=225.025n

.meas tran vdout0_9ck440 FIND v(dout0_9) AT=225.025n

.meas tran vdout0_10ck440 FIND v(dout0_10) AT=225.025n

.meas tran vdout0_11ck440 FIND v(dout0_11) AT=225.025n

.meas tran vdout0_12ck440 FIND v(dout0_12) AT=225.025n

.meas tran vdout0_13ck440 FIND v(dout0_13) AT=225.025n

.meas tran vdout0_14ck440 FIND v(dout0_14) AT=225.025n

.meas tran vdout0_15ck440 FIND v(dout0_15) AT=225.025n

.meas tran vdout0_16ck440 FIND v(dout0_16) AT=225.025n

.meas tran vdout0_17ck440 FIND v(dout0_17) AT=225.025n

.meas tran vdout0_18ck440 FIND v(dout0_18) AT=225.025n

.meas tran vdout0_19ck440 FIND v(dout0_19) AT=225.025n

.meas tran vdout0_20ck440 FIND v(dout0_20) AT=225.025n

.meas tran vdout0_21ck440 FIND v(dout0_21) AT=225.025n

.meas tran vdout0_22ck440 FIND v(dout0_22) AT=225.025n

.meas tran vdout0_23ck440 FIND v(dout0_23) AT=225.025n

.meas tran vdout0_24ck440 FIND v(dout0_24) AT=225.025n

.meas tran vdout0_25ck440 FIND v(dout0_25) AT=225.025n

.meas tran vdout0_26ck440 FIND v(dout0_26) AT=225.025n

.meas tran vdout0_27ck440 FIND v(dout0_27) AT=225.025n

.meas tran vdout0_28ck440 FIND v(dout0_28) AT=225.025n

.meas tran vdout0_29ck440 FIND v(dout0_29) AT=225.025n

.meas tran vdout0_30ck440 FIND v(dout0_30) AT=225.025n

.meas tran vdout0_31ck440 FIND v(dout0_31) AT=225.025n

.meas tran vdout0_32ck440 FIND v(dout0_32) AT=225.025n

.meas tran vdout0_33ck440 FIND v(dout0_33) AT=225.025n

.meas tran vdout0_34ck440 FIND v(dout0_34) AT=225.025n

.meas tran vdout0_35ck440 FIND v(dout0_35) AT=225.025n

.meas tran vdout0_36ck440 FIND v(dout0_36) AT=225.025n

.meas tran vdout0_37ck440 FIND v(dout0_37) AT=225.025n

.meas tran vdout0_38ck440 FIND v(dout0_38) AT=225.025n

.meas tran vdout0_39ck440 FIND v(dout0_39) AT=225.025n

.meas tran vdout0_40ck440 FIND v(dout0_40) AT=225.025n

.meas tran vdout0_41ck440 FIND v(dout0_41) AT=225.025n

.meas tran vdout0_42ck440 FIND v(dout0_42) AT=225.025n

.meas tran vdout0_43ck440 FIND v(dout0_43) AT=225.025n

.meas tran vdout0_44ck440 FIND v(dout0_44) AT=225.025n

.meas tran vdout0_45ck440 FIND v(dout0_45) AT=225.025n

.meas tran vdout0_46ck440 FIND v(dout0_46) AT=225.025n

.meas tran vdout0_47ck440 FIND v(dout0_47) AT=225.025n

.meas tran vdout0_48ck440 FIND v(dout0_48) AT=225.025n

.meas tran vdout0_49ck440 FIND v(dout0_49) AT=225.025n

.meas tran vdout0_50ck440 FIND v(dout0_50) AT=225.025n

.meas tran vdout0_51ck440 FIND v(dout0_51) AT=225.025n

.meas tran vdout0_52ck440 FIND v(dout0_52) AT=225.025n

.meas tran vdout0_53ck440 FIND v(dout0_53) AT=225.025n

.meas tran vdout0_54ck440 FIND v(dout0_54) AT=225.025n

.meas tran vdout0_55ck440 FIND v(dout0_55) AT=225.025n

.meas tran vdout0_56ck440 FIND v(dout0_56) AT=225.025n

.meas tran vdout0_57ck440 FIND v(dout0_57) AT=225.025n

.meas tran vdout0_58ck440 FIND v(dout0_58) AT=225.025n

.meas tran vdout0_59ck440 FIND v(dout0_59) AT=225.025n

.meas tran vdout0_60ck440 FIND v(dout0_60) AT=225.025n

.meas tran vdout0_61ck440 FIND v(dout0_61) AT=225.025n

.meas tran vdout0_62ck440 FIND v(dout0_62) AT=225.025n

.meas tran vdout0_63ck440 FIND v(dout0_63) AT=225.025n

.meas tran vdout0_64ck440 FIND v(dout0_64) AT=225.025n

.meas tran vdout0_65ck440 FIND v(dout0_65) AT=225.025n

.meas tran vdout0_66ck440 FIND v(dout0_66) AT=225.025n

.meas tran vdout0_67ck440 FIND v(dout0_67) AT=225.025n

.meas tran vdout0_68ck440 FIND v(dout0_68) AT=225.025n

.meas tran vdout0_69ck440 FIND v(dout0_69) AT=225.025n

.meas tran vdout0_70ck440 FIND v(dout0_70) AT=225.025n

.meas tran vdout0_71ck440 FIND v(dout0_71) AT=225.025n

.meas tran vdout0_72ck440 FIND v(dout0_72) AT=225.025n

.meas tran vdout0_73ck440 FIND v(dout0_73) AT=225.025n

.meas tran vdout0_74ck440 FIND v(dout0_74) AT=225.025n

.meas tran vdout0_75ck440 FIND v(dout0_75) AT=225.025n

.meas tran vdout0_76ck440 FIND v(dout0_76) AT=225.025n

.meas tran vdout0_77ck440 FIND v(dout0_77) AT=225.025n

.meas tran vdout0_78ck440 FIND v(dout0_78) AT=225.025n

.meas tran vdout0_79ck440 FIND v(dout0_79) AT=225.025n

.meas tran vdout0_80ck440 FIND v(dout0_80) AT=225.025n

.meas tran vdout0_81ck440 FIND v(dout0_81) AT=225.025n

.meas tran vdout0_82ck440 FIND v(dout0_82) AT=225.025n

.meas tran vdout0_83ck440 FIND v(dout0_83) AT=225.025n

.meas tran vdout0_84ck440 FIND v(dout0_84) AT=225.025n

.meas tran vdout0_85ck440 FIND v(dout0_85) AT=225.025n

.meas tran vdout0_86ck440 FIND v(dout0_86) AT=225.025n

.meas tran vdout0_87ck440 FIND v(dout0_87) AT=225.025n

.meas tran vdout0_88ck440 FIND v(dout0_88) AT=225.025n

.meas tran vdout0_89ck440 FIND v(dout0_89) AT=225.025n

.meas tran vdout0_90ck440 FIND v(dout0_90) AT=225.025n

.meas tran vdout0_91ck440 FIND v(dout0_91) AT=225.025n

.meas tran vdout0_92ck440 FIND v(dout0_92) AT=225.025n

.meas tran vdout0_93ck440 FIND v(dout0_93) AT=225.025n

.meas tran vdout0_94ck440 FIND v(dout0_94) AT=225.025n

.meas tran vdout0_95ck440 FIND v(dout0_95) AT=225.025n

.meas tran vdout0_96ck440 FIND v(dout0_96) AT=225.025n

.meas tran vdout0_97ck440 FIND v(dout0_97) AT=225.025n

.meas tran vdout0_98ck440 FIND v(dout0_98) AT=225.025n

.meas tran vdout0_99ck440 FIND v(dout0_99) AT=225.025n

.meas tran vdout0_100ck440 FIND v(dout0_100) AT=225.025n

.meas tran vdout0_101ck440 FIND v(dout0_101) AT=225.025n

.meas tran vdout0_102ck440 FIND v(dout0_102) AT=225.025n

.meas tran vdout0_103ck440 FIND v(dout0_103) AT=225.025n

.meas tran vdout0_104ck440 FIND v(dout0_104) AT=225.025n

.meas tran vdout0_105ck440 FIND v(dout0_105) AT=225.025n

.meas tran vdout0_106ck440 FIND v(dout0_106) AT=225.025n

.meas tran vdout0_107ck440 FIND v(dout0_107) AT=225.025n

.meas tran vdout0_108ck440 FIND v(dout0_108) AT=225.025n

.meas tran vdout0_109ck440 FIND v(dout0_109) AT=225.025n

.meas tran vdout0_110ck440 FIND v(dout0_110) AT=225.025n

.meas tran vdout0_111ck440 FIND v(dout0_111) AT=225.025n

.meas tran vdout0_112ck440 FIND v(dout0_112) AT=225.025n

.meas tran vdout0_113ck440 FIND v(dout0_113) AT=225.025n

.meas tran vdout0_114ck440 FIND v(dout0_114) AT=225.025n

.meas tran vdout0_115ck440 FIND v(dout0_115) AT=225.025n

.meas tran vdout0_116ck440 FIND v(dout0_116) AT=225.025n

.meas tran vdout0_117ck440 FIND v(dout0_117) AT=225.025n

.meas tran vdout0_118ck440 FIND v(dout0_118) AT=225.025n

.meas tran vdout0_119ck440 FIND v(dout0_119) AT=225.025n

.meas tran vdout0_120ck440 FIND v(dout0_120) AT=225.025n

.meas tran vdout0_121ck440 FIND v(dout0_121) AT=225.025n

.meas tran vdout0_122ck440 FIND v(dout0_122) AT=225.025n

.meas tran vdout0_123ck440 FIND v(dout0_123) AT=225.025n

.meas tran vdout0_124ck440 FIND v(dout0_124) AT=225.025n

.meas tran vdout0_125ck440 FIND v(dout0_125) AT=225.025n

.meas tran vdout0_126ck440 FIND v(dout0_126) AT=225.025n

.meas tran vdout0_127ck440 FIND v(dout0_127) AT=225.025n

.meas tran vdout0_0ck450 FIND v(dout0_0) AT=230.025n

.meas tran vdout0_1ck450 FIND v(dout0_1) AT=230.025n

.meas tran vdout0_2ck450 FIND v(dout0_2) AT=230.025n

.meas tran vdout0_3ck450 FIND v(dout0_3) AT=230.025n

.meas tran vdout0_4ck450 FIND v(dout0_4) AT=230.025n

.meas tran vdout0_5ck450 FIND v(dout0_5) AT=230.025n

.meas tran vdout0_6ck450 FIND v(dout0_6) AT=230.025n

.meas tran vdout0_7ck450 FIND v(dout0_7) AT=230.025n

.meas tran vdout0_8ck450 FIND v(dout0_8) AT=230.025n

.meas tran vdout0_9ck450 FIND v(dout0_9) AT=230.025n

.meas tran vdout0_10ck450 FIND v(dout0_10) AT=230.025n

.meas tran vdout0_11ck450 FIND v(dout0_11) AT=230.025n

.meas tran vdout0_12ck450 FIND v(dout0_12) AT=230.025n

.meas tran vdout0_13ck450 FIND v(dout0_13) AT=230.025n

.meas tran vdout0_14ck450 FIND v(dout0_14) AT=230.025n

.meas tran vdout0_15ck450 FIND v(dout0_15) AT=230.025n

.meas tran vdout0_16ck450 FIND v(dout0_16) AT=230.025n

.meas tran vdout0_17ck450 FIND v(dout0_17) AT=230.025n

.meas tran vdout0_18ck450 FIND v(dout0_18) AT=230.025n

.meas tran vdout0_19ck450 FIND v(dout0_19) AT=230.025n

.meas tran vdout0_20ck450 FIND v(dout0_20) AT=230.025n

.meas tran vdout0_21ck450 FIND v(dout0_21) AT=230.025n

.meas tran vdout0_22ck450 FIND v(dout0_22) AT=230.025n

.meas tran vdout0_23ck450 FIND v(dout0_23) AT=230.025n

.meas tran vdout0_24ck450 FIND v(dout0_24) AT=230.025n

.meas tran vdout0_25ck450 FIND v(dout0_25) AT=230.025n

.meas tran vdout0_26ck450 FIND v(dout0_26) AT=230.025n

.meas tran vdout0_27ck450 FIND v(dout0_27) AT=230.025n

.meas tran vdout0_28ck450 FIND v(dout0_28) AT=230.025n

.meas tran vdout0_29ck450 FIND v(dout0_29) AT=230.025n

.meas tran vdout0_30ck450 FIND v(dout0_30) AT=230.025n

.meas tran vdout0_31ck450 FIND v(dout0_31) AT=230.025n

.meas tran vdout0_32ck450 FIND v(dout0_32) AT=230.025n

.meas tran vdout0_33ck450 FIND v(dout0_33) AT=230.025n

.meas tran vdout0_34ck450 FIND v(dout0_34) AT=230.025n

.meas tran vdout0_35ck450 FIND v(dout0_35) AT=230.025n

.meas tran vdout0_36ck450 FIND v(dout0_36) AT=230.025n

.meas tran vdout0_37ck450 FIND v(dout0_37) AT=230.025n

.meas tran vdout0_38ck450 FIND v(dout0_38) AT=230.025n

.meas tran vdout0_39ck450 FIND v(dout0_39) AT=230.025n

.meas tran vdout0_40ck450 FIND v(dout0_40) AT=230.025n

.meas tran vdout0_41ck450 FIND v(dout0_41) AT=230.025n

.meas tran vdout0_42ck450 FIND v(dout0_42) AT=230.025n

.meas tran vdout0_43ck450 FIND v(dout0_43) AT=230.025n

.meas tran vdout0_44ck450 FIND v(dout0_44) AT=230.025n

.meas tran vdout0_45ck450 FIND v(dout0_45) AT=230.025n

.meas tran vdout0_46ck450 FIND v(dout0_46) AT=230.025n

.meas tran vdout0_47ck450 FIND v(dout0_47) AT=230.025n

.meas tran vdout0_48ck450 FIND v(dout0_48) AT=230.025n

.meas tran vdout0_49ck450 FIND v(dout0_49) AT=230.025n

.meas tran vdout0_50ck450 FIND v(dout0_50) AT=230.025n

.meas tran vdout0_51ck450 FIND v(dout0_51) AT=230.025n

.meas tran vdout0_52ck450 FIND v(dout0_52) AT=230.025n

.meas tran vdout0_53ck450 FIND v(dout0_53) AT=230.025n

.meas tran vdout0_54ck450 FIND v(dout0_54) AT=230.025n

.meas tran vdout0_55ck450 FIND v(dout0_55) AT=230.025n

.meas tran vdout0_56ck450 FIND v(dout0_56) AT=230.025n

.meas tran vdout0_57ck450 FIND v(dout0_57) AT=230.025n

.meas tran vdout0_58ck450 FIND v(dout0_58) AT=230.025n

.meas tran vdout0_59ck450 FIND v(dout0_59) AT=230.025n

.meas tran vdout0_60ck450 FIND v(dout0_60) AT=230.025n

.meas tran vdout0_61ck450 FIND v(dout0_61) AT=230.025n

.meas tran vdout0_62ck450 FIND v(dout0_62) AT=230.025n

.meas tran vdout0_63ck450 FIND v(dout0_63) AT=230.025n

.meas tran vdout0_64ck450 FIND v(dout0_64) AT=230.025n

.meas tran vdout0_65ck450 FIND v(dout0_65) AT=230.025n

.meas tran vdout0_66ck450 FIND v(dout0_66) AT=230.025n

.meas tran vdout0_67ck450 FIND v(dout0_67) AT=230.025n

.meas tran vdout0_68ck450 FIND v(dout0_68) AT=230.025n

.meas tran vdout0_69ck450 FIND v(dout0_69) AT=230.025n

.meas tran vdout0_70ck450 FIND v(dout0_70) AT=230.025n

.meas tran vdout0_71ck450 FIND v(dout0_71) AT=230.025n

.meas tran vdout0_72ck450 FIND v(dout0_72) AT=230.025n

.meas tran vdout0_73ck450 FIND v(dout0_73) AT=230.025n

.meas tran vdout0_74ck450 FIND v(dout0_74) AT=230.025n

.meas tran vdout0_75ck450 FIND v(dout0_75) AT=230.025n

.meas tran vdout0_76ck450 FIND v(dout0_76) AT=230.025n

.meas tran vdout0_77ck450 FIND v(dout0_77) AT=230.025n

.meas tran vdout0_78ck450 FIND v(dout0_78) AT=230.025n

.meas tran vdout0_79ck450 FIND v(dout0_79) AT=230.025n

.meas tran vdout0_80ck450 FIND v(dout0_80) AT=230.025n

.meas tran vdout0_81ck450 FIND v(dout0_81) AT=230.025n

.meas tran vdout0_82ck450 FIND v(dout0_82) AT=230.025n

.meas tran vdout0_83ck450 FIND v(dout0_83) AT=230.025n

.meas tran vdout0_84ck450 FIND v(dout0_84) AT=230.025n

.meas tran vdout0_85ck450 FIND v(dout0_85) AT=230.025n

.meas tran vdout0_86ck450 FIND v(dout0_86) AT=230.025n

.meas tran vdout0_87ck450 FIND v(dout0_87) AT=230.025n

.meas tran vdout0_88ck450 FIND v(dout0_88) AT=230.025n

.meas tran vdout0_89ck450 FIND v(dout0_89) AT=230.025n

.meas tran vdout0_90ck450 FIND v(dout0_90) AT=230.025n

.meas tran vdout0_91ck450 FIND v(dout0_91) AT=230.025n

.meas tran vdout0_92ck450 FIND v(dout0_92) AT=230.025n

.meas tran vdout0_93ck450 FIND v(dout0_93) AT=230.025n

.meas tran vdout0_94ck450 FIND v(dout0_94) AT=230.025n

.meas tran vdout0_95ck450 FIND v(dout0_95) AT=230.025n

.meas tran vdout0_96ck450 FIND v(dout0_96) AT=230.025n

.meas tran vdout0_97ck450 FIND v(dout0_97) AT=230.025n

.meas tran vdout0_98ck450 FIND v(dout0_98) AT=230.025n

.meas tran vdout0_99ck450 FIND v(dout0_99) AT=230.025n

.meas tran vdout0_100ck450 FIND v(dout0_100) AT=230.025n

.meas tran vdout0_101ck450 FIND v(dout0_101) AT=230.025n

.meas tran vdout0_102ck450 FIND v(dout0_102) AT=230.025n

.meas tran vdout0_103ck450 FIND v(dout0_103) AT=230.025n

.meas tran vdout0_104ck450 FIND v(dout0_104) AT=230.025n

.meas tran vdout0_105ck450 FIND v(dout0_105) AT=230.025n

.meas tran vdout0_106ck450 FIND v(dout0_106) AT=230.025n

.meas tran vdout0_107ck450 FIND v(dout0_107) AT=230.025n

.meas tran vdout0_108ck450 FIND v(dout0_108) AT=230.025n

.meas tran vdout0_109ck450 FIND v(dout0_109) AT=230.025n

.meas tran vdout0_110ck450 FIND v(dout0_110) AT=230.025n

.meas tran vdout0_111ck450 FIND v(dout0_111) AT=230.025n

.meas tran vdout0_112ck450 FIND v(dout0_112) AT=230.025n

.meas tran vdout0_113ck450 FIND v(dout0_113) AT=230.025n

.meas tran vdout0_114ck450 FIND v(dout0_114) AT=230.025n

.meas tran vdout0_115ck450 FIND v(dout0_115) AT=230.025n

.meas tran vdout0_116ck450 FIND v(dout0_116) AT=230.025n

.meas tran vdout0_117ck450 FIND v(dout0_117) AT=230.025n

.meas tran vdout0_118ck450 FIND v(dout0_118) AT=230.025n

.meas tran vdout0_119ck450 FIND v(dout0_119) AT=230.025n

.meas tran vdout0_120ck450 FIND v(dout0_120) AT=230.025n

.meas tran vdout0_121ck450 FIND v(dout0_121) AT=230.025n

.meas tran vdout0_122ck450 FIND v(dout0_122) AT=230.025n

.meas tran vdout0_123ck450 FIND v(dout0_123) AT=230.025n

.meas tran vdout0_124ck450 FIND v(dout0_124) AT=230.025n

.meas tran vdout0_125ck450 FIND v(dout0_125) AT=230.025n

.meas tran vdout0_126ck450 FIND v(dout0_126) AT=230.025n

.meas tran vdout0_127ck450 FIND v(dout0_127) AT=230.025n

.meas tran vdout0_0ck510 FIND v(dout0_0) AT=260.025n

.meas tran vdout0_1ck510 FIND v(dout0_1) AT=260.025n

.meas tran vdout0_2ck510 FIND v(dout0_2) AT=260.025n

.meas tran vdout0_3ck510 FIND v(dout0_3) AT=260.025n

.meas tran vdout0_4ck510 FIND v(dout0_4) AT=260.025n

.meas tran vdout0_5ck510 FIND v(dout0_5) AT=260.025n

.meas tran vdout0_6ck510 FIND v(dout0_6) AT=260.025n

.meas tran vdout0_7ck510 FIND v(dout0_7) AT=260.025n

.meas tran vdout0_8ck510 FIND v(dout0_8) AT=260.025n

.meas tran vdout0_9ck510 FIND v(dout0_9) AT=260.025n

.meas tran vdout0_10ck510 FIND v(dout0_10) AT=260.025n

.meas tran vdout0_11ck510 FIND v(dout0_11) AT=260.025n

.meas tran vdout0_12ck510 FIND v(dout0_12) AT=260.025n

.meas tran vdout0_13ck510 FIND v(dout0_13) AT=260.025n

.meas tran vdout0_14ck510 FIND v(dout0_14) AT=260.025n

.meas tran vdout0_15ck510 FIND v(dout0_15) AT=260.025n

.meas tran vdout0_16ck510 FIND v(dout0_16) AT=260.025n

.meas tran vdout0_17ck510 FIND v(dout0_17) AT=260.025n

.meas tran vdout0_18ck510 FIND v(dout0_18) AT=260.025n

.meas tran vdout0_19ck510 FIND v(dout0_19) AT=260.025n

.meas tran vdout0_20ck510 FIND v(dout0_20) AT=260.025n

.meas tran vdout0_21ck510 FIND v(dout0_21) AT=260.025n

.meas tran vdout0_22ck510 FIND v(dout0_22) AT=260.025n

.meas tran vdout0_23ck510 FIND v(dout0_23) AT=260.025n

.meas tran vdout0_24ck510 FIND v(dout0_24) AT=260.025n

.meas tran vdout0_25ck510 FIND v(dout0_25) AT=260.025n

.meas tran vdout0_26ck510 FIND v(dout0_26) AT=260.025n

.meas tran vdout0_27ck510 FIND v(dout0_27) AT=260.025n

.meas tran vdout0_28ck510 FIND v(dout0_28) AT=260.025n

.meas tran vdout0_29ck510 FIND v(dout0_29) AT=260.025n

.meas tran vdout0_30ck510 FIND v(dout0_30) AT=260.025n

.meas tran vdout0_31ck510 FIND v(dout0_31) AT=260.025n

.meas tran vdout0_32ck510 FIND v(dout0_32) AT=260.025n

.meas tran vdout0_33ck510 FIND v(dout0_33) AT=260.025n

.meas tran vdout0_34ck510 FIND v(dout0_34) AT=260.025n

.meas tran vdout0_35ck510 FIND v(dout0_35) AT=260.025n

.meas tran vdout0_36ck510 FIND v(dout0_36) AT=260.025n

.meas tran vdout0_37ck510 FIND v(dout0_37) AT=260.025n

.meas tran vdout0_38ck510 FIND v(dout0_38) AT=260.025n

.meas tran vdout0_39ck510 FIND v(dout0_39) AT=260.025n

.meas tran vdout0_40ck510 FIND v(dout0_40) AT=260.025n

.meas tran vdout0_41ck510 FIND v(dout0_41) AT=260.025n

.meas tran vdout0_42ck510 FIND v(dout0_42) AT=260.025n

.meas tran vdout0_43ck510 FIND v(dout0_43) AT=260.025n

.meas tran vdout0_44ck510 FIND v(dout0_44) AT=260.025n

.meas tran vdout0_45ck510 FIND v(dout0_45) AT=260.025n

.meas tran vdout0_46ck510 FIND v(dout0_46) AT=260.025n

.meas tran vdout0_47ck510 FIND v(dout0_47) AT=260.025n

.meas tran vdout0_48ck510 FIND v(dout0_48) AT=260.025n

.meas tran vdout0_49ck510 FIND v(dout0_49) AT=260.025n

.meas tran vdout0_50ck510 FIND v(dout0_50) AT=260.025n

.meas tran vdout0_51ck510 FIND v(dout0_51) AT=260.025n

.meas tran vdout0_52ck510 FIND v(dout0_52) AT=260.025n

.meas tran vdout0_53ck510 FIND v(dout0_53) AT=260.025n

.meas tran vdout0_54ck510 FIND v(dout0_54) AT=260.025n

.meas tran vdout0_55ck510 FIND v(dout0_55) AT=260.025n

.meas tran vdout0_56ck510 FIND v(dout0_56) AT=260.025n

.meas tran vdout0_57ck510 FIND v(dout0_57) AT=260.025n

.meas tran vdout0_58ck510 FIND v(dout0_58) AT=260.025n

.meas tran vdout0_59ck510 FIND v(dout0_59) AT=260.025n

.meas tran vdout0_60ck510 FIND v(dout0_60) AT=260.025n

.meas tran vdout0_61ck510 FIND v(dout0_61) AT=260.025n

.meas tran vdout0_62ck510 FIND v(dout0_62) AT=260.025n

.meas tran vdout0_63ck510 FIND v(dout0_63) AT=260.025n

.meas tran vdout0_64ck510 FIND v(dout0_64) AT=260.025n

.meas tran vdout0_65ck510 FIND v(dout0_65) AT=260.025n

.meas tran vdout0_66ck510 FIND v(dout0_66) AT=260.025n

.meas tran vdout0_67ck510 FIND v(dout0_67) AT=260.025n

.meas tran vdout0_68ck510 FIND v(dout0_68) AT=260.025n

.meas tran vdout0_69ck510 FIND v(dout0_69) AT=260.025n

.meas tran vdout0_70ck510 FIND v(dout0_70) AT=260.025n

.meas tran vdout0_71ck510 FIND v(dout0_71) AT=260.025n

.meas tran vdout0_72ck510 FIND v(dout0_72) AT=260.025n

.meas tran vdout0_73ck510 FIND v(dout0_73) AT=260.025n

.meas tran vdout0_74ck510 FIND v(dout0_74) AT=260.025n

.meas tran vdout0_75ck510 FIND v(dout0_75) AT=260.025n

.meas tran vdout0_76ck510 FIND v(dout0_76) AT=260.025n

.meas tran vdout0_77ck510 FIND v(dout0_77) AT=260.025n

.meas tran vdout0_78ck510 FIND v(dout0_78) AT=260.025n

.meas tran vdout0_79ck510 FIND v(dout0_79) AT=260.025n

.meas tran vdout0_80ck510 FIND v(dout0_80) AT=260.025n

.meas tran vdout0_81ck510 FIND v(dout0_81) AT=260.025n

.meas tran vdout0_82ck510 FIND v(dout0_82) AT=260.025n

.meas tran vdout0_83ck510 FIND v(dout0_83) AT=260.025n

.meas tran vdout0_84ck510 FIND v(dout0_84) AT=260.025n

.meas tran vdout0_85ck510 FIND v(dout0_85) AT=260.025n

.meas tran vdout0_86ck510 FIND v(dout0_86) AT=260.025n

.meas tran vdout0_87ck510 FIND v(dout0_87) AT=260.025n

.meas tran vdout0_88ck510 FIND v(dout0_88) AT=260.025n

.meas tran vdout0_89ck510 FIND v(dout0_89) AT=260.025n

.meas tran vdout0_90ck510 FIND v(dout0_90) AT=260.025n

.meas tran vdout0_91ck510 FIND v(dout0_91) AT=260.025n

.meas tran vdout0_92ck510 FIND v(dout0_92) AT=260.025n

.meas tran vdout0_93ck510 FIND v(dout0_93) AT=260.025n

.meas tran vdout0_94ck510 FIND v(dout0_94) AT=260.025n

.meas tran vdout0_95ck510 FIND v(dout0_95) AT=260.025n

.meas tran vdout0_96ck510 FIND v(dout0_96) AT=260.025n

.meas tran vdout0_97ck510 FIND v(dout0_97) AT=260.025n

.meas tran vdout0_98ck510 FIND v(dout0_98) AT=260.025n

.meas tran vdout0_99ck510 FIND v(dout0_99) AT=260.025n

.meas tran vdout0_100ck510 FIND v(dout0_100) AT=260.025n

.meas tran vdout0_101ck510 FIND v(dout0_101) AT=260.025n

.meas tran vdout0_102ck510 FIND v(dout0_102) AT=260.025n

.meas tran vdout0_103ck510 FIND v(dout0_103) AT=260.025n

.meas tran vdout0_104ck510 FIND v(dout0_104) AT=260.025n

.meas tran vdout0_105ck510 FIND v(dout0_105) AT=260.025n

.meas tran vdout0_106ck510 FIND v(dout0_106) AT=260.025n

.meas tran vdout0_107ck510 FIND v(dout0_107) AT=260.025n

.meas tran vdout0_108ck510 FIND v(dout0_108) AT=260.025n

.meas tran vdout0_109ck510 FIND v(dout0_109) AT=260.025n

.meas tran vdout0_110ck510 FIND v(dout0_110) AT=260.025n

.meas tran vdout0_111ck510 FIND v(dout0_111) AT=260.025n

.meas tran vdout0_112ck510 FIND v(dout0_112) AT=260.025n

.meas tran vdout0_113ck510 FIND v(dout0_113) AT=260.025n

.meas tran vdout0_114ck510 FIND v(dout0_114) AT=260.025n

.meas tran vdout0_115ck510 FIND v(dout0_115) AT=260.025n

.meas tran vdout0_116ck510 FIND v(dout0_116) AT=260.025n

.meas tran vdout0_117ck510 FIND v(dout0_117) AT=260.025n

.meas tran vdout0_118ck510 FIND v(dout0_118) AT=260.025n

.meas tran vdout0_119ck510 FIND v(dout0_119) AT=260.025n

.meas tran vdout0_120ck510 FIND v(dout0_120) AT=260.025n

.meas tran vdout0_121ck510 FIND v(dout0_121) AT=260.025n

.meas tran vdout0_122ck510 FIND v(dout0_122) AT=260.025n

.meas tran vdout0_123ck510 FIND v(dout0_123) AT=260.025n

.meas tran vdout0_124ck510 FIND v(dout0_124) AT=260.025n

.meas tran vdout0_125ck510 FIND v(dout0_125) AT=260.025n

.meas tran vdout0_126ck510 FIND v(dout0_126) AT=260.025n

.meas tran vdout0_127ck510 FIND v(dout0_127) AT=260.025n

.meas tran vdout0_0ck560 FIND v(dout0_0) AT=285.025n

.meas tran vdout0_1ck560 FIND v(dout0_1) AT=285.025n

.meas tran vdout0_2ck560 FIND v(dout0_2) AT=285.025n

.meas tran vdout0_3ck560 FIND v(dout0_3) AT=285.025n

.meas tran vdout0_4ck560 FIND v(dout0_4) AT=285.025n

.meas tran vdout0_5ck560 FIND v(dout0_5) AT=285.025n

.meas tran vdout0_6ck560 FIND v(dout0_6) AT=285.025n

.meas tran vdout0_7ck560 FIND v(dout0_7) AT=285.025n

.meas tran vdout0_8ck560 FIND v(dout0_8) AT=285.025n

.meas tran vdout0_9ck560 FIND v(dout0_9) AT=285.025n

.meas tran vdout0_10ck560 FIND v(dout0_10) AT=285.025n

.meas tran vdout0_11ck560 FIND v(dout0_11) AT=285.025n

.meas tran vdout0_12ck560 FIND v(dout0_12) AT=285.025n

.meas tran vdout0_13ck560 FIND v(dout0_13) AT=285.025n

.meas tran vdout0_14ck560 FIND v(dout0_14) AT=285.025n

.meas tran vdout0_15ck560 FIND v(dout0_15) AT=285.025n

.meas tran vdout0_16ck560 FIND v(dout0_16) AT=285.025n

.meas tran vdout0_17ck560 FIND v(dout0_17) AT=285.025n

.meas tran vdout0_18ck560 FIND v(dout0_18) AT=285.025n

.meas tran vdout0_19ck560 FIND v(dout0_19) AT=285.025n

.meas tran vdout0_20ck560 FIND v(dout0_20) AT=285.025n

.meas tran vdout0_21ck560 FIND v(dout0_21) AT=285.025n

.meas tran vdout0_22ck560 FIND v(dout0_22) AT=285.025n

.meas tran vdout0_23ck560 FIND v(dout0_23) AT=285.025n

.meas tran vdout0_24ck560 FIND v(dout0_24) AT=285.025n

.meas tran vdout0_25ck560 FIND v(dout0_25) AT=285.025n

.meas tran vdout0_26ck560 FIND v(dout0_26) AT=285.025n

.meas tran vdout0_27ck560 FIND v(dout0_27) AT=285.025n

.meas tran vdout0_28ck560 FIND v(dout0_28) AT=285.025n

.meas tran vdout0_29ck560 FIND v(dout0_29) AT=285.025n

.meas tran vdout0_30ck560 FIND v(dout0_30) AT=285.025n

.meas tran vdout0_31ck560 FIND v(dout0_31) AT=285.025n

.meas tran vdout0_32ck560 FIND v(dout0_32) AT=285.025n

.meas tran vdout0_33ck560 FIND v(dout0_33) AT=285.025n

.meas tran vdout0_34ck560 FIND v(dout0_34) AT=285.025n

.meas tran vdout0_35ck560 FIND v(dout0_35) AT=285.025n

.meas tran vdout0_36ck560 FIND v(dout0_36) AT=285.025n

.meas tran vdout0_37ck560 FIND v(dout0_37) AT=285.025n

.meas tran vdout0_38ck560 FIND v(dout0_38) AT=285.025n

.meas tran vdout0_39ck560 FIND v(dout0_39) AT=285.025n

.meas tran vdout0_40ck560 FIND v(dout0_40) AT=285.025n

.meas tran vdout0_41ck560 FIND v(dout0_41) AT=285.025n

.meas tran vdout0_42ck560 FIND v(dout0_42) AT=285.025n

.meas tran vdout0_43ck560 FIND v(dout0_43) AT=285.025n

.meas tran vdout0_44ck560 FIND v(dout0_44) AT=285.025n

.meas tran vdout0_45ck560 FIND v(dout0_45) AT=285.025n

.meas tran vdout0_46ck560 FIND v(dout0_46) AT=285.025n

.meas tran vdout0_47ck560 FIND v(dout0_47) AT=285.025n

.meas tran vdout0_48ck560 FIND v(dout0_48) AT=285.025n

.meas tran vdout0_49ck560 FIND v(dout0_49) AT=285.025n

.meas tran vdout0_50ck560 FIND v(dout0_50) AT=285.025n

.meas tran vdout0_51ck560 FIND v(dout0_51) AT=285.025n

.meas tran vdout0_52ck560 FIND v(dout0_52) AT=285.025n

.meas tran vdout0_53ck560 FIND v(dout0_53) AT=285.025n

.meas tran vdout0_54ck560 FIND v(dout0_54) AT=285.025n

.meas tran vdout0_55ck560 FIND v(dout0_55) AT=285.025n

.meas tran vdout0_56ck560 FIND v(dout0_56) AT=285.025n

.meas tran vdout0_57ck560 FIND v(dout0_57) AT=285.025n

.meas tran vdout0_58ck560 FIND v(dout0_58) AT=285.025n

.meas tran vdout0_59ck560 FIND v(dout0_59) AT=285.025n

.meas tran vdout0_60ck560 FIND v(dout0_60) AT=285.025n

.meas tran vdout0_61ck560 FIND v(dout0_61) AT=285.025n

.meas tran vdout0_62ck560 FIND v(dout0_62) AT=285.025n

.meas tran vdout0_63ck560 FIND v(dout0_63) AT=285.025n

.meas tran vdout0_64ck560 FIND v(dout0_64) AT=285.025n

.meas tran vdout0_65ck560 FIND v(dout0_65) AT=285.025n

.meas tran vdout0_66ck560 FIND v(dout0_66) AT=285.025n

.meas tran vdout0_67ck560 FIND v(dout0_67) AT=285.025n

.meas tran vdout0_68ck560 FIND v(dout0_68) AT=285.025n

.meas tran vdout0_69ck560 FIND v(dout0_69) AT=285.025n

.meas tran vdout0_70ck560 FIND v(dout0_70) AT=285.025n

.meas tran vdout0_71ck560 FIND v(dout0_71) AT=285.025n

.meas tran vdout0_72ck560 FIND v(dout0_72) AT=285.025n

.meas tran vdout0_73ck560 FIND v(dout0_73) AT=285.025n

.meas tran vdout0_74ck560 FIND v(dout0_74) AT=285.025n

.meas tran vdout0_75ck560 FIND v(dout0_75) AT=285.025n

.meas tran vdout0_76ck560 FIND v(dout0_76) AT=285.025n

.meas tran vdout0_77ck560 FIND v(dout0_77) AT=285.025n

.meas tran vdout0_78ck560 FIND v(dout0_78) AT=285.025n

.meas tran vdout0_79ck560 FIND v(dout0_79) AT=285.025n

.meas tran vdout0_80ck560 FIND v(dout0_80) AT=285.025n

.meas tran vdout0_81ck560 FIND v(dout0_81) AT=285.025n

.meas tran vdout0_82ck560 FIND v(dout0_82) AT=285.025n

.meas tran vdout0_83ck560 FIND v(dout0_83) AT=285.025n

.meas tran vdout0_84ck560 FIND v(dout0_84) AT=285.025n

.meas tran vdout0_85ck560 FIND v(dout0_85) AT=285.025n

.meas tran vdout0_86ck560 FIND v(dout0_86) AT=285.025n

.meas tran vdout0_87ck560 FIND v(dout0_87) AT=285.025n

.meas tran vdout0_88ck560 FIND v(dout0_88) AT=285.025n

.meas tran vdout0_89ck560 FIND v(dout0_89) AT=285.025n

.meas tran vdout0_90ck560 FIND v(dout0_90) AT=285.025n

.meas tran vdout0_91ck560 FIND v(dout0_91) AT=285.025n

.meas tran vdout0_92ck560 FIND v(dout0_92) AT=285.025n

.meas tran vdout0_93ck560 FIND v(dout0_93) AT=285.025n

.meas tran vdout0_94ck560 FIND v(dout0_94) AT=285.025n

.meas tran vdout0_95ck560 FIND v(dout0_95) AT=285.025n

.meas tran vdout0_96ck560 FIND v(dout0_96) AT=285.025n

.meas tran vdout0_97ck560 FIND v(dout0_97) AT=285.025n

.meas tran vdout0_98ck560 FIND v(dout0_98) AT=285.025n

.meas tran vdout0_99ck560 FIND v(dout0_99) AT=285.025n

.meas tran vdout0_100ck560 FIND v(dout0_100) AT=285.025n

.meas tran vdout0_101ck560 FIND v(dout0_101) AT=285.025n

.meas tran vdout0_102ck560 FIND v(dout0_102) AT=285.025n

.meas tran vdout0_103ck560 FIND v(dout0_103) AT=285.025n

.meas tran vdout0_104ck560 FIND v(dout0_104) AT=285.025n

.meas tran vdout0_105ck560 FIND v(dout0_105) AT=285.025n

.meas tran vdout0_106ck560 FIND v(dout0_106) AT=285.025n

.meas tran vdout0_107ck560 FIND v(dout0_107) AT=285.025n

.meas tran vdout0_108ck560 FIND v(dout0_108) AT=285.025n

.meas tran vdout0_109ck560 FIND v(dout0_109) AT=285.025n

.meas tran vdout0_110ck560 FIND v(dout0_110) AT=285.025n

.meas tran vdout0_111ck560 FIND v(dout0_111) AT=285.025n

.meas tran vdout0_112ck560 FIND v(dout0_112) AT=285.025n

.meas tran vdout0_113ck560 FIND v(dout0_113) AT=285.025n

.meas tran vdout0_114ck560 FIND v(dout0_114) AT=285.025n

.meas tran vdout0_115ck560 FIND v(dout0_115) AT=285.025n

.meas tran vdout0_116ck560 FIND v(dout0_116) AT=285.025n

.meas tran vdout0_117ck560 FIND v(dout0_117) AT=285.025n

.meas tran vdout0_118ck560 FIND v(dout0_118) AT=285.025n

.meas tran vdout0_119ck560 FIND v(dout0_119) AT=285.025n

.meas tran vdout0_120ck560 FIND v(dout0_120) AT=285.025n

.meas tran vdout0_121ck560 FIND v(dout0_121) AT=285.025n

.meas tran vdout0_122ck560 FIND v(dout0_122) AT=285.025n

.meas tran vdout0_123ck560 FIND v(dout0_123) AT=285.025n

.meas tran vdout0_124ck560 FIND v(dout0_124) AT=285.025n

.meas tran vdout0_125ck560 FIND v(dout0_125) AT=285.025n

.meas tran vdout0_126ck560 FIND v(dout0_126) AT=285.025n

.meas tran vdout0_127ck560 FIND v(dout0_127) AT=285.025n

.meas tran vdout0_0ck580 FIND v(dout0_0) AT=295.025n

.meas tran vdout0_1ck580 FIND v(dout0_1) AT=295.025n

.meas tran vdout0_2ck580 FIND v(dout0_2) AT=295.025n

.meas tran vdout0_3ck580 FIND v(dout0_3) AT=295.025n

.meas tran vdout0_4ck580 FIND v(dout0_4) AT=295.025n

.meas tran vdout0_5ck580 FIND v(dout0_5) AT=295.025n

.meas tran vdout0_6ck580 FIND v(dout0_6) AT=295.025n

.meas tran vdout0_7ck580 FIND v(dout0_7) AT=295.025n

.meas tran vdout0_8ck580 FIND v(dout0_8) AT=295.025n

.meas tran vdout0_9ck580 FIND v(dout0_9) AT=295.025n

.meas tran vdout0_10ck580 FIND v(dout0_10) AT=295.025n

.meas tran vdout0_11ck580 FIND v(dout0_11) AT=295.025n

.meas tran vdout0_12ck580 FIND v(dout0_12) AT=295.025n

.meas tran vdout0_13ck580 FIND v(dout0_13) AT=295.025n

.meas tran vdout0_14ck580 FIND v(dout0_14) AT=295.025n

.meas tran vdout0_15ck580 FIND v(dout0_15) AT=295.025n

.meas tran vdout0_16ck580 FIND v(dout0_16) AT=295.025n

.meas tran vdout0_17ck580 FIND v(dout0_17) AT=295.025n

.meas tran vdout0_18ck580 FIND v(dout0_18) AT=295.025n

.meas tran vdout0_19ck580 FIND v(dout0_19) AT=295.025n

.meas tran vdout0_20ck580 FIND v(dout0_20) AT=295.025n

.meas tran vdout0_21ck580 FIND v(dout0_21) AT=295.025n

.meas tran vdout0_22ck580 FIND v(dout0_22) AT=295.025n

.meas tran vdout0_23ck580 FIND v(dout0_23) AT=295.025n

.meas tran vdout0_24ck580 FIND v(dout0_24) AT=295.025n

.meas tran vdout0_25ck580 FIND v(dout0_25) AT=295.025n

.meas tran vdout0_26ck580 FIND v(dout0_26) AT=295.025n

.meas tran vdout0_27ck580 FIND v(dout0_27) AT=295.025n

.meas tran vdout0_28ck580 FIND v(dout0_28) AT=295.025n

.meas tran vdout0_29ck580 FIND v(dout0_29) AT=295.025n

.meas tran vdout0_30ck580 FIND v(dout0_30) AT=295.025n

.meas tran vdout0_31ck580 FIND v(dout0_31) AT=295.025n

.meas tran vdout0_32ck580 FIND v(dout0_32) AT=295.025n

.meas tran vdout0_33ck580 FIND v(dout0_33) AT=295.025n

.meas tran vdout0_34ck580 FIND v(dout0_34) AT=295.025n

.meas tran vdout0_35ck580 FIND v(dout0_35) AT=295.025n

.meas tran vdout0_36ck580 FIND v(dout0_36) AT=295.025n

.meas tran vdout0_37ck580 FIND v(dout0_37) AT=295.025n

.meas tran vdout0_38ck580 FIND v(dout0_38) AT=295.025n

.meas tran vdout0_39ck580 FIND v(dout0_39) AT=295.025n

.meas tran vdout0_40ck580 FIND v(dout0_40) AT=295.025n

.meas tran vdout0_41ck580 FIND v(dout0_41) AT=295.025n

.meas tran vdout0_42ck580 FIND v(dout0_42) AT=295.025n

.meas tran vdout0_43ck580 FIND v(dout0_43) AT=295.025n

.meas tran vdout0_44ck580 FIND v(dout0_44) AT=295.025n

.meas tran vdout0_45ck580 FIND v(dout0_45) AT=295.025n

.meas tran vdout0_46ck580 FIND v(dout0_46) AT=295.025n

.meas tran vdout0_47ck580 FIND v(dout0_47) AT=295.025n

.meas tran vdout0_48ck580 FIND v(dout0_48) AT=295.025n

.meas tran vdout0_49ck580 FIND v(dout0_49) AT=295.025n

.meas tran vdout0_50ck580 FIND v(dout0_50) AT=295.025n

.meas tran vdout0_51ck580 FIND v(dout0_51) AT=295.025n

.meas tran vdout0_52ck580 FIND v(dout0_52) AT=295.025n

.meas tran vdout0_53ck580 FIND v(dout0_53) AT=295.025n

.meas tran vdout0_54ck580 FIND v(dout0_54) AT=295.025n

.meas tran vdout0_55ck580 FIND v(dout0_55) AT=295.025n

.meas tran vdout0_56ck580 FIND v(dout0_56) AT=295.025n

.meas tran vdout0_57ck580 FIND v(dout0_57) AT=295.025n

.meas tran vdout0_58ck580 FIND v(dout0_58) AT=295.025n

.meas tran vdout0_59ck580 FIND v(dout0_59) AT=295.025n

.meas tran vdout0_60ck580 FIND v(dout0_60) AT=295.025n

.meas tran vdout0_61ck580 FIND v(dout0_61) AT=295.025n

.meas tran vdout0_62ck580 FIND v(dout0_62) AT=295.025n

.meas tran vdout0_63ck580 FIND v(dout0_63) AT=295.025n

.meas tran vdout0_64ck580 FIND v(dout0_64) AT=295.025n

.meas tran vdout0_65ck580 FIND v(dout0_65) AT=295.025n

.meas tran vdout0_66ck580 FIND v(dout0_66) AT=295.025n

.meas tran vdout0_67ck580 FIND v(dout0_67) AT=295.025n

.meas tran vdout0_68ck580 FIND v(dout0_68) AT=295.025n

.meas tran vdout0_69ck580 FIND v(dout0_69) AT=295.025n

.meas tran vdout0_70ck580 FIND v(dout0_70) AT=295.025n

.meas tran vdout0_71ck580 FIND v(dout0_71) AT=295.025n

.meas tran vdout0_72ck580 FIND v(dout0_72) AT=295.025n

.meas tran vdout0_73ck580 FIND v(dout0_73) AT=295.025n

.meas tran vdout0_74ck580 FIND v(dout0_74) AT=295.025n

.meas tran vdout0_75ck580 FIND v(dout0_75) AT=295.025n

.meas tran vdout0_76ck580 FIND v(dout0_76) AT=295.025n

.meas tran vdout0_77ck580 FIND v(dout0_77) AT=295.025n

.meas tran vdout0_78ck580 FIND v(dout0_78) AT=295.025n

.meas tran vdout0_79ck580 FIND v(dout0_79) AT=295.025n

.meas tran vdout0_80ck580 FIND v(dout0_80) AT=295.025n

.meas tran vdout0_81ck580 FIND v(dout0_81) AT=295.025n

.meas tran vdout0_82ck580 FIND v(dout0_82) AT=295.025n

.meas tran vdout0_83ck580 FIND v(dout0_83) AT=295.025n

.meas tran vdout0_84ck580 FIND v(dout0_84) AT=295.025n

.meas tran vdout0_85ck580 FIND v(dout0_85) AT=295.025n

.meas tran vdout0_86ck580 FIND v(dout0_86) AT=295.025n

.meas tran vdout0_87ck580 FIND v(dout0_87) AT=295.025n

.meas tran vdout0_88ck580 FIND v(dout0_88) AT=295.025n

.meas tran vdout0_89ck580 FIND v(dout0_89) AT=295.025n

.meas tran vdout0_90ck580 FIND v(dout0_90) AT=295.025n

.meas tran vdout0_91ck580 FIND v(dout0_91) AT=295.025n

.meas tran vdout0_92ck580 FIND v(dout0_92) AT=295.025n

.meas tran vdout0_93ck580 FIND v(dout0_93) AT=295.025n

.meas tran vdout0_94ck580 FIND v(dout0_94) AT=295.025n

.meas tran vdout0_95ck580 FIND v(dout0_95) AT=295.025n

.meas tran vdout0_96ck580 FIND v(dout0_96) AT=295.025n

.meas tran vdout0_97ck580 FIND v(dout0_97) AT=295.025n

.meas tran vdout0_98ck580 FIND v(dout0_98) AT=295.025n

.meas tran vdout0_99ck580 FIND v(dout0_99) AT=295.025n

.meas tran vdout0_100ck580 FIND v(dout0_100) AT=295.025n

.meas tran vdout0_101ck580 FIND v(dout0_101) AT=295.025n

.meas tran vdout0_102ck580 FIND v(dout0_102) AT=295.025n

.meas tran vdout0_103ck580 FIND v(dout0_103) AT=295.025n

.meas tran vdout0_104ck580 FIND v(dout0_104) AT=295.025n

.meas tran vdout0_105ck580 FIND v(dout0_105) AT=295.025n

.meas tran vdout0_106ck580 FIND v(dout0_106) AT=295.025n

.meas tran vdout0_107ck580 FIND v(dout0_107) AT=295.025n

.meas tran vdout0_108ck580 FIND v(dout0_108) AT=295.025n

.meas tran vdout0_109ck580 FIND v(dout0_109) AT=295.025n

.meas tran vdout0_110ck580 FIND v(dout0_110) AT=295.025n

.meas tran vdout0_111ck580 FIND v(dout0_111) AT=295.025n

.meas tran vdout0_112ck580 FIND v(dout0_112) AT=295.025n

.meas tran vdout0_113ck580 FIND v(dout0_113) AT=295.025n

.meas tran vdout0_114ck580 FIND v(dout0_114) AT=295.025n

.meas tran vdout0_115ck580 FIND v(dout0_115) AT=295.025n

.meas tran vdout0_116ck580 FIND v(dout0_116) AT=295.025n

.meas tran vdout0_117ck580 FIND v(dout0_117) AT=295.025n

.meas tran vdout0_118ck580 FIND v(dout0_118) AT=295.025n

.meas tran vdout0_119ck580 FIND v(dout0_119) AT=295.025n

.meas tran vdout0_120ck580 FIND v(dout0_120) AT=295.025n

.meas tran vdout0_121ck580 FIND v(dout0_121) AT=295.025n

.meas tran vdout0_122ck580 FIND v(dout0_122) AT=295.025n

.meas tran vdout0_123ck580 FIND v(dout0_123) AT=295.025n

.meas tran vdout0_124ck580 FIND v(dout0_124) AT=295.025n

.meas tran vdout0_125ck580 FIND v(dout0_125) AT=295.025n

.meas tran vdout0_126ck580 FIND v(dout0_126) AT=295.025n

.meas tran vdout0_127ck580 FIND v(dout0_127) AT=295.025n

.meas tran vdout0_0ck590 FIND v(dout0_0) AT=300.025n

.meas tran vdout0_1ck590 FIND v(dout0_1) AT=300.025n

.meas tran vdout0_2ck590 FIND v(dout0_2) AT=300.025n

.meas tran vdout0_3ck590 FIND v(dout0_3) AT=300.025n

.meas tran vdout0_4ck590 FIND v(dout0_4) AT=300.025n

.meas tran vdout0_5ck590 FIND v(dout0_5) AT=300.025n

.meas tran vdout0_6ck590 FIND v(dout0_6) AT=300.025n

.meas tran vdout0_7ck590 FIND v(dout0_7) AT=300.025n

.meas tran vdout0_8ck590 FIND v(dout0_8) AT=300.025n

.meas tran vdout0_9ck590 FIND v(dout0_9) AT=300.025n

.meas tran vdout0_10ck590 FIND v(dout0_10) AT=300.025n

.meas tran vdout0_11ck590 FIND v(dout0_11) AT=300.025n

.meas tran vdout0_12ck590 FIND v(dout0_12) AT=300.025n

.meas tran vdout0_13ck590 FIND v(dout0_13) AT=300.025n

.meas tran vdout0_14ck590 FIND v(dout0_14) AT=300.025n

.meas tran vdout0_15ck590 FIND v(dout0_15) AT=300.025n

.meas tran vdout0_16ck590 FIND v(dout0_16) AT=300.025n

.meas tran vdout0_17ck590 FIND v(dout0_17) AT=300.025n

.meas tran vdout0_18ck590 FIND v(dout0_18) AT=300.025n

.meas tran vdout0_19ck590 FIND v(dout0_19) AT=300.025n

.meas tran vdout0_20ck590 FIND v(dout0_20) AT=300.025n

.meas tran vdout0_21ck590 FIND v(dout0_21) AT=300.025n

.meas tran vdout0_22ck590 FIND v(dout0_22) AT=300.025n

.meas tran vdout0_23ck590 FIND v(dout0_23) AT=300.025n

.meas tran vdout0_24ck590 FIND v(dout0_24) AT=300.025n

.meas tran vdout0_25ck590 FIND v(dout0_25) AT=300.025n

.meas tran vdout0_26ck590 FIND v(dout0_26) AT=300.025n

.meas tran vdout0_27ck590 FIND v(dout0_27) AT=300.025n

.meas tran vdout0_28ck590 FIND v(dout0_28) AT=300.025n

.meas tran vdout0_29ck590 FIND v(dout0_29) AT=300.025n

.meas tran vdout0_30ck590 FIND v(dout0_30) AT=300.025n

.meas tran vdout0_31ck590 FIND v(dout0_31) AT=300.025n

.meas tran vdout0_32ck590 FIND v(dout0_32) AT=300.025n

.meas tran vdout0_33ck590 FIND v(dout0_33) AT=300.025n

.meas tran vdout0_34ck590 FIND v(dout0_34) AT=300.025n

.meas tran vdout0_35ck590 FIND v(dout0_35) AT=300.025n

.meas tran vdout0_36ck590 FIND v(dout0_36) AT=300.025n

.meas tran vdout0_37ck590 FIND v(dout0_37) AT=300.025n

.meas tran vdout0_38ck590 FIND v(dout0_38) AT=300.025n

.meas tran vdout0_39ck590 FIND v(dout0_39) AT=300.025n

.meas tran vdout0_40ck590 FIND v(dout0_40) AT=300.025n

.meas tran vdout0_41ck590 FIND v(dout0_41) AT=300.025n

.meas tran vdout0_42ck590 FIND v(dout0_42) AT=300.025n

.meas tran vdout0_43ck590 FIND v(dout0_43) AT=300.025n

.meas tran vdout0_44ck590 FIND v(dout0_44) AT=300.025n

.meas tran vdout0_45ck590 FIND v(dout0_45) AT=300.025n

.meas tran vdout0_46ck590 FIND v(dout0_46) AT=300.025n

.meas tran vdout0_47ck590 FIND v(dout0_47) AT=300.025n

.meas tran vdout0_48ck590 FIND v(dout0_48) AT=300.025n

.meas tran vdout0_49ck590 FIND v(dout0_49) AT=300.025n

.meas tran vdout0_50ck590 FIND v(dout0_50) AT=300.025n

.meas tran vdout0_51ck590 FIND v(dout0_51) AT=300.025n

.meas tran vdout0_52ck590 FIND v(dout0_52) AT=300.025n

.meas tran vdout0_53ck590 FIND v(dout0_53) AT=300.025n

.meas tran vdout0_54ck590 FIND v(dout0_54) AT=300.025n

.meas tran vdout0_55ck590 FIND v(dout0_55) AT=300.025n

.meas tran vdout0_56ck590 FIND v(dout0_56) AT=300.025n

.meas tran vdout0_57ck590 FIND v(dout0_57) AT=300.025n

.meas tran vdout0_58ck590 FIND v(dout0_58) AT=300.025n

.meas tran vdout0_59ck590 FIND v(dout0_59) AT=300.025n

.meas tran vdout0_60ck590 FIND v(dout0_60) AT=300.025n

.meas tran vdout0_61ck590 FIND v(dout0_61) AT=300.025n

.meas tran vdout0_62ck590 FIND v(dout0_62) AT=300.025n

.meas tran vdout0_63ck590 FIND v(dout0_63) AT=300.025n

.meas tran vdout0_64ck590 FIND v(dout0_64) AT=300.025n

.meas tran vdout0_65ck590 FIND v(dout0_65) AT=300.025n

.meas tran vdout0_66ck590 FIND v(dout0_66) AT=300.025n

.meas tran vdout0_67ck590 FIND v(dout0_67) AT=300.025n

.meas tran vdout0_68ck590 FIND v(dout0_68) AT=300.025n

.meas tran vdout0_69ck590 FIND v(dout0_69) AT=300.025n

.meas tran vdout0_70ck590 FIND v(dout0_70) AT=300.025n

.meas tran vdout0_71ck590 FIND v(dout0_71) AT=300.025n

.meas tran vdout0_72ck590 FIND v(dout0_72) AT=300.025n

.meas tran vdout0_73ck590 FIND v(dout0_73) AT=300.025n

.meas tran vdout0_74ck590 FIND v(dout0_74) AT=300.025n

.meas tran vdout0_75ck590 FIND v(dout0_75) AT=300.025n

.meas tran vdout0_76ck590 FIND v(dout0_76) AT=300.025n

.meas tran vdout0_77ck590 FIND v(dout0_77) AT=300.025n

.meas tran vdout0_78ck590 FIND v(dout0_78) AT=300.025n

.meas tran vdout0_79ck590 FIND v(dout0_79) AT=300.025n

.meas tran vdout0_80ck590 FIND v(dout0_80) AT=300.025n

.meas tran vdout0_81ck590 FIND v(dout0_81) AT=300.025n

.meas tran vdout0_82ck590 FIND v(dout0_82) AT=300.025n

.meas tran vdout0_83ck590 FIND v(dout0_83) AT=300.025n

.meas tran vdout0_84ck590 FIND v(dout0_84) AT=300.025n

.meas tran vdout0_85ck590 FIND v(dout0_85) AT=300.025n

.meas tran vdout0_86ck590 FIND v(dout0_86) AT=300.025n

.meas tran vdout0_87ck590 FIND v(dout0_87) AT=300.025n

.meas tran vdout0_88ck590 FIND v(dout0_88) AT=300.025n

.meas tran vdout0_89ck590 FIND v(dout0_89) AT=300.025n

.meas tran vdout0_90ck590 FIND v(dout0_90) AT=300.025n

.meas tran vdout0_91ck590 FIND v(dout0_91) AT=300.025n

.meas tran vdout0_92ck590 FIND v(dout0_92) AT=300.025n

.meas tran vdout0_93ck590 FIND v(dout0_93) AT=300.025n

.meas tran vdout0_94ck590 FIND v(dout0_94) AT=300.025n

.meas tran vdout0_95ck590 FIND v(dout0_95) AT=300.025n

.meas tran vdout0_96ck590 FIND v(dout0_96) AT=300.025n

.meas tran vdout0_97ck590 FIND v(dout0_97) AT=300.025n

.meas tran vdout0_98ck590 FIND v(dout0_98) AT=300.025n

.meas tran vdout0_99ck590 FIND v(dout0_99) AT=300.025n

.meas tran vdout0_100ck590 FIND v(dout0_100) AT=300.025n

.meas tran vdout0_101ck590 FIND v(dout0_101) AT=300.025n

.meas tran vdout0_102ck590 FIND v(dout0_102) AT=300.025n

.meas tran vdout0_103ck590 FIND v(dout0_103) AT=300.025n

.meas tran vdout0_104ck590 FIND v(dout0_104) AT=300.025n

.meas tran vdout0_105ck590 FIND v(dout0_105) AT=300.025n

.meas tran vdout0_106ck590 FIND v(dout0_106) AT=300.025n

.meas tran vdout0_107ck590 FIND v(dout0_107) AT=300.025n

.meas tran vdout0_108ck590 FIND v(dout0_108) AT=300.025n

.meas tran vdout0_109ck590 FIND v(dout0_109) AT=300.025n

.meas tran vdout0_110ck590 FIND v(dout0_110) AT=300.025n

.meas tran vdout0_111ck590 FIND v(dout0_111) AT=300.025n

.meas tran vdout0_112ck590 FIND v(dout0_112) AT=300.025n

.meas tran vdout0_113ck590 FIND v(dout0_113) AT=300.025n

.meas tran vdout0_114ck590 FIND v(dout0_114) AT=300.025n

.meas tran vdout0_115ck590 FIND v(dout0_115) AT=300.025n

.meas tran vdout0_116ck590 FIND v(dout0_116) AT=300.025n

.meas tran vdout0_117ck590 FIND v(dout0_117) AT=300.025n

.meas tran vdout0_118ck590 FIND v(dout0_118) AT=300.025n

.meas tran vdout0_119ck590 FIND v(dout0_119) AT=300.025n

.meas tran vdout0_120ck590 FIND v(dout0_120) AT=300.025n

.meas tran vdout0_121ck590 FIND v(dout0_121) AT=300.025n

.meas tran vdout0_122ck590 FIND v(dout0_122) AT=300.025n

.meas tran vdout0_123ck590 FIND v(dout0_123) AT=300.025n

.meas tran vdout0_124ck590 FIND v(dout0_124) AT=300.025n

.meas tran vdout0_125ck590 FIND v(dout0_125) AT=300.025n

.meas tran vdout0_126ck590 FIND v(dout0_126) AT=300.025n

.meas tran vdout0_127ck590 FIND v(dout0_127) AT=300.025n

.meas tran vdout0_0ck600 FIND v(dout0_0) AT=305.025n

.meas tran vdout0_1ck600 FIND v(dout0_1) AT=305.025n

.meas tran vdout0_2ck600 FIND v(dout0_2) AT=305.025n

.meas tran vdout0_3ck600 FIND v(dout0_3) AT=305.025n

.meas tran vdout0_4ck600 FIND v(dout0_4) AT=305.025n

.meas tran vdout0_5ck600 FIND v(dout0_5) AT=305.025n

.meas tran vdout0_6ck600 FIND v(dout0_6) AT=305.025n

.meas tran vdout0_7ck600 FIND v(dout0_7) AT=305.025n

.meas tran vdout0_8ck600 FIND v(dout0_8) AT=305.025n

.meas tran vdout0_9ck600 FIND v(dout0_9) AT=305.025n

.meas tran vdout0_10ck600 FIND v(dout0_10) AT=305.025n

.meas tran vdout0_11ck600 FIND v(dout0_11) AT=305.025n

.meas tran vdout0_12ck600 FIND v(dout0_12) AT=305.025n

.meas tran vdout0_13ck600 FIND v(dout0_13) AT=305.025n

.meas tran vdout0_14ck600 FIND v(dout0_14) AT=305.025n

.meas tran vdout0_15ck600 FIND v(dout0_15) AT=305.025n

.meas tran vdout0_16ck600 FIND v(dout0_16) AT=305.025n

.meas tran vdout0_17ck600 FIND v(dout0_17) AT=305.025n

.meas tran vdout0_18ck600 FIND v(dout0_18) AT=305.025n

.meas tran vdout0_19ck600 FIND v(dout0_19) AT=305.025n

.meas tran vdout0_20ck600 FIND v(dout0_20) AT=305.025n

.meas tran vdout0_21ck600 FIND v(dout0_21) AT=305.025n

.meas tran vdout0_22ck600 FIND v(dout0_22) AT=305.025n

.meas tran vdout0_23ck600 FIND v(dout0_23) AT=305.025n

.meas tran vdout0_24ck600 FIND v(dout0_24) AT=305.025n

.meas tran vdout0_25ck600 FIND v(dout0_25) AT=305.025n

.meas tran vdout0_26ck600 FIND v(dout0_26) AT=305.025n

.meas tran vdout0_27ck600 FIND v(dout0_27) AT=305.025n

.meas tran vdout0_28ck600 FIND v(dout0_28) AT=305.025n

.meas tran vdout0_29ck600 FIND v(dout0_29) AT=305.025n

.meas tran vdout0_30ck600 FIND v(dout0_30) AT=305.025n

.meas tran vdout0_31ck600 FIND v(dout0_31) AT=305.025n

.meas tran vdout0_32ck600 FIND v(dout0_32) AT=305.025n

.meas tran vdout0_33ck600 FIND v(dout0_33) AT=305.025n

.meas tran vdout0_34ck600 FIND v(dout0_34) AT=305.025n

.meas tran vdout0_35ck600 FIND v(dout0_35) AT=305.025n

.meas tran vdout0_36ck600 FIND v(dout0_36) AT=305.025n

.meas tran vdout0_37ck600 FIND v(dout0_37) AT=305.025n

.meas tran vdout0_38ck600 FIND v(dout0_38) AT=305.025n

.meas tran vdout0_39ck600 FIND v(dout0_39) AT=305.025n

.meas tran vdout0_40ck600 FIND v(dout0_40) AT=305.025n

.meas tran vdout0_41ck600 FIND v(dout0_41) AT=305.025n

.meas tran vdout0_42ck600 FIND v(dout0_42) AT=305.025n

.meas tran vdout0_43ck600 FIND v(dout0_43) AT=305.025n

.meas tran vdout0_44ck600 FIND v(dout0_44) AT=305.025n

.meas tran vdout0_45ck600 FIND v(dout0_45) AT=305.025n

.meas tran vdout0_46ck600 FIND v(dout0_46) AT=305.025n

.meas tran vdout0_47ck600 FIND v(dout0_47) AT=305.025n

.meas tran vdout0_48ck600 FIND v(dout0_48) AT=305.025n

.meas tran vdout0_49ck600 FIND v(dout0_49) AT=305.025n

.meas tran vdout0_50ck600 FIND v(dout0_50) AT=305.025n

.meas tran vdout0_51ck600 FIND v(dout0_51) AT=305.025n

.meas tran vdout0_52ck600 FIND v(dout0_52) AT=305.025n

.meas tran vdout0_53ck600 FIND v(dout0_53) AT=305.025n

.meas tran vdout0_54ck600 FIND v(dout0_54) AT=305.025n

.meas tran vdout0_55ck600 FIND v(dout0_55) AT=305.025n

.meas tran vdout0_56ck600 FIND v(dout0_56) AT=305.025n

.meas tran vdout0_57ck600 FIND v(dout0_57) AT=305.025n

.meas tran vdout0_58ck600 FIND v(dout0_58) AT=305.025n

.meas tran vdout0_59ck600 FIND v(dout0_59) AT=305.025n

.meas tran vdout0_60ck600 FIND v(dout0_60) AT=305.025n

.meas tran vdout0_61ck600 FIND v(dout0_61) AT=305.025n

.meas tran vdout0_62ck600 FIND v(dout0_62) AT=305.025n

.meas tran vdout0_63ck600 FIND v(dout0_63) AT=305.025n

.meas tran vdout0_64ck600 FIND v(dout0_64) AT=305.025n

.meas tran vdout0_65ck600 FIND v(dout0_65) AT=305.025n

.meas tran vdout0_66ck600 FIND v(dout0_66) AT=305.025n

.meas tran vdout0_67ck600 FIND v(dout0_67) AT=305.025n

.meas tran vdout0_68ck600 FIND v(dout0_68) AT=305.025n

.meas tran vdout0_69ck600 FIND v(dout0_69) AT=305.025n

.meas tran vdout0_70ck600 FIND v(dout0_70) AT=305.025n

.meas tran vdout0_71ck600 FIND v(dout0_71) AT=305.025n

.meas tran vdout0_72ck600 FIND v(dout0_72) AT=305.025n

.meas tran vdout0_73ck600 FIND v(dout0_73) AT=305.025n

.meas tran vdout0_74ck600 FIND v(dout0_74) AT=305.025n

.meas tran vdout0_75ck600 FIND v(dout0_75) AT=305.025n

.meas tran vdout0_76ck600 FIND v(dout0_76) AT=305.025n

.meas tran vdout0_77ck600 FIND v(dout0_77) AT=305.025n

.meas tran vdout0_78ck600 FIND v(dout0_78) AT=305.025n

.meas tran vdout0_79ck600 FIND v(dout0_79) AT=305.025n

.meas tran vdout0_80ck600 FIND v(dout0_80) AT=305.025n

.meas tran vdout0_81ck600 FIND v(dout0_81) AT=305.025n

.meas tran vdout0_82ck600 FIND v(dout0_82) AT=305.025n

.meas tran vdout0_83ck600 FIND v(dout0_83) AT=305.025n

.meas tran vdout0_84ck600 FIND v(dout0_84) AT=305.025n

.meas tran vdout0_85ck600 FIND v(dout0_85) AT=305.025n

.meas tran vdout0_86ck600 FIND v(dout0_86) AT=305.025n

.meas tran vdout0_87ck600 FIND v(dout0_87) AT=305.025n

.meas tran vdout0_88ck600 FIND v(dout0_88) AT=305.025n

.meas tran vdout0_89ck600 FIND v(dout0_89) AT=305.025n

.meas tran vdout0_90ck600 FIND v(dout0_90) AT=305.025n

.meas tran vdout0_91ck600 FIND v(dout0_91) AT=305.025n

.meas tran vdout0_92ck600 FIND v(dout0_92) AT=305.025n

.meas tran vdout0_93ck600 FIND v(dout0_93) AT=305.025n

.meas tran vdout0_94ck600 FIND v(dout0_94) AT=305.025n

.meas tran vdout0_95ck600 FIND v(dout0_95) AT=305.025n

.meas tran vdout0_96ck600 FIND v(dout0_96) AT=305.025n

.meas tran vdout0_97ck600 FIND v(dout0_97) AT=305.025n

.meas tran vdout0_98ck600 FIND v(dout0_98) AT=305.025n

.meas tran vdout0_99ck600 FIND v(dout0_99) AT=305.025n

.meas tran vdout0_100ck600 FIND v(dout0_100) AT=305.025n

.meas tran vdout0_101ck600 FIND v(dout0_101) AT=305.025n

.meas tran vdout0_102ck600 FIND v(dout0_102) AT=305.025n

.meas tran vdout0_103ck600 FIND v(dout0_103) AT=305.025n

.meas tran vdout0_104ck600 FIND v(dout0_104) AT=305.025n

.meas tran vdout0_105ck600 FIND v(dout0_105) AT=305.025n

.meas tran vdout0_106ck600 FIND v(dout0_106) AT=305.025n

.meas tran vdout0_107ck600 FIND v(dout0_107) AT=305.025n

.meas tran vdout0_108ck600 FIND v(dout0_108) AT=305.025n

.meas tran vdout0_109ck600 FIND v(dout0_109) AT=305.025n

.meas tran vdout0_110ck600 FIND v(dout0_110) AT=305.025n

.meas tran vdout0_111ck600 FIND v(dout0_111) AT=305.025n

.meas tran vdout0_112ck600 FIND v(dout0_112) AT=305.025n

.meas tran vdout0_113ck600 FIND v(dout0_113) AT=305.025n

.meas tran vdout0_114ck600 FIND v(dout0_114) AT=305.025n

.meas tran vdout0_115ck600 FIND v(dout0_115) AT=305.025n

.meas tran vdout0_116ck600 FIND v(dout0_116) AT=305.025n

.meas tran vdout0_117ck600 FIND v(dout0_117) AT=305.025n

.meas tran vdout0_118ck600 FIND v(dout0_118) AT=305.025n

.meas tran vdout0_119ck600 FIND v(dout0_119) AT=305.025n

.meas tran vdout0_120ck600 FIND v(dout0_120) AT=305.025n

.meas tran vdout0_121ck600 FIND v(dout0_121) AT=305.025n

.meas tran vdout0_122ck600 FIND v(dout0_122) AT=305.025n

.meas tran vdout0_123ck600 FIND v(dout0_123) AT=305.025n

.meas tran vdout0_124ck600 FIND v(dout0_124) AT=305.025n

.meas tran vdout0_125ck600 FIND v(dout0_125) AT=305.025n

.meas tran vdout0_126ck600 FIND v(dout0_126) AT=305.025n

.meas tran vdout0_127ck600 FIND v(dout0_127) AT=305.025n

.meas tran vdout0_0ck620 FIND v(dout0_0) AT=315.025n

.meas tran vdout0_1ck620 FIND v(dout0_1) AT=315.025n

.meas tran vdout0_2ck620 FIND v(dout0_2) AT=315.025n

.meas tran vdout0_3ck620 FIND v(dout0_3) AT=315.025n

.meas tran vdout0_4ck620 FIND v(dout0_4) AT=315.025n

.meas tran vdout0_5ck620 FIND v(dout0_5) AT=315.025n

.meas tran vdout0_6ck620 FIND v(dout0_6) AT=315.025n

.meas tran vdout0_7ck620 FIND v(dout0_7) AT=315.025n

.meas tran vdout0_8ck620 FIND v(dout0_8) AT=315.025n

.meas tran vdout0_9ck620 FIND v(dout0_9) AT=315.025n

.meas tran vdout0_10ck620 FIND v(dout0_10) AT=315.025n

.meas tran vdout0_11ck620 FIND v(dout0_11) AT=315.025n

.meas tran vdout0_12ck620 FIND v(dout0_12) AT=315.025n

.meas tran vdout0_13ck620 FIND v(dout0_13) AT=315.025n

.meas tran vdout0_14ck620 FIND v(dout0_14) AT=315.025n

.meas tran vdout0_15ck620 FIND v(dout0_15) AT=315.025n

.meas tran vdout0_16ck620 FIND v(dout0_16) AT=315.025n

.meas tran vdout0_17ck620 FIND v(dout0_17) AT=315.025n

.meas tran vdout0_18ck620 FIND v(dout0_18) AT=315.025n

.meas tran vdout0_19ck620 FIND v(dout0_19) AT=315.025n

.meas tran vdout0_20ck620 FIND v(dout0_20) AT=315.025n

.meas tran vdout0_21ck620 FIND v(dout0_21) AT=315.025n

.meas tran vdout0_22ck620 FIND v(dout0_22) AT=315.025n

.meas tran vdout0_23ck620 FIND v(dout0_23) AT=315.025n

.meas tran vdout0_24ck620 FIND v(dout0_24) AT=315.025n

.meas tran vdout0_25ck620 FIND v(dout0_25) AT=315.025n

.meas tran vdout0_26ck620 FIND v(dout0_26) AT=315.025n

.meas tran vdout0_27ck620 FIND v(dout0_27) AT=315.025n

.meas tran vdout0_28ck620 FIND v(dout0_28) AT=315.025n

.meas tran vdout0_29ck620 FIND v(dout0_29) AT=315.025n

.meas tran vdout0_30ck620 FIND v(dout0_30) AT=315.025n

.meas tran vdout0_31ck620 FIND v(dout0_31) AT=315.025n

.meas tran vdout0_32ck620 FIND v(dout0_32) AT=315.025n

.meas tran vdout0_33ck620 FIND v(dout0_33) AT=315.025n

.meas tran vdout0_34ck620 FIND v(dout0_34) AT=315.025n

.meas tran vdout0_35ck620 FIND v(dout0_35) AT=315.025n

.meas tran vdout0_36ck620 FIND v(dout0_36) AT=315.025n

.meas tran vdout0_37ck620 FIND v(dout0_37) AT=315.025n

.meas tran vdout0_38ck620 FIND v(dout0_38) AT=315.025n

.meas tran vdout0_39ck620 FIND v(dout0_39) AT=315.025n

.meas tran vdout0_40ck620 FIND v(dout0_40) AT=315.025n

.meas tran vdout0_41ck620 FIND v(dout0_41) AT=315.025n

.meas tran vdout0_42ck620 FIND v(dout0_42) AT=315.025n

.meas tran vdout0_43ck620 FIND v(dout0_43) AT=315.025n

.meas tran vdout0_44ck620 FIND v(dout0_44) AT=315.025n

.meas tran vdout0_45ck620 FIND v(dout0_45) AT=315.025n

.meas tran vdout0_46ck620 FIND v(dout0_46) AT=315.025n

.meas tran vdout0_47ck620 FIND v(dout0_47) AT=315.025n

.meas tran vdout0_48ck620 FIND v(dout0_48) AT=315.025n

.meas tran vdout0_49ck620 FIND v(dout0_49) AT=315.025n

.meas tran vdout0_50ck620 FIND v(dout0_50) AT=315.025n

.meas tran vdout0_51ck620 FIND v(dout0_51) AT=315.025n

.meas tran vdout0_52ck620 FIND v(dout0_52) AT=315.025n

.meas tran vdout0_53ck620 FIND v(dout0_53) AT=315.025n

.meas tran vdout0_54ck620 FIND v(dout0_54) AT=315.025n

.meas tran vdout0_55ck620 FIND v(dout0_55) AT=315.025n

.meas tran vdout0_56ck620 FIND v(dout0_56) AT=315.025n

.meas tran vdout0_57ck620 FIND v(dout0_57) AT=315.025n

.meas tran vdout0_58ck620 FIND v(dout0_58) AT=315.025n

.meas tran vdout0_59ck620 FIND v(dout0_59) AT=315.025n

.meas tran vdout0_60ck620 FIND v(dout0_60) AT=315.025n

.meas tran vdout0_61ck620 FIND v(dout0_61) AT=315.025n

.meas tran vdout0_62ck620 FIND v(dout0_62) AT=315.025n

.meas tran vdout0_63ck620 FIND v(dout0_63) AT=315.025n

.meas tran vdout0_64ck620 FIND v(dout0_64) AT=315.025n

.meas tran vdout0_65ck620 FIND v(dout0_65) AT=315.025n

.meas tran vdout0_66ck620 FIND v(dout0_66) AT=315.025n

.meas tran vdout0_67ck620 FIND v(dout0_67) AT=315.025n

.meas tran vdout0_68ck620 FIND v(dout0_68) AT=315.025n

.meas tran vdout0_69ck620 FIND v(dout0_69) AT=315.025n

.meas tran vdout0_70ck620 FIND v(dout0_70) AT=315.025n

.meas tran vdout0_71ck620 FIND v(dout0_71) AT=315.025n

.meas tran vdout0_72ck620 FIND v(dout0_72) AT=315.025n

.meas tran vdout0_73ck620 FIND v(dout0_73) AT=315.025n

.meas tran vdout0_74ck620 FIND v(dout0_74) AT=315.025n

.meas tran vdout0_75ck620 FIND v(dout0_75) AT=315.025n

.meas tran vdout0_76ck620 FIND v(dout0_76) AT=315.025n

.meas tran vdout0_77ck620 FIND v(dout0_77) AT=315.025n

.meas tran vdout0_78ck620 FIND v(dout0_78) AT=315.025n

.meas tran vdout0_79ck620 FIND v(dout0_79) AT=315.025n

.meas tran vdout0_80ck620 FIND v(dout0_80) AT=315.025n

.meas tran vdout0_81ck620 FIND v(dout0_81) AT=315.025n

.meas tran vdout0_82ck620 FIND v(dout0_82) AT=315.025n

.meas tran vdout0_83ck620 FIND v(dout0_83) AT=315.025n

.meas tran vdout0_84ck620 FIND v(dout0_84) AT=315.025n

.meas tran vdout0_85ck620 FIND v(dout0_85) AT=315.025n

.meas tran vdout0_86ck620 FIND v(dout0_86) AT=315.025n

.meas tran vdout0_87ck620 FIND v(dout0_87) AT=315.025n

.meas tran vdout0_88ck620 FIND v(dout0_88) AT=315.025n

.meas tran vdout0_89ck620 FIND v(dout0_89) AT=315.025n

.meas tran vdout0_90ck620 FIND v(dout0_90) AT=315.025n

.meas tran vdout0_91ck620 FIND v(dout0_91) AT=315.025n

.meas tran vdout0_92ck620 FIND v(dout0_92) AT=315.025n

.meas tran vdout0_93ck620 FIND v(dout0_93) AT=315.025n

.meas tran vdout0_94ck620 FIND v(dout0_94) AT=315.025n

.meas tran vdout0_95ck620 FIND v(dout0_95) AT=315.025n

.meas tran vdout0_96ck620 FIND v(dout0_96) AT=315.025n

.meas tran vdout0_97ck620 FIND v(dout0_97) AT=315.025n

.meas tran vdout0_98ck620 FIND v(dout0_98) AT=315.025n

.meas tran vdout0_99ck620 FIND v(dout0_99) AT=315.025n

.meas tran vdout0_100ck620 FIND v(dout0_100) AT=315.025n

.meas tran vdout0_101ck620 FIND v(dout0_101) AT=315.025n

.meas tran vdout0_102ck620 FIND v(dout0_102) AT=315.025n

.meas tran vdout0_103ck620 FIND v(dout0_103) AT=315.025n

.meas tran vdout0_104ck620 FIND v(dout0_104) AT=315.025n

.meas tran vdout0_105ck620 FIND v(dout0_105) AT=315.025n

.meas tran vdout0_106ck620 FIND v(dout0_106) AT=315.025n

.meas tran vdout0_107ck620 FIND v(dout0_107) AT=315.025n

.meas tran vdout0_108ck620 FIND v(dout0_108) AT=315.025n

.meas tran vdout0_109ck620 FIND v(dout0_109) AT=315.025n

.meas tran vdout0_110ck620 FIND v(dout0_110) AT=315.025n

.meas tran vdout0_111ck620 FIND v(dout0_111) AT=315.025n

.meas tran vdout0_112ck620 FIND v(dout0_112) AT=315.025n

.meas tran vdout0_113ck620 FIND v(dout0_113) AT=315.025n

.meas tran vdout0_114ck620 FIND v(dout0_114) AT=315.025n

.meas tran vdout0_115ck620 FIND v(dout0_115) AT=315.025n

.meas tran vdout0_116ck620 FIND v(dout0_116) AT=315.025n

.meas tran vdout0_117ck620 FIND v(dout0_117) AT=315.025n

.meas tran vdout0_118ck620 FIND v(dout0_118) AT=315.025n

.meas tran vdout0_119ck620 FIND v(dout0_119) AT=315.025n

.meas tran vdout0_120ck620 FIND v(dout0_120) AT=315.025n

.meas tran vdout0_121ck620 FIND v(dout0_121) AT=315.025n

.meas tran vdout0_122ck620 FIND v(dout0_122) AT=315.025n

.meas tran vdout0_123ck620 FIND v(dout0_123) AT=315.025n

.meas tran vdout0_124ck620 FIND v(dout0_124) AT=315.025n

.meas tran vdout0_125ck620 FIND v(dout0_125) AT=315.025n

.meas tran vdout0_126ck620 FIND v(dout0_126) AT=315.025n

.meas tran vdout0_127ck620 FIND v(dout0_127) AT=315.025n

.meas tran vdout0_0ck680 FIND v(dout0_0) AT=345.025n

.meas tran vdout0_1ck680 FIND v(dout0_1) AT=345.025n

.meas tran vdout0_2ck680 FIND v(dout0_2) AT=345.025n

.meas tran vdout0_3ck680 FIND v(dout0_3) AT=345.025n

.meas tran vdout0_4ck680 FIND v(dout0_4) AT=345.025n

.meas tran vdout0_5ck680 FIND v(dout0_5) AT=345.025n

.meas tran vdout0_6ck680 FIND v(dout0_6) AT=345.025n

.meas tran vdout0_7ck680 FIND v(dout0_7) AT=345.025n

.meas tran vdout0_8ck680 FIND v(dout0_8) AT=345.025n

.meas tran vdout0_9ck680 FIND v(dout0_9) AT=345.025n

.meas tran vdout0_10ck680 FIND v(dout0_10) AT=345.025n

.meas tran vdout0_11ck680 FIND v(dout0_11) AT=345.025n

.meas tran vdout0_12ck680 FIND v(dout0_12) AT=345.025n

.meas tran vdout0_13ck680 FIND v(dout0_13) AT=345.025n

.meas tran vdout0_14ck680 FIND v(dout0_14) AT=345.025n

.meas tran vdout0_15ck680 FIND v(dout0_15) AT=345.025n

.meas tran vdout0_16ck680 FIND v(dout0_16) AT=345.025n

.meas tran vdout0_17ck680 FIND v(dout0_17) AT=345.025n

.meas tran vdout0_18ck680 FIND v(dout0_18) AT=345.025n

.meas tran vdout0_19ck680 FIND v(dout0_19) AT=345.025n

.meas tran vdout0_20ck680 FIND v(dout0_20) AT=345.025n

.meas tran vdout0_21ck680 FIND v(dout0_21) AT=345.025n

.meas tran vdout0_22ck680 FIND v(dout0_22) AT=345.025n

.meas tran vdout0_23ck680 FIND v(dout0_23) AT=345.025n

.meas tran vdout0_24ck680 FIND v(dout0_24) AT=345.025n

.meas tran vdout0_25ck680 FIND v(dout0_25) AT=345.025n

.meas tran vdout0_26ck680 FIND v(dout0_26) AT=345.025n

.meas tran vdout0_27ck680 FIND v(dout0_27) AT=345.025n

.meas tran vdout0_28ck680 FIND v(dout0_28) AT=345.025n

.meas tran vdout0_29ck680 FIND v(dout0_29) AT=345.025n

.meas tran vdout0_30ck680 FIND v(dout0_30) AT=345.025n

.meas tran vdout0_31ck680 FIND v(dout0_31) AT=345.025n

.meas tran vdout0_32ck680 FIND v(dout0_32) AT=345.025n

.meas tran vdout0_33ck680 FIND v(dout0_33) AT=345.025n

.meas tran vdout0_34ck680 FIND v(dout0_34) AT=345.025n

.meas tran vdout0_35ck680 FIND v(dout0_35) AT=345.025n

.meas tran vdout0_36ck680 FIND v(dout0_36) AT=345.025n

.meas tran vdout0_37ck680 FIND v(dout0_37) AT=345.025n

.meas tran vdout0_38ck680 FIND v(dout0_38) AT=345.025n

.meas tran vdout0_39ck680 FIND v(dout0_39) AT=345.025n

.meas tran vdout0_40ck680 FIND v(dout0_40) AT=345.025n

.meas tran vdout0_41ck680 FIND v(dout0_41) AT=345.025n

.meas tran vdout0_42ck680 FIND v(dout0_42) AT=345.025n

.meas tran vdout0_43ck680 FIND v(dout0_43) AT=345.025n

.meas tran vdout0_44ck680 FIND v(dout0_44) AT=345.025n

.meas tran vdout0_45ck680 FIND v(dout0_45) AT=345.025n

.meas tran vdout0_46ck680 FIND v(dout0_46) AT=345.025n

.meas tran vdout0_47ck680 FIND v(dout0_47) AT=345.025n

.meas tran vdout0_48ck680 FIND v(dout0_48) AT=345.025n

.meas tran vdout0_49ck680 FIND v(dout0_49) AT=345.025n

.meas tran vdout0_50ck680 FIND v(dout0_50) AT=345.025n

.meas tran vdout0_51ck680 FIND v(dout0_51) AT=345.025n

.meas tran vdout0_52ck680 FIND v(dout0_52) AT=345.025n

.meas tran vdout0_53ck680 FIND v(dout0_53) AT=345.025n

.meas tran vdout0_54ck680 FIND v(dout0_54) AT=345.025n

.meas tran vdout0_55ck680 FIND v(dout0_55) AT=345.025n

.meas tran vdout0_56ck680 FIND v(dout0_56) AT=345.025n

.meas tran vdout0_57ck680 FIND v(dout0_57) AT=345.025n

.meas tran vdout0_58ck680 FIND v(dout0_58) AT=345.025n

.meas tran vdout0_59ck680 FIND v(dout0_59) AT=345.025n

.meas tran vdout0_60ck680 FIND v(dout0_60) AT=345.025n

.meas tran vdout0_61ck680 FIND v(dout0_61) AT=345.025n

.meas tran vdout0_62ck680 FIND v(dout0_62) AT=345.025n

.meas tran vdout0_63ck680 FIND v(dout0_63) AT=345.025n

.meas tran vdout0_64ck680 FIND v(dout0_64) AT=345.025n

.meas tran vdout0_65ck680 FIND v(dout0_65) AT=345.025n

.meas tran vdout0_66ck680 FIND v(dout0_66) AT=345.025n

.meas tran vdout0_67ck680 FIND v(dout0_67) AT=345.025n

.meas tran vdout0_68ck680 FIND v(dout0_68) AT=345.025n

.meas tran vdout0_69ck680 FIND v(dout0_69) AT=345.025n

.meas tran vdout0_70ck680 FIND v(dout0_70) AT=345.025n

.meas tran vdout0_71ck680 FIND v(dout0_71) AT=345.025n

.meas tran vdout0_72ck680 FIND v(dout0_72) AT=345.025n

.meas tran vdout0_73ck680 FIND v(dout0_73) AT=345.025n

.meas tran vdout0_74ck680 FIND v(dout0_74) AT=345.025n

.meas tran vdout0_75ck680 FIND v(dout0_75) AT=345.025n

.meas tran vdout0_76ck680 FIND v(dout0_76) AT=345.025n

.meas tran vdout0_77ck680 FIND v(dout0_77) AT=345.025n

.meas tran vdout0_78ck680 FIND v(dout0_78) AT=345.025n

.meas tran vdout0_79ck680 FIND v(dout0_79) AT=345.025n

.meas tran vdout0_80ck680 FIND v(dout0_80) AT=345.025n

.meas tran vdout0_81ck680 FIND v(dout0_81) AT=345.025n

.meas tran vdout0_82ck680 FIND v(dout0_82) AT=345.025n

.meas tran vdout0_83ck680 FIND v(dout0_83) AT=345.025n

.meas tran vdout0_84ck680 FIND v(dout0_84) AT=345.025n

.meas tran vdout0_85ck680 FIND v(dout0_85) AT=345.025n

.meas tran vdout0_86ck680 FIND v(dout0_86) AT=345.025n

.meas tran vdout0_87ck680 FIND v(dout0_87) AT=345.025n

.meas tran vdout0_88ck680 FIND v(dout0_88) AT=345.025n

.meas tran vdout0_89ck680 FIND v(dout0_89) AT=345.025n

.meas tran vdout0_90ck680 FIND v(dout0_90) AT=345.025n

.meas tran vdout0_91ck680 FIND v(dout0_91) AT=345.025n

.meas tran vdout0_92ck680 FIND v(dout0_92) AT=345.025n

.meas tran vdout0_93ck680 FIND v(dout0_93) AT=345.025n

.meas tran vdout0_94ck680 FIND v(dout0_94) AT=345.025n

.meas tran vdout0_95ck680 FIND v(dout0_95) AT=345.025n

.meas tran vdout0_96ck680 FIND v(dout0_96) AT=345.025n

.meas tran vdout0_97ck680 FIND v(dout0_97) AT=345.025n

.meas tran vdout0_98ck680 FIND v(dout0_98) AT=345.025n

.meas tran vdout0_99ck680 FIND v(dout0_99) AT=345.025n

.meas tran vdout0_100ck680 FIND v(dout0_100) AT=345.025n

.meas tran vdout0_101ck680 FIND v(dout0_101) AT=345.025n

.meas tran vdout0_102ck680 FIND v(dout0_102) AT=345.025n

.meas tran vdout0_103ck680 FIND v(dout0_103) AT=345.025n

.meas tran vdout0_104ck680 FIND v(dout0_104) AT=345.025n

.meas tran vdout0_105ck680 FIND v(dout0_105) AT=345.025n

.meas tran vdout0_106ck680 FIND v(dout0_106) AT=345.025n

.meas tran vdout0_107ck680 FIND v(dout0_107) AT=345.025n

.meas tran vdout0_108ck680 FIND v(dout0_108) AT=345.025n

.meas tran vdout0_109ck680 FIND v(dout0_109) AT=345.025n

.meas tran vdout0_110ck680 FIND v(dout0_110) AT=345.025n

.meas tran vdout0_111ck680 FIND v(dout0_111) AT=345.025n

.meas tran vdout0_112ck680 FIND v(dout0_112) AT=345.025n

.meas tran vdout0_113ck680 FIND v(dout0_113) AT=345.025n

.meas tran vdout0_114ck680 FIND v(dout0_114) AT=345.025n

.meas tran vdout0_115ck680 FIND v(dout0_115) AT=345.025n

.meas tran vdout0_116ck680 FIND v(dout0_116) AT=345.025n

.meas tran vdout0_117ck680 FIND v(dout0_117) AT=345.025n

.meas tran vdout0_118ck680 FIND v(dout0_118) AT=345.025n

.meas tran vdout0_119ck680 FIND v(dout0_119) AT=345.025n

.meas tran vdout0_120ck680 FIND v(dout0_120) AT=345.025n

.meas tran vdout0_121ck680 FIND v(dout0_121) AT=345.025n

.meas tran vdout0_122ck680 FIND v(dout0_122) AT=345.025n

.meas tran vdout0_123ck680 FIND v(dout0_123) AT=345.025n

.meas tran vdout0_124ck680 FIND v(dout0_124) AT=345.025n

.meas tran vdout0_125ck680 FIND v(dout0_125) AT=345.025n

.meas tran vdout0_126ck680 FIND v(dout0_126) AT=345.025n

.meas tran vdout0_127ck680 FIND v(dout0_127) AT=345.025n

.meas tran vdout0_0ck690 FIND v(dout0_0) AT=350.025n

.meas tran vdout0_1ck690 FIND v(dout0_1) AT=350.025n

.meas tran vdout0_2ck690 FIND v(dout0_2) AT=350.025n

.meas tran vdout0_3ck690 FIND v(dout0_3) AT=350.025n

.meas tran vdout0_4ck690 FIND v(dout0_4) AT=350.025n

.meas tran vdout0_5ck690 FIND v(dout0_5) AT=350.025n

.meas tran vdout0_6ck690 FIND v(dout0_6) AT=350.025n

.meas tran vdout0_7ck690 FIND v(dout0_7) AT=350.025n

.meas tran vdout0_8ck690 FIND v(dout0_8) AT=350.025n

.meas tran vdout0_9ck690 FIND v(dout0_9) AT=350.025n

.meas tran vdout0_10ck690 FIND v(dout0_10) AT=350.025n

.meas tran vdout0_11ck690 FIND v(dout0_11) AT=350.025n

.meas tran vdout0_12ck690 FIND v(dout0_12) AT=350.025n

.meas tran vdout0_13ck690 FIND v(dout0_13) AT=350.025n

.meas tran vdout0_14ck690 FIND v(dout0_14) AT=350.025n

.meas tran vdout0_15ck690 FIND v(dout0_15) AT=350.025n

.meas tran vdout0_16ck690 FIND v(dout0_16) AT=350.025n

.meas tran vdout0_17ck690 FIND v(dout0_17) AT=350.025n

.meas tran vdout0_18ck690 FIND v(dout0_18) AT=350.025n

.meas tran vdout0_19ck690 FIND v(dout0_19) AT=350.025n

.meas tran vdout0_20ck690 FIND v(dout0_20) AT=350.025n

.meas tran vdout0_21ck690 FIND v(dout0_21) AT=350.025n

.meas tran vdout0_22ck690 FIND v(dout0_22) AT=350.025n

.meas tran vdout0_23ck690 FIND v(dout0_23) AT=350.025n

.meas tran vdout0_24ck690 FIND v(dout0_24) AT=350.025n

.meas tran vdout0_25ck690 FIND v(dout0_25) AT=350.025n

.meas tran vdout0_26ck690 FIND v(dout0_26) AT=350.025n

.meas tran vdout0_27ck690 FIND v(dout0_27) AT=350.025n

.meas tran vdout0_28ck690 FIND v(dout0_28) AT=350.025n

.meas tran vdout0_29ck690 FIND v(dout0_29) AT=350.025n

.meas tran vdout0_30ck690 FIND v(dout0_30) AT=350.025n

.meas tran vdout0_31ck690 FIND v(dout0_31) AT=350.025n

.meas tran vdout0_32ck690 FIND v(dout0_32) AT=350.025n

.meas tran vdout0_33ck690 FIND v(dout0_33) AT=350.025n

.meas tran vdout0_34ck690 FIND v(dout0_34) AT=350.025n

.meas tran vdout0_35ck690 FIND v(dout0_35) AT=350.025n

.meas tran vdout0_36ck690 FIND v(dout0_36) AT=350.025n

.meas tran vdout0_37ck690 FIND v(dout0_37) AT=350.025n

.meas tran vdout0_38ck690 FIND v(dout0_38) AT=350.025n

.meas tran vdout0_39ck690 FIND v(dout0_39) AT=350.025n

.meas tran vdout0_40ck690 FIND v(dout0_40) AT=350.025n

.meas tran vdout0_41ck690 FIND v(dout0_41) AT=350.025n

.meas tran vdout0_42ck690 FIND v(dout0_42) AT=350.025n

.meas tran vdout0_43ck690 FIND v(dout0_43) AT=350.025n

.meas tran vdout0_44ck690 FIND v(dout0_44) AT=350.025n

.meas tran vdout0_45ck690 FIND v(dout0_45) AT=350.025n

.meas tran vdout0_46ck690 FIND v(dout0_46) AT=350.025n

.meas tran vdout0_47ck690 FIND v(dout0_47) AT=350.025n

.meas tran vdout0_48ck690 FIND v(dout0_48) AT=350.025n

.meas tran vdout0_49ck690 FIND v(dout0_49) AT=350.025n

.meas tran vdout0_50ck690 FIND v(dout0_50) AT=350.025n

.meas tran vdout0_51ck690 FIND v(dout0_51) AT=350.025n

.meas tran vdout0_52ck690 FIND v(dout0_52) AT=350.025n

.meas tran vdout0_53ck690 FIND v(dout0_53) AT=350.025n

.meas tran vdout0_54ck690 FIND v(dout0_54) AT=350.025n

.meas tran vdout0_55ck690 FIND v(dout0_55) AT=350.025n

.meas tran vdout0_56ck690 FIND v(dout0_56) AT=350.025n

.meas tran vdout0_57ck690 FIND v(dout0_57) AT=350.025n

.meas tran vdout0_58ck690 FIND v(dout0_58) AT=350.025n

.meas tran vdout0_59ck690 FIND v(dout0_59) AT=350.025n

.meas tran vdout0_60ck690 FIND v(dout0_60) AT=350.025n

.meas tran vdout0_61ck690 FIND v(dout0_61) AT=350.025n

.meas tran vdout0_62ck690 FIND v(dout0_62) AT=350.025n

.meas tran vdout0_63ck690 FIND v(dout0_63) AT=350.025n

.meas tran vdout0_64ck690 FIND v(dout0_64) AT=350.025n

.meas tran vdout0_65ck690 FIND v(dout0_65) AT=350.025n

.meas tran vdout0_66ck690 FIND v(dout0_66) AT=350.025n

.meas tran vdout0_67ck690 FIND v(dout0_67) AT=350.025n

.meas tran vdout0_68ck690 FIND v(dout0_68) AT=350.025n

.meas tran vdout0_69ck690 FIND v(dout0_69) AT=350.025n

.meas tran vdout0_70ck690 FIND v(dout0_70) AT=350.025n

.meas tran vdout0_71ck690 FIND v(dout0_71) AT=350.025n

.meas tran vdout0_72ck690 FIND v(dout0_72) AT=350.025n

.meas tran vdout0_73ck690 FIND v(dout0_73) AT=350.025n

.meas tran vdout0_74ck690 FIND v(dout0_74) AT=350.025n

.meas tran vdout0_75ck690 FIND v(dout0_75) AT=350.025n

.meas tran vdout0_76ck690 FIND v(dout0_76) AT=350.025n

.meas tran vdout0_77ck690 FIND v(dout0_77) AT=350.025n

.meas tran vdout0_78ck690 FIND v(dout0_78) AT=350.025n

.meas tran vdout0_79ck690 FIND v(dout0_79) AT=350.025n

.meas tran vdout0_80ck690 FIND v(dout0_80) AT=350.025n

.meas tran vdout0_81ck690 FIND v(dout0_81) AT=350.025n

.meas tran vdout0_82ck690 FIND v(dout0_82) AT=350.025n

.meas tran vdout0_83ck690 FIND v(dout0_83) AT=350.025n

.meas tran vdout0_84ck690 FIND v(dout0_84) AT=350.025n

.meas tran vdout0_85ck690 FIND v(dout0_85) AT=350.025n

.meas tran vdout0_86ck690 FIND v(dout0_86) AT=350.025n

.meas tran vdout0_87ck690 FIND v(dout0_87) AT=350.025n

.meas tran vdout0_88ck690 FIND v(dout0_88) AT=350.025n

.meas tran vdout0_89ck690 FIND v(dout0_89) AT=350.025n

.meas tran vdout0_90ck690 FIND v(dout0_90) AT=350.025n

.meas tran vdout0_91ck690 FIND v(dout0_91) AT=350.025n

.meas tran vdout0_92ck690 FIND v(dout0_92) AT=350.025n

.meas tran vdout0_93ck690 FIND v(dout0_93) AT=350.025n

.meas tran vdout0_94ck690 FIND v(dout0_94) AT=350.025n

.meas tran vdout0_95ck690 FIND v(dout0_95) AT=350.025n

.meas tran vdout0_96ck690 FIND v(dout0_96) AT=350.025n

.meas tran vdout0_97ck690 FIND v(dout0_97) AT=350.025n

.meas tran vdout0_98ck690 FIND v(dout0_98) AT=350.025n

.meas tran vdout0_99ck690 FIND v(dout0_99) AT=350.025n

.meas tran vdout0_100ck690 FIND v(dout0_100) AT=350.025n

.meas tran vdout0_101ck690 FIND v(dout0_101) AT=350.025n

.meas tran vdout0_102ck690 FIND v(dout0_102) AT=350.025n

.meas tran vdout0_103ck690 FIND v(dout0_103) AT=350.025n

.meas tran vdout0_104ck690 FIND v(dout0_104) AT=350.025n

.meas tran vdout0_105ck690 FIND v(dout0_105) AT=350.025n

.meas tran vdout0_106ck690 FIND v(dout0_106) AT=350.025n

.meas tran vdout0_107ck690 FIND v(dout0_107) AT=350.025n

.meas tran vdout0_108ck690 FIND v(dout0_108) AT=350.025n

.meas tran vdout0_109ck690 FIND v(dout0_109) AT=350.025n

.meas tran vdout0_110ck690 FIND v(dout0_110) AT=350.025n

.meas tran vdout0_111ck690 FIND v(dout0_111) AT=350.025n

.meas tran vdout0_112ck690 FIND v(dout0_112) AT=350.025n

.meas tran vdout0_113ck690 FIND v(dout0_113) AT=350.025n

.meas tran vdout0_114ck690 FIND v(dout0_114) AT=350.025n

.meas tran vdout0_115ck690 FIND v(dout0_115) AT=350.025n

.meas tran vdout0_116ck690 FIND v(dout0_116) AT=350.025n

.meas tran vdout0_117ck690 FIND v(dout0_117) AT=350.025n

.meas tran vdout0_118ck690 FIND v(dout0_118) AT=350.025n

.meas tran vdout0_119ck690 FIND v(dout0_119) AT=350.025n

.meas tran vdout0_120ck690 FIND v(dout0_120) AT=350.025n

.meas tran vdout0_121ck690 FIND v(dout0_121) AT=350.025n

.meas tran vdout0_122ck690 FIND v(dout0_122) AT=350.025n

.meas tran vdout0_123ck690 FIND v(dout0_123) AT=350.025n

.meas tran vdout0_124ck690 FIND v(dout0_124) AT=350.025n

.meas tran vdout0_125ck690 FIND v(dout0_125) AT=350.025n

.meas tran vdout0_126ck690 FIND v(dout0_126) AT=350.025n

.meas tran vdout0_127ck690 FIND v(dout0_127) AT=350.025n

.meas tran vdout0_0ck800 FIND v(dout0_0) AT=405.025n

.meas tran vdout0_1ck800 FIND v(dout0_1) AT=405.025n

.meas tran vdout0_2ck800 FIND v(dout0_2) AT=405.025n

.meas tran vdout0_3ck800 FIND v(dout0_3) AT=405.025n

.meas tran vdout0_4ck800 FIND v(dout0_4) AT=405.025n

.meas tran vdout0_5ck800 FIND v(dout0_5) AT=405.025n

.meas tran vdout0_6ck800 FIND v(dout0_6) AT=405.025n

.meas tran vdout0_7ck800 FIND v(dout0_7) AT=405.025n

.meas tran vdout0_8ck800 FIND v(dout0_8) AT=405.025n

.meas tran vdout0_9ck800 FIND v(dout0_9) AT=405.025n

.meas tran vdout0_10ck800 FIND v(dout0_10) AT=405.025n

.meas tran vdout0_11ck800 FIND v(dout0_11) AT=405.025n

.meas tran vdout0_12ck800 FIND v(dout0_12) AT=405.025n

.meas tran vdout0_13ck800 FIND v(dout0_13) AT=405.025n

.meas tran vdout0_14ck800 FIND v(dout0_14) AT=405.025n

.meas tran vdout0_15ck800 FIND v(dout0_15) AT=405.025n

.meas tran vdout0_16ck800 FIND v(dout0_16) AT=405.025n

.meas tran vdout0_17ck800 FIND v(dout0_17) AT=405.025n

.meas tran vdout0_18ck800 FIND v(dout0_18) AT=405.025n

.meas tran vdout0_19ck800 FIND v(dout0_19) AT=405.025n

.meas tran vdout0_20ck800 FIND v(dout0_20) AT=405.025n

.meas tran vdout0_21ck800 FIND v(dout0_21) AT=405.025n

.meas tran vdout0_22ck800 FIND v(dout0_22) AT=405.025n

.meas tran vdout0_23ck800 FIND v(dout0_23) AT=405.025n

.meas tran vdout0_24ck800 FIND v(dout0_24) AT=405.025n

.meas tran vdout0_25ck800 FIND v(dout0_25) AT=405.025n

.meas tran vdout0_26ck800 FIND v(dout0_26) AT=405.025n

.meas tran vdout0_27ck800 FIND v(dout0_27) AT=405.025n

.meas tran vdout0_28ck800 FIND v(dout0_28) AT=405.025n

.meas tran vdout0_29ck800 FIND v(dout0_29) AT=405.025n

.meas tran vdout0_30ck800 FIND v(dout0_30) AT=405.025n

.meas tran vdout0_31ck800 FIND v(dout0_31) AT=405.025n

.meas tran vdout0_32ck800 FIND v(dout0_32) AT=405.025n

.meas tran vdout0_33ck800 FIND v(dout0_33) AT=405.025n

.meas tran vdout0_34ck800 FIND v(dout0_34) AT=405.025n

.meas tran vdout0_35ck800 FIND v(dout0_35) AT=405.025n

.meas tran vdout0_36ck800 FIND v(dout0_36) AT=405.025n

.meas tran vdout0_37ck800 FIND v(dout0_37) AT=405.025n

.meas tran vdout0_38ck800 FIND v(dout0_38) AT=405.025n

.meas tran vdout0_39ck800 FIND v(dout0_39) AT=405.025n

.meas tran vdout0_40ck800 FIND v(dout0_40) AT=405.025n

.meas tran vdout0_41ck800 FIND v(dout0_41) AT=405.025n

.meas tran vdout0_42ck800 FIND v(dout0_42) AT=405.025n

.meas tran vdout0_43ck800 FIND v(dout0_43) AT=405.025n

.meas tran vdout0_44ck800 FIND v(dout0_44) AT=405.025n

.meas tran vdout0_45ck800 FIND v(dout0_45) AT=405.025n

.meas tran vdout0_46ck800 FIND v(dout0_46) AT=405.025n

.meas tran vdout0_47ck800 FIND v(dout0_47) AT=405.025n

.meas tran vdout0_48ck800 FIND v(dout0_48) AT=405.025n

.meas tran vdout0_49ck800 FIND v(dout0_49) AT=405.025n

.meas tran vdout0_50ck800 FIND v(dout0_50) AT=405.025n

.meas tran vdout0_51ck800 FIND v(dout0_51) AT=405.025n

.meas tran vdout0_52ck800 FIND v(dout0_52) AT=405.025n

.meas tran vdout0_53ck800 FIND v(dout0_53) AT=405.025n

.meas tran vdout0_54ck800 FIND v(dout0_54) AT=405.025n

.meas tran vdout0_55ck800 FIND v(dout0_55) AT=405.025n

.meas tran vdout0_56ck800 FIND v(dout0_56) AT=405.025n

.meas tran vdout0_57ck800 FIND v(dout0_57) AT=405.025n

.meas tran vdout0_58ck800 FIND v(dout0_58) AT=405.025n

.meas tran vdout0_59ck800 FIND v(dout0_59) AT=405.025n

.meas tran vdout0_60ck800 FIND v(dout0_60) AT=405.025n

.meas tran vdout0_61ck800 FIND v(dout0_61) AT=405.025n

.meas tran vdout0_62ck800 FIND v(dout0_62) AT=405.025n

.meas tran vdout0_63ck800 FIND v(dout0_63) AT=405.025n

.meas tran vdout0_64ck800 FIND v(dout0_64) AT=405.025n

.meas tran vdout0_65ck800 FIND v(dout0_65) AT=405.025n

.meas tran vdout0_66ck800 FIND v(dout0_66) AT=405.025n

.meas tran vdout0_67ck800 FIND v(dout0_67) AT=405.025n

.meas tran vdout0_68ck800 FIND v(dout0_68) AT=405.025n

.meas tran vdout0_69ck800 FIND v(dout0_69) AT=405.025n

.meas tran vdout0_70ck800 FIND v(dout0_70) AT=405.025n

.meas tran vdout0_71ck800 FIND v(dout0_71) AT=405.025n

.meas tran vdout0_72ck800 FIND v(dout0_72) AT=405.025n

.meas tran vdout0_73ck800 FIND v(dout0_73) AT=405.025n

.meas tran vdout0_74ck800 FIND v(dout0_74) AT=405.025n

.meas tran vdout0_75ck800 FIND v(dout0_75) AT=405.025n

.meas tran vdout0_76ck800 FIND v(dout0_76) AT=405.025n

.meas tran vdout0_77ck800 FIND v(dout0_77) AT=405.025n

.meas tran vdout0_78ck800 FIND v(dout0_78) AT=405.025n

.meas tran vdout0_79ck800 FIND v(dout0_79) AT=405.025n

.meas tran vdout0_80ck800 FIND v(dout0_80) AT=405.025n

.meas tran vdout0_81ck800 FIND v(dout0_81) AT=405.025n

.meas tran vdout0_82ck800 FIND v(dout0_82) AT=405.025n

.meas tran vdout0_83ck800 FIND v(dout0_83) AT=405.025n

.meas tran vdout0_84ck800 FIND v(dout0_84) AT=405.025n

.meas tran vdout0_85ck800 FIND v(dout0_85) AT=405.025n

.meas tran vdout0_86ck800 FIND v(dout0_86) AT=405.025n

.meas tran vdout0_87ck800 FIND v(dout0_87) AT=405.025n

.meas tran vdout0_88ck800 FIND v(dout0_88) AT=405.025n

.meas tran vdout0_89ck800 FIND v(dout0_89) AT=405.025n

.meas tran vdout0_90ck800 FIND v(dout0_90) AT=405.025n

.meas tran vdout0_91ck800 FIND v(dout0_91) AT=405.025n

.meas tran vdout0_92ck800 FIND v(dout0_92) AT=405.025n

.meas tran vdout0_93ck800 FIND v(dout0_93) AT=405.025n

.meas tran vdout0_94ck800 FIND v(dout0_94) AT=405.025n

.meas tran vdout0_95ck800 FIND v(dout0_95) AT=405.025n

.meas tran vdout0_96ck800 FIND v(dout0_96) AT=405.025n

.meas tran vdout0_97ck800 FIND v(dout0_97) AT=405.025n

.meas tran vdout0_98ck800 FIND v(dout0_98) AT=405.025n

.meas tran vdout0_99ck800 FIND v(dout0_99) AT=405.025n

.meas tran vdout0_100ck800 FIND v(dout0_100) AT=405.025n

.meas tran vdout0_101ck800 FIND v(dout0_101) AT=405.025n

.meas tran vdout0_102ck800 FIND v(dout0_102) AT=405.025n

.meas tran vdout0_103ck800 FIND v(dout0_103) AT=405.025n

.meas tran vdout0_104ck800 FIND v(dout0_104) AT=405.025n

.meas tran vdout0_105ck800 FIND v(dout0_105) AT=405.025n

.meas tran vdout0_106ck800 FIND v(dout0_106) AT=405.025n

.meas tran vdout0_107ck800 FIND v(dout0_107) AT=405.025n

.meas tran vdout0_108ck800 FIND v(dout0_108) AT=405.025n

.meas tran vdout0_109ck800 FIND v(dout0_109) AT=405.025n

.meas tran vdout0_110ck800 FIND v(dout0_110) AT=405.025n

.meas tran vdout0_111ck800 FIND v(dout0_111) AT=405.025n

.meas tran vdout0_112ck800 FIND v(dout0_112) AT=405.025n

.meas tran vdout0_113ck800 FIND v(dout0_113) AT=405.025n

.meas tran vdout0_114ck800 FIND v(dout0_114) AT=405.025n

.meas tran vdout0_115ck800 FIND v(dout0_115) AT=405.025n

.meas tran vdout0_116ck800 FIND v(dout0_116) AT=405.025n

.meas tran vdout0_117ck800 FIND v(dout0_117) AT=405.025n

.meas tran vdout0_118ck800 FIND v(dout0_118) AT=405.025n

.meas tran vdout0_119ck800 FIND v(dout0_119) AT=405.025n

.meas tran vdout0_120ck800 FIND v(dout0_120) AT=405.025n

.meas tran vdout0_121ck800 FIND v(dout0_121) AT=405.025n

.meas tran vdout0_122ck800 FIND v(dout0_122) AT=405.025n

.meas tran vdout0_123ck800 FIND v(dout0_123) AT=405.025n

.meas tran vdout0_124ck800 FIND v(dout0_124) AT=405.025n

.meas tran vdout0_125ck800 FIND v(dout0_125) AT=405.025n

.meas tran vdout0_126ck800 FIND v(dout0_126) AT=405.025n

.meas tran vdout0_127ck800 FIND v(dout0_127) AT=405.025n

.meas tran vdout0_0ck820 FIND v(dout0_0) AT=415.025n

.meas tran vdout0_1ck820 FIND v(dout0_1) AT=415.025n

.meas tran vdout0_2ck820 FIND v(dout0_2) AT=415.025n

.meas tran vdout0_3ck820 FIND v(dout0_3) AT=415.025n

.meas tran vdout0_4ck820 FIND v(dout0_4) AT=415.025n

.meas tran vdout0_5ck820 FIND v(dout0_5) AT=415.025n

.meas tran vdout0_6ck820 FIND v(dout0_6) AT=415.025n

.meas tran vdout0_7ck820 FIND v(dout0_7) AT=415.025n

.meas tran vdout0_8ck820 FIND v(dout0_8) AT=415.025n

.meas tran vdout0_9ck820 FIND v(dout0_9) AT=415.025n

.meas tran vdout0_10ck820 FIND v(dout0_10) AT=415.025n

.meas tran vdout0_11ck820 FIND v(dout0_11) AT=415.025n

.meas tran vdout0_12ck820 FIND v(dout0_12) AT=415.025n

.meas tran vdout0_13ck820 FIND v(dout0_13) AT=415.025n

.meas tran vdout0_14ck820 FIND v(dout0_14) AT=415.025n

.meas tran vdout0_15ck820 FIND v(dout0_15) AT=415.025n

.meas tran vdout0_16ck820 FIND v(dout0_16) AT=415.025n

.meas tran vdout0_17ck820 FIND v(dout0_17) AT=415.025n

.meas tran vdout0_18ck820 FIND v(dout0_18) AT=415.025n

.meas tran vdout0_19ck820 FIND v(dout0_19) AT=415.025n

.meas tran vdout0_20ck820 FIND v(dout0_20) AT=415.025n

.meas tran vdout0_21ck820 FIND v(dout0_21) AT=415.025n

.meas tran vdout0_22ck820 FIND v(dout0_22) AT=415.025n

.meas tran vdout0_23ck820 FIND v(dout0_23) AT=415.025n

.meas tran vdout0_24ck820 FIND v(dout0_24) AT=415.025n

.meas tran vdout0_25ck820 FIND v(dout0_25) AT=415.025n

.meas tran vdout0_26ck820 FIND v(dout0_26) AT=415.025n

.meas tran vdout0_27ck820 FIND v(dout0_27) AT=415.025n

.meas tran vdout0_28ck820 FIND v(dout0_28) AT=415.025n

.meas tran vdout0_29ck820 FIND v(dout0_29) AT=415.025n

.meas tran vdout0_30ck820 FIND v(dout0_30) AT=415.025n

.meas tran vdout0_31ck820 FIND v(dout0_31) AT=415.025n

.meas tran vdout0_32ck820 FIND v(dout0_32) AT=415.025n

.meas tran vdout0_33ck820 FIND v(dout0_33) AT=415.025n

.meas tran vdout0_34ck820 FIND v(dout0_34) AT=415.025n

.meas tran vdout0_35ck820 FIND v(dout0_35) AT=415.025n

.meas tran vdout0_36ck820 FIND v(dout0_36) AT=415.025n

.meas tran vdout0_37ck820 FIND v(dout0_37) AT=415.025n

.meas tran vdout0_38ck820 FIND v(dout0_38) AT=415.025n

.meas tran vdout0_39ck820 FIND v(dout0_39) AT=415.025n

.meas tran vdout0_40ck820 FIND v(dout0_40) AT=415.025n

.meas tran vdout0_41ck820 FIND v(dout0_41) AT=415.025n

.meas tran vdout0_42ck820 FIND v(dout0_42) AT=415.025n

.meas tran vdout0_43ck820 FIND v(dout0_43) AT=415.025n

.meas tran vdout0_44ck820 FIND v(dout0_44) AT=415.025n

.meas tran vdout0_45ck820 FIND v(dout0_45) AT=415.025n

.meas tran vdout0_46ck820 FIND v(dout0_46) AT=415.025n

.meas tran vdout0_47ck820 FIND v(dout0_47) AT=415.025n

.meas tran vdout0_48ck820 FIND v(dout0_48) AT=415.025n

.meas tran vdout0_49ck820 FIND v(dout0_49) AT=415.025n

.meas tran vdout0_50ck820 FIND v(dout0_50) AT=415.025n

.meas tran vdout0_51ck820 FIND v(dout0_51) AT=415.025n

.meas tran vdout0_52ck820 FIND v(dout0_52) AT=415.025n

.meas tran vdout0_53ck820 FIND v(dout0_53) AT=415.025n

.meas tran vdout0_54ck820 FIND v(dout0_54) AT=415.025n

.meas tran vdout0_55ck820 FIND v(dout0_55) AT=415.025n

.meas tran vdout0_56ck820 FIND v(dout0_56) AT=415.025n

.meas tran vdout0_57ck820 FIND v(dout0_57) AT=415.025n

.meas tran vdout0_58ck820 FIND v(dout0_58) AT=415.025n

.meas tran vdout0_59ck820 FIND v(dout0_59) AT=415.025n

.meas tran vdout0_60ck820 FIND v(dout0_60) AT=415.025n

.meas tran vdout0_61ck820 FIND v(dout0_61) AT=415.025n

.meas tran vdout0_62ck820 FIND v(dout0_62) AT=415.025n

.meas tran vdout0_63ck820 FIND v(dout0_63) AT=415.025n

.meas tran vdout0_64ck820 FIND v(dout0_64) AT=415.025n

.meas tran vdout0_65ck820 FIND v(dout0_65) AT=415.025n

.meas tran vdout0_66ck820 FIND v(dout0_66) AT=415.025n

.meas tran vdout0_67ck820 FIND v(dout0_67) AT=415.025n

.meas tran vdout0_68ck820 FIND v(dout0_68) AT=415.025n

.meas tran vdout0_69ck820 FIND v(dout0_69) AT=415.025n

.meas tran vdout0_70ck820 FIND v(dout0_70) AT=415.025n

.meas tran vdout0_71ck820 FIND v(dout0_71) AT=415.025n

.meas tran vdout0_72ck820 FIND v(dout0_72) AT=415.025n

.meas tran vdout0_73ck820 FIND v(dout0_73) AT=415.025n

.meas tran vdout0_74ck820 FIND v(dout0_74) AT=415.025n

.meas tran vdout0_75ck820 FIND v(dout0_75) AT=415.025n

.meas tran vdout0_76ck820 FIND v(dout0_76) AT=415.025n

.meas tran vdout0_77ck820 FIND v(dout0_77) AT=415.025n

.meas tran vdout0_78ck820 FIND v(dout0_78) AT=415.025n

.meas tran vdout0_79ck820 FIND v(dout0_79) AT=415.025n

.meas tran vdout0_80ck820 FIND v(dout0_80) AT=415.025n

.meas tran vdout0_81ck820 FIND v(dout0_81) AT=415.025n

.meas tran vdout0_82ck820 FIND v(dout0_82) AT=415.025n

.meas tran vdout0_83ck820 FIND v(dout0_83) AT=415.025n

.meas tran vdout0_84ck820 FIND v(dout0_84) AT=415.025n

.meas tran vdout0_85ck820 FIND v(dout0_85) AT=415.025n

.meas tran vdout0_86ck820 FIND v(dout0_86) AT=415.025n

.meas tran vdout0_87ck820 FIND v(dout0_87) AT=415.025n

.meas tran vdout0_88ck820 FIND v(dout0_88) AT=415.025n

.meas tran vdout0_89ck820 FIND v(dout0_89) AT=415.025n

.meas tran vdout0_90ck820 FIND v(dout0_90) AT=415.025n

.meas tran vdout0_91ck820 FIND v(dout0_91) AT=415.025n

.meas tran vdout0_92ck820 FIND v(dout0_92) AT=415.025n

.meas tran vdout0_93ck820 FIND v(dout0_93) AT=415.025n

.meas tran vdout0_94ck820 FIND v(dout0_94) AT=415.025n

.meas tran vdout0_95ck820 FIND v(dout0_95) AT=415.025n

.meas tran vdout0_96ck820 FIND v(dout0_96) AT=415.025n

.meas tran vdout0_97ck820 FIND v(dout0_97) AT=415.025n

.meas tran vdout0_98ck820 FIND v(dout0_98) AT=415.025n

.meas tran vdout0_99ck820 FIND v(dout0_99) AT=415.025n

.meas tran vdout0_100ck820 FIND v(dout0_100) AT=415.025n

.meas tran vdout0_101ck820 FIND v(dout0_101) AT=415.025n

.meas tran vdout0_102ck820 FIND v(dout0_102) AT=415.025n

.meas tran vdout0_103ck820 FIND v(dout0_103) AT=415.025n

.meas tran vdout0_104ck820 FIND v(dout0_104) AT=415.025n

.meas tran vdout0_105ck820 FIND v(dout0_105) AT=415.025n

.meas tran vdout0_106ck820 FIND v(dout0_106) AT=415.025n

.meas tran vdout0_107ck820 FIND v(dout0_107) AT=415.025n

.meas tran vdout0_108ck820 FIND v(dout0_108) AT=415.025n

.meas tran vdout0_109ck820 FIND v(dout0_109) AT=415.025n

.meas tran vdout0_110ck820 FIND v(dout0_110) AT=415.025n

.meas tran vdout0_111ck820 FIND v(dout0_111) AT=415.025n

.meas tran vdout0_112ck820 FIND v(dout0_112) AT=415.025n

.meas tran vdout0_113ck820 FIND v(dout0_113) AT=415.025n

.meas tran vdout0_114ck820 FIND v(dout0_114) AT=415.025n

.meas tran vdout0_115ck820 FIND v(dout0_115) AT=415.025n

.meas tran vdout0_116ck820 FIND v(dout0_116) AT=415.025n

.meas tran vdout0_117ck820 FIND v(dout0_117) AT=415.025n

.meas tran vdout0_118ck820 FIND v(dout0_118) AT=415.025n

.meas tran vdout0_119ck820 FIND v(dout0_119) AT=415.025n

.meas tran vdout0_120ck820 FIND v(dout0_120) AT=415.025n

.meas tran vdout0_121ck820 FIND v(dout0_121) AT=415.025n

.meas tran vdout0_122ck820 FIND v(dout0_122) AT=415.025n

.meas tran vdout0_123ck820 FIND v(dout0_123) AT=415.025n

.meas tran vdout0_124ck820 FIND v(dout0_124) AT=415.025n

.meas tran vdout0_125ck820 FIND v(dout0_125) AT=415.025n

.meas tran vdout0_126ck820 FIND v(dout0_126) AT=415.025n

.meas tran vdout0_127ck820 FIND v(dout0_127) AT=415.025n

.meas tran vdout0_0ck840 FIND v(dout0_0) AT=425.025n

.meas tran vdout0_1ck840 FIND v(dout0_1) AT=425.025n

.meas tran vdout0_2ck840 FIND v(dout0_2) AT=425.025n

.meas tran vdout0_3ck840 FIND v(dout0_3) AT=425.025n

.meas tran vdout0_4ck840 FIND v(dout0_4) AT=425.025n

.meas tran vdout0_5ck840 FIND v(dout0_5) AT=425.025n

.meas tran vdout0_6ck840 FIND v(dout0_6) AT=425.025n

.meas tran vdout0_7ck840 FIND v(dout0_7) AT=425.025n

.meas tran vdout0_8ck840 FIND v(dout0_8) AT=425.025n

.meas tran vdout0_9ck840 FIND v(dout0_9) AT=425.025n

.meas tran vdout0_10ck840 FIND v(dout0_10) AT=425.025n

.meas tran vdout0_11ck840 FIND v(dout0_11) AT=425.025n

.meas tran vdout0_12ck840 FIND v(dout0_12) AT=425.025n

.meas tran vdout0_13ck840 FIND v(dout0_13) AT=425.025n

.meas tran vdout0_14ck840 FIND v(dout0_14) AT=425.025n

.meas tran vdout0_15ck840 FIND v(dout0_15) AT=425.025n

.meas tran vdout0_16ck840 FIND v(dout0_16) AT=425.025n

.meas tran vdout0_17ck840 FIND v(dout0_17) AT=425.025n

.meas tran vdout0_18ck840 FIND v(dout0_18) AT=425.025n

.meas tran vdout0_19ck840 FIND v(dout0_19) AT=425.025n

.meas tran vdout0_20ck840 FIND v(dout0_20) AT=425.025n

.meas tran vdout0_21ck840 FIND v(dout0_21) AT=425.025n

.meas tran vdout0_22ck840 FIND v(dout0_22) AT=425.025n

.meas tran vdout0_23ck840 FIND v(dout0_23) AT=425.025n

.meas tran vdout0_24ck840 FIND v(dout0_24) AT=425.025n

.meas tran vdout0_25ck840 FIND v(dout0_25) AT=425.025n

.meas tran vdout0_26ck840 FIND v(dout0_26) AT=425.025n

.meas tran vdout0_27ck840 FIND v(dout0_27) AT=425.025n

.meas tran vdout0_28ck840 FIND v(dout0_28) AT=425.025n

.meas tran vdout0_29ck840 FIND v(dout0_29) AT=425.025n

.meas tran vdout0_30ck840 FIND v(dout0_30) AT=425.025n

.meas tran vdout0_31ck840 FIND v(dout0_31) AT=425.025n

.meas tran vdout0_32ck840 FIND v(dout0_32) AT=425.025n

.meas tran vdout0_33ck840 FIND v(dout0_33) AT=425.025n

.meas tran vdout0_34ck840 FIND v(dout0_34) AT=425.025n

.meas tran vdout0_35ck840 FIND v(dout0_35) AT=425.025n

.meas tran vdout0_36ck840 FIND v(dout0_36) AT=425.025n

.meas tran vdout0_37ck840 FIND v(dout0_37) AT=425.025n

.meas tran vdout0_38ck840 FIND v(dout0_38) AT=425.025n

.meas tran vdout0_39ck840 FIND v(dout0_39) AT=425.025n

.meas tran vdout0_40ck840 FIND v(dout0_40) AT=425.025n

.meas tran vdout0_41ck840 FIND v(dout0_41) AT=425.025n

.meas tran vdout0_42ck840 FIND v(dout0_42) AT=425.025n

.meas tran vdout0_43ck840 FIND v(dout0_43) AT=425.025n

.meas tran vdout0_44ck840 FIND v(dout0_44) AT=425.025n

.meas tran vdout0_45ck840 FIND v(dout0_45) AT=425.025n

.meas tran vdout0_46ck840 FIND v(dout0_46) AT=425.025n

.meas tran vdout0_47ck840 FIND v(dout0_47) AT=425.025n

.meas tran vdout0_48ck840 FIND v(dout0_48) AT=425.025n

.meas tran vdout0_49ck840 FIND v(dout0_49) AT=425.025n

.meas tran vdout0_50ck840 FIND v(dout0_50) AT=425.025n

.meas tran vdout0_51ck840 FIND v(dout0_51) AT=425.025n

.meas tran vdout0_52ck840 FIND v(dout0_52) AT=425.025n

.meas tran vdout0_53ck840 FIND v(dout0_53) AT=425.025n

.meas tran vdout0_54ck840 FIND v(dout0_54) AT=425.025n

.meas tran vdout0_55ck840 FIND v(dout0_55) AT=425.025n

.meas tran vdout0_56ck840 FIND v(dout0_56) AT=425.025n

.meas tran vdout0_57ck840 FIND v(dout0_57) AT=425.025n

.meas tran vdout0_58ck840 FIND v(dout0_58) AT=425.025n

.meas tran vdout0_59ck840 FIND v(dout0_59) AT=425.025n

.meas tran vdout0_60ck840 FIND v(dout0_60) AT=425.025n

.meas tran vdout0_61ck840 FIND v(dout0_61) AT=425.025n

.meas tran vdout0_62ck840 FIND v(dout0_62) AT=425.025n

.meas tran vdout0_63ck840 FIND v(dout0_63) AT=425.025n

.meas tran vdout0_64ck840 FIND v(dout0_64) AT=425.025n

.meas tran vdout0_65ck840 FIND v(dout0_65) AT=425.025n

.meas tran vdout0_66ck840 FIND v(dout0_66) AT=425.025n

.meas tran vdout0_67ck840 FIND v(dout0_67) AT=425.025n

.meas tran vdout0_68ck840 FIND v(dout0_68) AT=425.025n

.meas tran vdout0_69ck840 FIND v(dout0_69) AT=425.025n

.meas tran vdout0_70ck840 FIND v(dout0_70) AT=425.025n

.meas tran vdout0_71ck840 FIND v(dout0_71) AT=425.025n

.meas tran vdout0_72ck840 FIND v(dout0_72) AT=425.025n

.meas tran vdout0_73ck840 FIND v(dout0_73) AT=425.025n

.meas tran vdout0_74ck840 FIND v(dout0_74) AT=425.025n

.meas tran vdout0_75ck840 FIND v(dout0_75) AT=425.025n

.meas tran vdout0_76ck840 FIND v(dout0_76) AT=425.025n

.meas tran vdout0_77ck840 FIND v(dout0_77) AT=425.025n

.meas tran vdout0_78ck840 FIND v(dout0_78) AT=425.025n

.meas tran vdout0_79ck840 FIND v(dout0_79) AT=425.025n

.meas tran vdout0_80ck840 FIND v(dout0_80) AT=425.025n

.meas tran vdout0_81ck840 FIND v(dout0_81) AT=425.025n

.meas tran vdout0_82ck840 FIND v(dout0_82) AT=425.025n

.meas tran vdout0_83ck840 FIND v(dout0_83) AT=425.025n

.meas tran vdout0_84ck840 FIND v(dout0_84) AT=425.025n

.meas tran vdout0_85ck840 FIND v(dout0_85) AT=425.025n

.meas tran vdout0_86ck840 FIND v(dout0_86) AT=425.025n

.meas tran vdout0_87ck840 FIND v(dout0_87) AT=425.025n

.meas tran vdout0_88ck840 FIND v(dout0_88) AT=425.025n

.meas tran vdout0_89ck840 FIND v(dout0_89) AT=425.025n

.meas tran vdout0_90ck840 FIND v(dout0_90) AT=425.025n

.meas tran vdout0_91ck840 FIND v(dout0_91) AT=425.025n

.meas tran vdout0_92ck840 FIND v(dout0_92) AT=425.025n

.meas tran vdout0_93ck840 FIND v(dout0_93) AT=425.025n

.meas tran vdout0_94ck840 FIND v(dout0_94) AT=425.025n

.meas tran vdout0_95ck840 FIND v(dout0_95) AT=425.025n

.meas tran vdout0_96ck840 FIND v(dout0_96) AT=425.025n

.meas tran vdout0_97ck840 FIND v(dout0_97) AT=425.025n

.meas tran vdout0_98ck840 FIND v(dout0_98) AT=425.025n

.meas tran vdout0_99ck840 FIND v(dout0_99) AT=425.025n

.meas tran vdout0_100ck840 FIND v(dout0_100) AT=425.025n

.meas tran vdout0_101ck840 FIND v(dout0_101) AT=425.025n

.meas tran vdout0_102ck840 FIND v(dout0_102) AT=425.025n

.meas tran vdout0_103ck840 FIND v(dout0_103) AT=425.025n

.meas tran vdout0_104ck840 FIND v(dout0_104) AT=425.025n

.meas tran vdout0_105ck840 FIND v(dout0_105) AT=425.025n

.meas tran vdout0_106ck840 FIND v(dout0_106) AT=425.025n

.meas tran vdout0_107ck840 FIND v(dout0_107) AT=425.025n

.meas tran vdout0_108ck840 FIND v(dout0_108) AT=425.025n

.meas tran vdout0_109ck840 FIND v(dout0_109) AT=425.025n

.meas tran vdout0_110ck840 FIND v(dout0_110) AT=425.025n

.meas tran vdout0_111ck840 FIND v(dout0_111) AT=425.025n

.meas tran vdout0_112ck840 FIND v(dout0_112) AT=425.025n

.meas tran vdout0_113ck840 FIND v(dout0_113) AT=425.025n

.meas tran vdout0_114ck840 FIND v(dout0_114) AT=425.025n

.meas tran vdout0_115ck840 FIND v(dout0_115) AT=425.025n

.meas tran vdout0_116ck840 FIND v(dout0_116) AT=425.025n

.meas tran vdout0_117ck840 FIND v(dout0_117) AT=425.025n

.meas tran vdout0_118ck840 FIND v(dout0_118) AT=425.025n

.meas tran vdout0_119ck840 FIND v(dout0_119) AT=425.025n

.meas tran vdout0_120ck840 FIND v(dout0_120) AT=425.025n

.meas tran vdout0_121ck840 FIND v(dout0_121) AT=425.025n

.meas tran vdout0_122ck840 FIND v(dout0_122) AT=425.025n

.meas tran vdout0_123ck840 FIND v(dout0_123) AT=425.025n

.meas tran vdout0_124ck840 FIND v(dout0_124) AT=425.025n

.meas tran vdout0_125ck840 FIND v(dout0_125) AT=425.025n

.meas tran vdout0_126ck840 FIND v(dout0_126) AT=425.025n

.meas tran vdout0_127ck840 FIND v(dout0_127) AT=425.025n

.meas tran vdout0_0ck860 FIND v(dout0_0) AT=435.025n

.meas tran vdout0_1ck860 FIND v(dout0_1) AT=435.025n

.meas tran vdout0_2ck860 FIND v(dout0_2) AT=435.025n

.meas tran vdout0_3ck860 FIND v(dout0_3) AT=435.025n

.meas tran vdout0_4ck860 FIND v(dout0_4) AT=435.025n

.meas tran vdout0_5ck860 FIND v(dout0_5) AT=435.025n

.meas tran vdout0_6ck860 FIND v(dout0_6) AT=435.025n

.meas tran vdout0_7ck860 FIND v(dout0_7) AT=435.025n

.meas tran vdout0_8ck860 FIND v(dout0_8) AT=435.025n

.meas tran vdout0_9ck860 FIND v(dout0_9) AT=435.025n

.meas tran vdout0_10ck860 FIND v(dout0_10) AT=435.025n

.meas tran vdout0_11ck860 FIND v(dout0_11) AT=435.025n

.meas tran vdout0_12ck860 FIND v(dout0_12) AT=435.025n

.meas tran vdout0_13ck860 FIND v(dout0_13) AT=435.025n

.meas tran vdout0_14ck860 FIND v(dout0_14) AT=435.025n

.meas tran vdout0_15ck860 FIND v(dout0_15) AT=435.025n

.meas tran vdout0_16ck860 FIND v(dout0_16) AT=435.025n

.meas tran vdout0_17ck860 FIND v(dout0_17) AT=435.025n

.meas tran vdout0_18ck860 FIND v(dout0_18) AT=435.025n

.meas tran vdout0_19ck860 FIND v(dout0_19) AT=435.025n

.meas tran vdout0_20ck860 FIND v(dout0_20) AT=435.025n

.meas tran vdout0_21ck860 FIND v(dout0_21) AT=435.025n

.meas tran vdout0_22ck860 FIND v(dout0_22) AT=435.025n

.meas tran vdout0_23ck860 FIND v(dout0_23) AT=435.025n

.meas tran vdout0_24ck860 FIND v(dout0_24) AT=435.025n

.meas tran vdout0_25ck860 FIND v(dout0_25) AT=435.025n

.meas tran vdout0_26ck860 FIND v(dout0_26) AT=435.025n

.meas tran vdout0_27ck860 FIND v(dout0_27) AT=435.025n

.meas tran vdout0_28ck860 FIND v(dout0_28) AT=435.025n

.meas tran vdout0_29ck860 FIND v(dout0_29) AT=435.025n

.meas tran vdout0_30ck860 FIND v(dout0_30) AT=435.025n

.meas tran vdout0_31ck860 FIND v(dout0_31) AT=435.025n

.meas tran vdout0_32ck860 FIND v(dout0_32) AT=435.025n

.meas tran vdout0_33ck860 FIND v(dout0_33) AT=435.025n

.meas tran vdout0_34ck860 FIND v(dout0_34) AT=435.025n

.meas tran vdout0_35ck860 FIND v(dout0_35) AT=435.025n

.meas tran vdout0_36ck860 FIND v(dout0_36) AT=435.025n

.meas tran vdout0_37ck860 FIND v(dout0_37) AT=435.025n

.meas tran vdout0_38ck860 FIND v(dout0_38) AT=435.025n

.meas tran vdout0_39ck860 FIND v(dout0_39) AT=435.025n

.meas tran vdout0_40ck860 FIND v(dout0_40) AT=435.025n

.meas tran vdout0_41ck860 FIND v(dout0_41) AT=435.025n

.meas tran vdout0_42ck860 FIND v(dout0_42) AT=435.025n

.meas tran vdout0_43ck860 FIND v(dout0_43) AT=435.025n

.meas tran vdout0_44ck860 FIND v(dout0_44) AT=435.025n

.meas tran vdout0_45ck860 FIND v(dout0_45) AT=435.025n

.meas tran vdout0_46ck860 FIND v(dout0_46) AT=435.025n

.meas tran vdout0_47ck860 FIND v(dout0_47) AT=435.025n

.meas tran vdout0_48ck860 FIND v(dout0_48) AT=435.025n

.meas tran vdout0_49ck860 FIND v(dout0_49) AT=435.025n

.meas tran vdout0_50ck860 FIND v(dout0_50) AT=435.025n

.meas tran vdout0_51ck860 FIND v(dout0_51) AT=435.025n

.meas tran vdout0_52ck860 FIND v(dout0_52) AT=435.025n

.meas tran vdout0_53ck860 FIND v(dout0_53) AT=435.025n

.meas tran vdout0_54ck860 FIND v(dout0_54) AT=435.025n

.meas tran vdout0_55ck860 FIND v(dout0_55) AT=435.025n

.meas tran vdout0_56ck860 FIND v(dout0_56) AT=435.025n

.meas tran vdout0_57ck860 FIND v(dout0_57) AT=435.025n

.meas tran vdout0_58ck860 FIND v(dout0_58) AT=435.025n

.meas tran vdout0_59ck860 FIND v(dout0_59) AT=435.025n

.meas tran vdout0_60ck860 FIND v(dout0_60) AT=435.025n

.meas tran vdout0_61ck860 FIND v(dout0_61) AT=435.025n

.meas tran vdout0_62ck860 FIND v(dout0_62) AT=435.025n

.meas tran vdout0_63ck860 FIND v(dout0_63) AT=435.025n

.meas tran vdout0_64ck860 FIND v(dout0_64) AT=435.025n

.meas tran vdout0_65ck860 FIND v(dout0_65) AT=435.025n

.meas tran vdout0_66ck860 FIND v(dout0_66) AT=435.025n

.meas tran vdout0_67ck860 FIND v(dout0_67) AT=435.025n

.meas tran vdout0_68ck860 FIND v(dout0_68) AT=435.025n

.meas tran vdout0_69ck860 FIND v(dout0_69) AT=435.025n

.meas tran vdout0_70ck860 FIND v(dout0_70) AT=435.025n

.meas tran vdout0_71ck860 FIND v(dout0_71) AT=435.025n

.meas tran vdout0_72ck860 FIND v(dout0_72) AT=435.025n

.meas tran vdout0_73ck860 FIND v(dout0_73) AT=435.025n

.meas tran vdout0_74ck860 FIND v(dout0_74) AT=435.025n

.meas tran vdout0_75ck860 FIND v(dout0_75) AT=435.025n

.meas tran vdout0_76ck860 FIND v(dout0_76) AT=435.025n

.meas tran vdout0_77ck860 FIND v(dout0_77) AT=435.025n

.meas tran vdout0_78ck860 FIND v(dout0_78) AT=435.025n

.meas tran vdout0_79ck860 FIND v(dout0_79) AT=435.025n

.meas tran vdout0_80ck860 FIND v(dout0_80) AT=435.025n

.meas tran vdout0_81ck860 FIND v(dout0_81) AT=435.025n

.meas tran vdout0_82ck860 FIND v(dout0_82) AT=435.025n

.meas tran vdout0_83ck860 FIND v(dout0_83) AT=435.025n

.meas tran vdout0_84ck860 FIND v(dout0_84) AT=435.025n

.meas tran vdout0_85ck860 FIND v(dout0_85) AT=435.025n

.meas tran vdout0_86ck860 FIND v(dout0_86) AT=435.025n

.meas tran vdout0_87ck860 FIND v(dout0_87) AT=435.025n

.meas tran vdout0_88ck860 FIND v(dout0_88) AT=435.025n

.meas tran vdout0_89ck860 FIND v(dout0_89) AT=435.025n

.meas tran vdout0_90ck860 FIND v(dout0_90) AT=435.025n

.meas tran vdout0_91ck860 FIND v(dout0_91) AT=435.025n

.meas tran vdout0_92ck860 FIND v(dout0_92) AT=435.025n

.meas tran vdout0_93ck860 FIND v(dout0_93) AT=435.025n

.meas tran vdout0_94ck860 FIND v(dout0_94) AT=435.025n

.meas tran vdout0_95ck860 FIND v(dout0_95) AT=435.025n

.meas tran vdout0_96ck860 FIND v(dout0_96) AT=435.025n

.meas tran vdout0_97ck860 FIND v(dout0_97) AT=435.025n

.meas tran vdout0_98ck860 FIND v(dout0_98) AT=435.025n

.meas tran vdout0_99ck860 FIND v(dout0_99) AT=435.025n

.meas tran vdout0_100ck860 FIND v(dout0_100) AT=435.025n

.meas tran vdout0_101ck860 FIND v(dout0_101) AT=435.025n

.meas tran vdout0_102ck860 FIND v(dout0_102) AT=435.025n

.meas tran vdout0_103ck860 FIND v(dout0_103) AT=435.025n

.meas tran vdout0_104ck860 FIND v(dout0_104) AT=435.025n

.meas tran vdout0_105ck860 FIND v(dout0_105) AT=435.025n

.meas tran vdout0_106ck860 FIND v(dout0_106) AT=435.025n

.meas tran vdout0_107ck860 FIND v(dout0_107) AT=435.025n

.meas tran vdout0_108ck860 FIND v(dout0_108) AT=435.025n

.meas tran vdout0_109ck860 FIND v(dout0_109) AT=435.025n

.meas tran vdout0_110ck860 FIND v(dout0_110) AT=435.025n

.meas tran vdout0_111ck860 FIND v(dout0_111) AT=435.025n

.meas tran vdout0_112ck860 FIND v(dout0_112) AT=435.025n

.meas tran vdout0_113ck860 FIND v(dout0_113) AT=435.025n

.meas tran vdout0_114ck860 FIND v(dout0_114) AT=435.025n

.meas tran vdout0_115ck860 FIND v(dout0_115) AT=435.025n

.meas tran vdout0_116ck860 FIND v(dout0_116) AT=435.025n

.meas tran vdout0_117ck860 FIND v(dout0_117) AT=435.025n

.meas tran vdout0_118ck860 FIND v(dout0_118) AT=435.025n

.meas tran vdout0_119ck860 FIND v(dout0_119) AT=435.025n

.meas tran vdout0_120ck860 FIND v(dout0_120) AT=435.025n

.meas tran vdout0_121ck860 FIND v(dout0_121) AT=435.025n

.meas tran vdout0_122ck860 FIND v(dout0_122) AT=435.025n

.meas tran vdout0_123ck860 FIND v(dout0_123) AT=435.025n

.meas tran vdout0_124ck860 FIND v(dout0_124) AT=435.025n

.meas tran vdout0_125ck860 FIND v(dout0_125) AT=435.025n

.meas tran vdout0_126ck860 FIND v(dout0_126) AT=435.025n

.meas tran vdout0_127ck860 FIND v(dout0_127) AT=435.025n

.meas tran vdout0_0ck890 FIND v(dout0_0) AT=450.025n

.meas tran vdout0_1ck890 FIND v(dout0_1) AT=450.025n

.meas tran vdout0_2ck890 FIND v(dout0_2) AT=450.025n

.meas tran vdout0_3ck890 FIND v(dout0_3) AT=450.025n

.meas tran vdout0_4ck890 FIND v(dout0_4) AT=450.025n

.meas tran vdout0_5ck890 FIND v(dout0_5) AT=450.025n

.meas tran vdout0_6ck890 FIND v(dout0_6) AT=450.025n

.meas tran vdout0_7ck890 FIND v(dout0_7) AT=450.025n

.meas tran vdout0_8ck890 FIND v(dout0_8) AT=450.025n

.meas tran vdout0_9ck890 FIND v(dout0_9) AT=450.025n

.meas tran vdout0_10ck890 FIND v(dout0_10) AT=450.025n

.meas tran vdout0_11ck890 FIND v(dout0_11) AT=450.025n

.meas tran vdout0_12ck890 FIND v(dout0_12) AT=450.025n

.meas tran vdout0_13ck890 FIND v(dout0_13) AT=450.025n

.meas tran vdout0_14ck890 FIND v(dout0_14) AT=450.025n

.meas tran vdout0_15ck890 FIND v(dout0_15) AT=450.025n

.meas tran vdout0_16ck890 FIND v(dout0_16) AT=450.025n

.meas tran vdout0_17ck890 FIND v(dout0_17) AT=450.025n

.meas tran vdout0_18ck890 FIND v(dout0_18) AT=450.025n

.meas tran vdout0_19ck890 FIND v(dout0_19) AT=450.025n

.meas tran vdout0_20ck890 FIND v(dout0_20) AT=450.025n

.meas tran vdout0_21ck890 FIND v(dout0_21) AT=450.025n

.meas tran vdout0_22ck890 FIND v(dout0_22) AT=450.025n

.meas tran vdout0_23ck890 FIND v(dout0_23) AT=450.025n

.meas tran vdout0_24ck890 FIND v(dout0_24) AT=450.025n

.meas tran vdout0_25ck890 FIND v(dout0_25) AT=450.025n

.meas tran vdout0_26ck890 FIND v(dout0_26) AT=450.025n

.meas tran vdout0_27ck890 FIND v(dout0_27) AT=450.025n

.meas tran vdout0_28ck890 FIND v(dout0_28) AT=450.025n

.meas tran vdout0_29ck890 FIND v(dout0_29) AT=450.025n

.meas tran vdout0_30ck890 FIND v(dout0_30) AT=450.025n

.meas tran vdout0_31ck890 FIND v(dout0_31) AT=450.025n

.meas tran vdout0_32ck890 FIND v(dout0_32) AT=450.025n

.meas tran vdout0_33ck890 FIND v(dout0_33) AT=450.025n

.meas tran vdout0_34ck890 FIND v(dout0_34) AT=450.025n

.meas tran vdout0_35ck890 FIND v(dout0_35) AT=450.025n

.meas tran vdout0_36ck890 FIND v(dout0_36) AT=450.025n

.meas tran vdout0_37ck890 FIND v(dout0_37) AT=450.025n

.meas tran vdout0_38ck890 FIND v(dout0_38) AT=450.025n

.meas tran vdout0_39ck890 FIND v(dout0_39) AT=450.025n

.meas tran vdout0_40ck890 FIND v(dout0_40) AT=450.025n

.meas tran vdout0_41ck890 FIND v(dout0_41) AT=450.025n

.meas tran vdout0_42ck890 FIND v(dout0_42) AT=450.025n

.meas tran vdout0_43ck890 FIND v(dout0_43) AT=450.025n

.meas tran vdout0_44ck890 FIND v(dout0_44) AT=450.025n

.meas tran vdout0_45ck890 FIND v(dout0_45) AT=450.025n

.meas tran vdout0_46ck890 FIND v(dout0_46) AT=450.025n

.meas tran vdout0_47ck890 FIND v(dout0_47) AT=450.025n

.meas tran vdout0_48ck890 FIND v(dout0_48) AT=450.025n

.meas tran vdout0_49ck890 FIND v(dout0_49) AT=450.025n

.meas tran vdout0_50ck890 FIND v(dout0_50) AT=450.025n

.meas tran vdout0_51ck890 FIND v(dout0_51) AT=450.025n

.meas tran vdout0_52ck890 FIND v(dout0_52) AT=450.025n

.meas tran vdout0_53ck890 FIND v(dout0_53) AT=450.025n

.meas tran vdout0_54ck890 FIND v(dout0_54) AT=450.025n

.meas tran vdout0_55ck890 FIND v(dout0_55) AT=450.025n

.meas tran vdout0_56ck890 FIND v(dout0_56) AT=450.025n

.meas tran vdout0_57ck890 FIND v(dout0_57) AT=450.025n

.meas tran vdout0_58ck890 FIND v(dout0_58) AT=450.025n

.meas tran vdout0_59ck890 FIND v(dout0_59) AT=450.025n

.meas tran vdout0_60ck890 FIND v(dout0_60) AT=450.025n

.meas tran vdout0_61ck890 FIND v(dout0_61) AT=450.025n

.meas tran vdout0_62ck890 FIND v(dout0_62) AT=450.025n

.meas tran vdout0_63ck890 FIND v(dout0_63) AT=450.025n

.meas tran vdout0_64ck890 FIND v(dout0_64) AT=450.025n

.meas tran vdout0_65ck890 FIND v(dout0_65) AT=450.025n

.meas tran vdout0_66ck890 FIND v(dout0_66) AT=450.025n

.meas tran vdout0_67ck890 FIND v(dout0_67) AT=450.025n

.meas tran vdout0_68ck890 FIND v(dout0_68) AT=450.025n

.meas tran vdout0_69ck890 FIND v(dout0_69) AT=450.025n

.meas tran vdout0_70ck890 FIND v(dout0_70) AT=450.025n

.meas tran vdout0_71ck890 FIND v(dout0_71) AT=450.025n

.meas tran vdout0_72ck890 FIND v(dout0_72) AT=450.025n

.meas tran vdout0_73ck890 FIND v(dout0_73) AT=450.025n

.meas tran vdout0_74ck890 FIND v(dout0_74) AT=450.025n

.meas tran vdout0_75ck890 FIND v(dout0_75) AT=450.025n

.meas tran vdout0_76ck890 FIND v(dout0_76) AT=450.025n

.meas tran vdout0_77ck890 FIND v(dout0_77) AT=450.025n

.meas tran vdout0_78ck890 FIND v(dout0_78) AT=450.025n

.meas tran vdout0_79ck890 FIND v(dout0_79) AT=450.025n

.meas tran vdout0_80ck890 FIND v(dout0_80) AT=450.025n

.meas tran vdout0_81ck890 FIND v(dout0_81) AT=450.025n

.meas tran vdout0_82ck890 FIND v(dout0_82) AT=450.025n

.meas tran vdout0_83ck890 FIND v(dout0_83) AT=450.025n

.meas tran vdout0_84ck890 FIND v(dout0_84) AT=450.025n

.meas tran vdout0_85ck890 FIND v(dout0_85) AT=450.025n

.meas tran vdout0_86ck890 FIND v(dout0_86) AT=450.025n

.meas tran vdout0_87ck890 FIND v(dout0_87) AT=450.025n

.meas tran vdout0_88ck890 FIND v(dout0_88) AT=450.025n

.meas tran vdout0_89ck890 FIND v(dout0_89) AT=450.025n

.meas tran vdout0_90ck890 FIND v(dout0_90) AT=450.025n

.meas tran vdout0_91ck890 FIND v(dout0_91) AT=450.025n

.meas tran vdout0_92ck890 FIND v(dout0_92) AT=450.025n

.meas tran vdout0_93ck890 FIND v(dout0_93) AT=450.025n

.meas tran vdout0_94ck890 FIND v(dout0_94) AT=450.025n

.meas tran vdout0_95ck890 FIND v(dout0_95) AT=450.025n

.meas tran vdout0_96ck890 FIND v(dout0_96) AT=450.025n

.meas tran vdout0_97ck890 FIND v(dout0_97) AT=450.025n

.meas tran vdout0_98ck890 FIND v(dout0_98) AT=450.025n

.meas tran vdout0_99ck890 FIND v(dout0_99) AT=450.025n

.meas tran vdout0_100ck890 FIND v(dout0_100) AT=450.025n

.meas tran vdout0_101ck890 FIND v(dout0_101) AT=450.025n

.meas tran vdout0_102ck890 FIND v(dout0_102) AT=450.025n

.meas tran vdout0_103ck890 FIND v(dout0_103) AT=450.025n

.meas tran vdout0_104ck890 FIND v(dout0_104) AT=450.025n

.meas tran vdout0_105ck890 FIND v(dout0_105) AT=450.025n

.meas tran vdout0_106ck890 FIND v(dout0_106) AT=450.025n

.meas tran vdout0_107ck890 FIND v(dout0_107) AT=450.025n

.meas tran vdout0_108ck890 FIND v(dout0_108) AT=450.025n

.meas tran vdout0_109ck890 FIND v(dout0_109) AT=450.025n

.meas tran vdout0_110ck890 FIND v(dout0_110) AT=450.025n

.meas tran vdout0_111ck890 FIND v(dout0_111) AT=450.025n

.meas tran vdout0_112ck890 FIND v(dout0_112) AT=450.025n

.meas tran vdout0_113ck890 FIND v(dout0_113) AT=450.025n

.meas tran vdout0_114ck890 FIND v(dout0_114) AT=450.025n

.meas tran vdout0_115ck890 FIND v(dout0_115) AT=450.025n

.meas tran vdout0_116ck890 FIND v(dout0_116) AT=450.025n

.meas tran vdout0_117ck890 FIND v(dout0_117) AT=450.025n

.meas tran vdout0_118ck890 FIND v(dout0_118) AT=450.025n

.meas tran vdout0_119ck890 FIND v(dout0_119) AT=450.025n

.meas tran vdout0_120ck890 FIND v(dout0_120) AT=450.025n

.meas tran vdout0_121ck890 FIND v(dout0_121) AT=450.025n

.meas tran vdout0_122ck890 FIND v(dout0_122) AT=450.025n

.meas tran vdout0_123ck890 FIND v(dout0_123) AT=450.025n

.meas tran vdout0_124ck890 FIND v(dout0_124) AT=450.025n

.meas tran vdout0_125ck890 FIND v(dout0_125) AT=450.025n

.meas tran vdout0_126ck890 FIND v(dout0_126) AT=450.025n

.meas tran vdout0_127ck890 FIND v(dout0_127) AT=450.025n

.meas tran vdout0_0ck960 FIND v(dout0_0) AT=485.025n

.meas tran vdout0_1ck960 FIND v(dout0_1) AT=485.025n

.meas tran vdout0_2ck960 FIND v(dout0_2) AT=485.025n

.meas tran vdout0_3ck960 FIND v(dout0_3) AT=485.025n

.meas tran vdout0_4ck960 FIND v(dout0_4) AT=485.025n

.meas tran vdout0_5ck960 FIND v(dout0_5) AT=485.025n

.meas tran vdout0_6ck960 FIND v(dout0_6) AT=485.025n

.meas tran vdout0_7ck960 FIND v(dout0_7) AT=485.025n

.meas tran vdout0_8ck960 FIND v(dout0_8) AT=485.025n

.meas tran vdout0_9ck960 FIND v(dout0_9) AT=485.025n

.meas tran vdout0_10ck960 FIND v(dout0_10) AT=485.025n

.meas tran vdout0_11ck960 FIND v(dout0_11) AT=485.025n

.meas tran vdout0_12ck960 FIND v(dout0_12) AT=485.025n

.meas tran vdout0_13ck960 FIND v(dout0_13) AT=485.025n

.meas tran vdout0_14ck960 FIND v(dout0_14) AT=485.025n

.meas tran vdout0_15ck960 FIND v(dout0_15) AT=485.025n

.meas tran vdout0_16ck960 FIND v(dout0_16) AT=485.025n

.meas tran vdout0_17ck960 FIND v(dout0_17) AT=485.025n

.meas tran vdout0_18ck960 FIND v(dout0_18) AT=485.025n

.meas tran vdout0_19ck960 FIND v(dout0_19) AT=485.025n

.meas tran vdout0_20ck960 FIND v(dout0_20) AT=485.025n

.meas tran vdout0_21ck960 FIND v(dout0_21) AT=485.025n

.meas tran vdout0_22ck960 FIND v(dout0_22) AT=485.025n

.meas tran vdout0_23ck960 FIND v(dout0_23) AT=485.025n

.meas tran vdout0_24ck960 FIND v(dout0_24) AT=485.025n

.meas tran vdout0_25ck960 FIND v(dout0_25) AT=485.025n

.meas tran vdout0_26ck960 FIND v(dout0_26) AT=485.025n

.meas tran vdout0_27ck960 FIND v(dout0_27) AT=485.025n

.meas tran vdout0_28ck960 FIND v(dout0_28) AT=485.025n

.meas tran vdout0_29ck960 FIND v(dout0_29) AT=485.025n

.meas tran vdout0_30ck960 FIND v(dout0_30) AT=485.025n

.meas tran vdout0_31ck960 FIND v(dout0_31) AT=485.025n

.meas tran vdout0_32ck960 FIND v(dout0_32) AT=485.025n

.meas tran vdout0_33ck960 FIND v(dout0_33) AT=485.025n

.meas tran vdout0_34ck960 FIND v(dout0_34) AT=485.025n

.meas tran vdout0_35ck960 FIND v(dout0_35) AT=485.025n

.meas tran vdout0_36ck960 FIND v(dout0_36) AT=485.025n

.meas tran vdout0_37ck960 FIND v(dout0_37) AT=485.025n

.meas tran vdout0_38ck960 FIND v(dout0_38) AT=485.025n

.meas tran vdout0_39ck960 FIND v(dout0_39) AT=485.025n

.meas tran vdout0_40ck960 FIND v(dout0_40) AT=485.025n

.meas tran vdout0_41ck960 FIND v(dout0_41) AT=485.025n

.meas tran vdout0_42ck960 FIND v(dout0_42) AT=485.025n

.meas tran vdout0_43ck960 FIND v(dout0_43) AT=485.025n

.meas tran vdout0_44ck960 FIND v(dout0_44) AT=485.025n

.meas tran vdout0_45ck960 FIND v(dout0_45) AT=485.025n

.meas tran vdout0_46ck960 FIND v(dout0_46) AT=485.025n

.meas tran vdout0_47ck960 FIND v(dout0_47) AT=485.025n

.meas tran vdout0_48ck960 FIND v(dout0_48) AT=485.025n

.meas tran vdout0_49ck960 FIND v(dout0_49) AT=485.025n

.meas tran vdout0_50ck960 FIND v(dout0_50) AT=485.025n

.meas tran vdout0_51ck960 FIND v(dout0_51) AT=485.025n

.meas tran vdout0_52ck960 FIND v(dout0_52) AT=485.025n

.meas tran vdout0_53ck960 FIND v(dout0_53) AT=485.025n

.meas tran vdout0_54ck960 FIND v(dout0_54) AT=485.025n

.meas tran vdout0_55ck960 FIND v(dout0_55) AT=485.025n

.meas tran vdout0_56ck960 FIND v(dout0_56) AT=485.025n

.meas tran vdout0_57ck960 FIND v(dout0_57) AT=485.025n

.meas tran vdout0_58ck960 FIND v(dout0_58) AT=485.025n

.meas tran vdout0_59ck960 FIND v(dout0_59) AT=485.025n

.meas tran vdout0_60ck960 FIND v(dout0_60) AT=485.025n

.meas tran vdout0_61ck960 FIND v(dout0_61) AT=485.025n

.meas tran vdout0_62ck960 FIND v(dout0_62) AT=485.025n

.meas tran vdout0_63ck960 FIND v(dout0_63) AT=485.025n

.meas tran vdout0_64ck960 FIND v(dout0_64) AT=485.025n

.meas tran vdout0_65ck960 FIND v(dout0_65) AT=485.025n

.meas tran vdout0_66ck960 FIND v(dout0_66) AT=485.025n

.meas tran vdout0_67ck960 FIND v(dout0_67) AT=485.025n

.meas tran vdout0_68ck960 FIND v(dout0_68) AT=485.025n

.meas tran vdout0_69ck960 FIND v(dout0_69) AT=485.025n

.meas tran vdout0_70ck960 FIND v(dout0_70) AT=485.025n

.meas tran vdout0_71ck960 FIND v(dout0_71) AT=485.025n

.meas tran vdout0_72ck960 FIND v(dout0_72) AT=485.025n

.meas tran vdout0_73ck960 FIND v(dout0_73) AT=485.025n

.meas tran vdout0_74ck960 FIND v(dout0_74) AT=485.025n

.meas tran vdout0_75ck960 FIND v(dout0_75) AT=485.025n

.meas tran vdout0_76ck960 FIND v(dout0_76) AT=485.025n

.meas tran vdout0_77ck960 FIND v(dout0_77) AT=485.025n

.meas tran vdout0_78ck960 FIND v(dout0_78) AT=485.025n

.meas tran vdout0_79ck960 FIND v(dout0_79) AT=485.025n

.meas tran vdout0_80ck960 FIND v(dout0_80) AT=485.025n

.meas tran vdout0_81ck960 FIND v(dout0_81) AT=485.025n

.meas tran vdout0_82ck960 FIND v(dout0_82) AT=485.025n

.meas tran vdout0_83ck960 FIND v(dout0_83) AT=485.025n

.meas tran vdout0_84ck960 FIND v(dout0_84) AT=485.025n

.meas tran vdout0_85ck960 FIND v(dout0_85) AT=485.025n

.meas tran vdout0_86ck960 FIND v(dout0_86) AT=485.025n

.meas tran vdout0_87ck960 FIND v(dout0_87) AT=485.025n

.meas tran vdout0_88ck960 FIND v(dout0_88) AT=485.025n

.meas tran vdout0_89ck960 FIND v(dout0_89) AT=485.025n

.meas tran vdout0_90ck960 FIND v(dout0_90) AT=485.025n

.meas tran vdout0_91ck960 FIND v(dout0_91) AT=485.025n

.meas tran vdout0_92ck960 FIND v(dout0_92) AT=485.025n

.meas tran vdout0_93ck960 FIND v(dout0_93) AT=485.025n

.meas tran vdout0_94ck960 FIND v(dout0_94) AT=485.025n

.meas tran vdout0_95ck960 FIND v(dout0_95) AT=485.025n

.meas tran vdout0_96ck960 FIND v(dout0_96) AT=485.025n

.meas tran vdout0_97ck960 FIND v(dout0_97) AT=485.025n

.meas tran vdout0_98ck960 FIND v(dout0_98) AT=485.025n

.meas tran vdout0_99ck960 FIND v(dout0_99) AT=485.025n

.meas tran vdout0_100ck960 FIND v(dout0_100) AT=485.025n

.meas tran vdout0_101ck960 FIND v(dout0_101) AT=485.025n

.meas tran vdout0_102ck960 FIND v(dout0_102) AT=485.025n

.meas tran vdout0_103ck960 FIND v(dout0_103) AT=485.025n

.meas tran vdout0_104ck960 FIND v(dout0_104) AT=485.025n

.meas tran vdout0_105ck960 FIND v(dout0_105) AT=485.025n

.meas tran vdout0_106ck960 FIND v(dout0_106) AT=485.025n

.meas tran vdout0_107ck960 FIND v(dout0_107) AT=485.025n

.meas tran vdout0_108ck960 FIND v(dout0_108) AT=485.025n

.meas tran vdout0_109ck960 FIND v(dout0_109) AT=485.025n

.meas tran vdout0_110ck960 FIND v(dout0_110) AT=485.025n

.meas tran vdout0_111ck960 FIND v(dout0_111) AT=485.025n

.meas tran vdout0_112ck960 FIND v(dout0_112) AT=485.025n

.meas tran vdout0_113ck960 FIND v(dout0_113) AT=485.025n

.meas tran vdout0_114ck960 FIND v(dout0_114) AT=485.025n

.meas tran vdout0_115ck960 FIND v(dout0_115) AT=485.025n

.meas tran vdout0_116ck960 FIND v(dout0_116) AT=485.025n

.meas tran vdout0_117ck960 FIND v(dout0_117) AT=485.025n

.meas tran vdout0_118ck960 FIND v(dout0_118) AT=485.025n

.meas tran vdout0_119ck960 FIND v(dout0_119) AT=485.025n

.meas tran vdout0_120ck960 FIND v(dout0_120) AT=485.025n

.meas tran vdout0_121ck960 FIND v(dout0_121) AT=485.025n

.meas tran vdout0_122ck960 FIND v(dout0_122) AT=485.025n

.meas tran vdout0_123ck960 FIND v(dout0_123) AT=485.025n

.meas tran vdout0_124ck960 FIND v(dout0_124) AT=485.025n

.meas tran vdout0_125ck960 FIND v(dout0_125) AT=485.025n

.meas tran vdout0_126ck960 FIND v(dout0_126) AT=485.025n

.meas tran vdout0_127ck960 FIND v(dout0_127) AT=485.025n

.meas tran vdout0_0ck980 FIND v(dout0_0) AT=495.025n

.meas tran vdout0_1ck980 FIND v(dout0_1) AT=495.025n

.meas tran vdout0_2ck980 FIND v(dout0_2) AT=495.025n

.meas tran vdout0_3ck980 FIND v(dout0_3) AT=495.025n

.meas tran vdout0_4ck980 FIND v(dout0_4) AT=495.025n

.meas tran vdout0_5ck980 FIND v(dout0_5) AT=495.025n

.meas tran vdout0_6ck980 FIND v(dout0_6) AT=495.025n

.meas tran vdout0_7ck980 FIND v(dout0_7) AT=495.025n

.meas tran vdout0_8ck980 FIND v(dout0_8) AT=495.025n

.meas tran vdout0_9ck980 FIND v(dout0_9) AT=495.025n

.meas tran vdout0_10ck980 FIND v(dout0_10) AT=495.025n

.meas tran vdout0_11ck980 FIND v(dout0_11) AT=495.025n

.meas tran vdout0_12ck980 FIND v(dout0_12) AT=495.025n

.meas tran vdout0_13ck980 FIND v(dout0_13) AT=495.025n

.meas tran vdout0_14ck980 FIND v(dout0_14) AT=495.025n

.meas tran vdout0_15ck980 FIND v(dout0_15) AT=495.025n

.meas tran vdout0_16ck980 FIND v(dout0_16) AT=495.025n

.meas tran vdout0_17ck980 FIND v(dout0_17) AT=495.025n

.meas tran vdout0_18ck980 FIND v(dout0_18) AT=495.025n

.meas tran vdout0_19ck980 FIND v(dout0_19) AT=495.025n

.meas tran vdout0_20ck980 FIND v(dout0_20) AT=495.025n

.meas tran vdout0_21ck980 FIND v(dout0_21) AT=495.025n

.meas tran vdout0_22ck980 FIND v(dout0_22) AT=495.025n

.meas tran vdout0_23ck980 FIND v(dout0_23) AT=495.025n

.meas tran vdout0_24ck980 FIND v(dout0_24) AT=495.025n

.meas tran vdout0_25ck980 FIND v(dout0_25) AT=495.025n

.meas tran vdout0_26ck980 FIND v(dout0_26) AT=495.025n

.meas tran vdout0_27ck980 FIND v(dout0_27) AT=495.025n

.meas tran vdout0_28ck980 FIND v(dout0_28) AT=495.025n

.meas tran vdout0_29ck980 FIND v(dout0_29) AT=495.025n

.meas tran vdout0_30ck980 FIND v(dout0_30) AT=495.025n

.meas tran vdout0_31ck980 FIND v(dout0_31) AT=495.025n

.meas tran vdout0_32ck980 FIND v(dout0_32) AT=495.025n

.meas tran vdout0_33ck980 FIND v(dout0_33) AT=495.025n

.meas tran vdout0_34ck980 FIND v(dout0_34) AT=495.025n

.meas tran vdout0_35ck980 FIND v(dout0_35) AT=495.025n

.meas tran vdout0_36ck980 FIND v(dout0_36) AT=495.025n

.meas tran vdout0_37ck980 FIND v(dout0_37) AT=495.025n

.meas tran vdout0_38ck980 FIND v(dout0_38) AT=495.025n

.meas tran vdout0_39ck980 FIND v(dout0_39) AT=495.025n

.meas tran vdout0_40ck980 FIND v(dout0_40) AT=495.025n

.meas tran vdout0_41ck980 FIND v(dout0_41) AT=495.025n

.meas tran vdout0_42ck980 FIND v(dout0_42) AT=495.025n

.meas tran vdout0_43ck980 FIND v(dout0_43) AT=495.025n

.meas tran vdout0_44ck980 FIND v(dout0_44) AT=495.025n

.meas tran vdout0_45ck980 FIND v(dout0_45) AT=495.025n

.meas tran vdout0_46ck980 FIND v(dout0_46) AT=495.025n

.meas tran vdout0_47ck980 FIND v(dout0_47) AT=495.025n

.meas tran vdout0_48ck980 FIND v(dout0_48) AT=495.025n

.meas tran vdout0_49ck980 FIND v(dout0_49) AT=495.025n

.meas tran vdout0_50ck980 FIND v(dout0_50) AT=495.025n

.meas tran vdout0_51ck980 FIND v(dout0_51) AT=495.025n

.meas tran vdout0_52ck980 FIND v(dout0_52) AT=495.025n

.meas tran vdout0_53ck980 FIND v(dout0_53) AT=495.025n

.meas tran vdout0_54ck980 FIND v(dout0_54) AT=495.025n

.meas tran vdout0_55ck980 FIND v(dout0_55) AT=495.025n

.meas tran vdout0_56ck980 FIND v(dout0_56) AT=495.025n

.meas tran vdout0_57ck980 FIND v(dout0_57) AT=495.025n

.meas tran vdout0_58ck980 FIND v(dout0_58) AT=495.025n

.meas tran vdout0_59ck980 FIND v(dout0_59) AT=495.025n

.meas tran vdout0_60ck980 FIND v(dout0_60) AT=495.025n

.meas tran vdout0_61ck980 FIND v(dout0_61) AT=495.025n

.meas tran vdout0_62ck980 FIND v(dout0_62) AT=495.025n

.meas tran vdout0_63ck980 FIND v(dout0_63) AT=495.025n

.meas tran vdout0_64ck980 FIND v(dout0_64) AT=495.025n

.meas tran vdout0_65ck980 FIND v(dout0_65) AT=495.025n

.meas tran vdout0_66ck980 FIND v(dout0_66) AT=495.025n

.meas tran vdout0_67ck980 FIND v(dout0_67) AT=495.025n

.meas tran vdout0_68ck980 FIND v(dout0_68) AT=495.025n

.meas tran vdout0_69ck980 FIND v(dout0_69) AT=495.025n

.meas tran vdout0_70ck980 FIND v(dout0_70) AT=495.025n

.meas tran vdout0_71ck980 FIND v(dout0_71) AT=495.025n

.meas tran vdout0_72ck980 FIND v(dout0_72) AT=495.025n

.meas tran vdout0_73ck980 FIND v(dout0_73) AT=495.025n

.meas tran vdout0_74ck980 FIND v(dout0_74) AT=495.025n

.meas tran vdout0_75ck980 FIND v(dout0_75) AT=495.025n

.meas tran vdout0_76ck980 FIND v(dout0_76) AT=495.025n

.meas tran vdout0_77ck980 FIND v(dout0_77) AT=495.025n

.meas tran vdout0_78ck980 FIND v(dout0_78) AT=495.025n

.meas tran vdout0_79ck980 FIND v(dout0_79) AT=495.025n

.meas tran vdout0_80ck980 FIND v(dout0_80) AT=495.025n

.meas tran vdout0_81ck980 FIND v(dout0_81) AT=495.025n

.meas tran vdout0_82ck980 FIND v(dout0_82) AT=495.025n

.meas tran vdout0_83ck980 FIND v(dout0_83) AT=495.025n

.meas tran vdout0_84ck980 FIND v(dout0_84) AT=495.025n

.meas tran vdout0_85ck980 FIND v(dout0_85) AT=495.025n

.meas tran vdout0_86ck980 FIND v(dout0_86) AT=495.025n

.meas tran vdout0_87ck980 FIND v(dout0_87) AT=495.025n

.meas tran vdout0_88ck980 FIND v(dout0_88) AT=495.025n

.meas tran vdout0_89ck980 FIND v(dout0_89) AT=495.025n

.meas tran vdout0_90ck980 FIND v(dout0_90) AT=495.025n

.meas tran vdout0_91ck980 FIND v(dout0_91) AT=495.025n

.meas tran vdout0_92ck980 FIND v(dout0_92) AT=495.025n

.meas tran vdout0_93ck980 FIND v(dout0_93) AT=495.025n

.meas tran vdout0_94ck980 FIND v(dout0_94) AT=495.025n

.meas tran vdout0_95ck980 FIND v(dout0_95) AT=495.025n

.meas tran vdout0_96ck980 FIND v(dout0_96) AT=495.025n

.meas tran vdout0_97ck980 FIND v(dout0_97) AT=495.025n

.meas tran vdout0_98ck980 FIND v(dout0_98) AT=495.025n

.meas tran vdout0_99ck980 FIND v(dout0_99) AT=495.025n

.meas tran vdout0_100ck980 FIND v(dout0_100) AT=495.025n

.meas tran vdout0_101ck980 FIND v(dout0_101) AT=495.025n

.meas tran vdout0_102ck980 FIND v(dout0_102) AT=495.025n

.meas tran vdout0_103ck980 FIND v(dout0_103) AT=495.025n

.meas tran vdout0_104ck980 FIND v(dout0_104) AT=495.025n

.meas tran vdout0_105ck980 FIND v(dout0_105) AT=495.025n

.meas tran vdout0_106ck980 FIND v(dout0_106) AT=495.025n

.meas tran vdout0_107ck980 FIND v(dout0_107) AT=495.025n

.meas tran vdout0_108ck980 FIND v(dout0_108) AT=495.025n

.meas tran vdout0_109ck980 FIND v(dout0_109) AT=495.025n

.meas tran vdout0_110ck980 FIND v(dout0_110) AT=495.025n

.meas tran vdout0_111ck980 FIND v(dout0_111) AT=495.025n

.meas tran vdout0_112ck980 FIND v(dout0_112) AT=495.025n

.meas tran vdout0_113ck980 FIND v(dout0_113) AT=495.025n

.meas tran vdout0_114ck980 FIND v(dout0_114) AT=495.025n

.meas tran vdout0_115ck980 FIND v(dout0_115) AT=495.025n

.meas tran vdout0_116ck980 FIND v(dout0_116) AT=495.025n

.meas tran vdout0_117ck980 FIND v(dout0_117) AT=495.025n

.meas tran vdout0_118ck980 FIND v(dout0_118) AT=495.025n

.meas tran vdout0_119ck980 FIND v(dout0_119) AT=495.025n

.meas tran vdout0_120ck980 FIND v(dout0_120) AT=495.025n

.meas tran vdout0_121ck980 FIND v(dout0_121) AT=495.025n

.meas tran vdout0_122ck980 FIND v(dout0_122) AT=495.025n

.meas tran vdout0_123ck980 FIND v(dout0_123) AT=495.025n

.meas tran vdout0_124ck980 FIND v(dout0_124) AT=495.025n

.meas tran vdout0_125ck980 FIND v(dout0_125) AT=495.025n

.meas tran vdout0_126ck980 FIND v(dout0_126) AT=495.025n

.meas tran vdout0_127ck980 FIND v(dout0_127) AT=495.025n

.meas tran vdout0_0ck990 FIND v(dout0_0) AT=500.025n

.meas tran vdout0_1ck990 FIND v(dout0_1) AT=500.025n

.meas tran vdout0_2ck990 FIND v(dout0_2) AT=500.025n

.meas tran vdout0_3ck990 FIND v(dout0_3) AT=500.025n

.meas tran vdout0_4ck990 FIND v(dout0_4) AT=500.025n

.meas tran vdout0_5ck990 FIND v(dout0_5) AT=500.025n

.meas tran vdout0_6ck990 FIND v(dout0_6) AT=500.025n

.meas tran vdout0_7ck990 FIND v(dout0_7) AT=500.025n

.meas tran vdout0_8ck990 FIND v(dout0_8) AT=500.025n

.meas tran vdout0_9ck990 FIND v(dout0_9) AT=500.025n

.meas tran vdout0_10ck990 FIND v(dout0_10) AT=500.025n

.meas tran vdout0_11ck990 FIND v(dout0_11) AT=500.025n

.meas tran vdout0_12ck990 FIND v(dout0_12) AT=500.025n

.meas tran vdout0_13ck990 FIND v(dout0_13) AT=500.025n

.meas tran vdout0_14ck990 FIND v(dout0_14) AT=500.025n

.meas tran vdout0_15ck990 FIND v(dout0_15) AT=500.025n

.meas tran vdout0_16ck990 FIND v(dout0_16) AT=500.025n

.meas tran vdout0_17ck990 FIND v(dout0_17) AT=500.025n

.meas tran vdout0_18ck990 FIND v(dout0_18) AT=500.025n

.meas tran vdout0_19ck990 FIND v(dout0_19) AT=500.025n

.meas tran vdout0_20ck990 FIND v(dout0_20) AT=500.025n

.meas tran vdout0_21ck990 FIND v(dout0_21) AT=500.025n

.meas tran vdout0_22ck990 FIND v(dout0_22) AT=500.025n

.meas tran vdout0_23ck990 FIND v(dout0_23) AT=500.025n

.meas tran vdout0_24ck990 FIND v(dout0_24) AT=500.025n

.meas tran vdout0_25ck990 FIND v(dout0_25) AT=500.025n

.meas tran vdout0_26ck990 FIND v(dout0_26) AT=500.025n

.meas tran vdout0_27ck990 FIND v(dout0_27) AT=500.025n

.meas tran vdout0_28ck990 FIND v(dout0_28) AT=500.025n

.meas tran vdout0_29ck990 FIND v(dout0_29) AT=500.025n

.meas tran vdout0_30ck990 FIND v(dout0_30) AT=500.025n

.meas tran vdout0_31ck990 FIND v(dout0_31) AT=500.025n

.meas tran vdout0_32ck990 FIND v(dout0_32) AT=500.025n

.meas tran vdout0_33ck990 FIND v(dout0_33) AT=500.025n

.meas tran vdout0_34ck990 FIND v(dout0_34) AT=500.025n

.meas tran vdout0_35ck990 FIND v(dout0_35) AT=500.025n

.meas tran vdout0_36ck990 FIND v(dout0_36) AT=500.025n

.meas tran vdout0_37ck990 FIND v(dout0_37) AT=500.025n

.meas tran vdout0_38ck990 FIND v(dout0_38) AT=500.025n

.meas tran vdout0_39ck990 FIND v(dout0_39) AT=500.025n

.meas tran vdout0_40ck990 FIND v(dout0_40) AT=500.025n

.meas tran vdout0_41ck990 FIND v(dout0_41) AT=500.025n

.meas tran vdout0_42ck990 FIND v(dout0_42) AT=500.025n

.meas tran vdout0_43ck990 FIND v(dout0_43) AT=500.025n

.meas tran vdout0_44ck990 FIND v(dout0_44) AT=500.025n

.meas tran vdout0_45ck990 FIND v(dout0_45) AT=500.025n

.meas tran vdout0_46ck990 FIND v(dout0_46) AT=500.025n

.meas tran vdout0_47ck990 FIND v(dout0_47) AT=500.025n

.meas tran vdout0_48ck990 FIND v(dout0_48) AT=500.025n

.meas tran vdout0_49ck990 FIND v(dout0_49) AT=500.025n

.meas tran vdout0_50ck990 FIND v(dout0_50) AT=500.025n

.meas tran vdout0_51ck990 FIND v(dout0_51) AT=500.025n

.meas tran vdout0_52ck990 FIND v(dout0_52) AT=500.025n

.meas tran vdout0_53ck990 FIND v(dout0_53) AT=500.025n

.meas tran vdout0_54ck990 FIND v(dout0_54) AT=500.025n

.meas tran vdout0_55ck990 FIND v(dout0_55) AT=500.025n

.meas tran vdout0_56ck990 FIND v(dout0_56) AT=500.025n

.meas tran vdout0_57ck990 FIND v(dout0_57) AT=500.025n

.meas tran vdout0_58ck990 FIND v(dout0_58) AT=500.025n

.meas tran vdout0_59ck990 FIND v(dout0_59) AT=500.025n

.meas tran vdout0_60ck990 FIND v(dout0_60) AT=500.025n

.meas tran vdout0_61ck990 FIND v(dout0_61) AT=500.025n

.meas tran vdout0_62ck990 FIND v(dout0_62) AT=500.025n

.meas tran vdout0_63ck990 FIND v(dout0_63) AT=500.025n

.meas tran vdout0_64ck990 FIND v(dout0_64) AT=500.025n

.meas tran vdout0_65ck990 FIND v(dout0_65) AT=500.025n

.meas tran vdout0_66ck990 FIND v(dout0_66) AT=500.025n

.meas tran vdout0_67ck990 FIND v(dout0_67) AT=500.025n

.meas tran vdout0_68ck990 FIND v(dout0_68) AT=500.025n

.meas tran vdout0_69ck990 FIND v(dout0_69) AT=500.025n

.meas tran vdout0_70ck990 FIND v(dout0_70) AT=500.025n

.meas tran vdout0_71ck990 FIND v(dout0_71) AT=500.025n

.meas tran vdout0_72ck990 FIND v(dout0_72) AT=500.025n

.meas tran vdout0_73ck990 FIND v(dout0_73) AT=500.025n

.meas tran vdout0_74ck990 FIND v(dout0_74) AT=500.025n

.meas tran vdout0_75ck990 FIND v(dout0_75) AT=500.025n

.meas tran vdout0_76ck990 FIND v(dout0_76) AT=500.025n

.meas tran vdout0_77ck990 FIND v(dout0_77) AT=500.025n

.meas tran vdout0_78ck990 FIND v(dout0_78) AT=500.025n

.meas tran vdout0_79ck990 FIND v(dout0_79) AT=500.025n

.meas tran vdout0_80ck990 FIND v(dout0_80) AT=500.025n

.meas tran vdout0_81ck990 FIND v(dout0_81) AT=500.025n

.meas tran vdout0_82ck990 FIND v(dout0_82) AT=500.025n

.meas tran vdout0_83ck990 FIND v(dout0_83) AT=500.025n

.meas tran vdout0_84ck990 FIND v(dout0_84) AT=500.025n

.meas tran vdout0_85ck990 FIND v(dout0_85) AT=500.025n

.meas tran vdout0_86ck990 FIND v(dout0_86) AT=500.025n

.meas tran vdout0_87ck990 FIND v(dout0_87) AT=500.025n

.meas tran vdout0_88ck990 FIND v(dout0_88) AT=500.025n

.meas tran vdout0_89ck990 FIND v(dout0_89) AT=500.025n

.meas tran vdout0_90ck990 FIND v(dout0_90) AT=500.025n

.meas tran vdout0_91ck990 FIND v(dout0_91) AT=500.025n

.meas tran vdout0_92ck990 FIND v(dout0_92) AT=500.025n

.meas tran vdout0_93ck990 FIND v(dout0_93) AT=500.025n

.meas tran vdout0_94ck990 FIND v(dout0_94) AT=500.025n

.meas tran vdout0_95ck990 FIND v(dout0_95) AT=500.025n

.meas tran vdout0_96ck990 FIND v(dout0_96) AT=500.025n

.meas tran vdout0_97ck990 FIND v(dout0_97) AT=500.025n

.meas tran vdout0_98ck990 FIND v(dout0_98) AT=500.025n

.meas tran vdout0_99ck990 FIND v(dout0_99) AT=500.025n

.meas tran vdout0_100ck990 FIND v(dout0_100) AT=500.025n

.meas tran vdout0_101ck990 FIND v(dout0_101) AT=500.025n

.meas tran vdout0_102ck990 FIND v(dout0_102) AT=500.025n

.meas tran vdout0_103ck990 FIND v(dout0_103) AT=500.025n

.meas tran vdout0_104ck990 FIND v(dout0_104) AT=500.025n

.meas tran vdout0_105ck990 FIND v(dout0_105) AT=500.025n

.meas tran vdout0_106ck990 FIND v(dout0_106) AT=500.025n

.meas tran vdout0_107ck990 FIND v(dout0_107) AT=500.025n

.meas tran vdout0_108ck990 FIND v(dout0_108) AT=500.025n

.meas tran vdout0_109ck990 FIND v(dout0_109) AT=500.025n

.meas tran vdout0_110ck990 FIND v(dout0_110) AT=500.025n

.meas tran vdout0_111ck990 FIND v(dout0_111) AT=500.025n

.meas tran vdout0_112ck990 FIND v(dout0_112) AT=500.025n

.meas tran vdout0_113ck990 FIND v(dout0_113) AT=500.025n

.meas tran vdout0_114ck990 FIND v(dout0_114) AT=500.025n

.meas tran vdout0_115ck990 FIND v(dout0_115) AT=500.025n

.meas tran vdout0_116ck990 FIND v(dout0_116) AT=500.025n

.meas tran vdout0_117ck990 FIND v(dout0_117) AT=500.025n

.meas tran vdout0_118ck990 FIND v(dout0_118) AT=500.025n

.meas tran vdout0_119ck990 FIND v(dout0_119) AT=500.025n

.meas tran vdout0_120ck990 FIND v(dout0_120) AT=500.025n

.meas tran vdout0_121ck990 FIND v(dout0_121) AT=500.025n

.meas tran vdout0_122ck990 FIND v(dout0_122) AT=500.025n

.meas tran vdout0_123ck990 FIND v(dout0_123) AT=500.025n

.meas tran vdout0_124ck990 FIND v(dout0_124) AT=500.025n

.meas tran vdout0_125ck990 FIND v(dout0_125) AT=500.025n

.meas tran vdout0_126ck990 FIND v(dout0_126) AT=500.025n

.meas tran vdout0_127ck990 FIND v(dout0_127) AT=500.025n

.meas tran vdout0_0ck1080 FIND v(dout0_0) AT=545.025n

.meas tran vdout0_1ck1080 FIND v(dout0_1) AT=545.025n

.meas tran vdout0_2ck1080 FIND v(dout0_2) AT=545.025n

.meas tran vdout0_3ck1080 FIND v(dout0_3) AT=545.025n

.meas tran vdout0_4ck1080 FIND v(dout0_4) AT=545.025n

.meas tran vdout0_5ck1080 FIND v(dout0_5) AT=545.025n

.meas tran vdout0_6ck1080 FIND v(dout0_6) AT=545.025n

.meas tran vdout0_7ck1080 FIND v(dout0_7) AT=545.025n

.meas tran vdout0_8ck1080 FIND v(dout0_8) AT=545.025n

.meas tran vdout0_9ck1080 FIND v(dout0_9) AT=545.025n

.meas tran vdout0_10ck1080 FIND v(dout0_10) AT=545.025n

.meas tran vdout0_11ck1080 FIND v(dout0_11) AT=545.025n

.meas tran vdout0_12ck1080 FIND v(dout0_12) AT=545.025n

.meas tran vdout0_13ck1080 FIND v(dout0_13) AT=545.025n

.meas tran vdout0_14ck1080 FIND v(dout0_14) AT=545.025n

.meas tran vdout0_15ck1080 FIND v(dout0_15) AT=545.025n

.meas tran vdout0_16ck1080 FIND v(dout0_16) AT=545.025n

.meas tran vdout0_17ck1080 FIND v(dout0_17) AT=545.025n

.meas tran vdout0_18ck1080 FIND v(dout0_18) AT=545.025n

.meas tran vdout0_19ck1080 FIND v(dout0_19) AT=545.025n

.meas tran vdout0_20ck1080 FIND v(dout0_20) AT=545.025n

.meas tran vdout0_21ck1080 FIND v(dout0_21) AT=545.025n

.meas tran vdout0_22ck1080 FIND v(dout0_22) AT=545.025n

.meas tran vdout0_23ck1080 FIND v(dout0_23) AT=545.025n

.meas tran vdout0_24ck1080 FIND v(dout0_24) AT=545.025n

.meas tran vdout0_25ck1080 FIND v(dout0_25) AT=545.025n

.meas tran vdout0_26ck1080 FIND v(dout0_26) AT=545.025n

.meas tran vdout0_27ck1080 FIND v(dout0_27) AT=545.025n

.meas tran vdout0_28ck1080 FIND v(dout0_28) AT=545.025n

.meas tran vdout0_29ck1080 FIND v(dout0_29) AT=545.025n

.meas tran vdout0_30ck1080 FIND v(dout0_30) AT=545.025n

.meas tran vdout0_31ck1080 FIND v(dout0_31) AT=545.025n

.meas tran vdout0_32ck1080 FIND v(dout0_32) AT=545.025n

.meas tran vdout0_33ck1080 FIND v(dout0_33) AT=545.025n

.meas tran vdout0_34ck1080 FIND v(dout0_34) AT=545.025n

.meas tran vdout0_35ck1080 FIND v(dout0_35) AT=545.025n

.meas tran vdout0_36ck1080 FIND v(dout0_36) AT=545.025n

.meas tran vdout0_37ck1080 FIND v(dout0_37) AT=545.025n

.meas tran vdout0_38ck1080 FIND v(dout0_38) AT=545.025n

.meas tran vdout0_39ck1080 FIND v(dout0_39) AT=545.025n

.meas tran vdout0_40ck1080 FIND v(dout0_40) AT=545.025n

.meas tran vdout0_41ck1080 FIND v(dout0_41) AT=545.025n

.meas tran vdout0_42ck1080 FIND v(dout0_42) AT=545.025n

.meas tran vdout0_43ck1080 FIND v(dout0_43) AT=545.025n

.meas tran vdout0_44ck1080 FIND v(dout0_44) AT=545.025n

.meas tran vdout0_45ck1080 FIND v(dout0_45) AT=545.025n

.meas tran vdout0_46ck1080 FIND v(dout0_46) AT=545.025n

.meas tran vdout0_47ck1080 FIND v(dout0_47) AT=545.025n

.meas tran vdout0_48ck1080 FIND v(dout0_48) AT=545.025n

.meas tran vdout0_49ck1080 FIND v(dout0_49) AT=545.025n

.meas tran vdout0_50ck1080 FIND v(dout0_50) AT=545.025n

.meas tran vdout0_51ck1080 FIND v(dout0_51) AT=545.025n

.meas tran vdout0_52ck1080 FIND v(dout0_52) AT=545.025n

.meas tran vdout0_53ck1080 FIND v(dout0_53) AT=545.025n

.meas tran vdout0_54ck1080 FIND v(dout0_54) AT=545.025n

.meas tran vdout0_55ck1080 FIND v(dout0_55) AT=545.025n

.meas tran vdout0_56ck1080 FIND v(dout0_56) AT=545.025n

.meas tran vdout0_57ck1080 FIND v(dout0_57) AT=545.025n

.meas tran vdout0_58ck1080 FIND v(dout0_58) AT=545.025n

.meas tran vdout0_59ck1080 FIND v(dout0_59) AT=545.025n

.meas tran vdout0_60ck1080 FIND v(dout0_60) AT=545.025n

.meas tran vdout0_61ck1080 FIND v(dout0_61) AT=545.025n

.meas tran vdout0_62ck1080 FIND v(dout0_62) AT=545.025n

.meas tran vdout0_63ck1080 FIND v(dout0_63) AT=545.025n

.meas tran vdout0_64ck1080 FIND v(dout0_64) AT=545.025n

.meas tran vdout0_65ck1080 FIND v(dout0_65) AT=545.025n

.meas tran vdout0_66ck1080 FIND v(dout0_66) AT=545.025n

.meas tran vdout0_67ck1080 FIND v(dout0_67) AT=545.025n

.meas tran vdout0_68ck1080 FIND v(dout0_68) AT=545.025n

.meas tran vdout0_69ck1080 FIND v(dout0_69) AT=545.025n

.meas tran vdout0_70ck1080 FIND v(dout0_70) AT=545.025n

.meas tran vdout0_71ck1080 FIND v(dout0_71) AT=545.025n

.meas tran vdout0_72ck1080 FIND v(dout0_72) AT=545.025n

.meas tran vdout0_73ck1080 FIND v(dout0_73) AT=545.025n

.meas tran vdout0_74ck1080 FIND v(dout0_74) AT=545.025n

.meas tran vdout0_75ck1080 FIND v(dout0_75) AT=545.025n

.meas tran vdout0_76ck1080 FIND v(dout0_76) AT=545.025n

.meas tran vdout0_77ck1080 FIND v(dout0_77) AT=545.025n

.meas tran vdout0_78ck1080 FIND v(dout0_78) AT=545.025n

.meas tran vdout0_79ck1080 FIND v(dout0_79) AT=545.025n

.meas tran vdout0_80ck1080 FIND v(dout0_80) AT=545.025n

.meas tran vdout0_81ck1080 FIND v(dout0_81) AT=545.025n

.meas tran vdout0_82ck1080 FIND v(dout0_82) AT=545.025n

.meas tran vdout0_83ck1080 FIND v(dout0_83) AT=545.025n

.meas tran vdout0_84ck1080 FIND v(dout0_84) AT=545.025n

.meas tran vdout0_85ck1080 FIND v(dout0_85) AT=545.025n

.meas tran vdout0_86ck1080 FIND v(dout0_86) AT=545.025n

.meas tran vdout0_87ck1080 FIND v(dout0_87) AT=545.025n

.meas tran vdout0_88ck1080 FIND v(dout0_88) AT=545.025n

.meas tran vdout0_89ck1080 FIND v(dout0_89) AT=545.025n

.meas tran vdout0_90ck1080 FIND v(dout0_90) AT=545.025n

.meas tran vdout0_91ck1080 FIND v(dout0_91) AT=545.025n

.meas tran vdout0_92ck1080 FIND v(dout0_92) AT=545.025n

.meas tran vdout0_93ck1080 FIND v(dout0_93) AT=545.025n

.meas tran vdout0_94ck1080 FIND v(dout0_94) AT=545.025n

.meas tran vdout0_95ck1080 FIND v(dout0_95) AT=545.025n

.meas tran vdout0_96ck1080 FIND v(dout0_96) AT=545.025n

.meas tran vdout0_97ck1080 FIND v(dout0_97) AT=545.025n

.meas tran vdout0_98ck1080 FIND v(dout0_98) AT=545.025n

.meas tran vdout0_99ck1080 FIND v(dout0_99) AT=545.025n

.meas tran vdout0_100ck1080 FIND v(dout0_100) AT=545.025n

.meas tran vdout0_101ck1080 FIND v(dout0_101) AT=545.025n

.meas tran vdout0_102ck1080 FIND v(dout0_102) AT=545.025n

.meas tran vdout0_103ck1080 FIND v(dout0_103) AT=545.025n

.meas tran vdout0_104ck1080 FIND v(dout0_104) AT=545.025n

.meas tran vdout0_105ck1080 FIND v(dout0_105) AT=545.025n

.meas tran vdout0_106ck1080 FIND v(dout0_106) AT=545.025n

.meas tran vdout0_107ck1080 FIND v(dout0_107) AT=545.025n

.meas tran vdout0_108ck1080 FIND v(dout0_108) AT=545.025n

.meas tran vdout0_109ck1080 FIND v(dout0_109) AT=545.025n

.meas tran vdout0_110ck1080 FIND v(dout0_110) AT=545.025n

.meas tran vdout0_111ck1080 FIND v(dout0_111) AT=545.025n

.meas tran vdout0_112ck1080 FIND v(dout0_112) AT=545.025n

.meas tran vdout0_113ck1080 FIND v(dout0_113) AT=545.025n

.meas tran vdout0_114ck1080 FIND v(dout0_114) AT=545.025n

.meas tran vdout0_115ck1080 FIND v(dout0_115) AT=545.025n

.meas tran vdout0_116ck1080 FIND v(dout0_116) AT=545.025n

.meas tran vdout0_117ck1080 FIND v(dout0_117) AT=545.025n

.meas tran vdout0_118ck1080 FIND v(dout0_118) AT=545.025n

.meas tran vdout0_119ck1080 FIND v(dout0_119) AT=545.025n

.meas tran vdout0_120ck1080 FIND v(dout0_120) AT=545.025n

.meas tran vdout0_121ck1080 FIND v(dout0_121) AT=545.025n

.meas tran vdout0_122ck1080 FIND v(dout0_122) AT=545.025n

.meas tran vdout0_123ck1080 FIND v(dout0_123) AT=545.025n

.meas tran vdout0_124ck1080 FIND v(dout0_124) AT=545.025n

.meas tran vdout0_125ck1080 FIND v(dout0_125) AT=545.025n

.meas tran vdout0_126ck1080 FIND v(dout0_126) AT=545.025n

.meas tran vdout0_127ck1080 FIND v(dout0_127) AT=545.025n

.meas tran vdout0_0ck1090 FIND v(dout0_0) AT=550.025n

.meas tran vdout0_1ck1090 FIND v(dout0_1) AT=550.025n

.meas tran vdout0_2ck1090 FIND v(dout0_2) AT=550.025n

.meas tran vdout0_3ck1090 FIND v(dout0_3) AT=550.025n

.meas tran vdout0_4ck1090 FIND v(dout0_4) AT=550.025n

.meas tran vdout0_5ck1090 FIND v(dout0_5) AT=550.025n

.meas tran vdout0_6ck1090 FIND v(dout0_6) AT=550.025n

.meas tran vdout0_7ck1090 FIND v(dout0_7) AT=550.025n

.meas tran vdout0_8ck1090 FIND v(dout0_8) AT=550.025n

.meas tran vdout0_9ck1090 FIND v(dout0_9) AT=550.025n

.meas tran vdout0_10ck1090 FIND v(dout0_10) AT=550.025n

.meas tran vdout0_11ck1090 FIND v(dout0_11) AT=550.025n

.meas tran vdout0_12ck1090 FIND v(dout0_12) AT=550.025n

.meas tran vdout0_13ck1090 FIND v(dout0_13) AT=550.025n

.meas tran vdout0_14ck1090 FIND v(dout0_14) AT=550.025n

.meas tran vdout0_15ck1090 FIND v(dout0_15) AT=550.025n

.meas tran vdout0_16ck1090 FIND v(dout0_16) AT=550.025n

.meas tran vdout0_17ck1090 FIND v(dout0_17) AT=550.025n

.meas tran vdout0_18ck1090 FIND v(dout0_18) AT=550.025n

.meas tran vdout0_19ck1090 FIND v(dout0_19) AT=550.025n

.meas tran vdout0_20ck1090 FIND v(dout0_20) AT=550.025n

.meas tran vdout0_21ck1090 FIND v(dout0_21) AT=550.025n

.meas tran vdout0_22ck1090 FIND v(dout0_22) AT=550.025n

.meas tran vdout0_23ck1090 FIND v(dout0_23) AT=550.025n

.meas tran vdout0_24ck1090 FIND v(dout0_24) AT=550.025n

.meas tran vdout0_25ck1090 FIND v(dout0_25) AT=550.025n

.meas tran vdout0_26ck1090 FIND v(dout0_26) AT=550.025n

.meas tran vdout0_27ck1090 FIND v(dout0_27) AT=550.025n

.meas tran vdout0_28ck1090 FIND v(dout0_28) AT=550.025n

.meas tran vdout0_29ck1090 FIND v(dout0_29) AT=550.025n

.meas tran vdout0_30ck1090 FIND v(dout0_30) AT=550.025n

.meas tran vdout0_31ck1090 FIND v(dout0_31) AT=550.025n

.meas tran vdout0_32ck1090 FIND v(dout0_32) AT=550.025n

.meas tran vdout0_33ck1090 FIND v(dout0_33) AT=550.025n

.meas tran vdout0_34ck1090 FIND v(dout0_34) AT=550.025n

.meas tran vdout0_35ck1090 FIND v(dout0_35) AT=550.025n

.meas tran vdout0_36ck1090 FIND v(dout0_36) AT=550.025n

.meas tran vdout0_37ck1090 FIND v(dout0_37) AT=550.025n

.meas tran vdout0_38ck1090 FIND v(dout0_38) AT=550.025n

.meas tran vdout0_39ck1090 FIND v(dout0_39) AT=550.025n

.meas tran vdout0_40ck1090 FIND v(dout0_40) AT=550.025n

.meas tran vdout0_41ck1090 FIND v(dout0_41) AT=550.025n

.meas tran vdout0_42ck1090 FIND v(dout0_42) AT=550.025n

.meas tran vdout0_43ck1090 FIND v(dout0_43) AT=550.025n

.meas tran vdout0_44ck1090 FIND v(dout0_44) AT=550.025n

.meas tran vdout0_45ck1090 FIND v(dout0_45) AT=550.025n

.meas tran vdout0_46ck1090 FIND v(dout0_46) AT=550.025n

.meas tran vdout0_47ck1090 FIND v(dout0_47) AT=550.025n

.meas tran vdout0_48ck1090 FIND v(dout0_48) AT=550.025n

.meas tran vdout0_49ck1090 FIND v(dout0_49) AT=550.025n

.meas tran vdout0_50ck1090 FIND v(dout0_50) AT=550.025n

.meas tran vdout0_51ck1090 FIND v(dout0_51) AT=550.025n

.meas tran vdout0_52ck1090 FIND v(dout0_52) AT=550.025n

.meas tran vdout0_53ck1090 FIND v(dout0_53) AT=550.025n

.meas tran vdout0_54ck1090 FIND v(dout0_54) AT=550.025n

.meas tran vdout0_55ck1090 FIND v(dout0_55) AT=550.025n

.meas tran vdout0_56ck1090 FIND v(dout0_56) AT=550.025n

.meas tran vdout0_57ck1090 FIND v(dout0_57) AT=550.025n

.meas tran vdout0_58ck1090 FIND v(dout0_58) AT=550.025n

.meas tran vdout0_59ck1090 FIND v(dout0_59) AT=550.025n

.meas tran vdout0_60ck1090 FIND v(dout0_60) AT=550.025n

.meas tran vdout0_61ck1090 FIND v(dout0_61) AT=550.025n

.meas tran vdout0_62ck1090 FIND v(dout0_62) AT=550.025n

.meas tran vdout0_63ck1090 FIND v(dout0_63) AT=550.025n

.meas tran vdout0_64ck1090 FIND v(dout0_64) AT=550.025n

.meas tran vdout0_65ck1090 FIND v(dout0_65) AT=550.025n

.meas tran vdout0_66ck1090 FIND v(dout0_66) AT=550.025n

.meas tran vdout0_67ck1090 FIND v(dout0_67) AT=550.025n

.meas tran vdout0_68ck1090 FIND v(dout0_68) AT=550.025n

.meas tran vdout0_69ck1090 FIND v(dout0_69) AT=550.025n

.meas tran vdout0_70ck1090 FIND v(dout0_70) AT=550.025n

.meas tran vdout0_71ck1090 FIND v(dout0_71) AT=550.025n

.meas tran vdout0_72ck1090 FIND v(dout0_72) AT=550.025n

.meas tran vdout0_73ck1090 FIND v(dout0_73) AT=550.025n

.meas tran vdout0_74ck1090 FIND v(dout0_74) AT=550.025n

.meas tran vdout0_75ck1090 FIND v(dout0_75) AT=550.025n

.meas tran vdout0_76ck1090 FIND v(dout0_76) AT=550.025n

.meas tran vdout0_77ck1090 FIND v(dout0_77) AT=550.025n

.meas tran vdout0_78ck1090 FIND v(dout0_78) AT=550.025n

.meas tran vdout0_79ck1090 FIND v(dout0_79) AT=550.025n

.meas tran vdout0_80ck1090 FIND v(dout0_80) AT=550.025n

.meas tran vdout0_81ck1090 FIND v(dout0_81) AT=550.025n

.meas tran vdout0_82ck1090 FIND v(dout0_82) AT=550.025n

.meas tran vdout0_83ck1090 FIND v(dout0_83) AT=550.025n

.meas tran vdout0_84ck1090 FIND v(dout0_84) AT=550.025n

.meas tran vdout0_85ck1090 FIND v(dout0_85) AT=550.025n

.meas tran vdout0_86ck1090 FIND v(dout0_86) AT=550.025n

.meas tran vdout0_87ck1090 FIND v(dout0_87) AT=550.025n

.meas tran vdout0_88ck1090 FIND v(dout0_88) AT=550.025n

.meas tran vdout0_89ck1090 FIND v(dout0_89) AT=550.025n

.meas tran vdout0_90ck1090 FIND v(dout0_90) AT=550.025n

.meas tran vdout0_91ck1090 FIND v(dout0_91) AT=550.025n

.meas tran vdout0_92ck1090 FIND v(dout0_92) AT=550.025n

.meas tran vdout0_93ck1090 FIND v(dout0_93) AT=550.025n

.meas tran vdout0_94ck1090 FIND v(dout0_94) AT=550.025n

.meas tran vdout0_95ck1090 FIND v(dout0_95) AT=550.025n

.meas tran vdout0_96ck1090 FIND v(dout0_96) AT=550.025n

.meas tran vdout0_97ck1090 FIND v(dout0_97) AT=550.025n

.meas tran vdout0_98ck1090 FIND v(dout0_98) AT=550.025n

.meas tran vdout0_99ck1090 FIND v(dout0_99) AT=550.025n

.meas tran vdout0_100ck1090 FIND v(dout0_100) AT=550.025n

.meas tran vdout0_101ck1090 FIND v(dout0_101) AT=550.025n

.meas tran vdout0_102ck1090 FIND v(dout0_102) AT=550.025n

.meas tran vdout0_103ck1090 FIND v(dout0_103) AT=550.025n

.meas tran vdout0_104ck1090 FIND v(dout0_104) AT=550.025n

.meas tran vdout0_105ck1090 FIND v(dout0_105) AT=550.025n

.meas tran vdout0_106ck1090 FIND v(dout0_106) AT=550.025n

.meas tran vdout0_107ck1090 FIND v(dout0_107) AT=550.025n

.meas tran vdout0_108ck1090 FIND v(dout0_108) AT=550.025n

.meas tran vdout0_109ck1090 FIND v(dout0_109) AT=550.025n

.meas tran vdout0_110ck1090 FIND v(dout0_110) AT=550.025n

.meas tran vdout0_111ck1090 FIND v(dout0_111) AT=550.025n

.meas tran vdout0_112ck1090 FIND v(dout0_112) AT=550.025n

.meas tran vdout0_113ck1090 FIND v(dout0_113) AT=550.025n

.meas tran vdout0_114ck1090 FIND v(dout0_114) AT=550.025n

.meas tran vdout0_115ck1090 FIND v(dout0_115) AT=550.025n

.meas tran vdout0_116ck1090 FIND v(dout0_116) AT=550.025n

.meas tran vdout0_117ck1090 FIND v(dout0_117) AT=550.025n

.meas tran vdout0_118ck1090 FIND v(dout0_118) AT=550.025n

.meas tran vdout0_119ck1090 FIND v(dout0_119) AT=550.025n

.meas tran vdout0_120ck1090 FIND v(dout0_120) AT=550.025n

.meas tran vdout0_121ck1090 FIND v(dout0_121) AT=550.025n

.meas tran vdout0_122ck1090 FIND v(dout0_122) AT=550.025n

.meas tran vdout0_123ck1090 FIND v(dout0_123) AT=550.025n

.meas tran vdout0_124ck1090 FIND v(dout0_124) AT=550.025n

.meas tran vdout0_125ck1090 FIND v(dout0_125) AT=550.025n

.meas tran vdout0_126ck1090 FIND v(dout0_126) AT=550.025n

.meas tran vdout0_127ck1090 FIND v(dout0_127) AT=550.025n

.meas tran vdout0_0ck1100 FIND v(dout0_0) AT=555.025n

.meas tran vdout0_1ck1100 FIND v(dout0_1) AT=555.025n

.meas tran vdout0_2ck1100 FIND v(dout0_2) AT=555.025n

.meas tran vdout0_3ck1100 FIND v(dout0_3) AT=555.025n

.meas tran vdout0_4ck1100 FIND v(dout0_4) AT=555.025n

.meas tran vdout0_5ck1100 FIND v(dout0_5) AT=555.025n

.meas tran vdout0_6ck1100 FIND v(dout0_6) AT=555.025n

.meas tran vdout0_7ck1100 FIND v(dout0_7) AT=555.025n

.meas tran vdout0_8ck1100 FIND v(dout0_8) AT=555.025n

.meas tran vdout0_9ck1100 FIND v(dout0_9) AT=555.025n

.meas tran vdout0_10ck1100 FIND v(dout0_10) AT=555.025n

.meas tran vdout0_11ck1100 FIND v(dout0_11) AT=555.025n

.meas tran vdout0_12ck1100 FIND v(dout0_12) AT=555.025n

.meas tran vdout0_13ck1100 FIND v(dout0_13) AT=555.025n

.meas tran vdout0_14ck1100 FIND v(dout0_14) AT=555.025n

.meas tran vdout0_15ck1100 FIND v(dout0_15) AT=555.025n

.meas tran vdout0_16ck1100 FIND v(dout0_16) AT=555.025n

.meas tran vdout0_17ck1100 FIND v(dout0_17) AT=555.025n

.meas tran vdout0_18ck1100 FIND v(dout0_18) AT=555.025n

.meas tran vdout0_19ck1100 FIND v(dout0_19) AT=555.025n

.meas tran vdout0_20ck1100 FIND v(dout0_20) AT=555.025n

.meas tran vdout0_21ck1100 FIND v(dout0_21) AT=555.025n

.meas tran vdout0_22ck1100 FIND v(dout0_22) AT=555.025n

.meas tran vdout0_23ck1100 FIND v(dout0_23) AT=555.025n

.meas tran vdout0_24ck1100 FIND v(dout0_24) AT=555.025n

.meas tran vdout0_25ck1100 FIND v(dout0_25) AT=555.025n

.meas tran vdout0_26ck1100 FIND v(dout0_26) AT=555.025n

.meas tran vdout0_27ck1100 FIND v(dout0_27) AT=555.025n

.meas tran vdout0_28ck1100 FIND v(dout0_28) AT=555.025n

.meas tran vdout0_29ck1100 FIND v(dout0_29) AT=555.025n

.meas tran vdout0_30ck1100 FIND v(dout0_30) AT=555.025n

.meas tran vdout0_31ck1100 FIND v(dout0_31) AT=555.025n

.meas tran vdout0_32ck1100 FIND v(dout0_32) AT=555.025n

.meas tran vdout0_33ck1100 FIND v(dout0_33) AT=555.025n

.meas tran vdout0_34ck1100 FIND v(dout0_34) AT=555.025n

.meas tran vdout0_35ck1100 FIND v(dout0_35) AT=555.025n

.meas tran vdout0_36ck1100 FIND v(dout0_36) AT=555.025n

.meas tran vdout0_37ck1100 FIND v(dout0_37) AT=555.025n

.meas tran vdout0_38ck1100 FIND v(dout0_38) AT=555.025n

.meas tran vdout0_39ck1100 FIND v(dout0_39) AT=555.025n

.meas tran vdout0_40ck1100 FIND v(dout0_40) AT=555.025n

.meas tran vdout0_41ck1100 FIND v(dout0_41) AT=555.025n

.meas tran vdout0_42ck1100 FIND v(dout0_42) AT=555.025n

.meas tran vdout0_43ck1100 FIND v(dout0_43) AT=555.025n

.meas tran vdout0_44ck1100 FIND v(dout0_44) AT=555.025n

.meas tran vdout0_45ck1100 FIND v(dout0_45) AT=555.025n

.meas tran vdout0_46ck1100 FIND v(dout0_46) AT=555.025n

.meas tran vdout0_47ck1100 FIND v(dout0_47) AT=555.025n

.meas tran vdout0_48ck1100 FIND v(dout0_48) AT=555.025n

.meas tran vdout0_49ck1100 FIND v(dout0_49) AT=555.025n

.meas tran vdout0_50ck1100 FIND v(dout0_50) AT=555.025n

.meas tran vdout0_51ck1100 FIND v(dout0_51) AT=555.025n

.meas tran vdout0_52ck1100 FIND v(dout0_52) AT=555.025n

.meas tran vdout0_53ck1100 FIND v(dout0_53) AT=555.025n

.meas tran vdout0_54ck1100 FIND v(dout0_54) AT=555.025n

.meas tran vdout0_55ck1100 FIND v(dout0_55) AT=555.025n

.meas tran vdout0_56ck1100 FIND v(dout0_56) AT=555.025n

.meas tran vdout0_57ck1100 FIND v(dout0_57) AT=555.025n

.meas tran vdout0_58ck1100 FIND v(dout0_58) AT=555.025n

.meas tran vdout0_59ck1100 FIND v(dout0_59) AT=555.025n

.meas tran vdout0_60ck1100 FIND v(dout0_60) AT=555.025n

.meas tran vdout0_61ck1100 FIND v(dout0_61) AT=555.025n

.meas tran vdout0_62ck1100 FIND v(dout0_62) AT=555.025n

.meas tran vdout0_63ck1100 FIND v(dout0_63) AT=555.025n

.meas tran vdout0_64ck1100 FIND v(dout0_64) AT=555.025n

.meas tran vdout0_65ck1100 FIND v(dout0_65) AT=555.025n

.meas tran vdout0_66ck1100 FIND v(dout0_66) AT=555.025n

.meas tran vdout0_67ck1100 FIND v(dout0_67) AT=555.025n

.meas tran vdout0_68ck1100 FIND v(dout0_68) AT=555.025n

.meas tran vdout0_69ck1100 FIND v(dout0_69) AT=555.025n

.meas tran vdout0_70ck1100 FIND v(dout0_70) AT=555.025n

.meas tran vdout0_71ck1100 FIND v(dout0_71) AT=555.025n

.meas tran vdout0_72ck1100 FIND v(dout0_72) AT=555.025n

.meas tran vdout0_73ck1100 FIND v(dout0_73) AT=555.025n

.meas tran vdout0_74ck1100 FIND v(dout0_74) AT=555.025n

.meas tran vdout0_75ck1100 FIND v(dout0_75) AT=555.025n

.meas tran vdout0_76ck1100 FIND v(dout0_76) AT=555.025n

.meas tran vdout0_77ck1100 FIND v(dout0_77) AT=555.025n

.meas tran vdout0_78ck1100 FIND v(dout0_78) AT=555.025n

.meas tran vdout0_79ck1100 FIND v(dout0_79) AT=555.025n

.meas tran vdout0_80ck1100 FIND v(dout0_80) AT=555.025n

.meas tran vdout0_81ck1100 FIND v(dout0_81) AT=555.025n

.meas tran vdout0_82ck1100 FIND v(dout0_82) AT=555.025n

.meas tran vdout0_83ck1100 FIND v(dout0_83) AT=555.025n

.meas tran vdout0_84ck1100 FIND v(dout0_84) AT=555.025n

.meas tran vdout0_85ck1100 FIND v(dout0_85) AT=555.025n

.meas tran vdout0_86ck1100 FIND v(dout0_86) AT=555.025n

.meas tran vdout0_87ck1100 FIND v(dout0_87) AT=555.025n

.meas tran vdout0_88ck1100 FIND v(dout0_88) AT=555.025n

.meas tran vdout0_89ck1100 FIND v(dout0_89) AT=555.025n

.meas tran vdout0_90ck1100 FIND v(dout0_90) AT=555.025n

.meas tran vdout0_91ck1100 FIND v(dout0_91) AT=555.025n

.meas tran vdout0_92ck1100 FIND v(dout0_92) AT=555.025n

.meas tran vdout0_93ck1100 FIND v(dout0_93) AT=555.025n

.meas tran vdout0_94ck1100 FIND v(dout0_94) AT=555.025n

.meas tran vdout0_95ck1100 FIND v(dout0_95) AT=555.025n

.meas tran vdout0_96ck1100 FIND v(dout0_96) AT=555.025n

.meas tran vdout0_97ck1100 FIND v(dout0_97) AT=555.025n

.meas tran vdout0_98ck1100 FIND v(dout0_98) AT=555.025n

.meas tran vdout0_99ck1100 FIND v(dout0_99) AT=555.025n

.meas tran vdout0_100ck1100 FIND v(dout0_100) AT=555.025n

.meas tran vdout0_101ck1100 FIND v(dout0_101) AT=555.025n

.meas tran vdout0_102ck1100 FIND v(dout0_102) AT=555.025n

.meas tran vdout0_103ck1100 FIND v(dout0_103) AT=555.025n

.meas tran vdout0_104ck1100 FIND v(dout0_104) AT=555.025n

.meas tran vdout0_105ck1100 FIND v(dout0_105) AT=555.025n

.meas tran vdout0_106ck1100 FIND v(dout0_106) AT=555.025n

.meas tran vdout0_107ck1100 FIND v(dout0_107) AT=555.025n

.meas tran vdout0_108ck1100 FIND v(dout0_108) AT=555.025n

.meas tran vdout0_109ck1100 FIND v(dout0_109) AT=555.025n

.meas tran vdout0_110ck1100 FIND v(dout0_110) AT=555.025n

.meas tran vdout0_111ck1100 FIND v(dout0_111) AT=555.025n

.meas tran vdout0_112ck1100 FIND v(dout0_112) AT=555.025n

.meas tran vdout0_113ck1100 FIND v(dout0_113) AT=555.025n

.meas tran vdout0_114ck1100 FIND v(dout0_114) AT=555.025n

.meas tran vdout0_115ck1100 FIND v(dout0_115) AT=555.025n

.meas tran vdout0_116ck1100 FIND v(dout0_116) AT=555.025n

.meas tran vdout0_117ck1100 FIND v(dout0_117) AT=555.025n

.meas tran vdout0_118ck1100 FIND v(dout0_118) AT=555.025n

.meas tran vdout0_119ck1100 FIND v(dout0_119) AT=555.025n

.meas tran vdout0_120ck1100 FIND v(dout0_120) AT=555.025n

.meas tran vdout0_121ck1100 FIND v(dout0_121) AT=555.025n

.meas tran vdout0_122ck1100 FIND v(dout0_122) AT=555.025n

.meas tran vdout0_123ck1100 FIND v(dout0_123) AT=555.025n

.meas tran vdout0_124ck1100 FIND v(dout0_124) AT=555.025n

.meas tran vdout0_125ck1100 FIND v(dout0_125) AT=555.025n

.meas tran vdout0_126ck1100 FIND v(dout0_126) AT=555.025n

.meas tran vdout0_127ck1100 FIND v(dout0_127) AT=555.025n

.meas tran vdout0_0ck1130 FIND v(dout0_0) AT=570.025n

.meas tran vdout0_1ck1130 FIND v(dout0_1) AT=570.025n

.meas tran vdout0_2ck1130 FIND v(dout0_2) AT=570.025n

.meas tran vdout0_3ck1130 FIND v(dout0_3) AT=570.025n

.meas tran vdout0_4ck1130 FIND v(dout0_4) AT=570.025n

.meas tran vdout0_5ck1130 FIND v(dout0_5) AT=570.025n

.meas tran vdout0_6ck1130 FIND v(dout0_6) AT=570.025n

.meas tran vdout0_7ck1130 FIND v(dout0_7) AT=570.025n

.meas tran vdout0_8ck1130 FIND v(dout0_8) AT=570.025n

.meas tran vdout0_9ck1130 FIND v(dout0_9) AT=570.025n

.meas tran vdout0_10ck1130 FIND v(dout0_10) AT=570.025n

.meas tran vdout0_11ck1130 FIND v(dout0_11) AT=570.025n

.meas tran vdout0_12ck1130 FIND v(dout0_12) AT=570.025n

.meas tran vdout0_13ck1130 FIND v(dout0_13) AT=570.025n

.meas tran vdout0_14ck1130 FIND v(dout0_14) AT=570.025n

.meas tran vdout0_15ck1130 FIND v(dout0_15) AT=570.025n

.meas tran vdout0_16ck1130 FIND v(dout0_16) AT=570.025n

.meas tran vdout0_17ck1130 FIND v(dout0_17) AT=570.025n

.meas tran vdout0_18ck1130 FIND v(dout0_18) AT=570.025n

.meas tran vdout0_19ck1130 FIND v(dout0_19) AT=570.025n

.meas tran vdout0_20ck1130 FIND v(dout0_20) AT=570.025n

.meas tran vdout0_21ck1130 FIND v(dout0_21) AT=570.025n

.meas tran vdout0_22ck1130 FIND v(dout0_22) AT=570.025n

.meas tran vdout0_23ck1130 FIND v(dout0_23) AT=570.025n

.meas tran vdout0_24ck1130 FIND v(dout0_24) AT=570.025n

.meas tran vdout0_25ck1130 FIND v(dout0_25) AT=570.025n

.meas tran vdout0_26ck1130 FIND v(dout0_26) AT=570.025n

.meas tran vdout0_27ck1130 FIND v(dout0_27) AT=570.025n

.meas tran vdout0_28ck1130 FIND v(dout0_28) AT=570.025n

.meas tran vdout0_29ck1130 FIND v(dout0_29) AT=570.025n

.meas tran vdout0_30ck1130 FIND v(dout0_30) AT=570.025n

.meas tran vdout0_31ck1130 FIND v(dout0_31) AT=570.025n

.meas tran vdout0_32ck1130 FIND v(dout0_32) AT=570.025n

.meas tran vdout0_33ck1130 FIND v(dout0_33) AT=570.025n

.meas tran vdout0_34ck1130 FIND v(dout0_34) AT=570.025n

.meas tran vdout0_35ck1130 FIND v(dout0_35) AT=570.025n

.meas tran vdout0_36ck1130 FIND v(dout0_36) AT=570.025n

.meas tran vdout0_37ck1130 FIND v(dout0_37) AT=570.025n

.meas tran vdout0_38ck1130 FIND v(dout0_38) AT=570.025n

.meas tran vdout0_39ck1130 FIND v(dout0_39) AT=570.025n

.meas tran vdout0_40ck1130 FIND v(dout0_40) AT=570.025n

.meas tran vdout0_41ck1130 FIND v(dout0_41) AT=570.025n

.meas tran vdout0_42ck1130 FIND v(dout0_42) AT=570.025n

.meas tran vdout0_43ck1130 FIND v(dout0_43) AT=570.025n

.meas tran vdout0_44ck1130 FIND v(dout0_44) AT=570.025n

.meas tran vdout0_45ck1130 FIND v(dout0_45) AT=570.025n

.meas tran vdout0_46ck1130 FIND v(dout0_46) AT=570.025n

.meas tran vdout0_47ck1130 FIND v(dout0_47) AT=570.025n

.meas tran vdout0_48ck1130 FIND v(dout0_48) AT=570.025n

.meas tran vdout0_49ck1130 FIND v(dout0_49) AT=570.025n

.meas tran vdout0_50ck1130 FIND v(dout0_50) AT=570.025n

.meas tran vdout0_51ck1130 FIND v(dout0_51) AT=570.025n

.meas tran vdout0_52ck1130 FIND v(dout0_52) AT=570.025n

.meas tran vdout0_53ck1130 FIND v(dout0_53) AT=570.025n

.meas tran vdout0_54ck1130 FIND v(dout0_54) AT=570.025n

.meas tran vdout0_55ck1130 FIND v(dout0_55) AT=570.025n

.meas tran vdout0_56ck1130 FIND v(dout0_56) AT=570.025n

.meas tran vdout0_57ck1130 FIND v(dout0_57) AT=570.025n

.meas tran vdout0_58ck1130 FIND v(dout0_58) AT=570.025n

.meas tran vdout0_59ck1130 FIND v(dout0_59) AT=570.025n

.meas tran vdout0_60ck1130 FIND v(dout0_60) AT=570.025n

.meas tran vdout0_61ck1130 FIND v(dout0_61) AT=570.025n

.meas tran vdout0_62ck1130 FIND v(dout0_62) AT=570.025n

.meas tran vdout0_63ck1130 FIND v(dout0_63) AT=570.025n

.meas tran vdout0_64ck1130 FIND v(dout0_64) AT=570.025n

.meas tran vdout0_65ck1130 FIND v(dout0_65) AT=570.025n

.meas tran vdout0_66ck1130 FIND v(dout0_66) AT=570.025n

.meas tran vdout0_67ck1130 FIND v(dout0_67) AT=570.025n

.meas tran vdout0_68ck1130 FIND v(dout0_68) AT=570.025n

.meas tran vdout0_69ck1130 FIND v(dout0_69) AT=570.025n

.meas tran vdout0_70ck1130 FIND v(dout0_70) AT=570.025n

.meas tran vdout0_71ck1130 FIND v(dout0_71) AT=570.025n

.meas tran vdout0_72ck1130 FIND v(dout0_72) AT=570.025n

.meas tran vdout0_73ck1130 FIND v(dout0_73) AT=570.025n

.meas tran vdout0_74ck1130 FIND v(dout0_74) AT=570.025n

.meas tran vdout0_75ck1130 FIND v(dout0_75) AT=570.025n

.meas tran vdout0_76ck1130 FIND v(dout0_76) AT=570.025n

.meas tran vdout0_77ck1130 FIND v(dout0_77) AT=570.025n

.meas tran vdout0_78ck1130 FIND v(dout0_78) AT=570.025n

.meas tran vdout0_79ck1130 FIND v(dout0_79) AT=570.025n

.meas tran vdout0_80ck1130 FIND v(dout0_80) AT=570.025n

.meas tran vdout0_81ck1130 FIND v(dout0_81) AT=570.025n

.meas tran vdout0_82ck1130 FIND v(dout0_82) AT=570.025n

.meas tran vdout0_83ck1130 FIND v(dout0_83) AT=570.025n

.meas tran vdout0_84ck1130 FIND v(dout0_84) AT=570.025n

.meas tran vdout0_85ck1130 FIND v(dout0_85) AT=570.025n

.meas tran vdout0_86ck1130 FIND v(dout0_86) AT=570.025n

.meas tran vdout0_87ck1130 FIND v(dout0_87) AT=570.025n

.meas tran vdout0_88ck1130 FIND v(dout0_88) AT=570.025n

.meas tran vdout0_89ck1130 FIND v(dout0_89) AT=570.025n

.meas tran vdout0_90ck1130 FIND v(dout0_90) AT=570.025n

.meas tran vdout0_91ck1130 FIND v(dout0_91) AT=570.025n

.meas tran vdout0_92ck1130 FIND v(dout0_92) AT=570.025n

.meas tran vdout0_93ck1130 FIND v(dout0_93) AT=570.025n

.meas tran vdout0_94ck1130 FIND v(dout0_94) AT=570.025n

.meas tran vdout0_95ck1130 FIND v(dout0_95) AT=570.025n

.meas tran vdout0_96ck1130 FIND v(dout0_96) AT=570.025n

.meas tran vdout0_97ck1130 FIND v(dout0_97) AT=570.025n

.meas tran vdout0_98ck1130 FIND v(dout0_98) AT=570.025n

.meas tran vdout0_99ck1130 FIND v(dout0_99) AT=570.025n

.meas tran vdout0_100ck1130 FIND v(dout0_100) AT=570.025n

.meas tran vdout0_101ck1130 FIND v(dout0_101) AT=570.025n

.meas tran vdout0_102ck1130 FIND v(dout0_102) AT=570.025n

.meas tran vdout0_103ck1130 FIND v(dout0_103) AT=570.025n

.meas tran vdout0_104ck1130 FIND v(dout0_104) AT=570.025n

.meas tran vdout0_105ck1130 FIND v(dout0_105) AT=570.025n

.meas tran vdout0_106ck1130 FIND v(dout0_106) AT=570.025n

.meas tran vdout0_107ck1130 FIND v(dout0_107) AT=570.025n

.meas tran vdout0_108ck1130 FIND v(dout0_108) AT=570.025n

.meas tran vdout0_109ck1130 FIND v(dout0_109) AT=570.025n

.meas tran vdout0_110ck1130 FIND v(dout0_110) AT=570.025n

.meas tran vdout0_111ck1130 FIND v(dout0_111) AT=570.025n

.meas tran vdout0_112ck1130 FIND v(dout0_112) AT=570.025n

.meas tran vdout0_113ck1130 FIND v(dout0_113) AT=570.025n

.meas tran vdout0_114ck1130 FIND v(dout0_114) AT=570.025n

.meas tran vdout0_115ck1130 FIND v(dout0_115) AT=570.025n

.meas tran vdout0_116ck1130 FIND v(dout0_116) AT=570.025n

.meas tran vdout0_117ck1130 FIND v(dout0_117) AT=570.025n

.meas tran vdout0_118ck1130 FIND v(dout0_118) AT=570.025n

.meas tran vdout0_119ck1130 FIND v(dout0_119) AT=570.025n

.meas tran vdout0_120ck1130 FIND v(dout0_120) AT=570.025n

.meas tran vdout0_121ck1130 FIND v(dout0_121) AT=570.025n

.meas tran vdout0_122ck1130 FIND v(dout0_122) AT=570.025n

.meas tran vdout0_123ck1130 FIND v(dout0_123) AT=570.025n

.meas tran vdout0_124ck1130 FIND v(dout0_124) AT=570.025n

.meas tran vdout0_125ck1130 FIND v(dout0_125) AT=570.025n

.meas tran vdout0_126ck1130 FIND v(dout0_126) AT=570.025n

.meas tran vdout0_127ck1130 FIND v(dout0_127) AT=570.025n

.meas tran vdout0_0ck1140 FIND v(dout0_0) AT=575.025n

.meas tran vdout0_1ck1140 FIND v(dout0_1) AT=575.025n

.meas tran vdout0_2ck1140 FIND v(dout0_2) AT=575.025n

.meas tran vdout0_3ck1140 FIND v(dout0_3) AT=575.025n

.meas tran vdout0_4ck1140 FIND v(dout0_4) AT=575.025n

.meas tran vdout0_5ck1140 FIND v(dout0_5) AT=575.025n

.meas tran vdout0_6ck1140 FIND v(dout0_6) AT=575.025n

.meas tran vdout0_7ck1140 FIND v(dout0_7) AT=575.025n

.meas tran vdout0_8ck1140 FIND v(dout0_8) AT=575.025n

.meas tran vdout0_9ck1140 FIND v(dout0_9) AT=575.025n

.meas tran vdout0_10ck1140 FIND v(dout0_10) AT=575.025n

.meas tran vdout0_11ck1140 FIND v(dout0_11) AT=575.025n

.meas tran vdout0_12ck1140 FIND v(dout0_12) AT=575.025n

.meas tran vdout0_13ck1140 FIND v(dout0_13) AT=575.025n

.meas tran vdout0_14ck1140 FIND v(dout0_14) AT=575.025n

.meas tran vdout0_15ck1140 FIND v(dout0_15) AT=575.025n

.meas tran vdout0_16ck1140 FIND v(dout0_16) AT=575.025n

.meas tran vdout0_17ck1140 FIND v(dout0_17) AT=575.025n

.meas tran vdout0_18ck1140 FIND v(dout0_18) AT=575.025n

.meas tran vdout0_19ck1140 FIND v(dout0_19) AT=575.025n

.meas tran vdout0_20ck1140 FIND v(dout0_20) AT=575.025n

.meas tran vdout0_21ck1140 FIND v(dout0_21) AT=575.025n

.meas tran vdout0_22ck1140 FIND v(dout0_22) AT=575.025n

.meas tran vdout0_23ck1140 FIND v(dout0_23) AT=575.025n

.meas tran vdout0_24ck1140 FIND v(dout0_24) AT=575.025n

.meas tran vdout0_25ck1140 FIND v(dout0_25) AT=575.025n

.meas tran vdout0_26ck1140 FIND v(dout0_26) AT=575.025n

.meas tran vdout0_27ck1140 FIND v(dout0_27) AT=575.025n

.meas tran vdout0_28ck1140 FIND v(dout0_28) AT=575.025n

.meas tran vdout0_29ck1140 FIND v(dout0_29) AT=575.025n

.meas tran vdout0_30ck1140 FIND v(dout0_30) AT=575.025n

.meas tran vdout0_31ck1140 FIND v(dout0_31) AT=575.025n

.meas tran vdout0_32ck1140 FIND v(dout0_32) AT=575.025n

.meas tran vdout0_33ck1140 FIND v(dout0_33) AT=575.025n

.meas tran vdout0_34ck1140 FIND v(dout0_34) AT=575.025n

.meas tran vdout0_35ck1140 FIND v(dout0_35) AT=575.025n

.meas tran vdout0_36ck1140 FIND v(dout0_36) AT=575.025n

.meas tran vdout0_37ck1140 FIND v(dout0_37) AT=575.025n

.meas tran vdout0_38ck1140 FIND v(dout0_38) AT=575.025n

.meas tran vdout0_39ck1140 FIND v(dout0_39) AT=575.025n

.meas tran vdout0_40ck1140 FIND v(dout0_40) AT=575.025n

.meas tran vdout0_41ck1140 FIND v(dout0_41) AT=575.025n

.meas tran vdout0_42ck1140 FIND v(dout0_42) AT=575.025n

.meas tran vdout0_43ck1140 FIND v(dout0_43) AT=575.025n

.meas tran vdout0_44ck1140 FIND v(dout0_44) AT=575.025n

.meas tran vdout0_45ck1140 FIND v(dout0_45) AT=575.025n

.meas tran vdout0_46ck1140 FIND v(dout0_46) AT=575.025n

.meas tran vdout0_47ck1140 FIND v(dout0_47) AT=575.025n

.meas tran vdout0_48ck1140 FIND v(dout0_48) AT=575.025n

.meas tran vdout0_49ck1140 FIND v(dout0_49) AT=575.025n

.meas tran vdout0_50ck1140 FIND v(dout0_50) AT=575.025n

.meas tran vdout0_51ck1140 FIND v(dout0_51) AT=575.025n

.meas tran vdout0_52ck1140 FIND v(dout0_52) AT=575.025n

.meas tran vdout0_53ck1140 FIND v(dout0_53) AT=575.025n

.meas tran vdout0_54ck1140 FIND v(dout0_54) AT=575.025n

.meas tran vdout0_55ck1140 FIND v(dout0_55) AT=575.025n

.meas tran vdout0_56ck1140 FIND v(dout0_56) AT=575.025n

.meas tran vdout0_57ck1140 FIND v(dout0_57) AT=575.025n

.meas tran vdout0_58ck1140 FIND v(dout0_58) AT=575.025n

.meas tran vdout0_59ck1140 FIND v(dout0_59) AT=575.025n

.meas tran vdout0_60ck1140 FIND v(dout0_60) AT=575.025n

.meas tran vdout0_61ck1140 FIND v(dout0_61) AT=575.025n

.meas tran vdout0_62ck1140 FIND v(dout0_62) AT=575.025n

.meas tran vdout0_63ck1140 FIND v(dout0_63) AT=575.025n

.meas tran vdout0_64ck1140 FIND v(dout0_64) AT=575.025n

.meas tran vdout0_65ck1140 FIND v(dout0_65) AT=575.025n

.meas tran vdout0_66ck1140 FIND v(dout0_66) AT=575.025n

.meas tran vdout0_67ck1140 FIND v(dout0_67) AT=575.025n

.meas tran vdout0_68ck1140 FIND v(dout0_68) AT=575.025n

.meas tran vdout0_69ck1140 FIND v(dout0_69) AT=575.025n

.meas tran vdout0_70ck1140 FIND v(dout0_70) AT=575.025n

.meas tran vdout0_71ck1140 FIND v(dout0_71) AT=575.025n

.meas tran vdout0_72ck1140 FIND v(dout0_72) AT=575.025n

.meas tran vdout0_73ck1140 FIND v(dout0_73) AT=575.025n

.meas tran vdout0_74ck1140 FIND v(dout0_74) AT=575.025n

.meas tran vdout0_75ck1140 FIND v(dout0_75) AT=575.025n

.meas tran vdout0_76ck1140 FIND v(dout0_76) AT=575.025n

.meas tran vdout0_77ck1140 FIND v(dout0_77) AT=575.025n

.meas tran vdout0_78ck1140 FIND v(dout0_78) AT=575.025n

.meas tran vdout0_79ck1140 FIND v(dout0_79) AT=575.025n

.meas tran vdout0_80ck1140 FIND v(dout0_80) AT=575.025n

.meas tran vdout0_81ck1140 FIND v(dout0_81) AT=575.025n

.meas tran vdout0_82ck1140 FIND v(dout0_82) AT=575.025n

.meas tran vdout0_83ck1140 FIND v(dout0_83) AT=575.025n

.meas tran vdout0_84ck1140 FIND v(dout0_84) AT=575.025n

.meas tran vdout0_85ck1140 FIND v(dout0_85) AT=575.025n

.meas tran vdout0_86ck1140 FIND v(dout0_86) AT=575.025n

.meas tran vdout0_87ck1140 FIND v(dout0_87) AT=575.025n

.meas tran vdout0_88ck1140 FIND v(dout0_88) AT=575.025n

.meas tran vdout0_89ck1140 FIND v(dout0_89) AT=575.025n

.meas tran vdout0_90ck1140 FIND v(dout0_90) AT=575.025n

.meas tran vdout0_91ck1140 FIND v(dout0_91) AT=575.025n

.meas tran vdout0_92ck1140 FIND v(dout0_92) AT=575.025n

.meas tran vdout0_93ck1140 FIND v(dout0_93) AT=575.025n

.meas tran vdout0_94ck1140 FIND v(dout0_94) AT=575.025n

.meas tran vdout0_95ck1140 FIND v(dout0_95) AT=575.025n

.meas tran vdout0_96ck1140 FIND v(dout0_96) AT=575.025n

.meas tran vdout0_97ck1140 FIND v(dout0_97) AT=575.025n

.meas tran vdout0_98ck1140 FIND v(dout0_98) AT=575.025n

.meas tran vdout0_99ck1140 FIND v(dout0_99) AT=575.025n

.meas tran vdout0_100ck1140 FIND v(dout0_100) AT=575.025n

.meas tran vdout0_101ck1140 FIND v(dout0_101) AT=575.025n

.meas tran vdout0_102ck1140 FIND v(dout0_102) AT=575.025n

.meas tran vdout0_103ck1140 FIND v(dout0_103) AT=575.025n

.meas tran vdout0_104ck1140 FIND v(dout0_104) AT=575.025n

.meas tran vdout0_105ck1140 FIND v(dout0_105) AT=575.025n

.meas tran vdout0_106ck1140 FIND v(dout0_106) AT=575.025n

.meas tran vdout0_107ck1140 FIND v(dout0_107) AT=575.025n

.meas tran vdout0_108ck1140 FIND v(dout0_108) AT=575.025n

.meas tran vdout0_109ck1140 FIND v(dout0_109) AT=575.025n

.meas tran vdout0_110ck1140 FIND v(dout0_110) AT=575.025n

.meas tran vdout0_111ck1140 FIND v(dout0_111) AT=575.025n

.meas tran vdout0_112ck1140 FIND v(dout0_112) AT=575.025n

.meas tran vdout0_113ck1140 FIND v(dout0_113) AT=575.025n

.meas tran vdout0_114ck1140 FIND v(dout0_114) AT=575.025n

.meas tran vdout0_115ck1140 FIND v(dout0_115) AT=575.025n

.meas tran vdout0_116ck1140 FIND v(dout0_116) AT=575.025n

.meas tran vdout0_117ck1140 FIND v(dout0_117) AT=575.025n

.meas tran vdout0_118ck1140 FIND v(dout0_118) AT=575.025n

.meas tran vdout0_119ck1140 FIND v(dout0_119) AT=575.025n

.meas tran vdout0_120ck1140 FIND v(dout0_120) AT=575.025n

.meas tran vdout0_121ck1140 FIND v(dout0_121) AT=575.025n

.meas tran vdout0_122ck1140 FIND v(dout0_122) AT=575.025n

.meas tran vdout0_123ck1140 FIND v(dout0_123) AT=575.025n

.meas tran vdout0_124ck1140 FIND v(dout0_124) AT=575.025n

.meas tran vdout0_125ck1140 FIND v(dout0_125) AT=575.025n

.meas tran vdout0_126ck1140 FIND v(dout0_126) AT=575.025n

.meas tran vdout0_127ck1140 FIND v(dout0_127) AT=575.025n

.meas tran vdout0_0ck1170 FIND v(dout0_0) AT=590.025n

.meas tran vdout0_1ck1170 FIND v(dout0_1) AT=590.025n

.meas tran vdout0_2ck1170 FIND v(dout0_2) AT=590.025n

.meas tran vdout0_3ck1170 FIND v(dout0_3) AT=590.025n

.meas tran vdout0_4ck1170 FIND v(dout0_4) AT=590.025n

.meas tran vdout0_5ck1170 FIND v(dout0_5) AT=590.025n

.meas tran vdout0_6ck1170 FIND v(dout0_6) AT=590.025n

.meas tran vdout0_7ck1170 FIND v(dout0_7) AT=590.025n

.meas tran vdout0_8ck1170 FIND v(dout0_8) AT=590.025n

.meas tran vdout0_9ck1170 FIND v(dout0_9) AT=590.025n

.meas tran vdout0_10ck1170 FIND v(dout0_10) AT=590.025n

.meas tran vdout0_11ck1170 FIND v(dout0_11) AT=590.025n

.meas tran vdout0_12ck1170 FIND v(dout0_12) AT=590.025n

.meas tran vdout0_13ck1170 FIND v(dout0_13) AT=590.025n

.meas tran vdout0_14ck1170 FIND v(dout0_14) AT=590.025n

.meas tran vdout0_15ck1170 FIND v(dout0_15) AT=590.025n

.meas tran vdout0_16ck1170 FIND v(dout0_16) AT=590.025n

.meas tran vdout0_17ck1170 FIND v(dout0_17) AT=590.025n

.meas tran vdout0_18ck1170 FIND v(dout0_18) AT=590.025n

.meas tran vdout0_19ck1170 FIND v(dout0_19) AT=590.025n

.meas tran vdout0_20ck1170 FIND v(dout0_20) AT=590.025n

.meas tran vdout0_21ck1170 FIND v(dout0_21) AT=590.025n

.meas tran vdout0_22ck1170 FIND v(dout0_22) AT=590.025n

.meas tran vdout0_23ck1170 FIND v(dout0_23) AT=590.025n

.meas tran vdout0_24ck1170 FIND v(dout0_24) AT=590.025n

.meas tran vdout0_25ck1170 FIND v(dout0_25) AT=590.025n

.meas tran vdout0_26ck1170 FIND v(dout0_26) AT=590.025n

.meas tran vdout0_27ck1170 FIND v(dout0_27) AT=590.025n

.meas tran vdout0_28ck1170 FIND v(dout0_28) AT=590.025n

.meas tran vdout0_29ck1170 FIND v(dout0_29) AT=590.025n

.meas tran vdout0_30ck1170 FIND v(dout0_30) AT=590.025n

.meas tran vdout0_31ck1170 FIND v(dout0_31) AT=590.025n

.meas tran vdout0_32ck1170 FIND v(dout0_32) AT=590.025n

.meas tran vdout0_33ck1170 FIND v(dout0_33) AT=590.025n

.meas tran vdout0_34ck1170 FIND v(dout0_34) AT=590.025n

.meas tran vdout0_35ck1170 FIND v(dout0_35) AT=590.025n

.meas tran vdout0_36ck1170 FIND v(dout0_36) AT=590.025n

.meas tran vdout0_37ck1170 FIND v(dout0_37) AT=590.025n

.meas tran vdout0_38ck1170 FIND v(dout0_38) AT=590.025n

.meas tran vdout0_39ck1170 FIND v(dout0_39) AT=590.025n

.meas tran vdout0_40ck1170 FIND v(dout0_40) AT=590.025n

.meas tran vdout0_41ck1170 FIND v(dout0_41) AT=590.025n

.meas tran vdout0_42ck1170 FIND v(dout0_42) AT=590.025n

.meas tran vdout0_43ck1170 FIND v(dout0_43) AT=590.025n

.meas tran vdout0_44ck1170 FIND v(dout0_44) AT=590.025n

.meas tran vdout0_45ck1170 FIND v(dout0_45) AT=590.025n

.meas tran vdout0_46ck1170 FIND v(dout0_46) AT=590.025n

.meas tran vdout0_47ck1170 FIND v(dout0_47) AT=590.025n

.meas tran vdout0_48ck1170 FIND v(dout0_48) AT=590.025n

.meas tran vdout0_49ck1170 FIND v(dout0_49) AT=590.025n

.meas tran vdout0_50ck1170 FIND v(dout0_50) AT=590.025n

.meas tran vdout0_51ck1170 FIND v(dout0_51) AT=590.025n

.meas tran vdout0_52ck1170 FIND v(dout0_52) AT=590.025n

.meas tran vdout0_53ck1170 FIND v(dout0_53) AT=590.025n

.meas tran vdout0_54ck1170 FIND v(dout0_54) AT=590.025n

.meas tran vdout0_55ck1170 FIND v(dout0_55) AT=590.025n

.meas tran vdout0_56ck1170 FIND v(dout0_56) AT=590.025n

.meas tran vdout0_57ck1170 FIND v(dout0_57) AT=590.025n

.meas tran vdout0_58ck1170 FIND v(dout0_58) AT=590.025n

.meas tran vdout0_59ck1170 FIND v(dout0_59) AT=590.025n

.meas tran vdout0_60ck1170 FIND v(dout0_60) AT=590.025n

.meas tran vdout0_61ck1170 FIND v(dout0_61) AT=590.025n

.meas tran vdout0_62ck1170 FIND v(dout0_62) AT=590.025n

.meas tran vdout0_63ck1170 FIND v(dout0_63) AT=590.025n

.meas tran vdout0_64ck1170 FIND v(dout0_64) AT=590.025n

.meas tran vdout0_65ck1170 FIND v(dout0_65) AT=590.025n

.meas tran vdout0_66ck1170 FIND v(dout0_66) AT=590.025n

.meas tran vdout0_67ck1170 FIND v(dout0_67) AT=590.025n

.meas tran vdout0_68ck1170 FIND v(dout0_68) AT=590.025n

.meas tran vdout0_69ck1170 FIND v(dout0_69) AT=590.025n

.meas tran vdout0_70ck1170 FIND v(dout0_70) AT=590.025n

.meas tran vdout0_71ck1170 FIND v(dout0_71) AT=590.025n

.meas tran vdout0_72ck1170 FIND v(dout0_72) AT=590.025n

.meas tran vdout0_73ck1170 FIND v(dout0_73) AT=590.025n

.meas tran vdout0_74ck1170 FIND v(dout0_74) AT=590.025n

.meas tran vdout0_75ck1170 FIND v(dout0_75) AT=590.025n

.meas tran vdout0_76ck1170 FIND v(dout0_76) AT=590.025n

.meas tran vdout0_77ck1170 FIND v(dout0_77) AT=590.025n

.meas tran vdout0_78ck1170 FIND v(dout0_78) AT=590.025n

.meas tran vdout0_79ck1170 FIND v(dout0_79) AT=590.025n

.meas tran vdout0_80ck1170 FIND v(dout0_80) AT=590.025n

.meas tran vdout0_81ck1170 FIND v(dout0_81) AT=590.025n

.meas tran vdout0_82ck1170 FIND v(dout0_82) AT=590.025n

.meas tran vdout0_83ck1170 FIND v(dout0_83) AT=590.025n

.meas tran vdout0_84ck1170 FIND v(dout0_84) AT=590.025n

.meas tran vdout0_85ck1170 FIND v(dout0_85) AT=590.025n

.meas tran vdout0_86ck1170 FIND v(dout0_86) AT=590.025n

.meas tran vdout0_87ck1170 FIND v(dout0_87) AT=590.025n

.meas tran vdout0_88ck1170 FIND v(dout0_88) AT=590.025n

.meas tran vdout0_89ck1170 FIND v(dout0_89) AT=590.025n

.meas tran vdout0_90ck1170 FIND v(dout0_90) AT=590.025n

.meas tran vdout0_91ck1170 FIND v(dout0_91) AT=590.025n

.meas tran vdout0_92ck1170 FIND v(dout0_92) AT=590.025n

.meas tran vdout0_93ck1170 FIND v(dout0_93) AT=590.025n

.meas tran vdout0_94ck1170 FIND v(dout0_94) AT=590.025n

.meas tran vdout0_95ck1170 FIND v(dout0_95) AT=590.025n

.meas tran vdout0_96ck1170 FIND v(dout0_96) AT=590.025n

.meas tran vdout0_97ck1170 FIND v(dout0_97) AT=590.025n

.meas tran vdout0_98ck1170 FIND v(dout0_98) AT=590.025n

.meas tran vdout0_99ck1170 FIND v(dout0_99) AT=590.025n

.meas tran vdout0_100ck1170 FIND v(dout0_100) AT=590.025n

.meas tran vdout0_101ck1170 FIND v(dout0_101) AT=590.025n

.meas tran vdout0_102ck1170 FIND v(dout0_102) AT=590.025n

.meas tran vdout0_103ck1170 FIND v(dout0_103) AT=590.025n

.meas tran vdout0_104ck1170 FIND v(dout0_104) AT=590.025n

.meas tran vdout0_105ck1170 FIND v(dout0_105) AT=590.025n

.meas tran vdout0_106ck1170 FIND v(dout0_106) AT=590.025n

.meas tran vdout0_107ck1170 FIND v(dout0_107) AT=590.025n

.meas tran vdout0_108ck1170 FIND v(dout0_108) AT=590.025n

.meas tran vdout0_109ck1170 FIND v(dout0_109) AT=590.025n

.meas tran vdout0_110ck1170 FIND v(dout0_110) AT=590.025n

.meas tran vdout0_111ck1170 FIND v(dout0_111) AT=590.025n

.meas tran vdout0_112ck1170 FIND v(dout0_112) AT=590.025n

.meas tran vdout0_113ck1170 FIND v(dout0_113) AT=590.025n

.meas tran vdout0_114ck1170 FIND v(dout0_114) AT=590.025n

.meas tran vdout0_115ck1170 FIND v(dout0_115) AT=590.025n

.meas tran vdout0_116ck1170 FIND v(dout0_116) AT=590.025n

.meas tran vdout0_117ck1170 FIND v(dout0_117) AT=590.025n

.meas tran vdout0_118ck1170 FIND v(dout0_118) AT=590.025n

.meas tran vdout0_119ck1170 FIND v(dout0_119) AT=590.025n

.meas tran vdout0_120ck1170 FIND v(dout0_120) AT=590.025n

.meas tran vdout0_121ck1170 FIND v(dout0_121) AT=590.025n

.meas tran vdout0_122ck1170 FIND v(dout0_122) AT=590.025n

.meas tran vdout0_123ck1170 FIND v(dout0_123) AT=590.025n

.meas tran vdout0_124ck1170 FIND v(dout0_124) AT=590.025n

.meas tran vdout0_125ck1170 FIND v(dout0_125) AT=590.025n

.meas tran vdout0_126ck1170 FIND v(dout0_126) AT=590.025n

.meas tran vdout0_127ck1170 FIND v(dout0_127) AT=590.025n

.meas tran vdout0_0ck1210 FIND v(dout0_0) AT=610.025n

.meas tran vdout0_1ck1210 FIND v(dout0_1) AT=610.025n

.meas tran vdout0_2ck1210 FIND v(dout0_2) AT=610.025n

.meas tran vdout0_3ck1210 FIND v(dout0_3) AT=610.025n

.meas tran vdout0_4ck1210 FIND v(dout0_4) AT=610.025n

.meas tran vdout0_5ck1210 FIND v(dout0_5) AT=610.025n

.meas tran vdout0_6ck1210 FIND v(dout0_6) AT=610.025n

.meas tran vdout0_7ck1210 FIND v(dout0_7) AT=610.025n

.meas tran vdout0_8ck1210 FIND v(dout0_8) AT=610.025n

.meas tran vdout0_9ck1210 FIND v(dout0_9) AT=610.025n

.meas tran vdout0_10ck1210 FIND v(dout0_10) AT=610.025n

.meas tran vdout0_11ck1210 FIND v(dout0_11) AT=610.025n

.meas tran vdout0_12ck1210 FIND v(dout0_12) AT=610.025n

.meas tran vdout0_13ck1210 FIND v(dout0_13) AT=610.025n

.meas tran vdout0_14ck1210 FIND v(dout0_14) AT=610.025n

.meas tran vdout0_15ck1210 FIND v(dout0_15) AT=610.025n

.meas tran vdout0_16ck1210 FIND v(dout0_16) AT=610.025n

.meas tran vdout0_17ck1210 FIND v(dout0_17) AT=610.025n

.meas tran vdout0_18ck1210 FIND v(dout0_18) AT=610.025n

.meas tran vdout0_19ck1210 FIND v(dout0_19) AT=610.025n

.meas tran vdout0_20ck1210 FIND v(dout0_20) AT=610.025n

.meas tran vdout0_21ck1210 FIND v(dout0_21) AT=610.025n

.meas tran vdout0_22ck1210 FIND v(dout0_22) AT=610.025n

.meas tran vdout0_23ck1210 FIND v(dout0_23) AT=610.025n

.meas tran vdout0_24ck1210 FIND v(dout0_24) AT=610.025n

.meas tran vdout0_25ck1210 FIND v(dout0_25) AT=610.025n

.meas tran vdout0_26ck1210 FIND v(dout0_26) AT=610.025n

.meas tran vdout0_27ck1210 FIND v(dout0_27) AT=610.025n

.meas tran vdout0_28ck1210 FIND v(dout0_28) AT=610.025n

.meas tran vdout0_29ck1210 FIND v(dout0_29) AT=610.025n

.meas tran vdout0_30ck1210 FIND v(dout0_30) AT=610.025n

.meas tran vdout0_31ck1210 FIND v(dout0_31) AT=610.025n

.meas tran vdout0_32ck1210 FIND v(dout0_32) AT=610.025n

.meas tran vdout0_33ck1210 FIND v(dout0_33) AT=610.025n

.meas tran vdout0_34ck1210 FIND v(dout0_34) AT=610.025n

.meas tran vdout0_35ck1210 FIND v(dout0_35) AT=610.025n

.meas tran vdout0_36ck1210 FIND v(dout0_36) AT=610.025n

.meas tran vdout0_37ck1210 FIND v(dout0_37) AT=610.025n

.meas tran vdout0_38ck1210 FIND v(dout0_38) AT=610.025n

.meas tran vdout0_39ck1210 FIND v(dout0_39) AT=610.025n

.meas tran vdout0_40ck1210 FIND v(dout0_40) AT=610.025n

.meas tran vdout0_41ck1210 FIND v(dout0_41) AT=610.025n

.meas tran vdout0_42ck1210 FIND v(dout0_42) AT=610.025n

.meas tran vdout0_43ck1210 FIND v(dout0_43) AT=610.025n

.meas tran vdout0_44ck1210 FIND v(dout0_44) AT=610.025n

.meas tran vdout0_45ck1210 FIND v(dout0_45) AT=610.025n

.meas tran vdout0_46ck1210 FIND v(dout0_46) AT=610.025n

.meas tran vdout0_47ck1210 FIND v(dout0_47) AT=610.025n

.meas tran vdout0_48ck1210 FIND v(dout0_48) AT=610.025n

.meas tran vdout0_49ck1210 FIND v(dout0_49) AT=610.025n

.meas tran vdout0_50ck1210 FIND v(dout0_50) AT=610.025n

.meas tran vdout0_51ck1210 FIND v(dout0_51) AT=610.025n

.meas tran vdout0_52ck1210 FIND v(dout0_52) AT=610.025n

.meas tran vdout0_53ck1210 FIND v(dout0_53) AT=610.025n

.meas tran vdout0_54ck1210 FIND v(dout0_54) AT=610.025n

.meas tran vdout0_55ck1210 FIND v(dout0_55) AT=610.025n

.meas tran vdout0_56ck1210 FIND v(dout0_56) AT=610.025n

.meas tran vdout0_57ck1210 FIND v(dout0_57) AT=610.025n

.meas tran vdout0_58ck1210 FIND v(dout0_58) AT=610.025n

.meas tran vdout0_59ck1210 FIND v(dout0_59) AT=610.025n

.meas tran vdout0_60ck1210 FIND v(dout0_60) AT=610.025n

.meas tran vdout0_61ck1210 FIND v(dout0_61) AT=610.025n

.meas tran vdout0_62ck1210 FIND v(dout0_62) AT=610.025n

.meas tran vdout0_63ck1210 FIND v(dout0_63) AT=610.025n

.meas tran vdout0_64ck1210 FIND v(dout0_64) AT=610.025n

.meas tran vdout0_65ck1210 FIND v(dout0_65) AT=610.025n

.meas tran vdout0_66ck1210 FIND v(dout0_66) AT=610.025n

.meas tran vdout0_67ck1210 FIND v(dout0_67) AT=610.025n

.meas tran vdout0_68ck1210 FIND v(dout0_68) AT=610.025n

.meas tran vdout0_69ck1210 FIND v(dout0_69) AT=610.025n

.meas tran vdout0_70ck1210 FIND v(dout0_70) AT=610.025n

.meas tran vdout0_71ck1210 FIND v(dout0_71) AT=610.025n

.meas tran vdout0_72ck1210 FIND v(dout0_72) AT=610.025n

.meas tran vdout0_73ck1210 FIND v(dout0_73) AT=610.025n

.meas tran vdout0_74ck1210 FIND v(dout0_74) AT=610.025n

.meas tran vdout0_75ck1210 FIND v(dout0_75) AT=610.025n

.meas tran vdout0_76ck1210 FIND v(dout0_76) AT=610.025n

.meas tran vdout0_77ck1210 FIND v(dout0_77) AT=610.025n

.meas tran vdout0_78ck1210 FIND v(dout0_78) AT=610.025n

.meas tran vdout0_79ck1210 FIND v(dout0_79) AT=610.025n

.meas tran vdout0_80ck1210 FIND v(dout0_80) AT=610.025n

.meas tran vdout0_81ck1210 FIND v(dout0_81) AT=610.025n

.meas tran vdout0_82ck1210 FIND v(dout0_82) AT=610.025n

.meas tran vdout0_83ck1210 FIND v(dout0_83) AT=610.025n

.meas tran vdout0_84ck1210 FIND v(dout0_84) AT=610.025n

.meas tran vdout0_85ck1210 FIND v(dout0_85) AT=610.025n

.meas tran vdout0_86ck1210 FIND v(dout0_86) AT=610.025n

.meas tran vdout0_87ck1210 FIND v(dout0_87) AT=610.025n

.meas tran vdout0_88ck1210 FIND v(dout0_88) AT=610.025n

.meas tran vdout0_89ck1210 FIND v(dout0_89) AT=610.025n

.meas tran vdout0_90ck1210 FIND v(dout0_90) AT=610.025n

.meas tran vdout0_91ck1210 FIND v(dout0_91) AT=610.025n

.meas tran vdout0_92ck1210 FIND v(dout0_92) AT=610.025n

.meas tran vdout0_93ck1210 FIND v(dout0_93) AT=610.025n

.meas tran vdout0_94ck1210 FIND v(dout0_94) AT=610.025n

.meas tran vdout0_95ck1210 FIND v(dout0_95) AT=610.025n

.meas tran vdout0_96ck1210 FIND v(dout0_96) AT=610.025n

.meas tran vdout0_97ck1210 FIND v(dout0_97) AT=610.025n

.meas tran vdout0_98ck1210 FIND v(dout0_98) AT=610.025n

.meas tran vdout0_99ck1210 FIND v(dout0_99) AT=610.025n

.meas tran vdout0_100ck1210 FIND v(dout0_100) AT=610.025n

.meas tran vdout0_101ck1210 FIND v(dout0_101) AT=610.025n

.meas tran vdout0_102ck1210 FIND v(dout0_102) AT=610.025n

.meas tran vdout0_103ck1210 FIND v(dout0_103) AT=610.025n

.meas tran vdout0_104ck1210 FIND v(dout0_104) AT=610.025n

.meas tran vdout0_105ck1210 FIND v(dout0_105) AT=610.025n

.meas tran vdout0_106ck1210 FIND v(dout0_106) AT=610.025n

.meas tran vdout0_107ck1210 FIND v(dout0_107) AT=610.025n

.meas tran vdout0_108ck1210 FIND v(dout0_108) AT=610.025n

.meas tran vdout0_109ck1210 FIND v(dout0_109) AT=610.025n

.meas tran vdout0_110ck1210 FIND v(dout0_110) AT=610.025n

.meas tran vdout0_111ck1210 FIND v(dout0_111) AT=610.025n

.meas tran vdout0_112ck1210 FIND v(dout0_112) AT=610.025n

.meas tran vdout0_113ck1210 FIND v(dout0_113) AT=610.025n

.meas tran vdout0_114ck1210 FIND v(dout0_114) AT=610.025n

.meas tran vdout0_115ck1210 FIND v(dout0_115) AT=610.025n

.meas tran vdout0_116ck1210 FIND v(dout0_116) AT=610.025n

.meas tran vdout0_117ck1210 FIND v(dout0_117) AT=610.025n

.meas tran vdout0_118ck1210 FIND v(dout0_118) AT=610.025n

.meas tran vdout0_119ck1210 FIND v(dout0_119) AT=610.025n

.meas tran vdout0_120ck1210 FIND v(dout0_120) AT=610.025n

.meas tran vdout0_121ck1210 FIND v(dout0_121) AT=610.025n

.meas tran vdout0_122ck1210 FIND v(dout0_122) AT=610.025n

.meas tran vdout0_123ck1210 FIND v(dout0_123) AT=610.025n

.meas tran vdout0_124ck1210 FIND v(dout0_124) AT=610.025n

.meas tran vdout0_125ck1210 FIND v(dout0_125) AT=610.025n

.meas tran vdout0_126ck1210 FIND v(dout0_126) AT=610.025n

.meas tran vdout0_127ck1210 FIND v(dout0_127) AT=610.025n

.meas tran vdout0_0ck1250 FIND v(dout0_0) AT=630.025n

.meas tran vdout0_1ck1250 FIND v(dout0_1) AT=630.025n

.meas tran vdout0_2ck1250 FIND v(dout0_2) AT=630.025n

.meas tran vdout0_3ck1250 FIND v(dout0_3) AT=630.025n

.meas tran vdout0_4ck1250 FIND v(dout0_4) AT=630.025n

.meas tran vdout0_5ck1250 FIND v(dout0_5) AT=630.025n

.meas tran vdout0_6ck1250 FIND v(dout0_6) AT=630.025n

.meas tran vdout0_7ck1250 FIND v(dout0_7) AT=630.025n

.meas tran vdout0_8ck1250 FIND v(dout0_8) AT=630.025n

.meas tran vdout0_9ck1250 FIND v(dout0_9) AT=630.025n

.meas tran vdout0_10ck1250 FIND v(dout0_10) AT=630.025n

.meas tran vdout0_11ck1250 FIND v(dout0_11) AT=630.025n

.meas tran vdout0_12ck1250 FIND v(dout0_12) AT=630.025n

.meas tran vdout0_13ck1250 FIND v(dout0_13) AT=630.025n

.meas tran vdout0_14ck1250 FIND v(dout0_14) AT=630.025n

.meas tran vdout0_15ck1250 FIND v(dout0_15) AT=630.025n

.meas tran vdout0_16ck1250 FIND v(dout0_16) AT=630.025n

.meas tran vdout0_17ck1250 FIND v(dout0_17) AT=630.025n

.meas tran vdout0_18ck1250 FIND v(dout0_18) AT=630.025n

.meas tran vdout0_19ck1250 FIND v(dout0_19) AT=630.025n

.meas tran vdout0_20ck1250 FIND v(dout0_20) AT=630.025n

.meas tran vdout0_21ck1250 FIND v(dout0_21) AT=630.025n

.meas tran vdout0_22ck1250 FIND v(dout0_22) AT=630.025n

.meas tran vdout0_23ck1250 FIND v(dout0_23) AT=630.025n

.meas tran vdout0_24ck1250 FIND v(dout0_24) AT=630.025n

.meas tran vdout0_25ck1250 FIND v(dout0_25) AT=630.025n

.meas tran vdout0_26ck1250 FIND v(dout0_26) AT=630.025n

.meas tran vdout0_27ck1250 FIND v(dout0_27) AT=630.025n

.meas tran vdout0_28ck1250 FIND v(dout0_28) AT=630.025n

.meas tran vdout0_29ck1250 FIND v(dout0_29) AT=630.025n

.meas tran vdout0_30ck1250 FIND v(dout0_30) AT=630.025n

.meas tran vdout0_31ck1250 FIND v(dout0_31) AT=630.025n

.meas tran vdout0_32ck1250 FIND v(dout0_32) AT=630.025n

.meas tran vdout0_33ck1250 FIND v(dout0_33) AT=630.025n

.meas tran vdout0_34ck1250 FIND v(dout0_34) AT=630.025n

.meas tran vdout0_35ck1250 FIND v(dout0_35) AT=630.025n

.meas tran vdout0_36ck1250 FIND v(dout0_36) AT=630.025n

.meas tran vdout0_37ck1250 FIND v(dout0_37) AT=630.025n

.meas tran vdout0_38ck1250 FIND v(dout0_38) AT=630.025n

.meas tran vdout0_39ck1250 FIND v(dout0_39) AT=630.025n

.meas tran vdout0_40ck1250 FIND v(dout0_40) AT=630.025n

.meas tran vdout0_41ck1250 FIND v(dout0_41) AT=630.025n

.meas tran vdout0_42ck1250 FIND v(dout0_42) AT=630.025n

.meas tran vdout0_43ck1250 FIND v(dout0_43) AT=630.025n

.meas tran vdout0_44ck1250 FIND v(dout0_44) AT=630.025n

.meas tran vdout0_45ck1250 FIND v(dout0_45) AT=630.025n

.meas tran vdout0_46ck1250 FIND v(dout0_46) AT=630.025n

.meas tran vdout0_47ck1250 FIND v(dout0_47) AT=630.025n

.meas tran vdout0_48ck1250 FIND v(dout0_48) AT=630.025n

.meas tran vdout0_49ck1250 FIND v(dout0_49) AT=630.025n

.meas tran vdout0_50ck1250 FIND v(dout0_50) AT=630.025n

.meas tran vdout0_51ck1250 FIND v(dout0_51) AT=630.025n

.meas tran vdout0_52ck1250 FIND v(dout0_52) AT=630.025n

.meas tran vdout0_53ck1250 FIND v(dout0_53) AT=630.025n

.meas tran vdout0_54ck1250 FIND v(dout0_54) AT=630.025n

.meas tran vdout0_55ck1250 FIND v(dout0_55) AT=630.025n

.meas tran vdout0_56ck1250 FIND v(dout0_56) AT=630.025n

.meas tran vdout0_57ck1250 FIND v(dout0_57) AT=630.025n

.meas tran vdout0_58ck1250 FIND v(dout0_58) AT=630.025n

.meas tran vdout0_59ck1250 FIND v(dout0_59) AT=630.025n

.meas tran vdout0_60ck1250 FIND v(dout0_60) AT=630.025n

.meas tran vdout0_61ck1250 FIND v(dout0_61) AT=630.025n

.meas tran vdout0_62ck1250 FIND v(dout0_62) AT=630.025n

.meas tran vdout0_63ck1250 FIND v(dout0_63) AT=630.025n

.meas tran vdout0_64ck1250 FIND v(dout0_64) AT=630.025n

.meas tran vdout0_65ck1250 FIND v(dout0_65) AT=630.025n

.meas tran vdout0_66ck1250 FIND v(dout0_66) AT=630.025n

.meas tran vdout0_67ck1250 FIND v(dout0_67) AT=630.025n

.meas tran vdout0_68ck1250 FIND v(dout0_68) AT=630.025n

.meas tran vdout0_69ck1250 FIND v(dout0_69) AT=630.025n

.meas tran vdout0_70ck1250 FIND v(dout0_70) AT=630.025n

.meas tran vdout0_71ck1250 FIND v(dout0_71) AT=630.025n

.meas tran vdout0_72ck1250 FIND v(dout0_72) AT=630.025n

.meas tran vdout0_73ck1250 FIND v(dout0_73) AT=630.025n

.meas tran vdout0_74ck1250 FIND v(dout0_74) AT=630.025n

.meas tran vdout0_75ck1250 FIND v(dout0_75) AT=630.025n

.meas tran vdout0_76ck1250 FIND v(dout0_76) AT=630.025n

.meas tran vdout0_77ck1250 FIND v(dout0_77) AT=630.025n

.meas tran vdout0_78ck1250 FIND v(dout0_78) AT=630.025n

.meas tran vdout0_79ck1250 FIND v(dout0_79) AT=630.025n

.meas tran vdout0_80ck1250 FIND v(dout0_80) AT=630.025n

.meas tran vdout0_81ck1250 FIND v(dout0_81) AT=630.025n

.meas tran vdout0_82ck1250 FIND v(dout0_82) AT=630.025n

.meas tran vdout0_83ck1250 FIND v(dout0_83) AT=630.025n

.meas tran vdout0_84ck1250 FIND v(dout0_84) AT=630.025n

.meas tran vdout0_85ck1250 FIND v(dout0_85) AT=630.025n

.meas tran vdout0_86ck1250 FIND v(dout0_86) AT=630.025n

.meas tran vdout0_87ck1250 FIND v(dout0_87) AT=630.025n

.meas tran vdout0_88ck1250 FIND v(dout0_88) AT=630.025n

.meas tran vdout0_89ck1250 FIND v(dout0_89) AT=630.025n

.meas tran vdout0_90ck1250 FIND v(dout0_90) AT=630.025n

.meas tran vdout0_91ck1250 FIND v(dout0_91) AT=630.025n

.meas tran vdout0_92ck1250 FIND v(dout0_92) AT=630.025n

.meas tran vdout0_93ck1250 FIND v(dout0_93) AT=630.025n

.meas tran vdout0_94ck1250 FIND v(dout0_94) AT=630.025n

.meas tran vdout0_95ck1250 FIND v(dout0_95) AT=630.025n

.meas tran vdout0_96ck1250 FIND v(dout0_96) AT=630.025n

.meas tran vdout0_97ck1250 FIND v(dout0_97) AT=630.025n

.meas tran vdout0_98ck1250 FIND v(dout0_98) AT=630.025n

.meas tran vdout0_99ck1250 FIND v(dout0_99) AT=630.025n

.meas tran vdout0_100ck1250 FIND v(dout0_100) AT=630.025n

.meas tran vdout0_101ck1250 FIND v(dout0_101) AT=630.025n

.meas tran vdout0_102ck1250 FIND v(dout0_102) AT=630.025n

.meas tran vdout0_103ck1250 FIND v(dout0_103) AT=630.025n

.meas tran vdout0_104ck1250 FIND v(dout0_104) AT=630.025n

.meas tran vdout0_105ck1250 FIND v(dout0_105) AT=630.025n

.meas tran vdout0_106ck1250 FIND v(dout0_106) AT=630.025n

.meas tran vdout0_107ck1250 FIND v(dout0_107) AT=630.025n

.meas tran vdout0_108ck1250 FIND v(dout0_108) AT=630.025n

.meas tran vdout0_109ck1250 FIND v(dout0_109) AT=630.025n

.meas tran vdout0_110ck1250 FIND v(dout0_110) AT=630.025n

.meas tran vdout0_111ck1250 FIND v(dout0_111) AT=630.025n

.meas tran vdout0_112ck1250 FIND v(dout0_112) AT=630.025n

.meas tran vdout0_113ck1250 FIND v(dout0_113) AT=630.025n

.meas tran vdout0_114ck1250 FIND v(dout0_114) AT=630.025n

.meas tran vdout0_115ck1250 FIND v(dout0_115) AT=630.025n

.meas tran vdout0_116ck1250 FIND v(dout0_116) AT=630.025n

.meas tran vdout0_117ck1250 FIND v(dout0_117) AT=630.025n

.meas tran vdout0_118ck1250 FIND v(dout0_118) AT=630.025n

.meas tran vdout0_119ck1250 FIND v(dout0_119) AT=630.025n

.meas tran vdout0_120ck1250 FIND v(dout0_120) AT=630.025n

.meas tran vdout0_121ck1250 FIND v(dout0_121) AT=630.025n

.meas tran vdout0_122ck1250 FIND v(dout0_122) AT=630.025n

.meas tran vdout0_123ck1250 FIND v(dout0_123) AT=630.025n

.meas tran vdout0_124ck1250 FIND v(dout0_124) AT=630.025n

.meas tran vdout0_125ck1250 FIND v(dout0_125) AT=630.025n

.meas tran vdout0_126ck1250 FIND v(dout0_126) AT=630.025n

.meas tran vdout0_127ck1250 FIND v(dout0_127) AT=630.025n

.meas tran vdout0_0ck1260 FIND v(dout0_0) AT=635.025n

.meas tran vdout0_1ck1260 FIND v(dout0_1) AT=635.025n

.meas tran vdout0_2ck1260 FIND v(dout0_2) AT=635.025n

.meas tran vdout0_3ck1260 FIND v(dout0_3) AT=635.025n

.meas tran vdout0_4ck1260 FIND v(dout0_4) AT=635.025n

.meas tran vdout0_5ck1260 FIND v(dout0_5) AT=635.025n

.meas tran vdout0_6ck1260 FIND v(dout0_6) AT=635.025n

.meas tran vdout0_7ck1260 FIND v(dout0_7) AT=635.025n

.meas tran vdout0_8ck1260 FIND v(dout0_8) AT=635.025n

.meas tran vdout0_9ck1260 FIND v(dout0_9) AT=635.025n

.meas tran vdout0_10ck1260 FIND v(dout0_10) AT=635.025n

.meas tran vdout0_11ck1260 FIND v(dout0_11) AT=635.025n

.meas tran vdout0_12ck1260 FIND v(dout0_12) AT=635.025n

.meas tran vdout0_13ck1260 FIND v(dout0_13) AT=635.025n

.meas tran vdout0_14ck1260 FIND v(dout0_14) AT=635.025n

.meas tran vdout0_15ck1260 FIND v(dout0_15) AT=635.025n

.meas tran vdout0_16ck1260 FIND v(dout0_16) AT=635.025n

.meas tran vdout0_17ck1260 FIND v(dout0_17) AT=635.025n

.meas tran vdout0_18ck1260 FIND v(dout0_18) AT=635.025n

.meas tran vdout0_19ck1260 FIND v(dout0_19) AT=635.025n

.meas tran vdout0_20ck1260 FIND v(dout0_20) AT=635.025n

.meas tran vdout0_21ck1260 FIND v(dout0_21) AT=635.025n

.meas tran vdout0_22ck1260 FIND v(dout0_22) AT=635.025n

.meas tran vdout0_23ck1260 FIND v(dout0_23) AT=635.025n

.meas tran vdout0_24ck1260 FIND v(dout0_24) AT=635.025n

.meas tran vdout0_25ck1260 FIND v(dout0_25) AT=635.025n

.meas tran vdout0_26ck1260 FIND v(dout0_26) AT=635.025n

.meas tran vdout0_27ck1260 FIND v(dout0_27) AT=635.025n

.meas tran vdout0_28ck1260 FIND v(dout0_28) AT=635.025n

.meas tran vdout0_29ck1260 FIND v(dout0_29) AT=635.025n

.meas tran vdout0_30ck1260 FIND v(dout0_30) AT=635.025n

.meas tran vdout0_31ck1260 FIND v(dout0_31) AT=635.025n

.meas tran vdout0_32ck1260 FIND v(dout0_32) AT=635.025n

.meas tran vdout0_33ck1260 FIND v(dout0_33) AT=635.025n

.meas tran vdout0_34ck1260 FIND v(dout0_34) AT=635.025n

.meas tran vdout0_35ck1260 FIND v(dout0_35) AT=635.025n

.meas tran vdout0_36ck1260 FIND v(dout0_36) AT=635.025n

.meas tran vdout0_37ck1260 FIND v(dout0_37) AT=635.025n

.meas tran vdout0_38ck1260 FIND v(dout0_38) AT=635.025n

.meas tran vdout0_39ck1260 FIND v(dout0_39) AT=635.025n

.meas tran vdout0_40ck1260 FIND v(dout0_40) AT=635.025n

.meas tran vdout0_41ck1260 FIND v(dout0_41) AT=635.025n

.meas tran vdout0_42ck1260 FIND v(dout0_42) AT=635.025n

.meas tran vdout0_43ck1260 FIND v(dout0_43) AT=635.025n

.meas tran vdout0_44ck1260 FIND v(dout0_44) AT=635.025n

.meas tran vdout0_45ck1260 FIND v(dout0_45) AT=635.025n

.meas tran vdout0_46ck1260 FIND v(dout0_46) AT=635.025n

.meas tran vdout0_47ck1260 FIND v(dout0_47) AT=635.025n

.meas tran vdout0_48ck1260 FIND v(dout0_48) AT=635.025n

.meas tran vdout0_49ck1260 FIND v(dout0_49) AT=635.025n

.meas tran vdout0_50ck1260 FIND v(dout0_50) AT=635.025n

.meas tran vdout0_51ck1260 FIND v(dout0_51) AT=635.025n

.meas tran vdout0_52ck1260 FIND v(dout0_52) AT=635.025n

.meas tran vdout0_53ck1260 FIND v(dout0_53) AT=635.025n

.meas tran vdout0_54ck1260 FIND v(dout0_54) AT=635.025n

.meas tran vdout0_55ck1260 FIND v(dout0_55) AT=635.025n

.meas tran vdout0_56ck1260 FIND v(dout0_56) AT=635.025n

.meas tran vdout0_57ck1260 FIND v(dout0_57) AT=635.025n

.meas tran vdout0_58ck1260 FIND v(dout0_58) AT=635.025n

.meas tran vdout0_59ck1260 FIND v(dout0_59) AT=635.025n

.meas tran vdout0_60ck1260 FIND v(dout0_60) AT=635.025n

.meas tran vdout0_61ck1260 FIND v(dout0_61) AT=635.025n

.meas tran vdout0_62ck1260 FIND v(dout0_62) AT=635.025n

.meas tran vdout0_63ck1260 FIND v(dout0_63) AT=635.025n

.meas tran vdout0_64ck1260 FIND v(dout0_64) AT=635.025n

.meas tran vdout0_65ck1260 FIND v(dout0_65) AT=635.025n

.meas tran vdout0_66ck1260 FIND v(dout0_66) AT=635.025n

.meas tran vdout0_67ck1260 FIND v(dout0_67) AT=635.025n

.meas tran vdout0_68ck1260 FIND v(dout0_68) AT=635.025n

.meas tran vdout0_69ck1260 FIND v(dout0_69) AT=635.025n

.meas tran vdout0_70ck1260 FIND v(dout0_70) AT=635.025n

.meas tran vdout0_71ck1260 FIND v(dout0_71) AT=635.025n

.meas tran vdout0_72ck1260 FIND v(dout0_72) AT=635.025n

.meas tran vdout0_73ck1260 FIND v(dout0_73) AT=635.025n

.meas tran vdout0_74ck1260 FIND v(dout0_74) AT=635.025n

.meas tran vdout0_75ck1260 FIND v(dout0_75) AT=635.025n

.meas tran vdout0_76ck1260 FIND v(dout0_76) AT=635.025n

.meas tran vdout0_77ck1260 FIND v(dout0_77) AT=635.025n

.meas tran vdout0_78ck1260 FIND v(dout0_78) AT=635.025n

.meas tran vdout0_79ck1260 FIND v(dout0_79) AT=635.025n

.meas tran vdout0_80ck1260 FIND v(dout0_80) AT=635.025n

.meas tran vdout0_81ck1260 FIND v(dout0_81) AT=635.025n

.meas tran vdout0_82ck1260 FIND v(dout0_82) AT=635.025n

.meas tran vdout0_83ck1260 FIND v(dout0_83) AT=635.025n

.meas tran vdout0_84ck1260 FIND v(dout0_84) AT=635.025n

.meas tran vdout0_85ck1260 FIND v(dout0_85) AT=635.025n

.meas tran vdout0_86ck1260 FIND v(dout0_86) AT=635.025n

.meas tran vdout0_87ck1260 FIND v(dout0_87) AT=635.025n

.meas tran vdout0_88ck1260 FIND v(dout0_88) AT=635.025n

.meas tran vdout0_89ck1260 FIND v(dout0_89) AT=635.025n

.meas tran vdout0_90ck1260 FIND v(dout0_90) AT=635.025n

.meas tran vdout0_91ck1260 FIND v(dout0_91) AT=635.025n

.meas tran vdout0_92ck1260 FIND v(dout0_92) AT=635.025n

.meas tran vdout0_93ck1260 FIND v(dout0_93) AT=635.025n

.meas tran vdout0_94ck1260 FIND v(dout0_94) AT=635.025n

.meas tran vdout0_95ck1260 FIND v(dout0_95) AT=635.025n

.meas tran vdout0_96ck1260 FIND v(dout0_96) AT=635.025n

.meas tran vdout0_97ck1260 FIND v(dout0_97) AT=635.025n

.meas tran vdout0_98ck1260 FIND v(dout0_98) AT=635.025n

.meas tran vdout0_99ck1260 FIND v(dout0_99) AT=635.025n

.meas tran vdout0_100ck1260 FIND v(dout0_100) AT=635.025n

.meas tran vdout0_101ck1260 FIND v(dout0_101) AT=635.025n

.meas tran vdout0_102ck1260 FIND v(dout0_102) AT=635.025n

.meas tran vdout0_103ck1260 FIND v(dout0_103) AT=635.025n

.meas tran vdout0_104ck1260 FIND v(dout0_104) AT=635.025n

.meas tran vdout0_105ck1260 FIND v(dout0_105) AT=635.025n

.meas tran vdout0_106ck1260 FIND v(dout0_106) AT=635.025n

.meas tran vdout0_107ck1260 FIND v(dout0_107) AT=635.025n

.meas tran vdout0_108ck1260 FIND v(dout0_108) AT=635.025n

.meas tran vdout0_109ck1260 FIND v(dout0_109) AT=635.025n

.meas tran vdout0_110ck1260 FIND v(dout0_110) AT=635.025n

.meas tran vdout0_111ck1260 FIND v(dout0_111) AT=635.025n

.meas tran vdout0_112ck1260 FIND v(dout0_112) AT=635.025n

.meas tran vdout0_113ck1260 FIND v(dout0_113) AT=635.025n

.meas tran vdout0_114ck1260 FIND v(dout0_114) AT=635.025n

.meas tran vdout0_115ck1260 FIND v(dout0_115) AT=635.025n

.meas tran vdout0_116ck1260 FIND v(dout0_116) AT=635.025n

.meas tran vdout0_117ck1260 FIND v(dout0_117) AT=635.025n

.meas tran vdout0_118ck1260 FIND v(dout0_118) AT=635.025n

.meas tran vdout0_119ck1260 FIND v(dout0_119) AT=635.025n

.meas tran vdout0_120ck1260 FIND v(dout0_120) AT=635.025n

.meas tran vdout0_121ck1260 FIND v(dout0_121) AT=635.025n

.meas tran vdout0_122ck1260 FIND v(dout0_122) AT=635.025n

.meas tran vdout0_123ck1260 FIND v(dout0_123) AT=635.025n

.meas tran vdout0_124ck1260 FIND v(dout0_124) AT=635.025n

.meas tran vdout0_125ck1260 FIND v(dout0_125) AT=635.025n

.meas tran vdout0_126ck1260 FIND v(dout0_126) AT=635.025n

.meas tran vdout0_127ck1260 FIND v(dout0_127) AT=635.025n

.meas tran vdout0_0ck1270 FIND v(dout0_0) AT=640.025n

.meas tran vdout0_1ck1270 FIND v(dout0_1) AT=640.025n

.meas tran vdout0_2ck1270 FIND v(dout0_2) AT=640.025n

.meas tran vdout0_3ck1270 FIND v(dout0_3) AT=640.025n

.meas tran vdout0_4ck1270 FIND v(dout0_4) AT=640.025n

.meas tran vdout0_5ck1270 FIND v(dout0_5) AT=640.025n

.meas tran vdout0_6ck1270 FIND v(dout0_6) AT=640.025n

.meas tran vdout0_7ck1270 FIND v(dout0_7) AT=640.025n

.meas tran vdout0_8ck1270 FIND v(dout0_8) AT=640.025n

.meas tran vdout0_9ck1270 FIND v(dout0_9) AT=640.025n

.meas tran vdout0_10ck1270 FIND v(dout0_10) AT=640.025n

.meas tran vdout0_11ck1270 FIND v(dout0_11) AT=640.025n

.meas tran vdout0_12ck1270 FIND v(dout0_12) AT=640.025n

.meas tran vdout0_13ck1270 FIND v(dout0_13) AT=640.025n

.meas tran vdout0_14ck1270 FIND v(dout0_14) AT=640.025n

.meas tran vdout0_15ck1270 FIND v(dout0_15) AT=640.025n

.meas tran vdout0_16ck1270 FIND v(dout0_16) AT=640.025n

.meas tran vdout0_17ck1270 FIND v(dout0_17) AT=640.025n

.meas tran vdout0_18ck1270 FIND v(dout0_18) AT=640.025n

.meas tran vdout0_19ck1270 FIND v(dout0_19) AT=640.025n

.meas tran vdout0_20ck1270 FIND v(dout0_20) AT=640.025n

.meas tran vdout0_21ck1270 FIND v(dout0_21) AT=640.025n

.meas tran vdout0_22ck1270 FIND v(dout0_22) AT=640.025n

.meas tran vdout0_23ck1270 FIND v(dout0_23) AT=640.025n

.meas tran vdout0_24ck1270 FIND v(dout0_24) AT=640.025n

.meas tran vdout0_25ck1270 FIND v(dout0_25) AT=640.025n

.meas tran vdout0_26ck1270 FIND v(dout0_26) AT=640.025n

.meas tran vdout0_27ck1270 FIND v(dout0_27) AT=640.025n

.meas tran vdout0_28ck1270 FIND v(dout0_28) AT=640.025n

.meas tran vdout0_29ck1270 FIND v(dout0_29) AT=640.025n

.meas tran vdout0_30ck1270 FIND v(dout0_30) AT=640.025n

.meas tran vdout0_31ck1270 FIND v(dout0_31) AT=640.025n

.meas tran vdout0_32ck1270 FIND v(dout0_32) AT=640.025n

.meas tran vdout0_33ck1270 FIND v(dout0_33) AT=640.025n

.meas tran vdout0_34ck1270 FIND v(dout0_34) AT=640.025n

.meas tran vdout0_35ck1270 FIND v(dout0_35) AT=640.025n

.meas tran vdout0_36ck1270 FIND v(dout0_36) AT=640.025n

.meas tran vdout0_37ck1270 FIND v(dout0_37) AT=640.025n

.meas tran vdout0_38ck1270 FIND v(dout0_38) AT=640.025n

.meas tran vdout0_39ck1270 FIND v(dout0_39) AT=640.025n

.meas tran vdout0_40ck1270 FIND v(dout0_40) AT=640.025n

.meas tran vdout0_41ck1270 FIND v(dout0_41) AT=640.025n

.meas tran vdout0_42ck1270 FIND v(dout0_42) AT=640.025n

.meas tran vdout0_43ck1270 FIND v(dout0_43) AT=640.025n

.meas tran vdout0_44ck1270 FIND v(dout0_44) AT=640.025n

.meas tran vdout0_45ck1270 FIND v(dout0_45) AT=640.025n

.meas tran vdout0_46ck1270 FIND v(dout0_46) AT=640.025n

.meas tran vdout0_47ck1270 FIND v(dout0_47) AT=640.025n

.meas tran vdout0_48ck1270 FIND v(dout0_48) AT=640.025n

.meas tran vdout0_49ck1270 FIND v(dout0_49) AT=640.025n

.meas tran vdout0_50ck1270 FIND v(dout0_50) AT=640.025n

.meas tran vdout0_51ck1270 FIND v(dout0_51) AT=640.025n

.meas tran vdout0_52ck1270 FIND v(dout0_52) AT=640.025n

.meas tran vdout0_53ck1270 FIND v(dout0_53) AT=640.025n

.meas tran vdout0_54ck1270 FIND v(dout0_54) AT=640.025n

.meas tran vdout0_55ck1270 FIND v(dout0_55) AT=640.025n

.meas tran vdout0_56ck1270 FIND v(dout0_56) AT=640.025n

.meas tran vdout0_57ck1270 FIND v(dout0_57) AT=640.025n

.meas tran vdout0_58ck1270 FIND v(dout0_58) AT=640.025n

.meas tran vdout0_59ck1270 FIND v(dout0_59) AT=640.025n

.meas tran vdout0_60ck1270 FIND v(dout0_60) AT=640.025n

.meas tran vdout0_61ck1270 FIND v(dout0_61) AT=640.025n

.meas tran vdout0_62ck1270 FIND v(dout0_62) AT=640.025n

.meas tran vdout0_63ck1270 FIND v(dout0_63) AT=640.025n

.meas tran vdout0_64ck1270 FIND v(dout0_64) AT=640.025n

.meas tran vdout0_65ck1270 FIND v(dout0_65) AT=640.025n

.meas tran vdout0_66ck1270 FIND v(dout0_66) AT=640.025n

.meas tran vdout0_67ck1270 FIND v(dout0_67) AT=640.025n

.meas tran vdout0_68ck1270 FIND v(dout0_68) AT=640.025n

.meas tran vdout0_69ck1270 FIND v(dout0_69) AT=640.025n

.meas tran vdout0_70ck1270 FIND v(dout0_70) AT=640.025n

.meas tran vdout0_71ck1270 FIND v(dout0_71) AT=640.025n

.meas tran vdout0_72ck1270 FIND v(dout0_72) AT=640.025n

.meas tran vdout0_73ck1270 FIND v(dout0_73) AT=640.025n

.meas tran vdout0_74ck1270 FIND v(dout0_74) AT=640.025n

.meas tran vdout0_75ck1270 FIND v(dout0_75) AT=640.025n

.meas tran vdout0_76ck1270 FIND v(dout0_76) AT=640.025n

.meas tran vdout0_77ck1270 FIND v(dout0_77) AT=640.025n

.meas tran vdout0_78ck1270 FIND v(dout0_78) AT=640.025n

.meas tran vdout0_79ck1270 FIND v(dout0_79) AT=640.025n

.meas tran vdout0_80ck1270 FIND v(dout0_80) AT=640.025n

.meas tran vdout0_81ck1270 FIND v(dout0_81) AT=640.025n

.meas tran vdout0_82ck1270 FIND v(dout0_82) AT=640.025n

.meas tran vdout0_83ck1270 FIND v(dout0_83) AT=640.025n

.meas tran vdout0_84ck1270 FIND v(dout0_84) AT=640.025n

.meas tran vdout0_85ck1270 FIND v(dout0_85) AT=640.025n

.meas tran vdout0_86ck1270 FIND v(dout0_86) AT=640.025n

.meas tran vdout0_87ck1270 FIND v(dout0_87) AT=640.025n

.meas tran vdout0_88ck1270 FIND v(dout0_88) AT=640.025n

.meas tran vdout0_89ck1270 FIND v(dout0_89) AT=640.025n

.meas tran vdout0_90ck1270 FIND v(dout0_90) AT=640.025n

.meas tran vdout0_91ck1270 FIND v(dout0_91) AT=640.025n

.meas tran vdout0_92ck1270 FIND v(dout0_92) AT=640.025n

.meas tran vdout0_93ck1270 FIND v(dout0_93) AT=640.025n

.meas tran vdout0_94ck1270 FIND v(dout0_94) AT=640.025n

.meas tran vdout0_95ck1270 FIND v(dout0_95) AT=640.025n

.meas tran vdout0_96ck1270 FIND v(dout0_96) AT=640.025n

.meas tran vdout0_97ck1270 FIND v(dout0_97) AT=640.025n

.meas tran vdout0_98ck1270 FIND v(dout0_98) AT=640.025n

.meas tran vdout0_99ck1270 FIND v(dout0_99) AT=640.025n

.meas tran vdout0_100ck1270 FIND v(dout0_100) AT=640.025n

.meas tran vdout0_101ck1270 FIND v(dout0_101) AT=640.025n

.meas tran vdout0_102ck1270 FIND v(dout0_102) AT=640.025n

.meas tran vdout0_103ck1270 FIND v(dout0_103) AT=640.025n

.meas tran vdout0_104ck1270 FIND v(dout0_104) AT=640.025n

.meas tran vdout0_105ck1270 FIND v(dout0_105) AT=640.025n

.meas tran vdout0_106ck1270 FIND v(dout0_106) AT=640.025n

.meas tran vdout0_107ck1270 FIND v(dout0_107) AT=640.025n

.meas tran vdout0_108ck1270 FIND v(dout0_108) AT=640.025n

.meas tran vdout0_109ck1270 FIND v(dout0_109) AT=640.025n

.meas tran vdout0_110ck1270 FIND v(dout0_110) AT=640.025n

.meas tran vdout0_111ck1270 FIND v(dout0_111) AT=640.025n

.meas tran vdout0_112ck1270 FIND v(dout0_112) AT=640.025n

.meas tran vdout0_113ck1270 FIND v(dout0_113) AT=640.025n

.meas tran vdout0_114ck1270 FIND v(dout0_114) AT=640.025n

.meas tran vdout0_115ck1270 FIND v(dout0_115) AT=640.025n

.meas tran vdout0_116ck1270 FIND v(dout0_116) AT=640.025n

.meas tran vdout0_117ck1270 FIND v(dout0_117) AT=640.025n

.meas tran vdout0_118ck1270 FIND v(dout0_118) AT=640.025n

.meas tran vdout0_119ck1270 FIND v(dout0_119) AT=640.025n

.meas tran vdout0_120ck1270 FIND v(dout0_120) AT=640.025n

.meas tran vdout0_121ck1270 FIND v(dout0_121) AT=640.025n

.meas tran vdout0_122ck1270 FIND v(dout0_122) AT=640.025n

.meas tran vdout0_123ck1270 FIND v(dout0_123) AT=640.025n

.meas tran vdout0_124ck1270 FIND v(dout0_124) AT=640.025n

.meas tran vdout0_125ck1270 FIND v(dout0_125) AT=640.025n

.meas tran vdout0_126ck1270 FIND v(dout0_126) AT=640.025n

.meas tran vdout0_127ck1270 FIND v(dout0_127) AT=640.025n

.meas tran vdout0_0ck1290 FIND v(dout0_0) AT=650.025n

.meas tran vdout0_1ck1290 FIND v(dout0_1) AT=650.025n

.meas tran vdout0_2ck1290 FIND v(dout0_2) AT=650.025n

.meas tran vdout0_3ck1290 FIND v(dout0_3) AT=650.025n

.meas tran vdout0_4ck1290 FIND v(dout0_4) AT=650.025n

.meas tran vdout0_5ck1290 FIND v(dout0_5) AT=650.025n

.meas tran vdout0_6ck1290 FIND v(dout0_6) AT=650.025n

.meas tran vdout0_7ck1290 FIND v(dout0_7) AT=650.025n

.meas tran vdout0_8ck1290 FIND v(dout0_8) AT=650.025n

.meas tran vdout0_9ck1290 FIND v(dout0_9) AT=650.025n

.meas tran vdout0_10ck1290 FIND v(dout0_10) AT=650.025n

.meas tran vdout0_11ck1290 FIND v(dout0_11) AT=650.025n

.meas tran vdout0_12ck1290 FIND v(dout0_12) AT=650.025n

.meas tran vdout0_13ck1290 FIND v(dout0_13) AT=650.025n

.meas tran vdout0_14ck1290 FIND v(dout0_14) AT=650.025n

.meas tran vdout0_15ck1290 FIND v(dout0_15) AT=650.025n

.meas tran vdout0_16ck1290 FIND v(dout0_16) AT=650.025n

.meas tran vdout0_17ck1290 FIND v(dout0_17) AT=650.025n

.meas tran vdout0_18ck1290 FIND v(dout0_18) AT=650.025n

.meas tran vdout0_19ck1290 FIND v(dout0_19) AT=650.025n

.meas tran vdout0_20ck1290 FIND v(dout0_20) AT=650.025n

.meas tran vdout0_21ck1290 FIND v(dout0_21) AT=650.025n

.meas tran vdout0_22ck1290 FIND v(dout0_22) AT=650.025n

.meas tran vdout0_23ck1290 FIND v(dout0_23) AT=650.025n

.meas tran vdout0_24ck1290 FIND v(dout0_24) AT=650.025n

.meas tran vdout0_25ck1290 FIND v(dout0_25) AT=650.025n

.meas tran vdout0_26ck1290 FIND v(dout0_26) AT=650.025n

.meas tran vdout0_27ck1290 FIND v(dout0_27) AT=650.025n

.meas tran vdout0_28ck1290 FIND v(dout0_28) AT=650.025n

.meas tran vdout0_29ck1290 FIND v(dout0_29) AT=650.025n

.meas tran vdout0_30ck1290 FIND v(dout0_30) AT=650.025n

.meas tran vdout0_31ck1290 FIND v(dout0_31) AT=650.025n

.meas tran vdout0_32ck1290 FIND v(dout0_32) AT=650.025n

.meas tran vdout0_33ck1290 FIND v(dout0_33) AT=650.025n

.meas tran vdout0_34ck1290 FIND v(dout0_34) AT=650.025n

.meas tran vdout0_35ck1290 FIND v(dout0_35) AT=650.025n

.meas tran vdout0_36ck1290 FIND v(dout0_36) AT=650.025n

.meas tran vdout0_37ck1290 FIND v(dout0_37) AT=650.025n

.meas tran vdout0_38ck1290 FIND v(dout0_38) AT=650.025n

.meas tran vdout0_39ck1290 FIND v(dout0_39) AT=650.025n

.meas tran vdout0_40ck1290 FIND v(dout0_40) AT=650.025n

.meas tran vdout0_41ck1290 FIND v(dout0_41) AT=650.025n

.meas tran vdout0_42ck1290 FIND v(dout0_42) AT=650.025n

.meas tran vdout0_43ck1290 FIND v(dout0_43) AT=650.025n

.meas tran vdout0_44ck1290 FIND v(dout0_44) AT=650.025n

.meas tran vdout0_45ck1290 FIND v(dout0_45) AT=650.025n

.meas tran vdout0_46ck1290 FIND v(dout0_46) AT=650.025n

.meas tran vdout0_47ck1290 FIND v(dout0_47) AT=650.025n

.meas tran vdout0_48ck1290 FIND v(dout0_48) AT=650.025n

.meas tran vdout0_49ck1290 FIND v(dout0_49) AT=650.025n

.meas tran vdout0_50ck1290 FIND v(dout0_50) AT=650.025n

.meas tran vdout0_51ck1290 FIND v(dout0_51) AT=650.025n

.meas tran vdout0_52ck1290 FIND v(dout0_52) AT=650.025n

.meas tran vdout0_53ck1290 FIND v(dout0_53) AT=650.025n

.meas tran vdout0_54ck1290 FIND v(dout0_54) AT=650.025n

.meas tran vdout0_55ck1290 FIND v(dout0_55) AT=650.025n

.meas tran vdout0_56ck1290 FIND v(dout0_56) AT=650.025n

.meas tran vdout0_57ck1290 FIND v(dout0_57) AT=650.025n

.meas tran vdout0_58ck1290 FIND v(dout0_58) AT=650.025n

.meas tran vdout0_59ck1290 FIND v(dout0_59) AT=650.025n

.meas tran vdout0_60ck1290 FIND v(dout0_60) AT=650.025n

.meas tran vdout0_61ck1290 FIND v(dout0_61) AT=650.025n

.meas tran vdout0_62ck1290 FIND v(dout0_62) AT=650.025n

.meas tran vdout0_63ck1290 FIND v(dout0_63) AT=650.025n

.meas tran vdout0_64ck1290 FIND v(dout0_64) AT=650.025n

.meas tran vdout0_65ck1290 FIND v(dout0_65) AT=650.025n

.meas tran vdout0_66ck1290 FIND v(dout0_66) AT=650.025n

.meas tran vdout0_67ck1290 FIND v(dout0_67) AT=650.025n

.meas tran vdout0_68ck1290 FIND v(dout0_68) AT=650.025n

.meas tran vdout0_69ck1290 FIND v(dout0_69) AT=650.025n

.meas tran vdout0_70ck1290 FIND v(dout0_70) AT=650.025n

.meas tran vdout0_71ck1290 FIND v(dout0_71) AT=650.025n

.meas tran vdout0_72ck1290 FIND v(dout0_72) AT=650.025n

.meas tran vdout0_73ck1290 FIND v(dout0_73) AT=650.025n

.meas tran vdout0_74ck1290 FIND v(dout0_74) AT=650.025n

.meas tran vdout0_75ck1290 FIND v(dout0_75) AT=650.025n

.meas tran vdout0_76ck1290 FIND v(dout0_76) AT=650.025n

.meas tran vdout0_77ck1290 FIND v(dout0_77) AT=650.025n

.meas tran vdout0_78ck1290 FIND v(dout0_78) AT=650.025n

.meas tran vdout0_79ck1290 FIND v(dout0_79) AT=650.025n

.meas tran vdout0_80ck1290 FIND v(dout0_80) AT=650.025n

.meas tran vdout0_81ck1290 FIND v(dout0_81) AT=650.025n

.meas tran vdout0_82ck1290 FIND v(dout0_82) AT=650.025n

.meas tran vdout0_83ck1290 FIND v(dout0_83) AT=650.025n

.meas tran vdout0_84ck1290 FIND v(dout0_84) AT=650.025n

.meas tran vdout0_85ck1290 FIND v(dout0_85) AT=650.025n

.meas tran vdout0_86ck1290 FIND v(dout0_86) AT=650.025n

.meas tran vdout0_87ck1290 FIND v(dout0_87) AT=650.025n

.meas tran vdout0_88ck1290 FIND v(dout0_88) AT=650.025n

.meas tran vdout0_89ck1290 FIND v(dout0_89) AT=650.025n

.meas tran vdout0_90ck1290 FIND v(dout0_90) AT=650.025n

.meas tran vdout0_91ck1290 FIND v(dout0_91) AT=650.025n

.meas tran vdout0_92ck1290 FIND v(dout0_92) AT=650.025n

.meas tran vdout0_93ck1290 FIND v(dout0_93) AT=650.025n

.meas tran vdout0_94ck1290 FIND v(dout0_94) AT=650.025n

.meas tran vdout0_95ck1290 FIND v(dout0_95) AT=650.025n

.meas tran vdout0_96ck1290 FIND v(dout0_96) AT=650.025n

.meas tran vdout0_97ck1290 FIND v(dout0_97) AT=650.025n

.meas tran vdout0_98ck1290 FIND v(dout0_98) AT=650.025n

.meas tran vdout0_99ck1290 FIND v(dout0_99) AT=650.025n

.meas tran vdout0_100ck1290 FIND v(dout0_100) AT=650.025n

.meas tran vdout0_101ck1290 FIND v(dout0_101) AT=650.025n

.meas tran vdout0_102ck1290 FIND v(dout0_102) AT=650.025n

.meas tran vdout0_103ck1290 FIND v(dout0_103) AT=650.025n

.meas tran vdout0_104ck1290 FIND v(dout0_104) AT=650.025n

.meas tran vdout0_105ck1290 FIND v(dout0_105) AT=650.025n

.meas tran vdout0_106ck1290 FIND v(dout0_106) AT=650.025n

.meas tran vdout0_107ck1290 FIND v(dout0_107) AT=650.025n

.meas tran vdout0_108ck1290 FIND v(dout0_108) AT=650.025n

.meas tran vdout0_109ck1290 FIND v(dout0_109) AT=650.025n

.meas tran vdout0_110ck1290 FIND v(dout0_110) AT=650.025n

.meas tran vdout0_111ck1290 FIND v(dout0_111) AT=650.025n

.meas tran vdout0_112ck1290 FIND v(dout0_112) AT=650.025n

.meas tran vdout0_113ck1290 FIND v(dout0_113) AT=650.025n

.meas tran vdout0_114ck1290 FIND v(dout0_114) AT=650.025n

.meas tran vdout0_115ck1290 FIND v(dout0_115) AT=650.025n

.meas tran vdout0_116ck1290 FIND v(dout0_116) AT=650.025n

.meas tran vdout0_117ck1290 FIND v(dout0_117) AT=650.025n

.meas tran vdout0_118ck1290 FIND v(dout0_118) AT=650.025n

.meas tran vdout0_119ck1290 FIND v(dout0_119) AT=650.025n

.meas tran vdout0_120ck1290 FIND v(dout0_120) AT=650.025n

.meas tran vdout0_121ck1290 FIND v(dout0_121) AT=650.025n

.meas tran vdout0_122ck1290 FIND v(dout0_122) AT=650.025n

.meas tran vdout0_123ck1290 FIND v(dout0_123) AT=650.025n

.meas tran vdout0_124ck1290 FIND v(dout0_124) AT=650.025n

.meas tran vdout0_125ck1290 FIND v(dout0_125) AT=650.025n

.meas tran vdout0_126ck1290 FIND v(dout0_126) AT=650.025n

.meas tran vdout0_127ck1290 FIND v(dout0_127) AT=650.025n

.meas tran vdout0_0ck1380 FIND v(dout0_0) AT=695.025n

.meas tran vdout0_1ck1380 FIND v(dout0_1) AT=695.025n

.meas tran vdout0_2ck1380 FIND v(dout0_2) AT=695.025n

.meas tran vdout0_3ck1380 FIND v(dout0_3) AT=695.025n

.meas tran vdout0_4ck1380 FIND v(dout0_4) AT=695.025n

.meas tran vdout0_5ck1380 FIND v(dout0_5) AT=695.025n

.meas tran vdout0_6ck1380 FIND v(dout0_6) AT=695.025n

.meas tran vdout0_7ck1380 FIND v(dout0_7) AT=695.025n

.meas tran vdout0_8ck1380 FIND v(dout0_8) AT=695.025n

.meas tran vdout0_9ck1380 FIND v(dout0_9) AT=695.025n

.meas tran vdout0_10ck1380 FIND v(dout0_10) AT=695.025n

.meas tran vdout0_11ck1380 FIND v(dout0_11) AT=695.025n

.meas tran vdout0_12ck1380 FIND v(dout0_12) AT=695.025n

.meas tran vdout0_13ck1380 FIND v(dout0_13) AT=695.025n

.meas tran vdout0_14ck1380 FIND v(dout0_14) AT=695.025n

.meas tran vdout0_15ck1380 FIND v(dout0_15) AT=695.025n

.meas tran vdout0_16ck1380 FIND v(dout0_16) AT=695.025n

.meas tran vdout0_17ck1380 FIND v(dout0_17) AT=695.025n

.meas tran vdout0_18ck1380 FIND v(dout0_18) AT=695.025n

.meas tran vdout0_19ck1380 FIND v(dout0_19) AT=695.025n

.meas tran vdout0_20ck1380 FIND v(dout0_20) AT=695.025n

.meas tran vdout0_21ck1380 FIND v(dout0_21) AT=695.025n

.meas tran vdout0_22ck1380 FIND v(dout0_22) AT=695.025n

.meas tran vdout0_23ck1380 FIND v(dout0_23) AT=695.025n

.meas tran vdout0_24ck1380 FIND v(dout0_24) AT=695.025n

.meas tran vdout0_25ck1380 FIND v(dout0_25) AT=695.025n

.meas tran vdout0_26ck1380 FIND v(dout0_26) AT=695.025n

.meas tran vdout0_27ck1380 FIND v(dout0_27) AT=695.025n

.meas tran vdout0_28ck1380 FIND v(dout0_28) AT=695.025n

.meas tran vdout0_29ck1380 FIND v(dout0_29) AT=695.025n

.meas tran vdout0_30ck1380 FIND v(dout0_30) AT=695.025n

.meas tran vdout0_31ck1380 FIND v(dout0_31) AT=695.025n

.meas tran vdout0_32ck1380 FIND v(dout0_32) AT=695.025n

.meas tran vdout0_33ck1380 FIND v(dout0_33) AT=695.025n

.meas tran vdout0_34ck1380 FIND v(dout0_34) AT=695.025n

.meas tran vdout0_35ck1380 FIND v(dout0_35) AT=695.025n

.meas tran vdout0_36ck1380 FIND v(dout0_36) AT=695.025n

.meas tran vdout0_37ck1380 FIND v(dout0_37) AT=695.025n

.meas tran vdout0_38ck1380 FIND v(dout0_38) AT=695.025n

.meas tran vdout0_39ck1380 FIND v(dout0_39) AT=695.025n

.meas tran vdout0_40ck1380 FIND v(dout0_40) AT=695.025n

.meas tran vdout0_41ck1380 FIND v(dout0_41) AT=695.025n

.meas tran vdout0_42ck1380 FIND v(dout0_42) AT=695.025n

.meas tran vdout0_43ck1380 FIND v(dout0_43) AT=695.025n

.meas tran vdout0_44ck1380 FIND v(dout0_44) AT=695.025n

.meas tran vdout0_45ck1380 FIND v(dout0_45) AT=695.025n

.meas tran vdout0_46ck1380 FIND v(dout0_46) AT=695.025n

.meas tran vdout0_47ck1380 FIND v(dout0_47) AT=695.025n

.meas tran vdout0_48ck1380 FIND v(dout0_48) AT=695.025n

.meas tran vdout0_49ck1380 FIND v(dout0_49) AT=695.025n

.meas tran vdout0_50ck1380 FIND v(dout0_50) AT=695.025n

.meas tran vdout0_51ck1380 FIND v(dout0_51) AT=695.025n

.meas tran vdout0_52ck1380 FIND v(dout0_52) AT=695.025n

.meas tran vdout0_53ck1380 FIND v(dout0_53) AT=695.025n

.meas tran vdout0_54ck1380 FIND v(dout0_54) AT=695.025n

.meas tran vdout0_55ck1380 FIND v(dout0_55) AT=695.025n

.meas tran vdout0_56ck1380 FIND v(dout0_56) AT=695.025n

.meas tran vdout0_57ck1380 FIND v(dout0_57) AT=695.025n

.meas tran vdout0_58ck1380 FIND v(dout0_58) AT=695.025n

.meas tran vdout0_59ck1380 FIND v(dout0_59) AT=695.025n

.meas tran vdout0_60ck1380 FIND v(dout0_60) AT=695.025n

.meas tran vdout0_61ck1380 FIND v(dout0_61) AT=695.025n

.meas tran vdout0_62ck1380 FIND v(dout0_62) AT=695.025n

.meas tran vdout0_63ck1380 FIND v(dout0_63) AT=695.025n

.meas tran vdout0_64ck1380 FIND v(dout0_64) AT=695.025n

.meas tran vdout0_65ck1380 FIND v(dout0_65) AT=695.025n

.meas tran vdout0_66ck1380 FIND v(dout0_66) AT=695.025n

.meas tran vdout0_67ck1380 FIND v(dout0_67) AT=695.025n

.meas tran vdout0_68ck1380 FIND v(dout0_68) AT=695.025n

.meas tran vdout0_69ck1380 FIND v(dout0_69) AT=695.025n

.meas tran vdout0_70ck1380 FIND v(dout0_70) AT=695.025n

.meas tran vdout0_71ck1380 FIND v(dout0_71) AT=695.025n

.meas tran vdout0_72ck1380 FIND v(dout0_72) AT=695.025n

.meas tran vdout0_73ck1380 FIND v(dout0_73) AT=695.025n

.meas tran vdout0_74ck1380 FIND v(dout0_74) AT=695.025n

.meas tran vdout0_75ck1380 FIND v(dout0_75) AT=695.025n

.meas tran vdout0_76ck1380 FIND v(dout0_76) AT=695.025n

.meas tran vdout0_77ck1380 FIND v(dout0_77) AT=695.025n

.meas tran vdout0_78ck1380 FIND v(dout0_78) AT=695.025n

.meas tran vdout0_79ck1380 FIND v(dout0_79) AT=695.025n

.meas tran vdout0_80ck1380 FIND v(dout0_80) AT=695.025n

.meas tran vdout0_81ck1380 FIND v(dout0_81) AT=695.025n

.meas tran vdout0_82ck1380 FIND v(dout0_82) AT=695.025n

.meas tran vdout0_83ck1380 FIND v(dout0_83) AT=695.025n

.meas tran vdout0_84ck1380 FIND v(dout0_84) AT=695.025n

.meas tran vdout0_85ck1380 FIND v(dout0_85) AT=695.025n

.meas tran vdout0_86ck1380 FIND v(dout0_86) AT=695.025n

.meas tran vdout0_87ck1380 FIND v(dout0_87) AT=695.025n

.meas tran vdout0_88ck1380 FIND v(dout0_88) AT=695.025n

.meas tran vdout0_89ck1380 FIND v(dout0_89) AT=695.025n

.meas tran vdout0_90ck1380 FIND v(dout0_90) AT=695.025n

.meas tran vdout0_91ck1380 FIND v(dout0_91) AT=695.025n

.meas tran vdout0_92ck1380 FIND v(dout0_92) AT=695.025n

.meas tran vdout0_93ck1380 FIND v(dout0_93) AT=695.025n

.meas tran vdout0_94ck1380 FIND v(dout0_94) AT=695.025n

.meas tran vdout0_95ck1380 FIND v(dout0_95) AT=695.025n

.meas tran vdout0_96ck1380 FIND v(dout0_96) AT=695.025n

.meas tran vdout0_97ck1380 FIND v(dout0_97) AT=695.025n

.meas tran vdout0_98ck1380 FIND v(dout0_98) AT=695.025n

.meas tran vdout0_99ck1380 FIND v(dout0_99) AT=695.025n

.meas tran vdout0_100ck1380 FIND v(dout0_100) AT=695.025n

.meas tran vdout0_101ck1380 FIND v(dout0_101) AT=695.025n

.meas tran vdout0_102ck1380 FIND v(dout0_102) AT=695.025n

.meas tran vdout0_103ck1380 FIND v(dout0_103) AT=695.025n

.meas tran vdout0_104ck1380 FIND v(dout0_104) AT=695.025n

.meas tran vdout0_105ck1380 FIND v(dout0_105) AT=695.025n

.meas tran vdout0_106ck1380 FIND v(dout0_106) AT=695.025n

.meas tran vdout0_107ck1380 FIND v(dout0_107) AT=695.025n

.meas tran vdout0_108ck1380 FIND v(dout0_108) AT=695.025n

.meas tran vdout0_109ck1380 FIND v(dout0_109) AT=695.025n

.meas tran vdout0_110ck1380 FIND v(dout0_110) AT=695.025n

.meas tran vdout0_111ck1380 FIND v(dout0_111) AT=695.025n

.meas tran vdout0_112ck1380 FIND v(dout0_112) AT=695.025n

.meas tran vdout0_113ck1380 FIND v(dout0_113) AT=695.025n

.meas tran vdout0_114ck1380 FIND v(dout0_114) AT=695.025n

.meas tran vdout0_115ck1380 FIND v(dout0_115) AT=695.025n

.meas tran vdout0_116ck1380 FIND v(dout0_116) AT=695.025n

.meas tran vdout0_117ck1380 FIND v(dout0_117) AT=695.025n

.meas tran vdout0_118ck1380 FIND v(dout0_118) AT=695.025n

.meas tran vdout0_119ck1380 FIND v(dout0_119) AT=695.025n

.meas tran vdout0_120ck1380 FIND v(dout0_120) AT=695.025n

.meas tran vdout0_121ck1380 FIND v(dout0_121) AT=695.025n

.meas tran vdout0_122ck1380 FIND v(dout0_122) AT=695.025n

.meas tran vdout0_123ck1380 FIND v(dout0_123) AT=695.025n

.meas tran vdout0_124ck1380 FIND v(dout0_124) AT=695.025n

.meas tran vdout0_125ck1380 FIND v(dout0_125) AT=695.025n

.meas tran vdout0_126ck1380 FIND v(dout0_126) AT=695.025n

.meas tran vdout0_127ck1380 FIND v(dout0_127) AT=695.025n

.meas tran vdout0_0ck1400 FIND v(dout0_0) AT=705.025n

.meas tran vdout0_1ck1400 FIND v(dout0_1) AT=705.025n

.meas tran vdout0_2ck1400 FIND v(dout0_2) AT=705.025n

.meas tran vdout0_3ck1400 FIND v(dout0_3) AT=705.025n

.meas tran vdout0_4ck1400 FIND v(dout0_4) AT=705.025n

.meas tran vdout0_5ck1400 FIND v(dout0_5) AT=705.025n

.meas tran vdout0_6ck1400 FIND v(dout0_6) AT=705.025n

.meas tran vdout0_7ck1400 FIND v(dout0_7) AT=705.025n

.meas tran vdout0_8ck1400 FIND v(dout0_8) AT=705.025n

.meas tran vdout0_9ck1400 FIND v(dout0_9) AT=705.025n

.meas tran vdout0_10ck1400 FIND v(dout0_10) AT=705.025n

.meas tran vdout0_11ck1400 FIND v(dout0_11) AT=705.025n

.meas tran vdout0_12ck1400 FIND v(dout0_12) AT=705.025n

.meas tran vdout0_13ck1400 FIND v(dout0_13) AT=705.025n

.meas tran vdout0_14ck1400 FIND v(dout0_14) AT=705.025n

.meas tran vdout0_15ck1400 FIND v(dout0_15) AT=705.025n

.meas tran vdout0_16ck1400 FIND v(dout0_16) AT=705.025n

.meas tran vdout0_17ck1400 FIND v(dout0_17) AT=705.025n

.meas tran vdout0_18ck1400 FIND v(dout0_18) AT=705.025n

.meas tran vdout0_19ck1400 FIND v(dout0_19) AT=705.025n

.meas tran vdout0_20ck1400 FIND v(dout0_20) AT=705.025n

.meas tran vdout0_21ck1400 FIND v(dout0_21) AT=705.025n

.meas tran vdout0_22ck1400 FIND v(dout0_22) AT=705.025n

.meas tran vdout0_23ck1400 FIND v(dout0_23) AT=705.025n

.meas tran vdout0_24ck1400 FIND v(dout0_24) AT=705.025n

.meas tran vdout0_25ck1400 FIND v(dout0_25) AT=705.025n

.meas tran vdout0_26ck1400 FIND v(dout0_26) AT=705.025n

.meas tran vdout0_27ck1400 FIND v(dout0_27) AT=705.025n

.meas tran vdout0_28ck1400 FIND v(dout0_28) AT=705.025n

.meas tran vdout0_29ck1400 FIND v(dout0_29) AT=705.025n

.meas tran vdout0_30ck1400 FIND v(dout0_30) AT=705.025n

.meas tran vdout0_31ck1400 FIND v(dout0_31) AT=705.025n

.meas tran vdout0_32ck1400 FIND v(dout0_32) AT=705.025n

.meas tran vdout0_33ck1400 FIND v(dout0_33) AT=705.025n

.meas tran vdout0_34ck1400 FIND v(dout0_34) AT=705.025n

.meas tran vdout0_35ck1400 FIND v(dout0_35) AT=705.025n

.meas tran vdout0_36ck1400 FIND v(dout0_36) AT=705.025n

.meas tran vdout0_37ck1400 FIND v(dout0_37) AT=705.025n

.meas tran vdout0_38ck1400 FIND v(dout0_38) AT=705.025n

.meas tran vdout0_39ck1400 FIND v(dout0_39) AT=705.025n

.meas tran vdout0_40ck1400 FIND v(dout0_40) AT=705.025n

.meas tran vdout0_41ck1400 FIND v(dout0_41) AT=705.025n

.meas tran vdout0_42ck1400 FIND v(dout0_42) AT=705.025n

.meas tran vdout0_43ck1400 FIND v(dout0_43) AT=705.025n

.meas tran vdout0_44ck1400 FIND v(dout0_44) AT=705.025n

.meas tran vdout0_45ck1400 FIND v(dout0_45) AT=705.025n

.meas tran vdout0_46ck1400 FIND v(dout0_46) AT=705.025n

.meas tran vdout0_47ck1400 FIND v(dout0_47) AT=705.025n

.meas tran vdout0_48ck1400 FIND v(dout0_48) AT=705.025n

.meas tran vdout0_49ck1400 FIND v(dout0_49) AT=705.025n

.meas tran vdout0_50ck1400 FIND v(dout0_50) AT=705.025n

.meas tran vdout0_51ck1400 FIND v(dout0_51) AT=705.025n

.meas tran vdout0_52ck1400 FIND v(dout0_52) AT=705.025n

.meas tran vdout0_53ck1400 FIND v(dout0_53) AT=705.025n

.meas tran vdout0_54ck1400 FIND v(dout0_54) AT=705.025n

.meas tran vdout0_55ck1400 FIND v(dout0_55) AT=705.025n

.meas tran vdout0_56ck1400 FIND v(dout0_56) AT=705.025n

.meas tran vdout0_57ck1400 FIND v(dout0_57) AT=705.025n

.meas tran vdout0_58ck1400 FIND v(dout0_58) AT=705.025n

.meas tran vdout0_59ck1400 FIND v(dout0_59) AT=705.025n

.meas tran vdout0_60ck1400 FIND v(dout0_60) AT=705.025n

.meas tran vdout0_61ck1400 FIND v(dout0_61) AT=705.025n

.meas tran vdout0_62ck1400 FIND v(dout0_62) AT=705.025n

.meas tran vdout0_63ck1400 FIND v(dout0_63) AT=705.025n

.meas tran vdout0_64ck1400 FIND v(dout0_64) AT=705.025n

.meas tran vdout0_65ck1400 FIND v(dout0_65) AT=705.025n

.meas tran vdout0_66ck1400 FIND v(dout0_66) AT=705.025n

.meas tran vdout0_67ck1400 FIND v(dout0_67) AT=705.025n

.meas tran vdout0_68ck1400 FIND v(dout0_68) AT=705.025n

.meas tran vdout0_69ck1400 FIND v(dout0_69) AT=705.025n

.meas tran vdout0_70ck1400 FIND v(dout0_70) AT=705.025n

.meas tran vdout0_71ck1400 FIND v(dout0_71) AT=705.025n

.meas tran vdout0_72ck1400 FIND v(dout0_72) AT=705.025n

.meas tran vdout0_73ck1400 FIND v(dout0_73) AT=705.025n

.meas tran vdout0_74ck1400 FIND v(dout0_74) AT=705.025n

.meas tran vdout0_75ck1400 FIND v(dout0_75) AT=705.025n

.meas tran vdout0_76ck1400 FIND v(dout0_76) AT=705.025n

.meas tran vdout0_77ck1400 FIND v(dout0_77) AT=705.025n

.meas tran vdout0_78ck1400 FIND v(dout0_78) AT=705.025n

.meas tran vdout0_79ck1400 FIND v(dout0_79) AT=705.025n

.meas tran vdout0_80ck1400 FIND v(dout0_80) AT=705.025n

.meas tran vdout0_81ck1400 FIND v(dout0_81) AT=705.025n

.meas tran vdout0_82ck1400 FIND v(dout0_82) AT=705.025n

.meas tran vdout0_83ck1400 FIND v(dout0_83) AT=705.025n

.meas tran vdout0_84ck1400 FIND v(dout0_84) AT=705.025n

.meas tran vdout0_85ck1400 FIND v(dout0_85) AT=705.025n

.meas tran vdout0_86ck1400 FIND v(dout0_86) AT=705.025n

.meas tran vdout0_87ck1400 FIND v(dout0_87) AT=705.025n

.meas tran vdout0_88ck1400 FIND v(dout0_88) AT=705.025n

.meas tran vdout0_89ck1400 FIND v(dout0_89) AT=705.025n

.meas tran vdout0_90ck1400 FIND v(dout0_90) AT=705.025n

.meas tran vdout0_91ck1400 FIND v(dout0_91) AT=705.025n

.meas tran vdout0_92ck1400 FIND v(dout0_92) AT=705.025n

.meas tran vdout0_93ck1400 FIND v(dout0_93) AT=705.025n

.meas tran vdout0_94ck1400 FIND v(dout0_94) AT=705.025n

.meas tran vdout0_95ck1400 FIND v(dout0_95) AT=705.025n

.meas tran vdout0_96ck1400 FIND v(dout0_96) AT=705.025n

.meas tran vdout0_97ck1400 FIND v(dout0_97) AT=705.025n

.meas tran vdout0_98ck1400 FIND v(dout0_98) AT=705.025n

.meas tran vdout0_99ck1400 FIND v(dout0_99) AT=705.025n

.meas tran vdout0_100ck1400 FIND v(dout0_100) AT=705.025n

.meas tran vdout0_101ck1400 FIND v(dout0_101) AT=705.025n

.meas tran vdout0_102ck1400 FIND v(dout0_102) AT=705.025n

.meas tran vdout0_103ck1400 FIND v(dout0_103) AT=705.025n

.meas tran vdout0_104ck1400 FIND v(dout0_104) AT=705.025n

.meas tran vdout0_105ck1400 FIND v(dout0_105) AT=705.025n

.meas tran vdout0_106ck1400 FIND v(dout0_106) AT=705.025n

.meas tran vdout0_107ck1400 FIND v(dout0_107) AT=705.025n

.meas tran vdout0_108ck1400 FIND v(dout0_108) AT=705.025n

.meas tran vdout0_109ck1400 FIND v(dout0_109) AT=705.025n

.meas tran vdout0_110ck1400 FIND v(dout0_110) AT=705.025n

.meas tran vdout0_111ck1400 FIND v(dout0_111) AT=705.025n

.meas tran vdout0_112ck1400 FIND v(dout0_112) AT=705.025n

.meas tran vdout0_113ck1400 FIND v(dout0_113) AT=705.025n

.meas tran vdout0_114ck1400 FIND v(dout0_114) AT=705.025n

.meas tran vdout0_115ck1400 FIND v(dout0_115) AT=705.025n

.meas tran vdout0_116ck1400 FIND v(dout0_116) AT=705.025n

.meas tran vdout0_117ck1400 FIND v(dout0_117) AT=705.025n

.meas tran vdout0_118ck1400 FIND v(dout0_118) AT=705.025n

.meas tran vdout0_119ck1400 FIND v(dout0_119) AT=705.025n

.meas tran vdout0_120ck1400 FIND v(dout0_120) AT=705.025n

.meas tran vdout0_121ck1400 FIND v(dout0_121) AT=705.025n

.meas tran vdout0_122ck1400 FIND v(dout0_122) AT=705.025n

.meas tran vdout0_123ck1400 FIND v(dout0_123) AT=705.025n

.meas tran vdout0_124ck1400 FIND v(dout0_124) AT=705.025n

.meas tran vdout0_125ck1400 FIND v(dout0_125) AT=705.025n

.meas tran vdout0_126ck1400 FIND v(dout0_126) AT=705.025n

.meas tran vdout0_127ck1400 FIND v(dout0_127) AT=705.025n

.meas tran vdout0_0ck1430 FIND v(dout0_0) AT=720.025n

.meas tran vdout0_1ck1430 FIND v(dout0_1) AT=720.025n

.meas tran vdout0_2ck1430 FIND v(dout0_2) AT=720.025n

.meas tran vdout0_3ck1430 FIND v(dout0_3) AT=720.025n

.meas tran vdout0_4ck1430 FIND v(dout0_4) AT=720.025n

.meas tran vdout0_5ck1430 FIND v(dout0_5) AT=720.025n

.meas tran vdout0_6ck1430 FIND v(dout0_6) AT=720.025n

.meas tran vdout0_7ck1430 FIND v(dout0_7) AT=720.025n

.meas tran vdout0_8ck1430 FIND v(dout0_8) AT=720.025n

.meas tran vdout0_9ck1430 FIND v(dout0_9) AT=720.025n

.meas tran vdout0_10ck1430 FIND v(dout0_10) AT=720.025n

.meas tran vdout0_11ck1430 FIND v(dout0_11) AT=720.025n

.meas tran vdout0_12ck1430 FIND v(dout0_12) AT=720.025n

.meas tran vdout0_13ck1430 FIND v(dout0_13) AT=720.025n

.meas tran vdout0_14ck1430 FIND v(dout0_14) AT=720.025n

.meas tran vdout0_15ck1430 FIND v(dout0_15) AT=720.025n

.meas tran vdout0_16ck1430 FIND v(dout0_16) AT=720.025n

.meas tran vdout0_17ck1430 FIND v(dout0_17) AT=720.025n

.meas tran vdout0_18ck1430 FIND v(dout0_18) AT=720.025n

.meas tran vdout0_19ck1430 FIND v(dout0_19) AT=720.025n

.meas tran vdout0_20ck1430 FIND v(dout0_20) AT=720.025n

.meas tran vdout0_21ck1430 FIND v(dout0_21) AT=720.025n

.meas tran vdout0_22ck1430 FIND v(dout0_22) AT=720.025n

.meas tran vdout0_23ck1430 FIND v(dout0_23) AT=720.025n

.meas tran vdout0_24ck1430 FIND v(dout0_24) AT=720.025n

.meas tran vdout0_25ck1430 FIND v(dout0_25) AT=720.025n

.meas tran vdout0_26ck1430 FIND v(dout0_26) AT=720.025n

.meas tran vdout0_27ck1430 FIND v(dout0_27) AT=720.025n

.meas tran vdout0_28ck1430 FIND v(dout0_28) AT=720.025n

.meas tran vdout0_29ck1430 FIND v(dout0_29) AT=720.025n

.meas tran vdout0_30ck1430 FIND v(dout0_30) AT=720.025n

.meas tran vdout0_31ck1430 FIND v(dout0_31) AT=720.025n

.meas tran vdout0_32ck1430 FIND v(dout0_32) AT=720.025n

.meas tran vdout0_33ck1430 FIND v(dout0_33) AT=720.025n

.meas tran vdout0_34ck1430 FIND v(dout0_34) AT=720.025n

.meas tran vdout0_35ck1430 FIND v(dout0_35) AT=720.025n

.meas tran vdout0_36ck1430 FIND v(dout0_36) AT=720.025n

.meas tran vdout0_37ck1430 FIND v(dout0_37) AT=720.025n

.meas tran vdout0_38ck1430 FIND v(dout0_38) AT=720.025n

.meas tran vdout0_39ck1430 FIND v(dout0_39) AT=720.025n

.meas tran vdout0_40ck1430 FIND v(dout0_40) AT=720.025n

.meas tran vdout0_41ck1430 FIND v(dout0_41) AT=720.025n

.meas tran vdout0_42ck1430 FIND v(dout0_42) AT=720.025n

.meas tran vdout0_43ck1430 FIND v(dout0_43) AT=720.025n

.meas tran vdout0_44ck1430 FIND v(dout0_44) AT=720.025n

.meas tran vdout0_45ck1430 FIND v(dout0_45) AT=720.025n

.meas tran vdout0_46ck1430 FIND v(dout0_46) AT=720.025n

.meas tran vdout0_47ck1430 FIND v(dout0_47) AT=720.025n

.meas tran vdout0_48ck1430 FIND v(dout0_48) AT=720.025n

.meas tran vdout0_49ck1430 FIND v(dout0_49) AT=720.025n

.meas tran vdout0_50ck1430 FIND v(dout0_50) AT=720.025n

.meas tran vdout0_51ck1430 FIND v(dout0_51) AT=720.025n

.meas tran vdout0_52ck1430 FIND v(dout0_52) AT=720.025n

.meas tran vdout0_53ck1430 FIND v(dout0_53) AT=720.025n

.meas tran vdout0_54ck1430 FIND v(dout0_54) AT=720.025n

.meas tran vdout0_55ck1430 FIND v(dout0_55) AT=720.025n

.meas tran vdout0_56ck1430 FIND v(dout0_56) AT=720.025n

.meas tran vdout0_57ck1430 FIND v(dout0_57) AT=720.025n

.meas tran vdout0_58ck1430 FIND v(dout0_58) AT=720.025n

.meas tran vdout0_59ck1430 FIND v(dout0_59) AT=720.025n

.meas tran vdout0_60ck1430 FIND v(dout0_60) AT=720.025n

.meas tran vdout0_61ck1430 FIND v(dout0_61) AT=720.025n

.meas tran vdout0_62ck1430 FIND v(dout0_62) AT=720.025n

.meas tran vdout0_63ck1430 FIND v(dout0_63) AT=720.025n

.meas tran vdout0_64ck1430 FIND v(dout0_64) AT=720.025n

.meas tran vdout0_65ck1430 FIND v(dout0_65) AT=720.025n

.meas tran vdout0_66ck1430 FIND v(dout0_66) AT=720.025n

.meas tran vdout0_67ck1430 FIND v(dout0_67) AT=720.025n

.meas tran vdout0_68ck1430 FIND v(dout0_68) AT=720.025n

.meas tran vdout0_69ck1430 FIND v(dout0_69) AT=720.025n

.meas tran vdout0_70ck1430 FIND v(dout0_70) AT=720.025n

.meas tran vdout0_71ck1430 FIND v(dout0_71) AT=720.025n

.meas tran vdout0_72ck1430 FIND v(dout0_72) AT=720.025n

.meas tran vdout0_73ck1430 FIND v(dout0_73) AT=720.025n

.meas tran vdout0_74ck1430 FIND v(dout0_74) AT=720.025n

.meas tran vdout0_75ck1430 FIND v(dout0_75) AT=720.025n

.meas tran vdout0_76ck1430 FIND v(dout0_76) AT=720.025n

.meas tran vdout0_77ck1430 FIND v(dout0_77) AT=720.025n

.meas tran vdout0_78ck1430 FIND v(dout0_78) AT=720.025n

.meas tran vdout0_79ck1430 FIND v(dout0_79) AT=720.025n

.meas tran vdout0_80ck1430 FIND v(dout0_80) AT=720.025n

.meas tran vdout0_81ck1430 FIND v(dout0_81) AT=720.025n

.meas tran vdout0_82ck1430 FIND v(dout0_82) AT=720.025n

.meas tran vdout0_83ck1430 FIND v(dout0_83) AT=720.025n

.meas tran vdout0_84ck1430 FIND v(dout0_84) AT=720.025n

.meas tran vdout0_85ck1430 FIND v(dout0_85) AT=720.025n

.meas tran vdout0_86ck1430 FIND v(dout0_86) AT=720.025n

.meas tran vdout0_87ck1430 FIND v(dout0_87) AT=720.025n

.meas tran vdout0_88ck1430 FIND v(dout0_88) AT=720.025n

.meas tran vdout0_89ck1430 FIND v(dout0_89) AT=720.025n

.meas tran vdout0_90ck1430 FIND v(dout0_90) AT=720.025n

.meas tran vdout0_91ck1430 FIND v(dout0_91) AT=720.025n

.meas tran vdout0_92ck1430 FIND v(dout0_92) AT=720.025n

.meas tran vdout0_93ck1430 FIND v(dout0_93) AT=720.025n

.meas tran vdout0_94ck1430 FIND v(dout0_94) AT=720.025n

.meas tran vdout0_95ck1430 FIND v(dout0_95) AT=720.025n

.meas tran vdout0_96ck1430 FIND v(dout0_96) AT=720.025n

.meas tran vdout0_97ck1430 FIND v(dout0_97) AT=720.025n

.meas tran vdout0_98ck1430 FIND v(dout0_98) AT=720.025n

.meas tran vdout0_99ck1430 FIND v(dout0_99) AT=720.025n

.meas tran vdout0_100ck1430 FIND v(dout0_100) AT=720.025n

.meas tran vdout0_101ck1430 FIND v(dout0_101) AT=720.025n

.meas tran vdout0_102ck1430 FIND v(dout0_102) AT=720.025n

.meas tran vdout0_103ck1430 FIND v(dout0_103) AT=720.025n

.meas tran vdout0_104ck1430 FIND v(dout0_104) AT=720.025n

.meas tran vdout0_105ck1430 FIND v(dout0_105) AT=720.025n

.meas tran vdout0_106ck1430 FIND v(dout0_106) AT=720.025n

.meas tran vdout0_107ck1430 FIND v(dout0_107) AT=720.025n

.meas tran vdout0_108ck1430 FIND v(dout0_108) AT=720.025n

.meas tran vdout0_109ck1430 FIND v(dout0_109) AT=720.025n

.meas tran vdout0_110ck1430 FIND v(dout0_110) AT=720.025n

.meas tran vdout0_111ck1430 FIND v(dout0_111) AT=720.025n

.meas tran vdout0_112ck1430 FIND v(dout0_112) AT=720.025n

.meas tran vdout0_113ck1430 FIND v(dout0_113) AT=720.025n

.meas tran vdout0_114ck1430 FIND v(dout0_114) AT=720.025n

.meas tran vdout0_115ck1430 FIND v(dout0_115) AT=720.025n

.meas tran vdout0_116ck1430 FIND v(dout0_116) AT=720.025n

.meas tran vdout0_117ck1430 FIND v(dout0_117) AT=720.025n

.meas tran vdout0_118ck1430 FIND v(dout0_118) AT=720.025n

.meas tran vdout0_119ck1430 FIND v(dout0_119) AT=720.025n

.meas tran vdout0_120ck1430 FIND v(dout0_120) AT=720.025n

.meas tran vdout0_121ck1430 FIND v(dout0_121) AT=720.025n

.meas tran vdout0_122ck1430 FIND v(dout0_122) AT=720.025n

.meas tran vdout0_123ck1430 FIND v(dout0_123) AT=720.025n

.meas tran vdout0_124ck1430 FIND v(dout0_124) AT=720.025n

.meas tran vdout0_125ck1430 FIND v(dout0_125) AT=720.025n

.meas tran vdout0_126ck1430 FIND v(dout0_126) AT=720.025n

.meas tran vdout0_127ck1430 FIND v(dout0_127) AT=720.025n

.meas tran vdout0_0ck1440 FIND v(dout0_0) AT=725.025n

.meas tran vdout0_1ck1440 FIND v(dout0_1) AT=725.025n

.meas tran vdout0_2ck1440 FIND v(dout0_2) AT=725.025n

.meas tran vdout0_3ck1440 FIND v(dout0_3) AT=725.025n

.meas tran vdout0_4ck1440 FIND v(dout0_4) AT=725.025n

.meas tran vdout0_5ck1440 FIND v(dout0_5) AT=725.025n

.meas tran vdout0_6ck1440 FIND v(dout0_6) AT=725.025n

.meas tran vdout0_7ck1440 FIND v(dout0_7) AT=725.025n

.meas tran vdout0_8ck1440 FIND v(dout0_8) AT=725.025n

.meas tran vdout0_9ck1440 FIND v(dout0_9) AT=725.025n

.meas tran vdout0_10ck1440 FIND v(dout0_10) AT=725.025n

.meas tran vdout0_11ck1440 FIND v(dout0_11) AT=725.025n

.meas tran vdout0_12ck1440 FIND v(dout0_12) AT=725.025n

.meas tran vdout0_13ck1440 FIND v(dout0_13) AT=725.025n

.meas tran vdout0_14ck1440 FIND v(dout0_14) AT=725.025n

.meas tran vdout0_15ck1440 FIND v(dout0_15) AT=725.025n

.meas tran vdout0_16ck1440 FIND v(dout0_16) AT=725.025n

.meas tran vdout0_17ck1440 FIND v(dout0_17) AT=725.025n

.meas tran vdout0_18ck1440 FIND v(dout0_18) AT=725.025n

.meas tran vdout0_19ck1440 FIND v(dout0_19) AT=725.025n

.meas tran vdout0_20ck1440 FIND v(dout0_20) AT=725.025n

.meas tran vdout0_21ck1440 FIND v(dout0_21) AT=725.025n

.meas tran vdout0_22ck1440 FIND v(dout0_22) AT=725.025n

.meas tran vdout0_23ck1440 FIND v(dout0_23) AT=725.025n

.meas tran vdout0_24ck1440 FIND v(dout0_24) AT=725.025n

.meas tran vdout0_25ck1440 FIND v(dout0_25) AT=725.025n

.meas tran vdout0_26ck1440 FIND v(dout0_26) AT=725.025n

.meas tran vdout0_27ck1440 FIND v(dout0_27) AT=725.025n

.meas tran vdout0_28ck1440 FIND v(dout0_28) AT=725.025n

.meas tran vdout0_29ck1440 FIND v(dout0_29) AT=725.025n

.meas tran vdout0_30ck1440 FIND v(dout0_30) AT=725.025n

.meas tran vdout0_31ck1440 FIND v(dout0_31) AT=725.025n

.meas tran vdout0_32ck1440 FIND v(dout0_32) AT=725.025n

.meas tran vdout0_33ck1440 FIND v(dout0_33) AT=725.025n

.meas tran vdout0_34ck1440 FIND v(dout0_34) AT=725.025n

.meas tran vdout0_35ck1440 FIND v(dout0_35) AT=725.025n

.meas tran vdout0_36ck1440 FIND v(dout0_36) AT=725.025n

.meas tran vdout0_37ck1440 FIND v(dout0_37) AT=725.025n

.meas tran vdout0_38ck1440 FIND v(dout0_38) AT=725.025n

.meas tran vdout0_39ck1440 FIND v(dout0_39) AT=725.025n

.meas tran vdout0_40ck1440 FIND v(dout0_40) AT=725.025n

.meas tran vdout0_41ck1440 FIND v(dout0_41) AT=725.025n

.meas tran vdout0_42ck1440 FIND v(dout0_42) AT=725.025n

.meas tran vdout0_43ck1440 FIND v(dout0_43) AT=725.025n

.meas tran vdout0_44ck1440 FIND v(dout0_44) AT=725.025n

.meas tran vdout0_45ck1440 FIND v(dout0_45) AT=725.025n

.meas tran vdout0_46ck1440 FIND v(dout0_46) AT=725.025n

.meas tran vdout0_47ck1440 FIND v(dout0_47) AT=725.025n

.meas tran vdout0_48ck1440 FIND v(dout0_48) AT=725.025n

.meas tran vdout0_49ck1440 FIND v(dout0_49) AT=725.025n

.meas tran vdout0_50ck1440 FIND v(dout0_50) AT=725.025n

.meas tran vdout0_51ck1440 FIND v(dout0_51) AT=725.025n

.meas tran vdout0_52ck1440 FIND v(dout0_52) AT=725.025n

.meas tran vdout0_53ck1440 FIND v(dout0_53) AT=725.025n

.meas tran vdout0_54ck1440 FIND v(dout0_54) AT=725.025n

.meas tran vdout0_55ck1440 FIND v(dout0_55) AT=725.025n

.meas tran vdout0_56ck1440 FIND v(dout0_56) AT=725.025n

.meas tran vdout0_57ck1440 FIND v(dout0_57) AT=725.025n

.meas tran vdout0_58ck1440 FIND v(dout0_58) AT=725.025n

.meas tran vdout0_59ck1440 FIND v(dout0_59) AT=725.025n

.meas tran vdout0_60ck1440 FIND v(dout0_60) AT=725.025n

.meas tran vdout0_61ck1440 FIND v(dout0_61) AT=725.025n

.meas tran vdout0_62ck1440 FIND v(dout0_62) AT=725.025n

.meas tran vdout0_63ck1440 FIND v(dout0_63) AT=725.025n

.meas tran vdout0_64ck1440 FIND v(dout0_64) AT=725.025n

.meas tran vdout0_65ck1440 FIND v(dout0_65) AT=725.025n

.meas tran vdout0_66ck1440 FIND v(dout0_66) AT=725.025n

.meas tran vdout0_67ck1440 FIND v(dout0_67) AT=725.025n

.meas tran vdout0_68ck1440 FIND v(dout0_68) AT=725.025n

.meas tran vdout0_69ck1440 FIND v(dout0_69) AT=725.025n

.meas tran vdout0_70ck1440 FIND v(dout0_70) AT=725.025n

.meas tran vdout0_71ck1440 FIND v(dout0_71) AT=725.025n

.meas tran vdout0_72ck1440 FIND v(dout0_72) AT=725.025n

.meas tran vdout0_73ck1440 FIND v(dout0_73) AT=725.025n

.meas tran vdout0_74ck1440 FIND v(dout0_74) AT=725.025n

.meas tran vdout0_75ck1440 FIND v(dout0_75) AT=725.025n

.meas tran vdout0_76ck1440 FIND v(dout0_76) AT=725.025n

.meas tran vdout0_77ck1440 FIND v(dout0_77) AT=725.025n

.meas tran vdout0_78ck1440 FIND v(dout0_78) AT=725.025n

.meas tran vdout0_79ck1440 FIND v(dout0_79) AT=725.025n

.meas tran vdout0_80ck1440 FIND v(dout0_80) AT=725.025n

.meas tran vdout0_81ck1440 FIND v(dout0_81) AT=725.025n

.meas tran vdout0_82ck1440 FIND v(dout0_82) AT=725.025n

.meas tran vdout0_83ck1440 FIND v(dout0_83) AT=725.025n

.meas tran vdout0_84ck1440 FIND v(dout0_84) AT=725.025n

.meas tran vdout0_85ck1440 FIND v(dout0_85) AT=725.025n

.meas tran vdout0_86ck1440 FIND v(dout0_86) AT=725.025n

.meas tran vdout0_87ck1440 FIND v(dout0_87) AT=725.025n

.meas tran vdout0_88ck1440 FIND v(dout0_88) AT=725.025n

.meas tran vdout0_89ck1440 FIND v(dout0_89) AT=725.025n

.meas tran vdout0_90ck1440 FIND v(dout0_90) AT=725.025n

.meas tran vdout0_91ck1440 FIND v(dout0_91) AT=725.025n

.meas tran vdout0_92ck1440 FIND v(dout0_92) AT=725.025n

.meas tran vdout0_93ck1440 FIND v(dout0_93) AT=725.025n

.meas tran vdout0_94ck1440 FIND v(dout0_94) AT=725.025n

.meas tran vdout0_95ck1440 FIND v(dout0_95) AT=725.025n

.meas tran vdout0_96ck1440 FIND v(dout0_96) AT=725.025n

.meas tran vdout0_97ck1440 FIND v(dout0_97) AT=725.025n

.meas tran vdout0_98ck1440 FIND v(dout0_98) AT=725.025n

.meas tran vdout0_99ck1440 FIND v(dout0_99) AT=725.025n

.meas tran vdout0_100ck1440 FIND v(dout0_100) AT=725.025n

.meas tran vdout0_101ck1440 FIND v(dout0_101) AT=725.025n

.meas tran vdout0_102ck1440 FIND v(dout0_102) AT=725.025n

.meas tran vdout0_103ck1440 FIND v(dout0_103) AT=725.025n

.meas tran vdout0_104ck1440 FIND v(dout0_104) AT=725.025n

.meas tran vdout0_105ck1440 FIND v(dout0_105) AT=725.025n

.meas tran vdout0_106ck1440 FIND v(dout0_106) AT=725.025n

.meas tran vdout0_107ck1440 FIND v(dout0_107) AT=725.025n

.meas tran vdout0_108ck1440 FIND v(dout0_108) AT=725.025n

.meas tran vdout0_109ck1440 FIND v(dout0_109) AT=725.025n

.meas tran vdout0_110ck1440 FIND v(dout0_110) AT=725.025n

.meas tran vdout0_111ck1440 FIND v(dout0_111) AT=725.025n

.meas tran vdout0_112ck1440 FIND v(dout0_112) AT=725.025n

.meas tran vdout0_113ck1440 FIND v(dout0_113) AT=725.025n

.meas tran vdout0_114ck1440 FIND v(dout0_114) AT=725.025n

.meas tran vdout0_115ck1440 FIND v(dout0_115) AT=725.025n

.meas tran vdout0_116ck1440 FIND v(dout0_116) AT=725.025n

.meas tran vdout0_117ck1440 FIND v(dout0_117) AT=725.025n

.meas tran vdout0_118ck1440 FIND v(dout0_118) AT=725.025n

.meas tran vdout0_119ck1440 FIND v(dout0_119) AT=725.025n

.meas tran vdout0_120ck1440 FIND v(dout0_120) AT=725.025n

.meas tran vdout0_121ck1440 FIND v(dout0_121) AT=725.025n

.meas tran vdout0_122ck1440 FIND v(dout0_122) AT=725.025n

.meas tran vdout0_123ck1440 FIND v(dout0_123) AT=725.025n

.meas tran vdout0_124ck1440 FIND v(dout0_124) AT=725.025n

.meas tran vdout0_125ck1440 FIND v(dout0_125) AT=725.025n

.meas tran vdout0_126ck1440 FIND v(dout0_126) AT=725.025n

.meas tran vdout0_127ck1440 FIND v(dout0_127) AT=725.025n

.meas tran vdout0_0ck1450 FIND v(dout0_0) AT=730.025n

.meas tran vdout0_1ck1450 FIND v(dout0_1) AT=730.025n

.meas tran vdout0_2ck1450 FIND v(dout0_2) AT=730.025n

.meas tran vdout0_3ck1450 FIND v(dout0_3) AT=730.025n

.meas tran vdout0_4ck1450 FIND v(dout0_4) AT=730.025n

.meas tran vdout0_5ck1450 FIND v(dout0_5) AT=730.025n

.meas tran vdout0_6ck1450 FIND v(dout0_6) AT=730.025n

.meas tran vdout0_7ck1450 FIND v(dout0_7) AT=730.025n

.meas tran vdout0_8ck1450 FIND v(dout0_8) AT=730.025n

.meas tran vdout0_9ck1450 FIND v(dout0_9) AT=730.025n

.meas tran vdout0_10ck1450 FIND v(dout0_10) AT=730.025n

.meas tran vdout0_11ck1450 FIND v(dout0_11) AT=730.025n

.meas tran vdout0_12ck1450 FIND v(dout0_12) AT=730.025n

.meas tran vdout0_13ck1450 FIND v(dout0_13) AT=730.025n

.meas tran vdout0_14ck1450 FIND v(dout0_14) AT=730.025n

.meas tran vdout0_15ck1450 FIND v(dout0_15) AT=730.025n

.meas tran vdout0_16ck1450 FIND v(dout0_16) AT=730.025n

.meas tran vdout0_17ck1450 FIND v(dout0_17) AT=730.025n

.meas tran vdout0_18ck1450 FIND v(dout0_18) AT=730.025n

.meas tran vdout0_19ck1450 FIND v(dout0_19) AT=730.025n

.meas tran vdout0_20ck1450 FIND v(dout0_20) AT=730.025n

.meas tran vdout0_21ck1450 FIND v(dout0_21) AT=730.025n

.meas tran vdout0_22ck1450 FIND v(dout0_22) AT=730.025n

.meas tran vdout0_23ck1450 FIND v(dout0_23) AT=730.025n

.meas tran vdout0_24ck1450 FIND v(dout0_24) AT=730.025n

.meas tran vdout0_25ck1450 FIND v(dout0_25) AT=730.025n

.meas tran vdout0_26ck1450 FIND v(dout0_26) AT=730.025n

.meas tran vdout0_27ck1450 FIND v(dout0_27) AT=730.025n

.meas tran vdout0_28ck1450 FIND v(dout0_28) AT=730.025n

.meas tran vdout0_29ck1450 FIND v(dout0_29) AT=730.025n

.meas tran vdout0_30ck1450 FIND v(dout0_30) AT=730.025n

.meas tran vdout0_31ck1450 FIND v(dout0_31) AT=730.025n

.meas tran vdout0_32ck1450 FIND v(dout0_32) AT=730.025n

.meas tran vdout0_33ck1450 FIND v(dout0_33) AT=730.025n

.meas tran vdout0_34ck1450 FIND v(dout0_34) AT=730.025n

.meas tran vdout0_35ck1450 FIND v(dout0_35) AT=730.025n

.meas tran vdout0_36ck1450 FIND v(dout0_36) AT=730.025n

.meas tran vdout0_37ck1450 FIND v(dout0_37) AT=730.025n

.meas tran vdout0_38ck1450 FIND v(dout0_38) AT=730.025n

.meas tran vdout0_39ck1450 FIND v(dout0_39) AT=730.025n

.meas tran vdout0_40ck1450 FIND v(dout0_40) AT=730.025n

.meas tran vdout0_41ck1450 FIND v(dout0_41) AT=730.025n

.meas tran vdout0_42ck1450 FIND v(dout0_42) AT=730.025n

.meas tran vdout0_43ck1450 FIND v(dout0_43) AT=730.025n

.meas tran vdout0_44ck1450 FIND v(dout0_44) AT=730.025n

.meas tran vdout0_45ck1450 FIND v(dout0_45) AT=730.025n

.meas tran vdout0_46ck1450 FIND v(dout0_46) AT=730.025n

.meas tran vdout0_47ck1450 FIND v(dout0_47) AT=730.025n

.meas tran vdout0_48ck1450 FIND v(dout0_48) AT=730.025n

.meas tran vdout0_49ck1450 FIND v(dout0_49) AT=730.025n

.meas tran vdout0_50ck1450 FIND v(dout0_50) AT=730.025n

.meas tran vdout0_51ck1450 FIND v(dout0_51) AT=730.025n

.meas tran vdout0_52ck1450 FIND v(dout0_52) AT=730.025n

.meas tran vdout0_53ck1450 FIND v(dout0_53) AT=730.025n

.meas tran vdout0_54ck1450 FIND v(dout0_54) AT=730.025n

.meas tran vdout0_55ck1450 FIND v(dout0_55) AT=730.025n

.meas tran vdout0_56ck1450 FIND v(dout0_56) AT=730.025n

.meas tran vdout0_57ck1450 FIND v(dout0_57) AT=730.025n

.meas tran vdout0_58ck1450 FIND v(dout0_58) AT=730.025n

.meas tran vdout0_59ck1450 FIND v(dout0_59) AT=730.025n

.meas tran vdout0_60ck1450 FIND v(dout0_60) AT=730.025n

.meas tran vdout0_61ck1450 FIND v(dout0_61) AT=730.025n

.meas tran vdout0_62ck1450 FIND v(dout0_62) AT=730.025n

.meas tran vdout0_63ck1450 FIND v(dout0_63) AT=730.025n

.meas tran vdout0_64ck1450 FIND v(dout0_64) AT=730.025n

.meas tran vdout0_65ck1450 FIND v(dout0_65) AT=730.025n

.meas tran vdout0_66ck1450 FIND v(dout0_66) AT=730.025n

.meas tran vdout0_67ck1450 FIND v(dout0_67) AT=730.025n

.meas tran vdout0_68ck1450 FIND v(dout0_68) AT=730.025n

.meas tran vdout0_69ck1450 FIND v(dout0_69) AT=730.025n

.meas tran vdout0_70ck1450 FIND v(dout0_70) AT=730.025n

.meas tran vdout0_71ck1450 FIND v(dout0_71) AT=730.025n

.meas tran vdout0_72ck1450 FIND v(dout0_72) AT=730.025n

.meas tran vdout0_73ck1450 FIND v(dout0_73) AT=730.025n

.meas tran vdout0_74ck1450 FIND v(dout0_74) AT=730.025n

.meas tran vdout0_75ck1450 FIND v(dout0_75) AT=730.025n

.meas tran vdout0_76ck1450 FIND v(dout0_76) AT=730.025n

.meas tran vdout0_77ck1450 FIND v(dout0_77) AT=730.025n

.meas tran vdout0_78ck1450 FIND v(dout0_78) AT=730.025n

.meas tran vdout0_79ck1450 FIND v(dout0_79) AT=730.025n

.meas tran vdout0_80ck1450 FIND v(dout0_80) AT=730.025n

.meas tran vdout0_81ck1450 FIND v(dout0_81) AT=730.025n

.meas tran vdout0_82ck1450 FIND v(dout0_82) AT=730.025n

.meas tran vdout0_83ck1450 FIND v(dout0_83) AT=730.025n

.meas tran vdout0_84ck1450 FIND v(dout0_84) AT=730.025n

.meas tran vdout0_85ck1450 FIND v(dout0_85) AT=730.025n

.meas tran vdout0_86ck1450 FIND v(dout0_86) AT=730.025n

.meas tran vdout0_87ck1450 FIND v(dout0_87) AT=730.025n

.meas tran vdout0_88ck1450 FIND v(dout0_88) AT=730.025n

.meas tran vdout0_89ck1450 FIND v(dout0_89) AT=730.025n

.meas tran vdout0_90ck1450 FIND v(dout0_90) AT=730.025n

.meas tran vdout0_91ck1450 FIND v(dout0_91) AT=730.025n

.meas tran vdout0_92ck1450 FIND v(dout0_92) AT=730.025n

.meas tran vdout0_93ck1450 FIND v(dout0_93) AT=730.025n

.meas tran vdout0_94ck1450 FIND v(dout0_94) AT=730.025n

.meas tran vdout0_95ck1450 FIND v(dout0_95) AT=730.025n

.meas tran vdout0_96ck1450 FIND v(dout0_96) AT=730.025n

.meas tran vdout0_97ck1450 FIND v(dout0_97) AT=730.025n

.meas tran vdout0_98ck1450 FIND v(dout0_98) AT=730.025n

.meas tran vdout0_99ck1450 FIND v(dout0_99) AT=730.025n

.meas tran vdout0_100ck1450 FIND v(dout0_100) AT=730.025n

.meas tran vdout0_101ck1450 FIND v(dout0_101) AT=730.025n

.meas tran vdout0_102ck1450 FIND v(dout0_102) AT=730.025n

.meas tran vdout0_103ck1450 FIND v(dout0_103) AT=730.025n

.meas tran vdout0_104ck1450 FIND v(dout0_104) AT=730.025n

.meas tran vdout0_105ck1450 FIND v(dout0_105) AT=730.025n

.meas tran vdout0_106ck1450 FIND v(dout0_106) AT=730.025n

.meas tran vdout0_107ck1450 FIND v(dout0_107) AT=730.025n

.meas tran vdout0_108ck1450 FIND v(dout0_108) AT=730.025n

.meas tran vdout0_109ck1450 FIND v(dout0_109) AT=730.025n

.meas tran vdout0_110ck1450 FIND v(dout0_110) AT=730.025n

.meas tran vdout0_111ck1450 FIND v(dout0_111) AT=730.025n

.meas tran vdout0_112ck1450 FIND v(dout0_112) AT=730.025n

.meas tran vdout0_113ck1450 FIND v(dout0_113) AT=730.025n

.meas tran vdout0_114ck1450 FIND v(dout0_114) AT=730.025n

.meas tran vdout0_115ck1450 FIND v(dout0_115) AT=730.025n

.meas tran vdout0_116ck1450 FIND v(dout0_116) AT=730.025n

.meas tran vdout0_117ck1450 FIND v(dout0_117) AT=730.025n

.meas tran vdout0_118ck1450 FIND v(dout0_118) AT=730.025n

.meas tran vdout0_119ck1450 FIND v(dout0_119) AT=730.025n

.meas tran vdout0_120ck1450 FIND v(dout0_120) AT=730.025n

.meas tran vdout0_121ck1450 FIND v(dout0_121) AT=730.025n

.meas tran vdout0_122ck1450 FIND v(dout0_122) AT=730.025n

.meas tran vdout0_123ck1450 FIND v(dout0_123) AT=730.025n

.meas tran vdout0_124ck1450 FIND v(dout0_124) AT=730.025n

.meas tran vdout0_125ck1450 FIND v(dout0_125) AT=730.025n

.meas tran vdout0_126ck1450 FIND v(dout0_126) AT=730.025n

.meas tran vdout0_127ck1450 FIND v(dout0_127) AT=730.025n

.meas tran vdout0_0ck1480 FIND v(dout0_0) AT=745.025n

.meas tran vdout0_1ck1480 FIND v(dout0_1) AT=745.025n

.meas tran vdout0_2ck1480 FIND v(dout0_2) AT=745.025n

.meas tran vdout0_3ck1480 FIND v(dout0_3) AT=745.025n

.meas tran vdout0_4ck1480 FIND v(dout0_4) AT=745.025n

.meas tran vdout0_5ck1480 FIND v(dout0_5) AT=745.025n

.meas tran vdout0_6ck1480 FIND v(dout0_6) AT=745.025n

.meas tran vdout0_7ck1480 FIND v(dout0_7) AT=745.025n

.meas tran vdout0_8ck1480 FIND v(dout0_8) AT=745.025n

.meas tran vdout0_9ck1480 FIND v(dout0_9) AT=745.025n

.meas tran vdout0_10ck1480 FIND v(dout0_10) AT=745.025n

.meas tran vdout0_11ck1480 FIND v(dout0_11) AT=745.025n

.meas tran vdout0_12ck1480 FIND v(dout0_12) AT=745.025n

.meas tran vdout0_13ck1480 FIND v(dout0_13) AT=745.025n

.meas tran vdout0_14ck1480 FIND v(dout0_14) AT=745.025n

.meas tran vdout0_15ck1480 FIND v(dout0_15) AT=745.025n

.meas tran vdout0_16ck1480 FIND v(dout0_16) AT=745.025n

.meas tran vdout0_17ck1480 FIND v(dout0_17) AT=745.025n

.meas tran vdout0_18ck1480 FIND v(dout0_18) AT=745.025n

.meas tran vdout0_19ck1480 FIND v(dout0_19) AT=745.025n

.meas tran vdout0_20ck1480 FIND v(dout0_20) AT=745.025n

.meas tran vdout0_21ck1480 FIND v(dout0_21) AT=745.025n

.meas tran vdout0_22ck1480 FIND v(dout0_22) AT=745.025n

.meas tran vdout0_23ck1480 FIND v(dout0_23) AT=745.025n

.meas tran vdout0_24ck1480 FIND v(dout0_24) AT=745.025n

.meas tran vdout0_25ck1480 FIND v(dout0_25) AT=745.025n

.meas tran vdout0_26ck1480 FIND v(dout0_26) AT=745.025n

.meas tran vdout0_27ck1480 FIND v(dout0_27) AT=745.025n

.meas tran vdout0_28ck1480 FIND v(dout0_28) AT=745.025n

.meas tran vdout0_29ck1480 FIND v(dout0_29) AT=745.025n

.meas tran vdout0_30ck1480 FIND v(dout0_30) AT=745.025n

.meas tran vdout0_31ck1480 FIND v(dout0_31) AT=745.025n

.meas tran vdout0_32ck1480 FIND v(dout0_32) AT=745.025n

.meas tran vdout0_33ck1480 FIND v(dout0_33) AT=745.025n

.meas tran vdout0_34ck1480 FIND v(dout0_34) AT=745.025n

.meas tran vdout0_35ck1480 FIND v(dout0_35) AT=745.025n

.meas tran vdout0_36ck1480 FIND v(dout0_36) AT=745.025n

.meas tran vdout0_37ck1480 FIND v(dout0_37) AT=745.025n

.meas tran vdout0_38ck1480 FIND v(dout0_38) AT=745.025n

.meas tran vdout0_39ck1480 FIND v(dout0_39) AT=745.025n

.meas tran vdout0_40ck1480 FIND v(dout0_40) AT=745.025n

.meas tran vdout0_41ck1480 FIND v(dout0_41) AT=745.025n

.meas tran vdout0_42ck1480 FIND v(dout0_42) AT=745.025n

.meas tran vdout0_43ck1480 FIND v(dout0_43) AT=745.025n

.meas tran vdout0_44ck1480 FIND v(dout0_44) AT=745.025n

.meas tran vdout0_45ck1480 FIND v(dout0_45) AT=745.025n

.meas tran vdout0_46ck1480 FIND v(dout0_46) AT=745.025n

.meas tran vdout0_47ck1480 FIND v(dout0_47) AT=745.025n

.meas tran vdout0_48ck1480 FIND v(dout0_48) AT=745.025n

.meas tran vdout0_49ck1480 FIND v(dout0_49) AT=745.025n

.meas tran vdout0_50ck1480 FIND v(dout0_50) AT=745.025n

.meas tran vdout0_51ck1480 FIND v(dout0_51) AT=745.025n

.meas tran vdout0_52ck1480 FIND v(dout0_52) AT=745.025n

.meas tran vdout0_53ck1480 FIND v(dout0_53) AT=745.025n

.meas tran vdout0_54ck1480 FIND v(dout0_54) AT=745.025n

.meas tran vdout0_55ck1480 FIND v(dout0_55) AT=745.025n

.meas tran vdout0_56ck1480 FIND v(dout0_56) AT=745.025n

.meas tran vdout0_57ck1480 FIND v(dout0_57) AT=745.025n

.meas tran vdout0_58ck1480 FIND v(dout0_58) AT=745.025n

.meas tran vdout0_59ck1480 FIND v(dout0_59) AT=745.025n

.meas tran vdout0_60ck1480 FIND v(dout0_60) AT=745.025n

.meas tran vdout0_61ck1480 FIND v(dout0_61) AT=745.025n

.meas tran vdout0_62ck1480 FIND v(dout0_62) AT=745.025n

.meas tran vdout0_63ck1480 FIND v(dout0_63) AT=745.025n

.meas tran vdout0_64ck1480 FIND v(dout0_64) AT=745.025n

.meas tran vdout0_65ck1480 FIND v(dout0_65) AT=745.025n

.meas tran vdout0_66ck1480 FIND v(dout0_66) AT=745.025n

.meas tran vdout0_67ck1480 FIND v(dout0_67) AT=745.025n

.meas tran vdout0_68ck1480 FIND v(dout0_68) AT=745.025n

.meas tran vdout0_69ck1480 FIND v(dout0_69) AT=745.025n

.meas tran vdout0_70ck1480 FIND v(dout0_70) AT=745.025n

.meas tran vdout0_71ck1480 FIND v(dout0_71) AT=745.025n

.meas tran vdout0_72ck1480 FIND v(dout0_72) AT=745.025n

.meas tran vdout0_73ck1480 FIND v(dout0_73) AT=745.025n

.meas tran vdout0_74ck1480 FIND v(dout0_74) AT=745.025n

.meas tran vdout0_75ck1480 FIND v(dout0_75) AT=745.025n

.meas tran vdout0_76ck1480 FIND v(dout0_76) AT=745.025n

.meas tran vdout0_77ck1480 FIND v(dout0_77) AT=745.025n

.meas tran vdout0_78ck1480 FIND v(dout0_78) AT=745.025n

.meas tran vdout0_79ck1480 FIND v(dout0_79) AT=745.025n

.meas tran vdout0_80ck1480 FIND v(dout0_80) AT=745.025n

.meas tran vdout0_81ck1480 FIND v(dout0_81) AT=745.025n

.meas tran vdout0_82ck1480 FIND v(dout0_82) AT=745.025n

.meas tran vdout0_83ck1480 FIND v(dout0_83) AT=745.025n

.meas tran vdout0_84ck1480 FIND v(dout0_84) AT=745.025n

.meas tran vdout0_85ck1480 FIND v(dout0_85) AT=745.025n

.meas tran vdout0_86ck1480 FIND v(dout0_86) AT=745.025n

.meas tran vdout0_87ck1480 FIND v(dout0_87) AT=745.025n

.meas tran vdout0_88ck1480 FIND v(dout0_88) AT=745.025n

.meas tran vdout0_89ck1480 FIND v(dout0_89) AT=745.025n

.meas tran vdout0_90ck1480 FIND v(dout0_90) AT=745.025n

.meas tran vdout0_91ck1480 FIND v(dout0_91) AT=745.025n

.meas tran vdout0_92ck1480 FIND v(dout0_92) AT=745.025n

.meas tran vdout0_93ck1480 FIND v(dout0_93) AT=745.025n

.meas tran vdout0_94ck1480 FIND v(dout0_94) AT=745.025n

.meas tran vdout0_95ck1480 FIND v(dout0_95) AT=745.025n

.meas tran vdout0_96ck1480 FIND v(dout0_96) AT=745.025n

.meas tran vdout0_97ck1480 FIND v(dout0_97) AT=745.025n

.meas tran vdout0_98ck1480 FIND v(dout0_98) AT=745.025n

.meas tran vdout0_99ck1480 FIND v(dout0_99) AT=745.025n

.meas tran vdout0_100ck1480 FIND v(dout0_100) AT=745.025n

.meas tran vdout0_101ck1480 FIND v(dout0_101) AT=745.025n

.meas tran vdout0_102ck1480 FIND v(dout0_102) AT=745.025n

.meas tran vdout0_103ck1480 FIND v(dout0_103) AT=745.025n

.meas tran vdout0_104ck1480 FIND v(dout0_104) AT=745.025n

.meas tran vdout0_105ck1480 FIND v(dout0_105) AT=745.025n

.meas tran vdout0_106ck1480 FIND v(dout0_106) AT=745.025n

.meas tran vdout0_107ck1480 FIND v(dout0_107) AT=745.025n

.meas tran vdout0_108ck1480 FIND v(dout0_108) AT=745.025n

.meas tran vdout0_109ck1480 FIND v(dout0_109) AT=745.025n

.meas tran vdout0_110ck1480 FIND v(dout0_110) AT=745.025n

.meas tran vdout0_111ck1480 FIND v(dout0_111) AT=745.025n

.meas tran vdout0_112ck1480 FIND v(dout0_112) AT=745.025n

.meas tran vdout0_113ck1480 FIND v(dout0_113) AT=745.025n

.meas tran vdout0_114ck1480 FIND v(dout0_114) AT=745.025n

.meas tran vdout0_115ck1480 FIND v(dout0_115) AT=745.025n

.meas tran vdout0_116ck1480 FIND v(dout0_116) AT=745.025n

.meas tran vdout0_117ck1480 FIND v(dout0_117) AT=745.025n

.meas tran vdout0_118ck1480 FIND v(dout0_118) AT=745.025n

.meas tran vdout0_119ck1480 FIND v(dout0_119) AT=745.025n

.meas tran vdout0_120ck1480 FIND v(dout0_120) AT=745.025n

.meas tran vdout0_121ck1480 FIND v(dout0_121) AT=745.025n

.meas tran vdout0_122ck1480 FIND v(dout0_122) AT=745.025n

.meas tran vdout0_123ck1480 FIND v(dout0_123) AT=745.025n

.meas tran vdout0_124ck1480 FIND v(dout0_124) AT=745.025n

.meas tran vdout0_125ck1480 FIND v(dout0_125) AT=745.025n

.meas tran vdout0_126ck1480 FIND v(dout0_126) AT=745.025n

.meas tran vdout0_127ck1480 FIND v(dout0_127) AT=745.025n

.meas tran vdout0_0ck1530 FIND v(dout0_0) AT=770.025n

.meas tran vdout0_1ck1530 FIND v(dout0_1) AT=770.025n

.meas tran vdout0_2ck1530 FIND v(dout0_2) AT=770.025n

.meas tran vdout0_3ck1530 FIND v(dout0_3) AT=770.025n

.meas tran vdout0_4ck1530 FIND v(dout0_4) AT=770.025n

.meas tran vdout0_5ck1530 FIND v(dout0_5) AT=770.025n

.meas tran vdout0_6ck1530 FIND v(dout0_6) AT=770.025n

.meas tran vdout0_7ck1530 FIND v(dout0_7) AT=770.025n

.meas tran vdout0_8ck1530 FIND v(dout0_8) AT=770.025n

.meas tran vdout0_9ck1530 FIND v(dout0_9) AT=770.025n

.meas tran vdout0_10ck1530 FIND v(dout0_10) AT=770.025n

.meas tran vdout0_11ck1530 FIND v(dout0_11) AT=770.025n

.meas tran vdout0_12ck1530 FIND v(dout0_12) AT=770.025n

.meas tran vdout0_13ck1530 FIND v(dout0_13) AT=770.025n

.meas tran vdout0_14ck1530 FIND v(dout0_14) AT=770.025n

.meas tran vdout0_15ck1530 FIND v(dout0_15) AT=770.025n

.meas tran vdout0_16ck1530 FIND v(dout0_16) AT=770.025n

.meas tran vdout0_17ck1530 FIND v(dout0_17) AT=770.025n

.meas tran vdout0_18ck1530 FIND v(dout0_18) AT=770.025n

.meas tran vdout0_19ck1530 FIND v(dout0_19) AT=770.025n

.meas tran vdout0_20ck1530 FIND v(dout0_20) AT=770.025n

.meas tran vdout0_21ck1530 FIND v(dout0_21) AT=770.025n

.meas tran vdout0_22ck1530 FIND v(dout0_22) AT=770.025n

.meas tran vdout0_23ck1530 FIND v(dout0_23) AT=770.025n

.meas tran vdout0_24ck1530 FIND v(dout0_24) AT=770.025n

.meas tran vdout0_25ck1530 FIND v(dout0_25) AT=770.025n

.meas tran vdout0_26ck1530 FIND v(dout0_26) AT=770.025n

.meas tran vdout0_27ck1530 FIND v(dout0_27) AT=770.025n

.meas tran vdout0_28ck1530 FIND v(dout0_28) AT=770.025n

.meas tran vdout0_29ck1530 FIND v(dout0_29) AT=770.025n

.meas tran vdout0_30ck1530 FIND v(dout0_30) AT=770.025n

.meas tran vdout0_31ck1530 FIND v(dout0_31) AT=770.025n

.meas tran vdout0_32ck1530 FIND v(dout0_32) AT=770.025n

.meas tran vdout0_33ck1530 FIND v(dout0_33) AT=770.025n

.meas tran vdout0_34ck1530 FIND v(dout0_34) AT=770.025n

.meas tran vdout0_35ck1530 FIND v(dout0_35) AT=770.025n

.meas tran vdout0_36ck1530 FIND v(dout0_36) AT=770.025n

.meas tran vdout0_37ck1530 FIND v(dout0_37) AT=770.025n

.meas tran vdout0_38ck1530 FIND v(dout0_38) AT=770.025n

.meas tran vdout0_39ck1530 FIND v(dout0_39) AT=770.025n

.meas tran vdout0_40ck1530 FIND v(dout0_40) AT=770.025n

.meas tran vdout0_41ck1530 FIND v(dout0_41) AT=770.025n

.meas tran vdout0_42ck1530 FIND v(dout0_42) AT=770.025n

.meas tran vdout0_43ck1530 FIND v(dout0_43) AT=770.025n

.meas tran vdout0_44ck1530 FIND v(dout0_44) AT=770.025n

.meas tran vdout0_45ck1530 FIND v(dout0_45) AT=770.025n

.meas tran vdout0_46ck1530 FIND v(dout0_46) AT=770.025n

.meas tran vdout0_47ck1530 FIND v(dout0_47) AT=770.025n

.meas tran vdout0_48ck1530 FIND v(dout0_48) AT=770.025n

.meas tran vdout0_49ck1530 FIND v(dout0_49) AT=770.025n

.meas tran vdout0_50ck1530 FIND v(dout0_50) AT=770.025n

.meas tran vdout0_51ck1530 FIND v(dout0_51) AT=770.025n

.meas tran vdout0_52ck1530 FIND v(dout0_52) AT=770.025n

.meas tran vdout0_53ck1530 FIND v(dout0_53) AT=770.025n

.meas tran vdout0_54ck1530 FIND v(dout0_54) AT=770.025n

.meas tran vdout0_55ck1530 FIND v(dout0_55) AT=770.025n

.meas tran vdout0_56ck1530 FIND v(dout0_56) AT=770.025n

.meas tran vdout0_57ck1530 FIND v(dout0_57) AT=770.025n

.meas tran vdout0_58ck1530 FIND v(dout0_58) AT=770.025n

.meas tran vdout0_59ck1530 FIND v(dout0_59) AT=770.025n

.meas tran vdout0_60ck1530 FIND v(dout0_60) AT=770.025n

.meas tran vdout0_61ck1530 FIND v(dout0_61) AT=770.025n

.meas tran vdout0_62ck1530 FIND v(dout0_62) AT=770.025n

.meas tran vdout0_63ck1530 FIND v(dout0_63) AT=770.025n

.meas tran vdout0_64ck1530 FIND v(dout0_64) AT=770.025n

.meas tran vdout0_65ck1530 FIND v(dout0_65) AT=770.025n

.meas tran vdout0_66ck1530 FIND v(dout0_66) AT=770.025n

.meas tran vdout0_67ck1530 FIND v(dout0_67) AT=770.025n

.meas tran vdout0_68ck1530 FIND v(dout0_68) AT=770.025n

.meas tran vdout0_69ck1530 FIND v(dout0_69) AT=770.025n

.meas tran vdout0_70ck1530 FIND v(dout0_70) AT=770.025n

.meas tran vdout0_71ck1530 FIND v(dout0_71) AT=770.025n

.meas tran vdout0_72ck1530 FIND v(dout0_72) AT=770.025n

.meas tran vdout0_73ck1530 FIND v(dout0_73) AT=770.025n

.meas tran vdout0_74ck1530 FIND v(dout0_74) AT=770.025n

.meas tran vdout0_75ck1530 FIND v(dout0_75) AT=770.025n

.meas tran vdout0_76ck1530 FIND v(dout0_76) AT=770.025n

.meas tran vdout0_77ck1530 FIND v(dout0_77) AT=770.025n

.meas tran vdout0_78ck1530 FIND v(dout0_78) AT=770.025n

.meas tran vdout0_79ck1530 FIND v(dout0_79) AT=770.025n

.meas tran vdout0_80ck1530 FIND v(dout0_80) AT=770.025n

.meas tran vdout0_81ck1530 FIND v(dout0_81) AT=770.025n

.meas tran vdout0_82ck1530 FIND v(dout0_82) AT=770.025n

.meas tran vdout0_83ck1530 FIND v(dout0_83) AT=770.025n

.meas tran vdout0_84ck1530 FIND v(dout0_84) AT=770.025n

.meas tran vdout0_85ck1530 FIND v(dout0_85) AT=770.025n

.meas tran vdout0_86ck1530 FIND v(dout0_86) AT=770.025n

.meas tran vdout0_87ck1530 FIND v(dout0_87) AT=770.025n

.meas tran vdout0_88ck1530 FIND v(dout0_88) AT=770.025n

.meas tran vdout0_89ck1530 FIND v(dout0_89) AT=770.025n

.meas tran vdout0_90ck1530 FIND v(dout0_90) AT=770.025n

.meas tran vdout0_91ck1530 FIND v(dout0_91) AT=770.025n

.meas tran vdout0_92ck1530 FIND v(dout0_92) AT=770.025n

.meas tran vdout0_93ck1530 FIND v(dout0_93) AT=770.025n

.meas tran vdout0_94ck1530 FIND v(dout0_94) AT=770.025n

.meas tran vdout0_95ck1530 FIND v(dout0_95) AT=770.025n

.meas tran vdout0_96ck1530 FIND v(dout0_96) AT=770.025n

.meas tran vdout0_97ck1530 FIND v(dout0_97) AT=770.025n

.meas tran vdout0_98ck1530 FIND v(dout0_98) AT=770.025n

.meas tran vdout0_99ck1530 FIND v(dout0_99) AT=770.025n

.meas tran vdout0_100ck1530 FIND v(dout0_100) AT=770.025n

.meas tran vdout0_101ck1530 FIND v(dout0_101) AT=770.025n

.meas tran vdout0_102ck1530 FIND v(dout0_102) AT=770.025n

.meas tran vdout0_103ck1530 FIND v(dout0_103) AT=770.025n

.meas tran vdout0_104ck1530 FIND v(dout0_104) AT=770.025n

.meas tran vdout0_105ck1530 FIND v(dout0_105) AT=770.025n

.meas tran vdout0_106ck1530 FIND v(dout0_106) AT=770.025n

.meas tran vdout0_107ck1530 FIND v(dout0_107) AT=770.025n

.meas tran vdout0_108ck1530 FIND v(dout0_108) AT=770.025n

.meas tran vdout0_109ck1530 FIND v(dout0_109) AT=770.025n

.meas tran vdout0_110ck1530 FIND v(dout0_110) AT=770.025n

.meas tran vdout0_111ck1530 FIND v(dout0_111) AT=770.025n

.meas tran vdout0_112ck1530 FIND v(dout0_112) AT=770.025n

.meas tran vdout0_113ck1530 FIND v(dout0_113) AT=770.025n

.meas tran vdout0_114ck1530 FIND v(dout0_114) AT=770.025n

.meas tran vdout0_115ck1530 FIND v(dout0_115) AT=770.025n

.meas tran vdout0_116ck1530 FIND v(dout0_116) AT=770.025n

.meas tran vdout0_117ck1530 FIND v(dout0_117) AT=770.025n

.meas tran vdout0_118ck1530 FIND v(dout0_118) AT=770.025n

.meas tran vdout0_119ck1530 FIND v(dout0_119) AT=770.025n

.meas tran vdout0_120ck1530 FIND v(dout0_120) AT=770.025n

.meas tran vdout0_121ck1530 FIND v(dout0_121) AT=770.025n

.meas tran vdout0_122ck1530 FIND v(dout0_122) AT=770.025n

.meas tran vdout0_123ck1530 FIND v(dout0_123) AT=770.025n

.meas tran vdout0_124ck1530 FIND v(dout0_124) AT=770.025n

.meas tran vdout0_125ck1530 FIND v(dout0_125) AT=770.025n

.meas tran vdout0_126ck1530 FIND v(dout0_126) AT=770.025n

.meas tran vdout0_127ck1530 FIND v(dout0_127) AT=770.025n

.meas tran vdout0_0ck1540 FIND v(dout0_0) AT=775.025n

.meas tran vdout0_1ck1540 FIND v(dout0_1) AT=775.025n

.meas tran vdout0_2ck1540 FIND v(dout0_2) AT=775.025n

.meas tran vdout0_3ck1540 FIND v(dout0_3) AT=775.025n

.meas tran vdout0_4ck1540 FIND v(dout0_4) AT=775.025n

.meas tran vdout0_5ck1540 FIND v(dout0_5) AT=775.025n

.meas tran vdout0_6ck1540 FIND v(dout0_6) AT=775.025n

.meas tran vdout0_7ck1540 FIND v(dout0_7) AT=775.025n

.meas tran vdout0_8ck1540 FIND v(dout0_8) AT=775.025n

.meas tran vdout0_9ck1540 FIND v(dout0_9) AT=775.025n

.meas tran vdout0_10ck1540 FIND v(dout0_10) AT=775.025n

.meas tran vdout0_11ck1540 FIND v(dout0_11) AT=775.025n

.meas tran vdout0_12ck1540 FIND v(dout0_12) AT=775.025n

.meas tran vdout0_13ck1540 FIND v(dout0_13) AT=775.025n

.meas tran vdout0_14ck1540 FIND v(dout0_14) AT=775.025n

.meas tran vdout0_15ck1540 FIND v(dout0_15) AT=775.025n

.meas tran vdout0_16ck1540 FIND v(dout0_16) AT=775.025n

.meas tran vdout0_17ck1540 FIND v(dout0_17) AT=775.025n

.meas tran vdout0_18ck1540 FIND v(dout0_18) AT=775.025n

.meas tran vdout0_19ck1540 FIND v(dout0_19) AT=775.025n

.meas tran vdout0_20ck1540 FIND v(dout0_20) AT=775.025n

.meas tran vdout0_21ck1540 FIND v(dout0_21) AT=775.025n

.meas tran vdout0_22ck1540 FIND v(dout0_22) AT=775.025n

.meas tran vdout0_23ck1540 FIND v(dout0_23) AT=775.025n

.meas tran vdout0_24ck1540 FIND v(dout0_24) AT=775.025n

.meas tran vdout0_25ck1540 FIND v(dout0_25) AT=775.025n

.meas tran vdout0_26ck1540 FIND v(dout0_26) AT=775.025n

.meas tran vdout0_27ck1540 FIND v(dout0_27) AT=775.025n

.meas tran vdout0_28ck1540 FIND v(dout0_28) AT=775.025n

.meas tran vdout0_29ck1540 FIND v(dout0_29) AT=775.025n

.meas tran vdout0_30ck1540 FIND v(dout0_30) AT=775.025n

.meas tran vdout0_31ck1540 FIND v(dout0_31) AT=775.025n

.meas tran vdout0_32ck1540 FIND v(dout0_32) AT=775.025n

.meas tran vdout0_33ck1540 FIND v(dout0_33) AT=775.025n

.meas tran vdout0_34ck1540 FIND v(dout0_34) AT=775.025n

.meas tran vdout0_35ck1540 FIND v(dout0_35) AT=775.025n

.meas tran vdout0_36ck1540 FIND v(dout0_36) AT=775.025n

.meas tran vdout0_37ck1540 FIND v(dout0_37) AT=775.025n

.meas tran vdout0_38ck1540 FIND v(dout0_38) AT=775.025n

.meas tran vdout0_39ck1540 FIND v(dout0_39) AT=775.025n

.meas tran vdout0_40ck1540 FIND v(dout0_40) AT=775.025n

.meas tran vdout0_41ck1540 FIND v(dout0_41) AT=775.025n

.meas tran vdout0_42ck1540 FIND v(dout0_42) AT=775.025n

.meas tran vdout0_43ck1540 FIND v(dout0_43) AT=775.025n

.meas tran vdout0_44ck1540 FIND v(dout0_44) AT=775.025n

.meas tran vdout0_45ck1540 FIND v(dout0_45) AT=775.025n

.meas tran vdout0_46ck1540 FIND v(dout0_46) AT=775.025n

.meas tran vdout0_47ck1540 FIND v(dout0_47) AT=775.025n

.meas tran vdout0_48ck1540 FIND v(dout0_48) AT=775.025n

.meas tran vdout0_49ck1540 FIND v(dout0_49) AT=775.025n

.meas tran vdout0_50ck1540 FIND v(dout0_50) AT=775.025n

.meas tran vdout0_51ck1540 FIND v(dout0_51) AT=775.025n

.meas tran vdout0_52ck1540 FIND v(dout0_52) AT=775.025n

.meas tran vdout0_53ck1540 FIND v(dout0_53) AT=775.025n

.meas tran vdout0_54ck1540 FIND v(dout0_54) AT=775.025n

.meas tran vdout0_55ck1540 FIND v(dout0_55) AT=775.025n

.meas tran vdout0_56ck1540 FIND v(dout0_56) AT=775.025n

.meas tran vdout0_57ck1540 FIND v(dout0_57) AT=775.025n

.meas tran vdout0_58ck1540 FIND v(dout0_58) AT=775.025n

.meas tran vdout0_59ck1540 FIND v(dout0_59) AT=775.025n

.meas tran vdout0_60ck1540 FIND v(dout0_60) AT=775.025n

.meas tran vdout0_61ck1540 FIND v(dout0_61) AT=775.025n

.meas tran vdout0_62ck1540 FIND v(dout0_62) AT=775.025n

.meas tran vdout0_63ck1540 FIND v(dout0_63) AT=775.025n

.meas tran vdout0_64ck1540 FIND v(dout0_64) AT=775.025n

.meas tran vdout0_65ck1540 FIND v(dout0_65) AT=775.025n

.meas tran vdout0_66ck1540 FIND v(dout0_66) AT=775.025n

.meas tran vdout0_67ck1540 FIND v(dout0_67) AT=775.025n

.meas tran vdout0_68ck1540 FIND v(dout0_68) AT=775.025n

.meas tran vdout0_69ck1540 FIND v(dout0_69) AT=775.025n

.meas tran vdout0_70ck1540 FIND v(dout0_70) AT=775.025n

.meas tran vdout0_71ck1540 FIND v(dout0_71) AT=775.025n

.meas tran vdout0_72ck1540 FIND v(dout0_72) AT=775.025n

.meas tran vdout0_73ck1540 FIND v(dout0_73) AT=775.025n

.meas tran vdout0_74ck1540 FIND v(dout0_74) AT=775.025n

.meas tran vdout0_75ck1540 FIND v(dout0_75) AT=775.025n

.meas tran vdout0_76ck1540 FIND v(dout0_76) AT=775.025n

.meas tran vdout0_77ck1540 FIND v(dout0_77) AT=775.025n

.meas tran vdout0_78ck1540 FIND v(dout0_78) AT=775.025n

.meas tran vdout0_79ck1540 FIND v(dout0_79) AT=775.025n

.meas tran vdout0_80ck1540 FIND v(dout0_80) AT=775.025n

.meas tran vdout0_81ck1540 FIND v(dout0_81) AT=775.025n

.meas tran vdout0_82ck1540 FIND v(dout0_82) AT=775.025n

.meas tran vdout0_83ck1540 FIND v(dout0_83) AT=775.025n

.meas tran vdout0_84ck1540 FIND v(dout0_84) AT=775.025n

.meas tran vdout0_85ck1540 FIND v(dout0_85) AT=775.025n

.meas tran vdout0_86ck1540 FIND v(dout0_86) AT=775.025n

.meas tran vdout0_87ck1540 FIND v(dout0_87) AT=775.025n

.meas tran vdout0_88ck1540 FIND v(dout0_88) AT=775.025n

.meas tran vdout0_89ck1540 FIND v(dout0_89) AT=775.025n

.meas tran vdout0_90ck1540 FIND v(dout0_90) AT=775.025n

.meas tran vdout0_91ck1540 FIND v(dout0_91) AT=775.025n

.meas tran vdout0_92ck1540 FIND v(dout0_92) AT=775.025n

.meas tran vdout0_93ck1540 FIND v(dout0_93) AT=775.025n

.meas tran vdout0_94ck1540 FIND v(dout0_94) AT=775.025n

.meas tran vdout0_95ck1540 FIND v(dout0_95) AT=775.025n

.meas tran vdout0_96ck1540 FIND v(dout0_96) AT=775.025n

.meas tran vdout0_97ck1540 FIND v(dout0_97) AT=775.025n

.meas tran vdout0_98ck1540 FIND v(dout0_98) AT=775.025n

.meas tran vdout0_99ck1540 FIND v(dout0_99) AT=775.025n

.meas tran vdout0_100ck1540 FIND v(dout0_100) AT=775.025n

.meas tran vdout0_101ck1540 FIND v(dout0_101) AT=775.025n

.meas tran vdout0_102ck1540 FIND v(dout0_102) AT=775.025n

.meas tran vdout0_103ck1540 FIND v(dout0_103) AT=775.025n

.meas tran vdout0_104ck1540 FIND v(dout0_104) AT=775.025n

.meas tran vdout0_105ck1540 FIND v(dout0_105) AT=775.025n

.meas tran vdout0_106ck1540 FIND v(dout0_106) AT=775.025n

.meas tran vdout0_107ck1540 FIND v(dout0_107) AT=775.025n

.meas tran vdout0_108ck1540 FIND v(dout0_108) AT=775.025n

.meas tran vdout0_109ck1540 FIND v(dout0_109) AT=775.025n

.meas tran vdout0_110ck1540 FIND v(dout0_110) AT=775.025n

.meas tran vdout0_111ck1540 FIND v(dout0_111) AT=775.025n

.meas tran vdout0_112ck1540 FIND v(dout0_112) AT=775.025n

.meas tran vdout0_113ck1540 FIND v(dout0_113) AT=775.025n

.meas tran vdout0_114ck1540 FIND v(dout0_114) AT=775.025n

.meas tran vdout0_115ck1540 FIND v(dout0_115) AT=775.025n

.meas tran vdout0_116ck1540 FIND v(dout0_116) AT=775.025n

.meas tran vdout0_117ck1540 FIND v(dout0_117) AT=775.025n

.meas tran vdout0_118ck1540 FIND v(dout0_118) AT=775.025n

.meas tran vdout0_119ck1540 FIND v(dout0_119) AT=775.025n

.meas tran vdout0_120ck1540 FIND v(dout0_120) AT=775.025n

.meas tran vdout0_121ck1540 FIND v(dout0_121) AT=775.025n

.meas tran vdout0_122ck1540 FIND v(dout0_122) AT=775.025n

.meas tran vdout0_123ck1540 FIND v(dout0_123) AT=775.025n

.meas tran vdout0_124ck1540 FIND v(dout0_124) AT=775.025n

.meas tran vdout0_125ck1540 FIND v(dout0_125) AT=775.025n

.meas tran vdout0_126ck1540 FIND v(dout0_126) AT=775.025n

.meas tran vdout0_127ck1540 FIND v(dout0_127) AT=775.025n

.meas tran vdout0_0ck1570 FIND v(dout0_0) AT=790.025n

.meas tran vdout0_1ck1570 FIND v(dout0_1) AT=790.025n

.meas tran vdout0_2ck1570 FIND v(dout0_2) AT=790.025n

.meas tran vdout0_3ck1570 FIND v(dout0_3) AT=790.025n

.meas tran vdout0_4ck1570 FIND v(dout0_4) AT=790.025n

.meas tran vdout0_5ck1570 FIND v(dout0_5) AT=790.025n

.meas tran vdout0_6ck1570 FIND v(dout0_6) AT=790.025n

.meas tran vdout0_7ck1570 FIND v(dout0_7) AT=790.025n

.meas tran vdout0_8ck1570 FIND v(dout0_8) AT=790.025n

.meas tran vdout0_9ck1570 FIND v(dout0_9) AT=790.025n

.meas tran vdout0_10ck1570 FIND v(dout0_10) AT=790.025n

.meas tran vdout0_11ck1570 FIND v(dout0_11) AT=790.025n

.meas tran vdout0_12ck1570 FIND v(dout0_12) AT=790.025n

.meas tran vdout0_13ck1570 FIND v(dout0_13) AT=790.025n

.meas tran vdout0_14ck1570 FIND v(dout0_14) AT=790.025n

.meas tran vdout0_15ck1570 FIND v(dout0_15) AT=790.025n

.meas tran vdout0_16ck1570 FIND v(dout0_16) AT=790.025n

.meas tran vdout0_17ck1570 FIND v(dout0_17) AT=790.025n

.meas tran vdout0_18ck1570 FIND v(dout0_18) AT=790.025n

.meas tran vdout0_19ck1570 FIND v(dout0_19) AT=790.025n

.meas tran vdout0_20ck1570 FIND v(dout0_20) AT=790.025n

.meas tran vdout0_21ck1570 FIND v(dout0_21) AT=790.025n

.meas tran vdout0_22ck1570 FIND v(dout0_22) AT=790.025n

.meas tran vdout0_23ck1570 FIND v(dout0_23) AT=790.025n

.meas tran vdout0_24ck1570 FIND v(dout0_24) AT=790.025n

.meas tran vdout0_25ck1570 FIND v(dout0_25) AT=790.025n

.meas tran vdout0_26ck1570 FIND v(dout0_26) AT=790.025n

.meas tran vdout0_27ck1570 FIND v(dout0_27) AT=790.025n

.meas tran vdout0_28ck1570 FIND v(dout0_28) AT=790.025n

.meas tran vdout0_29ck1570 FIND v(dout0_29) AT=790.025n

.meas tran vdout0_30ck1570 FIND v(dout0_30) AT=790.025n

.meas tran vdout0_31ck1570 FIND v(dout0_31) AT=790.025n

.meas tran vdout0_32ck1570 FIND v(dout0_32) AT=790.025n

.meas tran vdout0_33ck1570 FIND v(dout0_33) AT=790.025n

.meas tran vdout0_34ck1570 FIND v(dout0_34) AT=790.025n

.meas tran vdout0_35ck1570 FIND v(dout0_35) AT=790.025n

.meas tran vdout0_36ck1570 FIND v(dout0_36) AT=790.025n

.meas tran vdout0_37ck1570 FIND v(dout0_37) AT=790.025n

.meas tran vdout0_38ck1570 FIND v(dout0_38) AT=790.025n

.meas tran vdout0_39ck1570 FIND v(dout0_39) AT=790.025n

.meas tran vdout0_40ck1570 FIND v(dout0_40) AT=790.025n

.meas tran vdout0_41ck1570 FIND v(dout0_41) AT=790.025n

.meas tran vdout0_42ck1570 FIND v(dout0_42) AT=790.025n

.meas tran vdout0_43ck1570 FIND v(dout0_43) AT=790.025n

.meas tran vdout0_44ck1570 FIND v(dout0_44) AT=790.025n

.meas tran vdout0_45ck1570 FIND v(dout0_45) AT=790.025n

.meas tran vdout0_46ck1570 FIND v(dout0_46) AT=790.025n

.meas tran vdout0_47ck1570 FIND v(dout0_47) AT=790.025n

.meas tran vdout0_48ck1570 FIND v(dout0_48) AT=790.025n

.meas tran vdout0_49ck1570 FIND v(dout0_49) AT=790.025n

.meas tran vdout0_50ck1570 FIND v(dout0_50) AT=790.025n

.meas tran vdout0_51ck1570 FIND v(dout0_51) AT=790.025n

.meas tran vdout0_52ck1570 FIND v(dout0_52) AT=790.025n

.meas tran vdout0_53ck1570 FIND v(dout0_53) AT=790.025n

.meas tran vdout0_54ck1570 FIND v(dout0_54) AT=790.025n

.meas tran vdout0_55ck1570 FIND v(dout0_55) AT=790.025n

.meas tran vdout0_56ck1570 FIND v(dout0_56) AT=790.025n

.meas tran vdout0_57ck1570 FIND v(dout0_57) AT=790.025n

.meas tran vdout0_58ck1570 FIND v(dout0_58) AT=790.025n

.meas tran vdout0_59ck1570 FIND v(dout0_59) AT=790.025n

.meas tran vdout0_60ck1570 FIND v(dout0_60) AT=790.025n

.meas tran vdout0_61ck1570 FIND v(dout0_61) AT=790.025n

.meas tran vdout0_62ck1570 FIND v(dout0_62) AT=790.025n

.meas tran vdout0_63ck1570 FIND v(dout0_63) AT=790.025n

.meas tran vdout0_64ck1570 FIND v(dout0_64) AT=790.025n

.meas tran vdout0_65ck1570 FIND v(dout0_65) AT=790.025n

.meas tran vdout0_66ck1570 FIND v(dout0_66) AT=790.025n

.meas tran vdout0_67ck1570 FIND v(dout0_67) AT=790.025n

.meas tran vdout0_68ck1570 FIND v(dout0_68) AT=790.025n

.meas tran vdout0_69ck1570 FIND v(dout0_69) AT=790.025n

.meas tran vdout0_70ck1570 FIND v(dout0_70) AT=790.025n

.meas tran vdout0_71ck1570 FIND v(dout0_71) AT=790.025n

.meas tran vdout0_72ck1570 FIND v(dout0_72) AT=790.025n

.meas tran vdout0_73ck1570 FIND v(dout0_73) AT=790.025n

.meas tran vdout0_74ck1570 FIND v(dout0_74) AT=790.025n

.meas tran vdout0_75ck1570 FIND v(dout0_75) AT=790.025n

.meas tran vdout0_76ck1570 FIND v(dout0_76) AT=790.025n

.meas tran vdout0_77ck1570 FIND v(dout0_77) AT=790.025n

.meas tran vdout0_78ck1570 FIND v(dout0_78) AT=790.025n

.meas tran vdout0_79ck1570 FIND v(dout0_79) AT=790.025n

.meas tran vdout0_80ck1570 FIND v(dout0_80) AT=790.025n

.meas tran vdout0_81ck1570 FIND v(dout0_81) AT=790.025n

.meas tran vdout0_82ck1570 FIND v(dout0_82) AT=790.025n

.meas tran vdout0_83ck1570 FIND v(dout0_83) AT=790.025n

.meas tran vdout0_84ck1570 FIND v(dout0_84) AT=790.025n

.meas tran vdout0_85ck1570 FIND v(dout0_85) AT=790.025n

.meas tran vdout0_86ck1570 FIND v(dout0_86) AT=790.025n

.meas tran vdout0_87ck1570 FIND v(dout0_87) AT=790.025n

.meas tran vdout0_88ck1570 FIND v(dout0_88) AT=790.025n

.meas tran vdout0_89ck1570 FIND v(dout0_89) AT=790.025n

.meas tran vdout0_90ck1570 FIND v(dout0_90) AT=790.025n

.meas tran vdout0_91ck1570 FIND v(dout0_91) AT=790.025n

.meas tran vdout0_92ck1570 FIND v(dout0_92) AT=790.025n

.meas tran vdout0_93ck1570 FIND v(dout0_93) AT=790.025n

.meas tran vdout0_94ck1570 FIND v(dout0_94) AT=790.025n

.meas tran vdout0_95ck1570 FIND v(dout0_95) AT=790.025n

.meas tran vdout0_96ck1570 FIND v(dout0_96) AT=790.025n

.meas tran vdout0_97ck1570 FIND v(dout0_97) AT=790.025n

.meas tran vdout0_98ck1570 FIND v(dout0_98) AT=790.025n

.meas tran vdout0_99ck1570 FIND v(dout0_99) AT=790.025n

.meas tran vdout0_100ck1570 FIND v(dout0_100) AT=790.025n

.meas tran vdout0_101ck1570 FIND v(dout0_101) AT=790.025n

.meas tran vdout0_102ck1570 FIND v(dout0_102) AT=790.025n

.meas tran vdout0_103ck1570 FIND v(dout0_103) AT=790.025n

.meas tran vdout0_104ck1570 FIND v(dout0_104) AT=790.025n

.meas tran vdout0_105ck1570 FIND v(dout0_105) AT=790.025n

.meas tran vdout0_106ck1570 FIND v(dout0_106) AT=790.025n

.meas tran vdout0_107ck1570 FIND v(dout0_107) AT=790.025n

.meas tran vdout0_108ck1570 FIND v(dout0_108) AT=790.025n

.meas tran vdout0_109ck1570 FIND v(dout0_109) AT=790.025n

.meas tran vdout0_110ck1570 FIND v(dout0_110) AT=790.025n

.meas tran vdout0_111ck1570 FIND v(dout0_111) AT=790.025n

.meas tran vdout0_112ck1570 FIND v(dout0_112) AT=790.025n

.meas tran vdout0_113ck1570 FIND v(dout0_113) AT=790.025n

.meas tran vdout0_114ck1570 FIND v(dout0_114) AT=790.025n

.meas tran vdout0_115ck1570 FIND v(dout0_115) AT=790.025n

.meas tran vdout0_116ck1570 FIND v(dout0_116) AT=790.025n

.meas tran vdout0_117ck1570 FIND v(dout0_117) AT=790.025n

.meas tran vdout0_118ck1570 FIND v(dout0_118) AT=790.025n

.meas tran vdout0_119ck1570 FIND v(dout0_119) AT=790.025n

.meas tran vdout0_120ck1570 FIND v(dout0_120) AT=790.025n

.meas tran vdout0_121ck1570 FIND v(dout0_121) AT=790.025n

.meas tran vdout0_122ck1570 FIND v(dout0_122) AT=790.025n

.meas tran vdout0_123ck1570 FIND v(dout0_123) AT=790.025n

.meas tran vdout0_124ck1570 FIND v(dout0_124) AT=790.025n

.meas tran vdout0_125ck1570 FIND v(dout0_125) AT=790.025n

.meas tran vdout0_126ck1570 FIND v(dout0_126) AT=790.025n

.meas tran vdout0_127ck1570 FIND v(dout0_127) AT=790.025n

.meas tran vdout0_0ck1580 FIND v(dout0_0) AT=795.025n

.meas tran vdout0_1ck1580 FIND v(dout0_1) AT=795.025n

.meas tran vdout0_2ck1580 FIND v(dout0_2) AT=795.025n

.meas tran vdout0_3ck1580 FIND v(dout0_3) AT=795.025n

.meas tran vdout0_4ck1580 FIND v(dout0_4) AT=795.025n

.meas tran vdout0_5ck1580 FIND v(dout0_5) AT=795.025n

.meas tran vdout0_6ck1580 FIND v(dout0_6) AT=795.025n

.meas tran vdout0_7ck1580 FIND v(dout0_7) AT=795.025n

.meas tran vdout0_8ck1580 FIND v(dout0_8) AT=795.025n

.meas tran vdout0_9ck1580 FIND v(dout0_9) AT=795.025n

.meas tran vdout0_10ck1580 FIND v(dout0_10) AT=795.025n

.meas tran vdout0_11ck1580 FIND v(dout0_11) AT=795.025n

.meas tran vdout0_12ck1580 FIND v(dout0_12) AT=795.025n

.meas tran vdout0_13ck1580 FIND v(dout0_13) AT=795.025n

.meas tran vdout0_14ck1580 FIND v(dout0_14) AT=795.025n

.meas tran vdout0_15ck1580 FIND v(dout0_15) AT=795.025n

.meas tran vdout0_16ck1580 FIND v(dout0_16) AT=795.025n

.meas tran vdout0_17ck1580 FIND v(dout0_17) AT=795.025n

.meas tran vdout0_18ck1580 FIND v(dout0_18) AT=795.025n

.meas tran vdout0_19ck1580 FIND v(dout0_19) AT=795.025n

.meas tran vdout0_20ck1580 FIND v(dout0_20) AT=795.025n

.meas tran vdout0_21ck1580 FIND v(dout0_21) AT=795.025n

.meas tran vdout0_22ck1580 FIND v(dout0_22) AT=795.025n

.meas tran vdout0_23ck1580 FIND v(dout0_23) AT=795.025n

.meas tran vdout0_24ck1580 FIND v(dout0_24) AT=795.025n

.meas tran vdout0_25ck1580 FIND v(dout0_25) AT=795.025n

.meas tran vdout0_26ck1580 FIND v(dout0_26) AT=795.025n

.meas tran vdout0_27ck1580 FIND v(dout0_27) AT=795.025n

.meas tran vdout0_28ck1580 FIND v(dout0_28) AT=795.025n

.meas tran vdout0_29ck1580 FIND v(dout0_29) AT=795.025n

.meas tran vdout0_30ck1580 FIND v(dout0_30) AT=795.025n

.meas tran vdout0_31ck1580 FIND v(dout0_31) AT=795.025n

.meas tran vdout0_32ck1580 FIND v(dout0_32) AT=795.025n

.meas tran vdout0_33ck1580 FIND v(dout0_33) AT=795.025n

.meas tran vdout0_34ck1580 FIND v(dout0_34) AT=795.025n

.meas tran vdout0_35ck1580 FIND v(dout0_35) AT=795.025n

.meas tran vdout0_36ck1580 FIND v(dout0_36) AT=795.025n

.meas tran vdout0_37ck1580 FIND v(dout0_37) AT=795.025n

.meas tran vdout0_38ck1580 FIND v(dout0_38) AT=795.025n

.meas tran vdout0_39ck1580 FIND v(dout0_39) AT=795.025n

.meas tran vdout0_40ck1580 FIND v(dout0_40) AT=795.025n

.meas tran vdout0_41ck1580 FIND v(dout0_41) AT=795.025n

.meas tran vdout0_42ck1580 FIND v(dout0_42) AT=795.025n

.meas tran vdout0_43ck1580 FIND v(dout0_43) AT=795.025n

.meas tran vdout0_44ck1580 FIND v(dout0_44) AT=795.025n

.meas tran vdout0_45ck1580 FIND v(dout0_45) AT=795.025n

.meas tran vdout0_46ck1580 FIND v(dout0_46) AT=795.025n

.meas tran vdout0_47ck1580 FIND v(dout0_47) AT=795.025n

.meas tran vdout0_48ck1580 FIND v(dout0_48) AT=795.025n

.meas tran vdout0_49ck1580 FIND v(dout0_49) AT=795.025n

.meas tran vdout0_50ck1580 FIND v(dout0_50) AT=795.025n

.meas tran vdout0_51ck1580 FIND v(dout0_51) AT=795.025n

.meas tran vdout0_52ck1580 FIND v(dout0_52) AT=795.025n

.meas tran vdout0_53ck1580 FIND v(dout0_53) AT=795.025n

.meas tran vdout0_54ck1580 FIND v(dout0_54) AT=795.025n

.meas tran vdout0_55ck1580 FIND v(dout0_55) AT=795.025n

.meas tran vdout0_56ck1580 FIND v(dout0_56) AT=795.025n

.meas tran vdout0_57ck1580 FIND v(dout0_57) AT=795.025n

.meas tran vdout0_58ck1580 FIND v(dout0_58) AT=795.025n

.meas tran vdout0_59ck1580 FIND v(dout0_59) AT=795.025n

.meas tran vdout0_60ck1580 FIND v(dout0_60) AT=795.025n

.meas tran vdout0_61ck1580 FIND v(dout0_61) AT=795.025n

.meas tran vdout0_62ck1580 FIND v(dout0_62) AT=795.025n

.meas tran vdout0_63ck1580 FIND v(dout0_63) AT=795.025n

.meas tran vdout0_64ck1580 FIND v(dout0_64) AT=795.025n

.meas tran vdout0_65ck1580 FIND v(dout0_65) AT=795.025n

.meas tran vdout0_66ck1580 FIND v(dout0_66) AT=795.025n

.meas tran vdout0_67ck1580 FIND v(dout0_67) AT=795.025n

.meas tran vdout0_68ck1580 FIND v(dout0_68) AT=795.025n

.meas tran vdout0_69ck1580 FIND v(dout0_69) AT=795.025n

.meas tran vdout0_70ck1580 FIND v(dout0_70) AT=795.025n

.meas tran vdout0_71ck1580 FIND v(dout0_71) AT=795.025n

.meas tran vdout0_72ck1580 FIND v(dout0_72) AT=795.025n

.meas tran vdout0_73ck1580 FIND v(dout0_73) AT=795.025n

.meas tran vdout0_74ck1580 FIND v(dout0_74) AT=795.025n

.meas tran vdout0_75ck1580 FIND v(dout0_75) AT=795.025n

.meas tran vdout0_76ck1580 FIND v(dout0_76) AT=795.025n

.meas tran vdout0_77ck1580 FIND v(dout0_77) AT=795.025n

.meas tran vdout0_78ck1580 FIND v(dout0_78) AT=795.025n

.meas tran vdout0_79ck1580 FIND v(dout0_79) AT=795.025n

.meas tran vdout0_80ck1580 FIND v(dout0_80) AT=795.025n

.meas tran vdout0_81ck1580 FIND v(dout0_81) AT=795.025n

.meas tran vdout0_82ck1580 FIND v(dout0_82) AT=795.025n

.meas tran vdout0_83ck1580 FIND v(dout0_83) AT=795.025n

.meas tran vdout0_84ck1580 FIND v(dout0_84) AT=795.025n

.meas tran vdout0_85ck1580 FIND v(dout0_85) AT=795.025n

.meas tran vdout0_86ck1580 FIND v(dout0_86) AT=795.025n

.meas tran vdout0_87ck1580 FIND v(dout0_87) AT=795.025n

.meas tran vdout0_88ck1580 FIND v(dout0_88) AT=795.025n

.meas tran vdout0_89ck1580 FIND v(dout0_89) AT=795.025n

.meas tran vdout0_90ck1580 FIND v(dout0_90) AT=795.025n

.meas tran vdout0_91ck1580 FIND v(dout0_91) AT=795.025n

.meas tran vdout0_92ck1580 FIND v(dout0_92) AT=795.025n

.meas tran vdout0_93ck1580 FIND v(dout0_93) AT=795.025n

.meas tran vdout0_94ck1580 FIND v(dout0_94) AT=795.025n

.meas tran vdout0_95ck1580 FIND v(dout0_95) AT=795.025n

.meas tran vdout0_96ck1580 FIND v(dout0_96) AT=795.025n

.meas tran vdout0_97ck1580 FIND v(dout0_97) AT=795.025n

.meas tran vdout0_98ck1580 FIND v(dout0_98) AT=795.025n

.meas tran vdout0_99ck1580 FIND v(dout0_99) AT=795.025n

.meas tran vdout0_100ck1580 FIND v(dout0_100) AT=795.025n

.meas tran vdout0_101ck1580 FIND v(dout0_101) AT=795.025n

.meas tran vdout0_102ck1580 FIND v(dout0_102) AT=795.025n

.meas tran vdout0_103ck1580 FIND v(dout0_103) AT=795.025n

.meas tran vdout0_104ck1580 FIND v(dout0_104) AT=795.025n

.meas tran vdout0_105ck1580 FIND v(dout0_105) AT=795.025n

.meas tran vdout0_106ck1580 FIND v(dout0_106) AT=795.025n

.meas tran vdout0_107ck1580 FIND v(dout0_107) AT=795.025n

.meas tran vdout0_108ck1580 FIND v(dout0_108) AT=795.025n

.meas tran vdout0_109ck1580 FIND v(dout0_109) AT=795.025n

.meas tran vdout0_110ck1580 FIND v(dout0_110) AT=795.025n

.meas tran vdout0_111ck1580 FIND v(dout0_111) AT=795.025n

.meas tran vdout0_112ck1580 FIND v(dout0_112) AT=795.025n

.meas tran vdout0_113ck1580 FIND v(dout0_113) AT=795.025n

.meas tran vdout0_114ck1580 FIND v(dout0_114) AT=795.025n

.meas tran vdout0_115ck1580 FIND v(dout0_115) AT=795.025n

.meas tran vdout0_116ck1580 FIND v(dout0_116) AT=795.025n

.meas tran vdout0_117ck1580 FIND v(dout0_117) AT=795.025n

.meas tran vdout0_118ck1580 FIND v(dout0_118) AT=795.025n

.meas tran vdout0_119ck1580 FIND v(dout0_119) AT=795.025n

.meas tran vdout0_120ck1580 FIND v(dout0_120) AT=795.025n

.meas tran vdout0_121ck1580 FIND v(dout0_121) AT=795.025n

.meas tran vdout0_122ck1580 FIND v(dout0_122) AT=795.025n

.meas tran vdout0_123ck1580 FIND v(dout0_123) AT=795.025n

.meas tran vdout0_124ck1580 FIND v(dout0_124) AT=795.025n

.meas tran vdout0_125ck1580 FIND v(dout0_125) AT=795.025n

.meas tran vdout0_126ck1580 FIND v(dout0_126) AT=795.025n

.meas tran vdout0_127ck1580 FIND v(dout0_127) AT=795.025n

.meas tran vdout0_0ck1590 FIND v(dout0_0) AT=800.025n

.meas tran vdout0_1ck1590 FIND v(dout0_1) AT=800.025n

.meas tran vdout0_2ck1590 FIND v(dout0_2) AT=800.025n

.meas tran vdout0_3ck1590 FIND v(dout0_3) AT=800.025n

.meas tran vdout0_4ck1590 FIND v(dout0_4) AT=800.025n

.meas tran vdout0_5ck1590 FIND v(dout0_5) AT=800.025n

.meas tran vdout0_6ck1590 FIND v(dout0_6) AT=800.025n

.meas tran vdout0_7ck1590 FIND v(dout0_7) AT=800.025n

.meas tran vdout0_8ck1590 FIND v(dout0_8) AT=800.025n

.meas tran vdout0_9ck1590 FIND v(dout0_9) AT=800.025n

.meas tran vdout0_10ck1590 FIND v(dout0_10) AT=800.025n

.meas tran vdout0_11ck1590 FIND v(dout0_11) AT=800.025n

.meas tran vdout0_12ck1590 FIND v(dout0_12) AT=800.025n

.meas tran vdout0_13ck1590 FIND v(dout0_13) AT=800.025n

.meas tran vdout0_14ck1590 FIND v(dout0_14) AT=800.025n

.meas tran vdout0_15ck1590 FIND v(dout0_15) AT=800.025n

.meas tran vdout0_16ck1590 FIND v(dout0_16) AT=800.025n

.meas tran vdout0_17ck1590 FIND v(dout0_17) AT=800.025n

.meas tran vdout0_18ck1590 FIND v(dout0_18) AT=800.025n

.meas tran vdout0_19ck1590 FIND v(dout0_19) AT=800.025n

.meas tran vdout0_20ck1590 FIND v(dout0_20) AT=800.025n

.meas tran vdout0_21ck1590 FIND v(dout0_21) AT=800.025n

.meas tran vdout0_22ck1590 FIND v(dout0_22) AT=800.025n

.meas tran vdout0_23ck1590 FIND v(dout0_23) AT=800.025n

.meas tran vdout0_24ck1590 FIND v(dout0_24) AT=800.025n

.meas tran vdout0_25ck1590 FIND v(dout0_25) AT=800.025n

.meas tran vdout0_26ck1590 FIND v(dout0_26) AT=800.025n

.meas tran vdout0_27ck1590 FIND v(dout0_27) AT=800.025n

.meas tran vdout0_28ck1590 FIND v(dout0_28) AT=800.025n

.meas tran vdout0_29ck1590 FIND v(dout0_29) AT=800.025n

.meas tran vdout0_30ck1590 FIND v(dout0_30) AT=800.025n

.meas tran vdout0_31ck1590 FIND v(dout0_31) AT=800.025n

.meas tran vdout0_32ck1590 FIND v(dout0_32) AT=800.025n

.meas tran vdout0_33ck1590 FIND v(dout0_33) AT=800.025n

.meas tran vdout0_34ck1590 FIND v(dout0_34) AT=800.025n

.meas tran vdout0_35ck1590 FIND v(dout0_35) AT=800.025n

.meas tran vdout0_36ck1590 FIND v(dout0_36) AT=800.025n

.meas tran vdout0_37ck1590 FIND v(dout0_37) AT=800.025n

.meas tran vdout0_38ck1590 FIND v(dout0_38) AT=800.025n

.meas tran vdout0_39ck1590 FIND v(dout0_39) AT=800.025n

.meas tran vdout0_40ck1590 FIND v(dout0_40) AT=800.025n

.meas tran vdout0_41ck1590 FIND v(dout0_41) AT=800.025n

.meas tran vdout0_42ck1590 FIND v(dout0_42) AT=800.025n

.meas tran vdout0_43ck1590 FIND v(dout0_43) AT=800.025n

.meas tran vdout0_44ck1590 FIND v(dout0_44) AT=800.025n

.meas tran vdout0_45ck1590 FIND v(dout0_45) AT=800.025n

.meas tran vdout0_46ck1590 FIND v(dout0_46) AT=800.025n

.meas tran vdout0_47ck1590 FIND v(dout0_47) AT=800.025n

.meas tran vdout0_48ck1590 FIND v(dout0_48) AT=800.025n

.meas tran vdout0_49ck1590 FIND v(dout0_49) AT=800.025n

.meas tran vdout0_50ck1590 FIND v(dout0_50) AT=800.025n

.meas tran vdout0_51ck1590 FIND v(dout0_51) AT=800.025n

.meas tran vdout0_52ck1590 FIND v(dout0_52) AT=800.025n

.meas tran vdout0_53ck1590 FIND v(dout0_53) AT=800.025n

.meas tran vdout0_54ck1590 FIND v(dout0_54) AT=800.025n

.meas tran vdout0_55ck1590 FIND v(dout0_55) AT=800.025n

.meas tran vdout0_56ck1590 FIND v(dout0_56) AT=800.025n

.meas tran vdout0_57ck1590 FIND v(dout0_57) AT=800.025n

.meas tran vdout0_58ck1590 FIND v(dout0_58) AT=800.025n

.meas tran vdout0_59ck1590 FIND v(dout0_59) AT=800.025n

.meas tran vdout0_60ck1590 FIND v(dout0_60) AT=800.025n

.meas tran vdout0_61ck1590 FIND v(dout0_61) AT=800.025n

.meas tran vdout0_62ck1590 FIND v(dout0_62) AT=800.025n

.meas tran vdout0_63ck1590 FIND v(dout0_63) AT=800.025n

.meas tran vdout0_64ck1590 FIND v(dout0_64) AT=800.025n

.meas tran vdout0_65ck1590 FIND v(dout0_65) AT=800.025n

.meas tran vdout0_66ck1590 FIND v(dout0_66) AT=800.025n

.meas tran vdout0_67ck1590 FIND v(dout0_67) AT=800.025n

.meas tran vdout0_68ck1590 FIND v(dout0_68) AT=800.025n

.meas tran vdout0_69ck1590 FIND v(dout0_69) AT=800.025n

.meas tran vdout0_70ck1590 FIND v(dout0_70) AT=800.025n

.meas tran vdout0_71ck1590 FIND v(dout0_71) AT=800.025n

.meas tran vdout0_72ck1590 FIND v(dout0_72) AT=800.025n

.meas tran vdout0_73ck1590 FIND v(dout0_73) AT=800.025n

.meas tran vdout0_74ck1590 FIND v(dout0_74) AT=800.025n

.meas tran vdout0_75ck1590 FIND v(dout0_75) AT=800.025n

.meas tran vdout0_76ck1590 FIND v(dout0_76) AT=800.025n

.meas tran vdout0_77ck1590 FIND v(dout0_77) AT=800.025n

.meas tran vdout0_78ck1590 FIND v(dout0_78) AT=800.025n

.meas tran vdout0_79ck1590 FIND v(dout0_79) AT=800.025n

.meas tran vdout0_80ck1590 FIND v(dout0_80) AT=800.025n

.meas tran vdout0_81ck1590 FIND v(dout0_81) AT=800.025n

.meas tran vdout0_82ck1590 FIND v(dout0_82) AT=800.025n

.meas tran vdout0_83ck1590 FIND v(dout0_83) AT=800.025n

.meas tran vdout0_84ck1590 FIND v(dout0_84) AT=800.025n

.meas tran vdout0_85ck1590 FIND v(dout0_85) AT=800.025n

.meas tran vdout0_86ck1590 FIND v(dout0_86) AT=800.025n

.meas tran vdout0_87ck1590 FIND v(dout0_87) AT=800.025n

.meas tran vdout0_88ck1590 FIND v(dout0_88) AT=800.025n

.meas tran vdout0_89ck1590 FIND v(dout0_89) AT=800.025n

.meas tran vdout0_90ck1590 FIND v(dout0_90) AT=800.025n

.meas tran vdout0_91ck1590 FIND v(dout0_91) AT=800.025n

.meas tran vdout0_92ck1590 FIND v(dout0_92) AT=800.025n

.meas tran vdout0_93ck1590 FIND v(dout0_93) AT=800.025n

.meas tran vdout0_94ck1590 FIND v(dout0_94) AT=800.025n

.meas tran vdout0_95ck1590 FIND v(dout0_95) AT=800.025n

.meas tran vdout0_96ck1590 FIND v(dout0_96) AT=800.025n

.meas tran vdout0_97ck1590 FIND v(dout0_97) AT=800.025n

.meas tran vdout0_98ck1590 FIND v(dout0_98) AT=800.025n

.meas tran vdout0_99ck1590 FIND v(dout0_99) AT=800.025n

.meas tran vdout0_100ck1590 FIND v(dout0_100) AT=800.025n

.meas tran vdout0_101ck1590 FIND v(dout0_101) AT=800.025n

.meas tran vdout0_102ck1590 FIND v(dout0_102) AT=800.025n

.meas tran vdout0_103ck1590 FIND v(dout0_103) AT=800.025n

.meas tran vdout0_104ck1590 FIND v(dout0_104) AT=800.025n

.meas tran vdout0_105ck1590 FIND v(dout0_105) AT=800.025n

.meas tran vdout0_106ck1590 FIND v(dout0_106) AT=800.025n

.meas tran vdout0_107ck1590 FIND v(dout0_107) AT=800.025n

.meas tran vdout0_108ck1590 FIND v(dout0_108) AT=800.025n

.meas tran vdout0_109ck1590 FIND v(dout0_109) AT=800.025n

.meas tran vdout0_110ck1590 FIND v(dout0_110) AT=800.025n

.meas tran vdout0_111ck1590 FIND v(dout0_111) AT=800.025n

.meas tran vdout0_112ck1590 FIND v(dout0_112) AT=800.025n

.meas tran vdout0_113ck1590 FIND v(dout0_113) AT=800.025n

.meas tran vdout0_114ck1590 FIND v(dout0_114) AT=800.025n

.meas tran vdout0_115ck1590 FIND v(dout0_115) AT=800.025n

.meas tran vdout0_116ck1590 FIND v(dout0_116) AT=800.025n

.meas tran vdout0_117ck1590 FIND v(dout0_117) AT=800.025n

.meas tran vdout0_118ck1590 FIND v(dout0_118) AT=800.025n

.meas tran vdout0_119ck1590 FIND v(dout0_119) AT=800.025n

.meas tran vdout0_120ck1590 FIND v(dout0_120) AT=800.025n

.meas tran vdout0_121ck1590 FIND v(dout0_121) AT=800.025n

.meas tran vdout0_122ck1590 FIND v(dout0_122) AT=800.025n

.meas tran vdout0_123ck1590 FIND v(dout0_123) AT=800.025n

.meas tran vdout0_124ck1590 FIND v(dout0_124) AT=800.025n

.meas tran vdout0_125ck1590 FIND v(dout0_125) AT=800.025n

.meas tran vdout0_126ck1590 FIND v(dout0_126) AT=800.025n

.meas tran vdout0_127ck1590 FIND v(dout0_127) AT=800.025n

.meas tran vdout0_0ck1600 FIND v(dout0_0) AT=805.025n

.meas tran vdout0_1ck1600 FIND v(dout0_1) AT=805.025n

.meas tran vdout0_2ck1600 FIND v(dout0_2) AT=805.025n

.meas tran vdout0_3ck1600 FIND v(dout0_3) AT=805.025n

.meas tran vdout0_4ck1600 FIND v(dout0_4) AT=805.025n

.meas tran vdout0_5ck1600 FIND v(dout0_5) AT=805.025n

.meas tran vdout0_6ck1600 FIND v(dout0_6) AT=805.025n

.meas tran vdout0_7ck1600 FIND v(dout0_7) AT=805.025n

.meas tran vdout0_8ck1600 FIND v(dout0_8) AT=805.025n

.meas tran vdout0_9ck1600 FIND v(dout0_9) AT=805.025n

.meas tran vdout0_10ck1600 FIND v(dout0_10) AT=805.025n

.meas tran vdout0_11ck1600 FIND v(dout0_11) AT=805.025n

.meas tran vdout0_12ck1600 FIND v(dout0_12) AT=805.025n

.meas tran vdout0_13ck1600 FIND v(dout0_13) AT=805.025n

.meas tran vdout0_14ck1600 FIND v(dout0_14) AT=805.025n

.meas tran vdout0_15ck1600 FIND v(dout0_15) AT=805.025n

.meas tran vdout0_16ck1600 FIND v(dout0_16) AT=805.025n

.meas tran vdout0_17ck1600 FIND v(dout0_17) AT=805.025n

.meas tran vdout0_18ck1600 FIND v(dout0_18) AT=805.025n

.meas tran vdout0_19ck1600 FIND v(dout0_19) AT=805.025n

.meas tran vdout0_20ck1600 FIND v(dout0_20) AT=805.025n

.meas tran vdout0_21ck1600 FIND v(dout0_21) AT=805.025n

.meas tran vdout0_22ck1600 FIND v(dout0_22) AT=805.025n

.meas tran vdout0_23ck1600 FIND v(dout0_23) AT=805.025n

.meas tran vdout0_24ck1600 FIND v(dout0_24) AT=805.025n

.meas tran vdout0_25ck1600 FIND v(dout0_25) AT=805.025n

.meas tran vdout0_26ck1600 FIND v(dout0_26) AT=805.025n

.meas tran vdout0_27ck1600 FIND v(dout0_27) AT=805.025n

.meas tran vdout0_28ck1600 FIND v(dout0_28) AT=805.025n

.meas tran vdout0_29ck1600 FIND v(dout0_29) AT=805.025n

.meas tran vdout0_30ck1600 FIND v(dout0_30) AT=805.025n

.meas tran vdout0_31ck1600 FIND v(dout0_31) AT=805.025n

.meas tran vdout0_32ck1600 FIND v(dout0_32) AT=805.025n

.meas tran vdout0_33ck1600 FIND v(dout0_33) AT=805.025n

.meas tran vdout0_34ck1600 FIND v(dout0_34) AT=805.025n

.meas tran vdout0_35ck1600 FIND v(dout0_35) AT=805.025n

.meas tran vdout0_36ck1600 FIND v(dout0_36) AT=805.025n

.meas tran vdout0_37ck1600 FIND v(dout0_37) AT=805.025n

.meas tran vdout0_38ck1600 FIND v(dout0_38) AT=805.025n

.meas tran vdout0_39ck1600 FIND v(dout0_39) AT=805.025n

.meas tran vdout0_40ck1600 FIND v(dout0_40) AT=805.025n

.meas tran vdout0_41ck1600 FIND v(dout0_41) AT=805.025n

.meas tran vdout0_42ck1600 FIND v(dout0_42) AT=805.025n

.meas tran vdout0_43ck1600 FIND v(dout0_43) AT=805.025n

.meas tran vdout0_44ck1600 FIND v(dout0_44) AT=805.025n

.meas tran vdout0_45ck1600 FIND v(dout0_45) AT=805.025n

.meas tran vdout0_46ck1600 FIND v(dout0_46) AT=805.025n

.meas tran vdout0_47ck1600 FIND v(dout0_47) AT=805.025n

.meas tran vdout0_48ck1600 FIND v(dout0_48) AT=805.025n

.meas tran vdout0_49ck1600 FIND v(dout0_49) AT=805.025n

.meas tran vdout0_50ck1600 FIND v(dout0_50) AT=805.025n

.meas tran vdout0_51ck1600 FIND v(dout0_51) AT=805.025n

.meas tran vdout0_52ck1600 FIND v(dout0_52) AT=805.025n

.meas tran vdout0_53ck1600 FIND v(dout0_53) AT=805.025n

.meas tran vdout0_54ck1600 FIND v(dout0_54) AT=805.025n

.meas tran vdout0_55ck1600 FIND v(dout0_55) AT=805.025n

.meas tran vdout0_56ck1600 FIND v(dout0_56) AT=805.025n

.meas tran vdout0_57ck1600 FIND v(dout0_57) AT=805.025n

.meas tran vdout0_58ck1600 FIND v(dout0_58) AT=805.025n

.meas tran vdout0_59ck1600 FIND v(dout0_59) AT=805.025n

.meas tran vdout0_60ck1600 FIND v(dout0_60) AT=805.025n

.meas tran vdout0_61ck1600 FIND v(dout0_61) AT=805.025n

.meas tran vdout0_62ck1600 FIND v(dout0_62) AT=805.025n

.meas tran vdout0_63ck1600 FIND v(dout0_63) AT=805.025n

.meas tran vdout0_64ck1600 FIND v(dout0_64) AT=805.025n

.meas tran vdout0_65ck1600 FIND v(dout0_65) AT=805.025n

.meas tran vdout0_66ck1600 FIND v(dout0_66) AT=805.025n

.meas tran vdout0_67ck1600 FIND v(dout0_67) AT=805.025n

.meas tran vdout0_68ck1600 FIND v(dout0_68) AT=805.025n

.meas tran vdout0_69ck1600 FIND v(dout0_69) AT=805.025n

.meas tran vdout0_70ck1600 FIND v(dout0_70) AT=805.025n

.meas tran vdout0_71ck1600 FIND v(dout0_71) AT=805.025n

.meas tran vdout0_72ck1600 FIND v(dout0_72) AT=805.025n

.meas tran vdout0_73ck1600 FIND v(dout0_73) AT=805.025n

.meas tran vdout0_74ck1600 FIND v(dout0_74) AT=805.025n

.meas tran vdout0_75ck1600 FIND v(dout0_75) AT=805.025n

.meas tran vdout0_76ck1600 FIND v(dout0_76) AT=805.025n

.meas tran vdout0_77ck1600 FIND v(dout0_77) AT=805.025n

.meas tran vdout0_78ck1600 FIND v(dout0_78) AT=805.025n

.meas tran vdout0_79ck1600 FIND v(dout0_79) AT=805.025n

.meas tran vdout0_80ck1600 FIND v(dout0_80) AT=805.025n

.meas tran vdout0_81ck1600 FIND v(dout0_81) AT=805.025n

.meas tran vdout0_82ck1600 FIND v(dout0_82) AT=805.025n

.meas tran vdout0_83ck1600 FIND v(dout0_83) AT=805.025n

.meas tran vdout0_84ck1600 FIND v(dout0_84) AT=805.025n

.meas tran vdout0_85ck1600 FIND v(dout0_85) AT=805.025n

.meas tran vdout0_86ck1600 FIND v(dout0_86) AT=805.025n

.meas tran vdout0_87ck1600 FIND v(dout0_87) AT=805.025n

.meas tran vdout0_88ck1600 FIND v(dout0_88) AT=805.025n

.meas tran vdout0_89ck1600 FIND v(dout0_89) AT=805.025n

.meas tran vdout0_90ck1600 FIND v(dout0_90) AT=805.025n

.meas tran vdout0_91ck1600 FIND v(dout0_91) AT=805.025n

.meas tran vdout0_92ck1600 FIND v(dout0_92) AT=805.025n

.meas tran vdout0_93ck1600 FIND v(dout0_93) AT=805.025n

.meas tran vdout0_94ck1600 FIND v(dout0_94) AT=805.025n

.meas tran vdout0_95ck1600 FIND v(dout0_95) AT=805.025n

.meas tran vdout0_96ck1600 FIND v(dout0_96) AT=805.025n

.meas tran vdout0_97ck1600 FIND v(dout0_97) AT=805.025n

.meas tran vdout0_98ck1600 FIND v(dout0_98) AT=805.025n

.meas tran vdout0_99ck1600 FIND v(dout0_99) AT=805.025n

.meas tran vdout0_100ck1600 FIND v(dout0_100) AT=805.025n

.meas tran vdout0_101ck1600 FIND v(dout0_101) AT=805.025n

.meas tran vdout0_102ck1600 FIND v(dout0_102) AT=805.025n

.meas tran vdout0_103ck1600 FIND v(dout0_103) AT=805.025n

.meas tran vdout0_104ck1600 FIND v(dout0_104) AT=805.025n

.meas tran vdout0_105ck1600 FIND v(dout0_105) AT=805.025n

.meas tran vdout0_106ck1600 FIND v(dout0_106) AT=805.025n

.meas tran vdout0_107ck1600 FIND v(dout0_107) AT=805.025n

.meas tran vdout0_108ck1600 FIND v(dout0_108) AT=805.025n

.meas tran vdout0_109ck1600 FIND v(dout0_109) AT=805.025n

.meas tran vdout0_110ck1600 FIND v(dout0_110) AT=805.025n

.meas tran vdout0_111ck1600 FIND v(dout0_111) AT=805.025n

.meas tran vdout0_112ck1600 FIND v(dout0_112) AT=805.025n

.meas tran vdout0_113ck1600 FIND v(dout0_113) AT=805.025n

.meas tran vdout0_114ck1600 FIND v(dout0_114) AT=805.025n

.meas tran vdout0_115ck1600 FIND v(dout0_115) AT=805.025n

.meas tran vdout0_116ck1600 FIND v(dout0_116) AT=805.025n

.meas tran vdout0_117ck1600 FIND v(dout0_117) AT=805.025n

.meas tran vdout0_118ck1600 FIND v(dout0_118) AT=805.025n

.meas tran vdout0_119ck1600 FIND v(dout0_119) AT=805.025n

.meas tran vdout0_120ck1600 FIND v(dout0_120) AT=805.025n

.meas tran vdout0_121ck1600 FIND v(dout0_121) AT=805.025n

.meas tran vdout0_122ck1600 FIND v(dout0_122) AT=805.025n

.meas tran vdout0_123ck1600 FIND v(dout0_123) AT=805.025n

.meas tran vdout0_124ck1600 FIND v(dout0_124) AT=805.025n

.meas tran vdout0_125ck1600 FIND v(dout0_125) AT=805.025n

.meas tran vdout0_126ck1600 FIND v(dout0_126) AT=805.025n

.meas tran vdout0_127ck1600 FIND v(dout0_127) AT=805.025n

.meas tran vdout0_0ck1630 FIND v(dout0_0) AT=820.025n

.meas tran vdout0_1ck1630 FIND v(dout0_1) AT=820.025n

.meas tran vdout0_2ck1630 FIND v(dout0_2) AT=820.025n

.meas tran vdout0_3ck1630 FIND v(dout0_3) AT=820.025n

.meas tran vdout0_4ck1630 FIND v(dout0_4) AT=820.025n

.meas tran vdout0_5ck1630 FIND v(dout0_5) AT=820.025n

.meas tran vdout0_6ck1630 FIND v(dout0_6) AT=820.025n

.meas tran vdout0_7ck1630 FIND v(dout0_7) AT=820.025n

.meas tran vdout0_8ck1630 FIND v(dout0_8) AT=820.025n

.meas tran vdout0_9ck1630 FIND v(dout0_9) AT=820.025n

.meas tran vdout0_10ck1630 FIND v(dout0_10) AT=820.025n

.meas tran vdout0_11ck1630 FIND v(dout0_11) AT=820.025n

.meas tran vdout0_12ck1630 FIND v(dout0_12) AT=820.025n

.meas tran vdout0_13ck1630 FIND v(dout0_13) AT=820.025n

.meas tran vdout0_14ck1630 FIND v(dout0_14) AT=820.025n

.meas tran vdout0_15ck1630 FIND v(dout0_15) AT=820.025n

.meas tran vdout0_16ck1630 FIND v(dout0_16) AT=820.025n

.meas tran vdout0_17ck1630 FIND v(dout0_17) AT=820.025n

.meas tran vdout0_18ck1630 FIND v(dout0_18) AT=820.025n

.meas tran vdout0_19ck1630 FIND v(dout0_19) AT=820.025n

.meas tran vdout0_20ck1630 FIND v(dout0_20) AT=820.025n

.meas tran vdout0_21ck1630 FIND v(dout0_21) AT=820.025n

.meas tran vdout0_22ck1630 FIND v(dout0_22) AT=820.025n

.meas tran vdout0_23ck1630 FIND v(dout0_23) AT=820.025n

.meas tran vdout0_24ck1630 FIND v(dout0_24) AT=820.025n

.meas tran vdout0_25ck1630 FIND v(dout0_25) AT=820.025n

.meas tran vdout0_26ck1630 FIND v(dout0_26) AT=820.025n

.meas tran vdout0_27ck1630 FIND v(dout0_27) AT=820.025n

.meas tran vdout0_28ck1630 FIND v(dout0_28) AT=820.025n

.meas tran vdout0_29ck1630 FIND v(dout0_29) AT=820.025n

.meas tran vdout0_30ck1630 FIND v(dout0_30) AT=820.025n

.meas tran vdout0_31ck1630 FIND v(dout0_31) AT=820.025n

.meas tran vdout0_32ck1630 FIND v(dout0_32) AT=820.025n

.meas tran vdout0_33ck1630 FIND v(dout0_33) AT=820.025n

.meas tran vdout0_34ck1630 FIND v(dout0_34) AT=820.025n

.meas tran vdout0_35ck1630 FIND v(dout0_35) AT=820.025n

.meas tran vdout0_36ck1630 FIND v(dout0_36) AT=820.025n

.meas tran vdout0_37ck1630 FIND v(dout0_37) AT=820.025n

.meas tran vdout0_38ck1630 FIND v(dout0_38) AT=820.025n

.meas tran vdout0_39ck1630 FIND v(dout0_39) AT=820.025n

.meas tran vdout0_40ck1630 FIND v(dout0_40) AT=820.025n

.meas tran vdout0_41ck1630 FIND v(dout0_41) AT=820.025n

.meas tran vdout0_42ck1630 FIND v(dout0_42) AT=820.025n

.meas tran vdout0_43ck1630 FIND v(dout0_43) AT=820.025n

.meas tran vdout0_44ck1630 FIND v(dout0_44) AT=820.025n

.meas tran vdout0_45ck1630 FIND v(dout0_45) AT=820.025n

.meas tran vdout0_46ck1630 FIND v(dout0_46) AT=820.025n

.meas tran vdout0_47ck1630 FIND v(dout0_47) AT=820.025n

.meas tran vdout0_48ck1630 FIND v(dout0_48) AT=820.025n

.meas tran vdout0_49ck1630 FIND v(dout0_49) AT=820.025n

.meas tran vdout0_50ck1630 FIND v(dout0_50) AT=820.025n

.meas tran vdout0_51ck1630 FIND v(dout0_51) AT=820.025n

.meas tran vdout0_52ck1630 FIND v(dout0_52) AT=820.025n

.meas tran vdout0_53ck1630 FIND v(dout0_53) AT=820.025n

.meas tran vdout0_54ck1630 FIND v(dout0_54) AT=820.025n

.meas tran vdout0_55ck1630 FIND v(dout0_55) AT=820.025n

.meas tran vdout0_56ck1630 FIND v(dout0_56) AT=820.025n

.meas tran vdout0_57ck1630 FIND v(dout0_57) AT=820.025n

.meas tran vdout0_58ck1630 FIND v(dout0_58) AT=820.025n

.meas tran vdout0_59ck1630 FIND v(dout0_59) AT=820.025n

.meas tran vdout0_60ck1630 FIND v(dout0_60) AT=820.025n

.meas tran vdout0_61ck1630 FIND v(dout0_61) AT=820.025n

.meas tran vdout0_62ck1630 FIND v(dout0_62) AT=820.025n

.meas tran vdout0_63ck1630 FIND v(dout0_63) AT=820.025n

.meas tran vdout0_64ck1630 FIND v(dout0_64) AT=820.025n

.meas tran vdout0_65ck1630 FIND v(dout0_65) AT=820.025n

.meas tran vdout0_66ck1630 FIND v(dout0_66) AT=820.025n

.meas tran vdout0_67ck1630 FIND v(dout0_67) AT=820.025n

.meas tran vdout0_68ck1630 FIND v(dout0_68) AT=820.025n

.meas tran vdout0_69ck1630 FIND v(dout0_69) AT=820.025n

.meas tran vdout0_70ck1630 FIND v(dout0_70) AT=820.025n

.meas tran vdout0_71ck1630 FIND v(dout0_71) AT=820.025n

.meas tran vdout0_72ck1630 FIND v(dout0_72) AT=820.025n

.meas tran vdout0_73ck1630 FIND v(dout0_73) AT=820.025n

.meas tran vdout0_74ck1630 FIND v(dout0_74) AT=820.025n

.meas tran vdout0_75ck1630 FIND v(dout0_75) AT=820.025n

.meas tran vdout0_76ck1630 FIND v(dout0_76) AT=820.025n

.meas tran vdout0_77ck1630 FIND v(dout0_77) AT=820.025n

.meas tran vdout0_78ck1630 FIND v(dout0_78) AT=820.025n

.meas tran vdout0_79ck1630 FIND v(dout0_79) AT=820.025n

.meas tran vdout0_80ck1630 FIND v(dout0_80) AT=820.025n

.meas tran vdout0_81ck1630 FIND v(dout0_81) AT=820.025n

.meas tran vdout0_82ck1630 FIND v(dout0_82) AT=820.025n

.meas tran vdout0_83ck1630 FIND v(dout0_83) AT=820.025n

.meas tran vdout0_84ck1630 FIND v(dout0_84) AT=820.025n

.meas tran vdout0_85ck1630 FIND v(dout0_85) AT=820.025n

.meas tran vdout0_86ck1630 FIND v(dout0_86) AT=820.025n

.meas tran vdout0_87ck1630 FIND v(dout0_87) AT=820.025n

.meas tran vdout0_88ck1630 FIND v(dout0_88) AT=820.025n

.meas tran vdout0_89ck1630 FIND v(dout0_89) AT=820.025n

.meas tran vdout0_90ck1630 FIND v(dout0_90) AT=820.025n

.meas tran vdout0_91ck1630 FIND v(dout0_91) AT=820.025n

.meas tran vdout0_92ck1630 FIND v(dout0_92) AT=820.025n

.meas tran vdout0_93ck1630 FIND v(dout0_93) AT=820.025n

.meas tran vdout0_94ck1630 FIND v(dout0_94) AT=820.025n

.meas tran vdout0_95ck1630 FIND v(dout0_95) AT=820.025n

.meas tran vdout0_96ck1630 FIND v(dout0_96) AT=820.025n

.meas tran vdout0_97ck1630 FIND v(dout0_97) AT=820.025n

.meas tran vdout0_98ck1630 FIND v(dout0_98) AT=820.025n

.meas tran vdout0_99ck1630 FIND v(dout0_99) AT=820.025n

.meas tran vdout0_100ck1630 FIND v(dout0_100) AT=820.025n

.meas tran vdout0_101ck1630 FIND v(dout0_101) AT=820.025n

.meas tran vdout0_102ck1630 FIND v(dout0_102) AT=820.025n

.meas tran vdout0_103ck1630 FIND v(dout0_103) AT=820.025n

.meas tran vdout0_104ck1630 FIND v(dout0_104) AT=820.025n

.meas tran vdout0_105ck1630 FIND v(dout0_105) AT=820.025n

.meas tran vdout0_106ck1630 FIND v(dout0_106) AT=820.025n

.meas tran vdout0_107ck1630 FIND v(dout0_107) AT=820.025n

.meas tran vdout0_108ck1630 FIND v(dout0_108) AT=820.025n

.meas tran vdout0_109ck1630 FIND v(dout0_109) AT=820.025n

.meas tran vdout0_110ck1630 FIND v(dout0_110) AT=820.025n

.meas tran vdout0_111ck1630 FIND v(dout0_111) AT=820.025n

.meas tran vdout0_112ck1630 FIND v(dout0_112) AT=820.025n

.meas tran vdout0_113ck1630 FIND v(dout0_113) AT=820.025n

.meas tran vdout0_114ck1630 FIND v(dout0_114) AT=820.025n

.meas tran vdout0_115ck1630 FIND v(dout0_115) AT=820.025n

.meas tran vdout0_116ck1630 FIND v(dout0_116) AT=820.025n

.meas tran vdout0_117ck1630 FIND v(dout0_117) AT=820.025n

.meas tran vdout0_118ck1630 FIND v(dout0_118) AT=820.025n

.meas tran vdout0_119ck1630 FIND v(dout0_119) AT=820.025n

.meas tran vdout0_120ck1630 FIND v(dout0_120) AT=820.025n

.meas tran vdout0_121ck1630 FIND v(dout0_121) AT=820.025n

.meas tran vdout0_122ck1630 FIND v(dout0_122) AT=820.025n

.meas tran vdout0_123ck1630 FIND v(dout0_123) AT=820.025n

.meas tran vdout0_124ck1630 FIND v(dout0_124) AT=820.025n

.meas tran vdout0_125ck1630 FIND v(dout0_125) AT=820.025n

.meas tran vdout0_126ck1630 FIND v(dout0_126) AT=820.025n

.meas tran vdout0_127ck1630 FIND v(dout0_127) AT=820.025n

.meas tran vdout0_0ck1680 FIND v(dout0_0) AT=845.025n

.meas tran vdout0_1ck1680 FIND v(dout0_1) AT=845.025n

.meas tran vdout0_2ck1680 FIND v(dout0_2) AT=845.025n

.meas tran vdout0_3ck1680 FIND v(dout0_3) AT=845.025n

.meas tran vdout0_4ck1680 FIND v(dout0_4) AT=845.025n

.meas tran vdout0_5ck1680 FIND v(dout0_5) AT=845.025n

.meas tran vdout0_6ck1680 FIND v(dout0_6) AT=845.025n

.meas tran vdout0_7ck1680 FIND v(dout0_7) AT=845.025n

.meas tran vdout0_8ck1680 FIND v(dout0_8) AT=845.025n

.meas tran vdout0_9ck1680 FIND v(dout0_9) AT=845.025n

.meas tran vdout0_10ck1680 FIND v(dout0_10) AT=845.025n

.meas tran vdout0_11ck1680 FIND v(dout0_11) AT=845.025n

.meas tran vdout0_12ck1680 FIND v(dout0_12) AT=845.025n

.meas tran vdout0_13ck1680 FIND v(dout0_13) AT=845.025n

.meas tran vdout0_14ck1680 FIND v(dout0_14) AT=845.025n

.meas tran vdout0_15ck1680 FIND v(dout0_15) AT=845.025n

.meas tran vdout0_16ck1680 FIND v(dout0_16) AT=845.025n

.meas tran vdout0_17ck1680 FIND v(dout0_17) AT=845.025n

.meas tran vdout0_18ck1680 FIND v(dout0_18) AT=845.025n

.meas tran vdout0_19ck1680 FIND v(dout0_19) AT=845.025n

.meas tran vdout0_20ck1680 FIND v(dout0_20) AT=845.025n

.meas tran vdout0_21ck1680 FIND v(dout0_21) AT=845.025n

.meas tran vdout0_22ck1680 FIND v(dout0_22) AT=845.025n

.meas tran vdout0_23ck1680 FIND v(dout0_23) AT=845.025n

.meas tran vdout0_24ck1680 FIND v(dout0_24) AT=845.025n

.meas tran vdout0_25ck1680 FIND v(dout0_25) AT=845.025n

.meas tran vdout0_26ck1680 FIND v(dout0_26) AT=845.025n

.meas tran vdout0_27ck1680 FIND v(dout0_27) AT=845.025n

.meas tran vdout0_28ck1680 FIND v(dout0_28) AT=845.025n

.meas tran vdout0_29ck1680 FIND v(dout0_29) AT=845.025n

.meas tran vdout0_30ck1680 FIND v(dout0_30) AT=845.025n

.meas tran vdout0_31ck1680 FIND v(dout0_31) AT=845.025n

.meas tran vdout0_32ck1680 FIND v(dout0_32) AT=845.025n

.meas tran vdout0_33ck1680 FIND v(dout0_33) AT=845.025n

.meas tran vdout0_34ck1680 FIND v(dout0_34) AT=845.025n

.meas tran vdout0_35ck1680 FIND v(dout0_35) AT=845.025n

.meas tran vdout0_36ck1680 FIND v(dout0_36) AT=845.025n

.meas tran vdout0_37ck1680 FIND v(dout0_37) AT=845.025n

.meas tran vdout0_38ck1680 FIND v(dout0_38) AT=845.025n

.meas tran vdout0_39ck1680 FIND v(dout0_39) AT=845.025n

.meas tran vdout0_40ck1680 FIND v(dout0_40) AT=845.025n

.meas tran vdout0_41ck1680 FIND v(dout0_41) AT=845.025n

.meas tran vdout0_42ck1680 FIND v(dout0_42) AT=845.025n

.meas tran vdout0_43ck1680 FIND v(dout0_43) AT=845.025n

.meas tran vdout0_44ck1680 FIND v(dout0_44) AT=845.025n

.meas tran vdout0_45ck1680 FIND v(dout0_45) AT=845.025n

.meas tran vdout0_46ck1680 FIND v(dout0_46) AT=845.025n

.meas tran vdout0_47ck1680 FIND v(dout0_47) AT=845.025n

.meas tran vdout0_48ck1680 FIND v(dout0_48) AT=845.025n

.meas tran vdout0_49ck1680 FIND v(dout0_49) AT=845.025n

.meas tran vdout0_50ck1680 FIND v(dout0_50) AT=845.025n

.meas tran vdout0_51ck1680 FIND v(dout0_51) AT=845.025n

.meas tran vdout0_52ck1680 FIND v(dout0_52) AT=845.025n

.meas tran vdout0_53ck1680 FIND v(dout0_53) AT=845.025n

.meas tran vdout0_54ck1680 FIND v(dout0_54) AT=845.025n

.meas tran vdout0_55ck1680 FIND v(dout0_55) AT=845.025n

.meas tran vdout0_56ck1680 FIND v(dout0_56) AT=845.025n

.meas tran vdout0_57ck1680 FIND v(dout0_57) AT=845.025n

.meas tran vdout0_58ck1680 FIND v(dout0_58) AT=845.025n

.meas tran vdout0_59ck1680 FIND v(dout0_59) AT=845.025n

.meas tran vdout0_60ck1680 FIND v(dout0_60) AT=845.025n

.meas tran vdout0_61ck1680 FIND v(dout0_61) AT=845.025n

.meas tran vdout0_62ck1680 FIND v(dout0_62) AT=845.025n

.meas tran vdout0_63ck1680 FIND v(dout0_63) AT=845.025n

.meas tran vdout0_64ck1680 FIND v(dout0_64) AT=845.025n

.meas tran vdout0_65ck1680 FIND v(dout0_65) AT=845.025n

.meas tran vdout0_66ck1680 FIND v(dout0_66) AT=845.025n

.meas tran vdout0_67ck1680 FIND v(dout0_67) AT=845.025n

.meas tran vdout0_68ck1680 FIND v(dout0_68) AT=845.025n

.meas tran vdout0_69ck1680 FIND v(dout0_69) AT=845.025n

.meas tran vdout0_70ck1680 FIND v(dout0_70) AT=845.025n

.meas tran vdout0_71ck1680 FIND v(dout0_71) AT=845.025n

.meas tran vdout0_72ck1680 FIND v(dout0_72) AT=845.025n

.meas tran vdout0_73ck1680 FIND v(dout0_73) AT=845.025n

.meas tran vdout0_74ck1680 FIND v(dout0_74) AT=845.025n

.meas tran vdout0_75ck1680 FIND v(dout0_75) AT=845.025n

.meas tran vdout0_76ck1680 FIND v(dout0_76) AT=845.025n

.meas tran vdout0_77ck1680 FIND v(dout0_77) AT=845.025n

.meas tran vdout0_78ck1680 FIND v(dout0_78) AT=845.025n

.meas tran vdout0_79ck1680 FIND v(dout0_79) AT=845.025n

.meas tran vdout0_80ck1680 FIND v(dout0_80) AT=845.025n

.meas tran vdout0_81ck1680 FIND v(dout0_81) AT=845.025n

.meas tran vdout0_82ck1680 FIND v(dout0_82) AT=845.025n

.meas tran vdout0_83ck1680 FIND v(dout0_83) AT=845.025n

.meas tran vdout0_84ck1680 FIND v(dout0_84) AT=845.025n

.meas tran vdout0_85ck1680 FIND v(dout0_85) AT=845.025n

.meas tran vdout0_86ck1680 FIND v(dout0_86) AT=845.025n

.meas tran vdout0_87ck1680 FIND v(dout0_87) AT=845.025n

.meas tran vdout0_88ck1680 FIND v(dout0_88) AT=845.025n

.meas tran vdout0_89ck1680 FIND v(dout0_89) AT=845.025n

.meas tran vdout0_90ck1680 FIND v(dout0_90) AT=845.025n

.meas tran vdout0_91ck1680 FIND v(dout0_91) AT=845.025n

.meas tran vdout0_92ck1680 FIND v(dout0_92) AT=845.025n

.meas tran vdout0_93ck1680 FIND v(dout0_93) AT=845.025n

.meas tran vdout0_94ck1680 FIND v(dout0_94) AT=845.025n

.meas tran vdout0_95ck1680 FIND v(dout0_95) AT=845.025n

.meas tran vdout0_96ck1680 FIND v(dout0_96) AT=845.025n

.meas tran vdout0_97ck1680 FIND v(dout0_97) AT=845.025n

.meas tran vdout0_98ck1680 FIND v(dout0_98) AT=845.025n

.meas tran vdout0_99ck1680 FIND v(dout0_99) AT=845.025n

.meas tran vdout0_100ck1680 FIND v(dout0_100) AT=845.025n

.meas tran vdout0_101ck1680 FIND v(dout0_101) AT=845.025n

.meas tran vdout0_102ck1680 FIND v(dout0_102) AT=845.025n

.meas tran vdout0_103ck1680 FIND v(dout0_103) AT=845.025n

.meas tran vdout0_104ck1680 FIND v(dout0_104) AT=845.025n

.meas tran vdout0_105ck1680 FIND v(dout0_105) AT=845.025n

.meas tran vdout0_106ck1680 FIND v(dout0_106) AT=845.025n

.meas tran vdout0_107ck1680 FIND v(dout0_107) AT=845.025n

.meas tran vdout0_108ck1680 FIND v(dout0_108) AT=845.025n

.meas tran vdout0_109ck1680 FIND v(dout0_109) AT=845.025n

.meas tran vdout0_110ck1680 FIND v(dout0_110) AT=845.025n

.meas tran vdout0_111ck1680 FIND v(dout0_111) AT=845.025n

.meas tran vdout0_112ck1680 FIND v(dout0_112) AT=845.025n

.meas tran vdout0_113ck1680 FIND v(dout0_113) AT=845.025n

.meas tran vdout0_114ck1680 FIND v(dout0_114) AT=845.025n

.meas tran vdout0_115ck1680 FIND v(dout0_115) AT=845.025n

.meas tran vdout0_116ck1680 FIND v(dout0_116) AT=845.025n

.meas tran vdout0_117ck1680 FIND v(dout0_117) AT=845.025n

.meas tran vdout0_118ck1680 FIND v(dout0_118) AT=845.025n

.meas tran vdout0_119ck1680 FIND v(dout0_119) AT=845.025n

.meas tran vdout0_120ck1680 FIND v(dout0_120) AT=845.025n

.meas tran vdout0_121ck1680 FIND v(dout0_121) AT=845.025n

.meas tran vdout0_122ck1680 FIND v(dout0_122) AT=845.025n

.meas tran vdout0_123ck1680 FIND v(dout0_123) AT=845.025n

.meas tran vdout0_124ck1680 FIND v(dout0_124) AT=845.025n

.meas tran vdout0_125ck1680 FIND v(dout0_125) AT=845.025n

.meas tran vdout0_126ck1680 FIND v(dout0_126) AT=845.025n

.meas tran vdout0_127ck1680 FIND v(dout0_127) AT=845.025n

.meas tran vdout0_0ck1690 FIND v(dout0_0) AT=850.025n

.meas tran vdout0_1ck1690 FIND v(dout0_1) AT=850.025n

.meas tran vdout0_2ck1690 FIND v(dout0_2) AT=850.025n

.meas tran vdout0_3ck1690 FIND v(dout0_3) AT=850.025n

.meas tran vdout0_4ck1690 FIND v(dout0_4) AT=850.025n

.meas tran vdout0_5ck1690 FIND v(dout0_5) AT=850.025n

.meas tran vdout0_6ck1690 FIND v(dout0_6) AT=850.025n

.meas tran vdout0_7ck1690 FIND v(dout0_7) AT=850.025n

.meas tran vdout0_8ck1690 FIND v(dout0_8) AT=850.025n

.meas tran vdout0_9ck1690 FIND v(dout0_9) AT=850.025n

.meas tran vdout0_10ck1690 FIND v(dout0_10) AT=850.025n

.meas tran vdout0_11ck1690 FIND v(dout0_11) AT=850.025n

.meas tran vdout0_12ck1690 FIND v(dout0_12) AT=850.025n

.meas tran vdout0_13ck1690 FIND v(dout0_13) AT=850.025n

.meas tran vdout0_14ck1690 FIND v(dout0_14) AT=850.025n

.meas tran vdout0_15ck1690 FIND v(dout0_15) AT=850.025n

.meas tran vdout0_16ck1690 FIND v(dout0_16) AT=850.025n

.meas tran vdout0_17ck1690 FIND v(dout0_17) AT=850.025n

.meas tran vdout0_18ck1690 FIND v(dout0_18) AT=850.025n

.meas tran vdout0_19ck1690 FIND v(dout0_19) AT=850.025n

.meas tran vdout0_20ck1690 FIND v(dout0_20) AT=850.025n

.meas tran vdout0_21ck1690 FIND v(dout0_21) AT=850.025n

.meas tran vdout0_22ck1690 FIND v(dout0_22) AT=850.025n

.meas tran vdout0_23ck1690 FIND v(dout0_23) AT=850.025n

.meas tran vdout0_24ck1690 FIND v(dout0_24) AT=850.025n

.meas tran vdout0_25ck1690 FIND v(dout0_25) AT=850.025n

.meas tran vdout0_26ck1690 FIND v(dout0_26) AT=850.025n

.meas tran vdout0_27ck1690 FIND v(dout0_27) AT=850.025n

.meas tran vdout0_28ck1690 FIND v(dout0_28) AT=850.025n

.meas tran vdout0_29ck1690 FIND v(dout0_29) AT=850.025n

.meas tran vdout0_30ck1690 FIND v(dout0_30) AT=850.025n

.meas tran vdout0_31ck1690 FIND v(dout0_31) AT=850.025n

.meas tran vdout0_32ck1690 FIND v(dout0_32) AT=850.025n

.meas tran vdout0_33ck1690 FIND v(dout0_33) AT=850.025n

.meas tran vdout0_34ck1690 FIND v(dout0_34) AT=850.025n

.meas tran vdout0_35ck1690 FIND v(dout0_35) AT=850.025n

.meas tran vdout0_36ck1690 FIND v(dout0_36) AT=850.025n

.meas tran vdout0_37ck1690 FIND v(dout0_37) AT=850.025n

.meas tran vdout0_38ck1690 FIND v(dout0_38) AT=850.025n

.meas tran vdout0_39ck1690 FIND v(dout0_39) AT=850.025n

.meas tran vdout0_40ck1690 FIND v(dout0_40) AT=850.025n

.meas tran vdout0_41ck1690 FIND v(dout0_41) AT=850.025n

.meas tran vdout0_42ck1690 FIND v(dout0_42) AT=850.025n

.meas tran vdout0_43ck1690 FIND v(dout0_43) AT=850.025n

.meas tran vdout0_44ck1690 FIND v(dout0_44) AT=850.025n

.meas tran vdout0_45ck1690 FIND v(dout0_45) AT=850.025n

.meas tran vdout0_46ck1690 FIND v(dout0_46) AT=850.025n

.meas tran vdout0_47ck1690 FIND v(dout0_47) AT=850.025n

.meas tran vdout0_48ck1690 FIND v(dout0_48) AT=850.025n

.meas tran vdout0_49ck1690 FIND v(dout0_49) AT=850.025n

.meas tran vdout0_50ck1690 FIND v(dout0_50) AT=850.025n

.meas tran vdout0_51ck1690 FIND v(dout0_51) AT=850.025n

.meas tran vdout0_52ck1690 FIND v(dout0_52) AT=850.025n

.meas tran vdout0_53ck1690 FIND v(dout0_53) AT=850.025n

.meas tran vdout0_54ck1690 FIND v(dout0_54) AT=850.025n

.meas tran vdout0_55ck1690 FIND v(dout0_55) AT=850.025n

.meas tran vdout0_56ck1690 FIND v(dout0_56) AT=850.025n

.meas tran vdout0_57ck1690 FIND v(dout0_57) AT=850.025n

.meas tran vdout0_58ck1690 FIND v(dout0_58) AT=850.025n

.meas tran vdout0_59ck1690 FIND v(dout0_59) AT=850.025n

.meas tran vdout0_60ck1690 FIND v(dout0_60) AT=850.025n

.meas tran vdout0_61ck1690 FIND v(dout0_61) AT=850.025n

.meas tran vdout0_62ck1690 FIND v(dout0_62) AT=850.025n

.meas tran vdout0_63ck1690 FIND v(dout0_63) AT=850.025n

.meas tran vdout0_64ck1690 FIND v(dout0_64) AT=850.025n

.meas tran vdout0_65ck1690 FIND v(dout0_65) AT=850.025n

.meas tran vdout0_66ck1690 FIND v(dout0_66) AT=850.025n

.meas tran vdout0_67ck1690 FIND v(dout0_67) AT=850.025n

.meas tran vdout0_68ck1690 FIND v(dout0_68) AT=850.025n

.meas tran vdout0_69ck1690 FIND v(dout0_69) AT=850.025n

.meas tran vdout0_70ck1690 FIND v(dout0_70) AT=850.025n

.meas tran vdout0_71ck1690 FIND v(dout0_71) AT=850.025n

.meas tran vdout0_72ck1690 FIND v(dout0_72) AT=850.025n

.meas tran vdout0_73ck1690 FIND v(dout0_73) AT=850.025n

.meas tran vdout0_74ck1690 FIND v(dout0_74) AT=850.025n

.meas tran vdout0_75ck1690 FIND v(dout0_75) AT=850.025n

.meas tran vdout0_76ck1690 FIND v(dout0_76) AT=850.025n

.meas tran vdout0_77ck1690 FIND v(dout0_77) AT=850.025n

.meas tran vdout0_78ck1690 FIND v(dout0_78) AT=850.025n

.meas tran vdout0_79ck1690 FIND v(dout0_79) AT=850.025n

.meas tran vdout0_80ck1690 FIND v(dout0_80) AT=850.025n

.meas tran vdout0_81ck1690 FIND v(dout0_81) AT=850.025n

.meas tran vdout0_82ck1690 FIND v(dout0_82) AT=850.025n

.meas tran vdout0_83ck1690 FIND v(dout0_83) AT=850.025n

.meas tran vdout0_84ck1690 FIND v(dout0_84) AT=850.025n

.meas tran vdout0_85ck1690 FIND v(dout0_85) AT=850.025n

.meas tran vdout0_86ck1690 FIND v(dout0_86) AT=850.025n

.meas tran vdout0_87ck1690 FIND v(dout0_87) AT=850.025n

.meas tran vdout0_88ck1690 FIND v(dout0_88) AT=850.025n

.meas tran vdout0_89ck1690 FIND v(dout0_89) AT=850.025n

.meas tran vdout0_90ck1690 FIND v(dout0_90) AT=850.025n

.meas tran vdout0_91ck1690 FIND v(dout0_91) AT=850.025n

.meas tran vdout0_92ck1690 FIND v(dout0_92) AT=850.025n

.meas tran vdout0_93ck1690 FIND v(dout0_93) AT=850.025n

.meas tran vdout0_94ck1690 FIND v(dout0_94) AT=850.025n

.meas tran vdout0_95ck1690 FIND v(dout0_95) AT=850.025n

.meas tran vdout0_96ck1690 FIND v(dout0_96) AT=850.025n

.meas tran vdout0_97ck1690 FIND v(dout0_97) AT=850.025n

.meas tran vdout0_98ck1690 FIND v(dout0_98) AT=850.025n

.meas tran vdout0_99ck1690 FIND v(dout0_99) AT=850.025n

.meas tran vdout0_100ck1690 FIND v(dout0_100) AT=850.025n

.meas tran vdout0_101ck1690 FIND v(dout0_101) AT=850.025n

.meas tran vdout0_102ck1690 FIND v(dout0_102) AT=850.025n

.meas tran vdout0_103ck1690 FIND v(dout0_103) AT=850.025n

.meas tran vdout0_104ck1690 FIND v(dout0_104) AT=850.025n

.meas tran vdout0_105ck1690 FIND v(dout0_105) AT=850.025n

.meas tran vdout0_106ck1690 FIND v(dout0_106) AT=850.025n

.meas tran vdout0_107ck1690 FIND v(dout0_107) AT=850.025n

.meas tran vdout0_108ck1690 FIND v(dout0_108) AT=850.025n

.meas tran vdout0_109ck1690 FIND v(dout0_109) AT=850.025n

.meas tran vdout0_110ck1690 FIND v(dout0_110) AT=850.025n

.meas tran vdout0_111ck1690 FIND v(dout0_111) AT=850.025n

.meas tran vdout0_112ck1690 FIND v(dout0_112) AT=850.025n

.meas tran vdout0_113ck1690 FIND v(dout0_113) AT=850.025n

.meas tran vdout0_114ck1690 FIND v(dout0_114) AT=850.025n

.meas tran vdout0_115ck1690 FIND v(dout0_115) AT=850.025n

.meas tran vdout0_116ck1690 FIND v(dout0_116) AT=850.025n

.meas tran vdout0_117ck1690 FIND v(dout0_117) AT=850.025n

.meas tran vdout0_118ck1690 FIND v(dout0_118) AT=850.025n

.meas tran vdout0_119ck1690 FIND v(dout0_119) AT=850.025n

.meas tran vdout0_120ck1690 FIND v(dout0_120) AT=850.025n

.meas tran vdout0_121ck1690 FIND v(dout0_121) AT=850.025n

.meas tran vdout0_122ck1690 FIND v(dout0_122) AT=850.025n

.meas tran vdout0_123ck1690 FIND v(dout0_123) AT=850.025n

.meas tran vdout0_124ck1690 FIND v(dout0_124) AT=850.025n

.meas tran vdout0_125ck1690 FIND v(dout0_125) AT=850.025n

.meas tran vdout0_126ck1690 FIND v(dout0_126) AT=850.025n

.meas tran vdout0_127ck1690 FIND v(dout0_127) AT=850.025n

.meas tran vdout0_0ck1700 FIND v(dout0_0) AT=855.025n

.meas tran vdout0_1ck1700 FIND v(dout0_1) AT=855.025n

.meas tran vdout0_2ck1700 FIND v(dout0_2) AT=855.025n

.meas tran vdout0_3ck1700 FIND v(dout0_3) AT=855.025n

.meas tran vdout0_4ck1700 FIND v(dout0_4) AT=855.025n

.meas tran vdout0_5ck1700 FIND v(dout0_5) AT=855.025n

.meas tran vdout0_6ck1700 FIND v(dout0_6) AT=855.025n

.meas tran vdout0_7ck1700 FIND v(dout0_7) AT=855.025n

.meas tran vdout0_8ck1700 FIND v(dout0_8) AT=855.025n

.meas tran vdout0_9ck1700 FIND v(dout0_9) AT=855.025n

.meas tran vdout0_10ck1700 FIND v(dout0_10) AT=855.025n

.meas tran vdout0_11ck1700 FIND v(dout0_11) AT=855.025n

.meas tran vdout0_12ck1700 FIND v(dout0_12) AT=855.025n

.meas tran vdout0_13ck1700 FIND v(dout0_13) AT=855.025n

.meas tran vdout0_14ck1700 FIND v(dout0_14) AT=855.025n

.meas tran vdout0_15ck1700 FIND v(dout0_15) AT=855.025n

.meas tran vdout0_16ck1700 FIND v(dout0_16) AT=855.025n

.meas tran vdout0_17ck1700 FIND v(dout0_17) AT=855.025n

.meas tran vdout0_18ck1700 FIND v(dout0_18) AT=855.025n

.meas tran vdout0_19ck1700 FIND v(dout0_19) AT=855.025n

.meas tran vdout0_20ck1700 FIND v(dout0_20) AT=855.025n

.meas tran vdout0_21ck1700 FIND v(dout0_21) AT=855.025n

.meas tran vdout0_22ck1700 FIND v(dout0_22) AT=855.025n

.meas tran vdout0_23ck1700 FIND v(dout0_23) AT=855.025n

.meas tran vdout0_24ck1700 FIND v(dout0_24) AT=855.025n

.meas tran vdout0_25ck1700 FIND v(dout0_25) AT=855.025n

.meas tran vdout0_26ck1700 FIND v(dout0_26) AT=855.025n

.meas tran vdout0_27ck1700 FIND v(dout0_27) AT=855.025n

.meas tran vdout0_28ck1700 FIND v(dout0_28) AT=855.025n

.meas tran vdout0_29ck1700 FIND v(dout0_29) AT=855.025n

.meas tran vdout0_30ck1700 FIND v(dout0_30) AT=855.025n

.meas tran vdout0_31ck1700 FIND v(dout0_31) AT=855.025n

.meas tran vdout0_32ck1700 FIND v(dout0_32) AT=855.025n

.meas tran vdout0_33ck1700 FIND v(dout0_33) AT=855.025n

.meas tran vdout0_34ck1700 FIND v(dout0_34) AT=855.025n

.meas tran vdout0_35ck1700 FIND v(dout0_35) AT=855.025n

.meas tran vdout0_36ck1700 FIND v(dout0_36) AT=855.025n

.meas tran vdout0_37ck1700 FIND v(dout0_37) AT=855.025n

.meas tran vdout0_38ck1700 FIND v(dout0_38) AT=855.025n

.meas tran vdout0_39ck1700 FIND v(dout0_39) AT=855.025n

.meas tran vdout0_40ck1700 FIND v(dout0_40) AT=855.025n

.meas tran vdout0_41ck1700 FIND v(dout0_41) AT=855.025n

.meas tran vdout0_42ck1700 FIND v(dout0_42) AT=855.025n

.meas tran vdout0_43ck1700 FIND v(dout0_43) AT=855.025n

.meas tran vdout0_44ck1700 FIND v(dout0_44) AT=855.025n

.meas tran vdout0_45ck1700 FIND v(dout0_45) AT=855.025n

.meas tran vdout0_46ck1700 FIND v(dout0_46) AT=855.025n

.meas tran vdout0_47ck1700 FIND v(dout0_47) AT=855.025n

.meas tran vdout0_48ck1700 FIND v(dout0_48) AT=855.025n

.meas tran vdout0_49ck1700 FIND v(dout0_49) AT=855.025n

.meas tran vdout0_50ck1700 FIND v(dout0_50) AT=855.025n

.meas tran vdout0_51ck1700 FIND v(dout0_51) AT=855.025n

.meas tran vdout0_52ck1700 FIND v(dout0_52) AT=855.025n

.meas tran vdout0_53ck1700 FIND v(dout0_53) AT=855.025n

.meas tran vdout0_54ck1700 FIND v(dout0_54) AT=855.025n

.meas tran vdout0_55ck1700 FIND v(dout0_55) AT=855.025n

.meas tran vdout0_56ck1700 FIND v(dout0_56) AT=855.025n

.meas tran vdout0_57ck1700 FIND v(dout0_57) AT=855.025n

.meas tran vdout0_58ck1700 FIND v(dout0_58) AT=855.025n

.meas tran vdout0_59ck1700 FIND v(dout0_59) AT=855.025n

.meas tran vdout0_60ck1700 FIND v(dout0_60) AT=855.025n

.meas tran vdout0_61ck1700 FIND v(dout0_61) AT=855.025n

.meas tran vdout0_62ck1700 FIND v(dout0_62) AT=855.025n

.meas tran vdout0_63ck1700 FIND v(dout0_63) AT=855.025n

.meas tran vdout0_64ck1700 FIND v(dout0_64) AT=855.025n

.meas tran vdout0_65ck1700 FIND v(dout0_65) AT=855.025n

.meas tran vdout0_66ck1700 FIND v(dout0_66) AT=855.025n

.meas tran vdout0_67ck1700 FIND v(dout0_67) AT=855.025n

.meas tran vdout0_68ck1700 FIND v(dout0_68) AT=855.025n

.meas tran vdout0_69ck1700 FIND v(dout0_69) AT=855.025n

.meas tran vdout0_70ck1700 FIND v(dout0_70) AT=855.025n

.meas tran vdout0_71ck1700 FIND v(dout0_71) AT=855.025n

.meas tran vdout0_72ck1700 FIND v(dout0_72) AT=855.025n

.meas tran vdout0_73ck1700 FIND v(dout0_73) AT=855.025n

.meas tran vdout0_74ck1700 FIND v(dout0_74) AT=855.025n

.meas tran vdout0_75ck1700 FIND v(dout0_75) AT=855.025n

.meas tran vdout0_76ck1700 FIND v(dout0_76) AT=855.025n

.meas tran vdout0_77ck1700 FIND v(dout0_77) AT=855.025n

.meas tran vdout0_78ck1700 FIND v(dout0_78) AT=855.025n

.meas tran vdout0_79ck1700 FIND v(dout0_79) AT=855.025n

.meas tran vdout0_80ck1700 FIND v(dout0_80) AT=855.025n

.meas tran vdout0_81ck1700 FIND v(dout0_81) AT=855.025n

.meas tran vdout0_82ck1700 FIND v(dout0_82) AT=855.025n

.meas tran vdout0_83ck1700 FIND v(dout0_83) AT=855.025n

.meas tran vdout0_84ck1700 FIND v(dout0_84) AT=855.025n

.meas tran vdout0_85ck1700 FIND v(dout0_85) AT=855.025n

.meas tran vdout0_86ck1700 FIND v(dout0_86) AT=855.025n

.meas tran vdout0_87ck1700 FIND v(dout0_87) AT=855.025n

.meas tran vdout0_88ck1700 FIND v(dout0_88) AT=855.025n

.meas tran vdout0_89ck1700 FIND v(dout0_89) AT=855.025n

.meas tran vdout0_90ck1700 FIND v(dout0_90) AT=855.025n

.meas tran vdout0_91ck1700 FIND v(dout0_91) AT=855.025n

.meas tran vdout0_92ck1700 FIND v(dout0_92) AT=855.025n

.meas tran vdout0_93ck1700 FIND v(dout0_93) AT=855.025n

.meas tran vdout0_94ck1700 FIND v(dout0_94) AT=855.025n

.meas tran vdout0_95ck1700 FIND v(dout0_95) AT=855.025n

.meas tran vdout0_96ck1700 FIND v(dout0_96) AT=855.025n

.meas tran vdout0_97ck1700 FIND v(dout0_97) AT=855.025n

.meas tran vdout0_98ck1700 FIND v(dout0_98) AT=855.025n

.meas tran vdout0_99ck1700 FIND v(dout0_99) AT=855.025n

.meas tran vdout0_100ck1700 FIND v(dout0_100) AT=855.025n

.meas tran vdout0_101ck1700 FIND v(dout0_101) AT=855.025n

.meas tran vdout0_102ck1700 FIND v(dout0_102) AT=855.025n

.meas tran vdout0_103ck1700 FIND v(dout0_103) AT=855.025n

.meas tran vdout0_104ck1700 FIND v(dout0_104) AT=855.025n

.meas tran vdout0_105ck1700 FIND v(dout0_105) AT=855.025n

.meas tran vdout0_106ck1700 FIND v(dout0_106) AT=855.025n

.meas tran vdout0_107ck1700 FIND v(dout0_107) AT=855.025n

.meas tran vdout0_108ck1700 FIND v(dout0_108) AT=855.025n

.meas tran vdout0_109ck1700 FIND v(dout0_109) AT=855.025n

.meas tran vdout0_110ck1700 FIND v(dout0_110) AT=855.025n

.meas tran vdout0_111ck1700 FIND v(dout0_111) AT=855.025n

.meas tran vdout0_112ck1700 FIND v(dout0_112) AT=855.025n

.meas tran vdout0_113ck1700 FIND v(dout0_113) AT=855.025n

.meas tran vdout0_114ck1700 FIND v(dout0_114) AT=855.025n

.meas tran vdout0_115ck1700 FIND v(dout0_115) AT=855.025n

.meas tran vdout0_116ck1700 FIND v(dout0_116) AT=855.025n

.meas tran vdout0_117ck1700 FIND v(dout0_117) AT=855.025n

.meas tran vdout0_118ck1700 FIND v(dout0_118) AT=855.025n

.meas tran vdout0_119ck1700 FIND v(dout0_119) AT=855.025n

.meas tran vdout0_120ck1700 FIND v(dout0_120) AT=855.025n

.meas tran vdout0_121ck1700 FIND v(dout0_121) AT=855.025n

.meas tran vdout0_122ck1700 FIND v(dout0_122) AT=855.025n

.meas tran vdout0_123ck1700 FIND v(dout0_123) AT=855.025n

.meas tran vdout0_124ck1700 FIND v(dout0_124) AT=855.025n

.meas tran vdout0_125ck1700 FIND v(dout0_125) AT=855.025n

.meas tran vdout0_126ck1700 FIND v(dout0_126) AT=855.025n

.meas tran vdout0_127ck1700 FIND v(dout0_127) AT=855.025n

.meas tran vdout0_0ck1720 FIND v(dout0_0) AT=865.025n

.meas tran vdout0_1ck1720 FIND v(dout0_1) AT=865.025n

.meas tran vdout0_2ck1720 FIND v(dout0_2) AT=865.025n

.meas tran vdout0_3ck1720 FIND v(dout0_3) AT=865.025n

.meas tran vdout0_4ck1720 FIND v(dout0_4) AT=865.025n

.meas tran vdout0_5ck1720 FIND v(dout0_5) AT=865.025n

.meas tran vdout0_6ck1720 FIND v(dout0_6) AT=865.025n

.meas tran vdout0_7ck1720 FIND v(dout0_7) AT=865.025n

.meas tran vdout0_8ck1720 FIND v(dout0_8) AT=865.025n

.meas tran vdout0_9ck1720 FIND v(dout0_9) AT=865.025n

.meas tran vdout0_10ck1720 FIND v(dout0_10) AT=865.025n

.meas tran vdout0_11ck1720 FIND v(dout0_11) AT=865.025n

.meas tran vdout0_12ck1720 FIND v(dout0_12) AT=865.025n

.meas tran vdout0_13ck1720 FIND v(dout0_13) AT=865.025n

.meas tran vdout0_14ck1720 FIND v(dout0_14) AT=865.025n

.meas tran vdout0_15ck1720 FIND v(dout0_15) AT=865.025n

.meas tran vdout0_16ck1720 FIND v(dout0_16) AT=865.025n

.meas tran vdout0_17ck1720 FIND v(dout0_17) AT=865.025n

.meas tran vdout0_18ck1720 FIND v(dout0_18) AT=865.025n

.meas tran vdout0_19ck1720 FIND v(dout0_19) AT=865.025n

.meas tran vdout0_20ck1720 FIND v(dout0_20) AT=865.025n

.meas tran vdout0_21ck1720 FIND v(dout0_21) AT=865.025n

.meas tran vdout0_22ck1720 FIND v(dout0_22) AT=865.025n

.meas tran vdout0_23ck1720 FIND v(dout0_23) AT=865.025n

.meas tran vdout0_24ck1720 FIND v(dout0_24) AT=865.025n

.meas tran vdout0_25ck1720 FIND v(dout0_25) AT=865.025n

.meas tran vdout0_26ck1720 FIND v(dout0_26) AT=865.025n

.meas tran vdout0_27ck1720 FIND v(dout0_27) AT=865.025n

.meas tran vdout0_28ck1720 FIND v(dout0_28) AT=865.025n

.meas tran vdout0_29ck1720 FIND v(dout0_29) AT=865.025n

.meas tran vdout0_30ck1720 FIND v(dout0_30) AT=865.025n

.meas tran vdout0_31ck1720 FIND v(dout0_31) AT=865.025n

.meas tran vdout0_32ck1720 FIND v(dout0_32) AT=865.025n

.meas tran vdout0_33ck1720 FIND v(dout0_33) AT=865.025n

.meas tran vdout0_34ck1720 FIND v(dout0_34) AT=865.025n

.meas tran vdout0_35ck1720 FIND v(dout0_35) AT=865.025n

.meas tran vdout0_36ck1720 FIND v(dout0_36) AT=865.025n

.meas tran vdout0_37ck1720 FIND v(dout0_37) AT=865.025n

.meas tran vdout0_38ck1720 FIND v(dout0_38) AT=865.025n

.meas tran vdout0_39ck1720 FIND v(dout0_39) AT=865.025n

.meas tran vdout0_40ck1720 FIND v(dout0_40) AT=865.025n

.meas tran vdout0_41ck1720 FIND v(dout0_41) AT=865.025n

.meas tran vdout0_42ck1720 FIND v(dout0_42) AT=865.025n

.meas tran vdout0_43ck1720 FIND v(dout0_43) AT=865.025n

.meas tran vdout0_44ck1720 FIND v(dout0_44) AT=865.025n

.meas tran vdout0_45ck1720 FIND v(dout0_45) AT=865.025n

.meas tran vdout0_46ck1720 FIND v(dout0_46) AT=865.025n

.meas tran vdout0_47ck1720 FIND v(dout0_47) AT=865.025n

.meas tran vdout0_48ck1720 FIND v(dout0_48) AT=865.025n

.meas tran vdout0_49ck1720 FIND v(dout0_49) AT=865.025n

.meas tran vdout0_50ck1720 FIND v(dout0_50) AT=865.025n

.meas tran vdout0_51ck1720 FIND v(dout0_51) AT=865.025n

.meas tran vdout0_52ck1720 FIND v(dout0_52) AT=865.025n

.meas tran vdout0_53ck1720 FIND v(dout0_53) AT=865.025n

.meas tran vdout0_54ck1720 FIND v(dout0_54) AT=865.025n

.meas tran vdout0_55ck1720 FIND v(dout0_55) AT=865.025n

.meas tran vdout0_56ck1720 FIND v(dout0_56) AT=865.025n

.meas tran vdout0_57ck1720 FIND v(dout0_57) AT=865.025n

.meas tran vdout0_58ck1720 FIND v(dout0_58) AT=865.025n

.meas tran vdout0_59ck1720 FIND v(dout0_59) AT=865.025n

.meas tran vdout0_60ck1720 FIND v(dout0_60) AT=865.025n

.meas tran vdout0_61ck1720 FIND v(dout0_61) AT=865.025n

.meas tran vdout0_62ck1720 FIND v(dout0_62) AT=865.025n

.meas tran vdout0_63ck1720 FIND v(dout0_63) AT=865.025n

.meas tran vdout0_64ck1720 FIND v(dout0_64) AT=865.025n

.meas tran vdout0_65ck1720 FIND v(dout0_65) AT=865.025n

.meas tran vdout0_66ck1720 FIND v(dout0_66) AT=865.025n

.meas tran vdout0_67ck1720 FIND v(dout0_67) AT=865.025n

.meas tran vdout0_68ck1720 FIND v(dout0_68) AT=865.025n

.meas tran vdout0_69ck1720 FIND v(dout0_69) AT=865.025n

.meas tran vdout0_70ck1720 FIND v(dout0_70) AT=865.025n

.meas tran vdout0_71ck1720 FIND v(dout0_71) AT=865.025n

.meas tran vdout0_72ck1720 FIND v(dout0_72) AT=865.025n

.meas tran vdout0_73ck1720 FIND v(dout0_73) AT=865.025n

.meas tran vdout0_74ck1720 FIND v(dout0_74) AT=865.025n

.meas tran vdout0_75ck1720 FIND v(dout0_75) AT=865.025n

.meas tran vdout0_76ck1720 FIND v(dout0_76) AT=865.025n

.meas tran vdout0_77ck1720 FIND v(dout0_77) AT=865.025n

.meas tran vdout0_78ck1720 FIND v(dout0_78) AT=865.025n

.meas tran vdout0_79ck1720 FIND v(dout0_79) AT=865.025n

.meas tran vdout0_80ck1720 FIND v(dout0_80) AT=865.025n

.meas tran vdout0_81ck1720 FIND v(dout0_81) AT=865.025n

.meas tran vdout0_82ck1720 FIND v(dout0_82) AT=865.025n

.meas tran vdout0_83ck1720 FIND v(dout0_83) AT=865.025n

.meas tran vdout0_84ck1720 FIND v(dout0_84) AT=865.025n

.meas tran vdout0_85ck1720 FIND v(dout0_85) AT=865.025n

.meas tran vdout0_86ck1720 FIND v(dout0_86) AT=865.025n

.meas tran vdout0_87ck1720 FIND v(dout0_87) AT=865.025n

.meas tran vdout0_88ck1720 FIND v(dout0_88) AT=865.025n

.meas tran vdout0_89ck1720 FIND v(dout0_89) AT=865.025n

.meas tran vdout0_90ck1720 FIND v(dout0_90) AT=865.025n

.meas tran vdout0_91ck1720 FIND v(dout0_91) AT=865.025n

.meas tran vdout0_92ck1720 FIND v(dout0_92) AT=865.025n

.meas tran vdout0_93ck1720 FIND v(dout0_93) AT=865.025n

.meas tran vdout0_94ck1720 FIND v(dout0_94) AT=865.025n

.meas tran vdout0_95ck1720 FIND v(dout0_95) AT=865.025n

.meas tran vdout0_96ck1720 FIND v(dout0_96) AT=865.025n

.meas tran vdout0_97ck1720 FIND v(dout0_97) AT=865.025n

.meas tran vdout0_98ck1720 FIND v(dout0_98) AT=865.025n

.meas tran vdout0_99ck1720 FIND v(dout0_99) AT=865.025n

.meas tran vdout0_100ck1720 FIND v(dout0_100) AT=865.025n

.meas tran vdout0_101ck1720 FIND v(dout0_101) AT=865.025n

.meas tran vdout0_102ck1720 FIND v(dout0_102) AT=865.025n

.meas tran vdout0_103ck1720 FIND v(dout0_103) AT=865.025n

.meas tran vdout0_104ck1720 FIND v(dout0_104) AT=865.025n

.meas tran vdout0_105ck1720 FIND v(dout0_105) AT=865.025n

.meas tran vdout0_106ck1720 FIND v(dout0_106) AT=865.025n

.meas tran vdout0_107ck1720 FIND v(dout0_107) AT=865.025n

.meas tran vdout0_108ck1720 FIND v(dout0_108) AT=865.025n

.meas tran vdout0_109ck1720 FIND v(dout0_109) AT=865.025n

.meas tran vdout0_110ck1720 FIND v(dout0_110) AT=865.025n

.meas tran vdout0_111ck1720 FIND v(dout0_111) AT=865.025n

.meas tran vdout0_112ck1720 FIND v(dout0_112) AT=865.025n

.meas tran vdout0_113ck1720 FIND v(dout0_113) AT=865.025n

.meas tran vdout0_114ck1720 FIND v(dout0_114) AT=865.025n

.meas tran vdout0_115ck1720 FIND v(dout0_115) AT=865.025n

.meas tran vdout0_116ck1720 FIND v(dout0_116) AT=865.025n

.meas tran vdout0_117ck1720 FIND v(dout0_117) AT=865.025n

.meas tran vdout0_118ck1720 FIND v(dout0_118) AT=865.025n

.meas tran vdout0_119ck1720 FIND v(dout0_119) AT=865.025n

.meas tran vdout0_120ck1720 FIND v(dout0_120) AT=865.025n

.meas tran vdout0_121ck1720 FIND v(dout0_121) AT=865.025n

.meas tran vdout0_122ck1720 FIND v(dout0_122) AT=865.025n

.meas tran vdout0_123ck1720 FIND v(dout0_123) AT=865.025n

.meas tran vdout0_124ck1720 FIND v(dout0_124) AT=865.025n

.meas tran vdout0_125ck1720 FIND v(dout0_125) AT=865.025n

.meas tran vdout0_126ck1720 FIND v(dout0_126) AT=865.025n

.meas tran vdout0_127ck1720 FIND v(dout0_127) AT=865.025n

.meas tran vdout0_0ck1740 FIND v(dout0_0) AT=875.025n

.meas tran vdout0_1ck1740 FIND v(dout0_1) AT=875.025n

.meas tran vdout0_2ck1740 FIND v(dout0_2) AT=875.025n

.meas tran vdout0_3ck1740 FIND v(dout0_3) AT=875.025n

.meas tran vdout0_4ck1740 FIND v(dout0_4) AT=875.025n

.meas tran vdout0_5ck1740 FIND v(dout0_5) AT=875.025n

.meas tran vdout0_6ck1740 FIND v(dout0_6) AT=875.025n

.meas tran vdout0_7ck1740 FIND v(dout0_7) AT=875.025n

.meas tran vdout0_8ck1740 FIND v(dout0_8) AT=875.025n

.meas tran vdout0_9ck1740 FIND v(dout0_9) AT=875.025n

.meas tran vdout0_10ck1740 FIND v(dout0_10) AT=875.025n

.meas tran vdout0_11ck1740 FIND v(dout0_11) AT=875.025n

.meas tran vdout0_12ck1740 FIND v(dout0_12) AT=875.025n

.meas tran vdout0_13ck1740 FIND v(dout0_13) AT=875.025n

.meas tran vdout0_14ck1740 FIND v(dout0_14) AT=875.025n

.meas tran vdout0_15ck1740 FIND v(dout0_15) AT=875.025n

.meas tran vdout0_16ck1740 FIND v(dout0_16) AT=875.025n

.meas tran vdout0_17ck1740 FIND v(dout0_17) AT=875.025n

.meas tran vdout0_18ck1740 FIND v(dout0_18) AT=875.025n

.meas tran vdout0_19ck1740 FIND v(dout0_19) AT=875.025n

.meas tran vdout0_20ck1740 FIND v(dout0_20) AT=875.025n

.meas tran vdout0_21ck1740 FIND v(dout0_21) AT=875.025n

.meas tran vdout0_22ck1740 FIND v(dout0_22) AT=875.025n

.meas tran vdout0_23ck1740 FIND v(dout0_23) AT=875.025n

.meas tran vdout0_24ck1740 FIND v(dout0_24) AT=875.025n

.meas tran vdout0_25ck1740 FIND v(dout0_25) AT=875.025n

.meas tran vdout0_26ck1740 FIND v(dout0_26) AT=875.025n

.meas tran vdout0_27ck1740 FIND v(dout0_27) AT=875.025n

.meas tran vdout0_28ck1740 FIND v(dout0_28) AT=875.025n

.meas tran vdout0_29ck1740 FIND v(dout0_29) AT=875.025n

.meas tran vdout0_30ck1740 FIND v(dout0_30) AT=875.025n

.meas tran vdout0_31ck1740 FIND v(dout0_31) AT=875.025n

.meas tran vdout0_32ck1740 FIND v(dout0_32) AT=875.025n

.meas tran vdout0_33ck1740 FIND v(dout0_33) AT=875.025n

.meas tran vdout0_34ck1740 FIND v(dout0_34) AT=875.025n

.meas tran vdout0_35ck1740 FIND v(dout0_35) AT=875.025n

.meas tran vdout0_36ck1740 FIND v(dout0_36) AT=875.025n

.meas tran vdout0_37ck1740 FIND v(dout0_37) AT=875.025n

.meas tran vdout0_38ck1740 FIND v(dout0_38) AT=875.025n

.meas tran vdout0_39ck1740 FIND v(dout0_39) AT=875.025n

.meas tran vdout0_40ck1740 FIND v(dout0_40) AT=875.025n

.meas tran vdout0_41ck1740 FIND v(dout0_41) AT=875.025n

.meas tran vdout0_42ck1740 FIND v(dout0_42) AT=875.025n

.meas tran vdout0_43ck1740 FIND v(dout0_43) AT=875.025n

.meas tran vdout0_44ck1740 FIND v(dout0_44) AT=875.025n

.meas tran vdout0_45ck1740 FIND v(dout0_45) AT=875.025n

.meas tran vdout0_46ck1740 FIND v(dout0_46) AT=875.025n

.meas tran vdout0_47ck1740 FIND v(dout0_47) AT=875.025n

.meas tran vdout0_48ck1740 FIND v(dout0_48) AT=875.025n

.meas tran vdout0_49ck1740 FIND v(dout0_49) AT=875.025n

.meas tran vdout0_50ck1740 FIND v(dout0_50) AT=875.025n

.meas tran vdout0_51ck1740 FIND v(dout0_51) AT=875.025n

.meas tran vdout0_52ck1740 FIND v(dout0_52) AT=875.025n

.meas tran vdout0_53ck1740 FIND v(dout0_53) AT=875.025n

.meas tran vdout0_54ck1740 FIND v(dout0_54) AT=875.025n

.meas tran vdout0_55ck1740 FIND v(dout0_55) AT=875.025n

.meas tran vdout0_56ck1740 FIND v(dout0_56) AT=875.025n

.meas tran vdout0_57ck1740 FIND v(dout0_57) AT=875.025n

.meas tran vdout0_58ck1740 FIND v(dout0_58) AT=875.025n

.meas tran vdout0_59ck1740 FIND v(dout0_59) AT=875.025n

.meas tran vdout0_60ck1740 FIND v(dout0_60) AT=875.025n

.meas tran vdout0_61ck1740 FIND v(dout0_61) AT=875.025n

.meas tran vdout0_62ck1740 FIND v(dout0_62) AT=875.025n

.meas tran vdout0_63ck1740 FIND v(dout0_63) AT=875.025n

.meas tran vdout0_64ck1740 FIND v(dout0_64) AT=875.025n

.meas tran vdout0_65ck1740 FIND v(dout0_65) AT=875.025n

.meas tran vdout0_66ck1740 FIND v(dout0_66) AT=875.025n

.meas tran vdout0_67ck1740 FIND v(dout0_67) AT=875.025n

.meas tran vdout0_68ck1740 FIND v(dout0_68) AT=875.025n

.meas tran vdout0_69ck1740 FIND v(dout0_69) AT=875.025n

.meas tran vdout0_70ck1740 FIND v(dout0_70) AT=875.025n

.meas tran vdout0_71ck1740 FIND v(dout0_71) AT=875.025n

.meas tran vdout0_72ck1740 FIND v(dout0_72) AT=875.025n

.meas tran vdout0_73ck1740 FIND v(dout0_73) AT=875.025n

.meas tran vdout0_74ck1740 FIND v(dout0_74) AT=875.025n

.meas tran vdout0_75ck1740 FIND v(dout0_75) AT=875.025n

.meas tran vdout0_76ck1740 FIND v(dout0_76) AT=875.025n

.meas tran vdout0_77ck1740 FIND v(dout0_77) AT=875.025n

.meas tran vdout0_78ck1740 FIND v(dout0_78) AT=875.025n

.meas tran vdout0_79ck1740 FIND v(dout0_79) AT=875.025n

.meas tran vdout0_80ck1740 FIND v(dout0_80) AT=875.025n

.meas tran vdout0_81ck1740 FIND v(dout0_81) AT=875.025n

.meas tran vdout0_82ck1740 FIND v(dout0_82) AT=875.025n

.meas tran vdout0_83ck1740 FIND v(dout0_83) AT=875.025n

.meas tran vdout0_84ck1740 FIND v(dout0_84) AT=875.025n

.meas tran vdout0_85ck1740 FIND v(dout0_85) AT=875.025n

.meas tran vdout0_86ck1740 FIND v(dout0_86) AT=875.025n

.meas tran vdout0_87ck1740 FIND v(dout0_87) AT=875.025n

.meas tran vdout0_88ck1740 FIND v(dout0_88) AT=875.025n

.meas tran vdout0_89ck1740 FIND v(dout0_89) AT=875.025n

.meas tran vdout0_90ck1740 FIND v(dout0_90) AT=875.025n

.meas tran vdout0_91ck1740 FIND v(dout0_91) AT=875.025n

.meas tran vdout0_92ck1740 FIND v(dout0_92) AT=875.025n

.meas tran vdout0_93ck1740 FIND v(dout0_93) AT=875.025n

.meas tran vdout0_94ck1740 FIND v(dout0_94) AT=875.025n

.meas tran vdout0_95ck1740 FIND v(dout0_95) AT=875.025n

.meas tran vdout0_96ck1740 FIND v(dout0_96) AT=875.025n

.meas tran vdout0_97ck1740 FIND v(dout0_97) AT=875.025n

.meas tran vdout0_98ck1740 FIND v(dout0_98) AT=875.025n

.meas tran vdout0_99ck1740 FIND v(dout0_99) AT=875.025n

.meas tran vdout0_100ck1740 FIND v(dout0_100) AT=875.025n

.meas tran vdout0_101ck1740 FIND v(dout0_101) AT=875.025n

.meas tran vdout0_102ck1740 FIND v(dout0_102) AT=875.025n

.meas tran vdout0_103ck1740 FIND v(dout0_103) AT=875.025n

.meas tran vdout0_104ck1740 FIND v(dout0_104) AT=875.025n

.meas tran vdout0_105ck1740 FIND v(dout0_105) AT=875.025n

.meas tran vdout0_106ck1740 FIND v(dout0_106) AT=875.025n

.meas tran vdout0_107ck1740 FIND v(dout0_107) AT=875.025n

.meas tran vdout0_108ck1740 FIND v(dout0_108) AT=875.025n

.meas tran vdout0_109ck1740 FIND v(dout0_109) AT=875.025n

.meas tran vdout0_110ck1740 FIND v(dout0_110) AT=875.025n

.meas tran vdout0_111ck1740 FIND v(dout0_111) AT=875.025n

.meas tran vdout0_112ck1740 FIND v(dout0_112) AT=875.025n

.meas tran vdout0_113ck1740 FIND v(dout0_113) AT=875.025n

.meas tran vdout0_114ck1740 FIND v(dout0_114) AT=875.025n

.meas tran vdout0_115ck1740 FIND v(dout0_115) AT=875.025n

.meas tran vdout0_116ck1740 FIND v(dout0_116) AT=875.025n

.meas tran vdout0_117ck1740 FIND v(dout0_117) AT=875.025n

.meas tran vdout0_118ck1740 FIND v(dout0_118) AT=875.025n

.meas tran vdout0_119ck1740 FIND v(dout0_119) AT=875.025n

.meas tran vdout0_120ck1740 FIND v(dout0_120) AT=875.025n

.meas tran vdout0_121ck1740 FIND v(dout0_121) AT=875.025n

.meas tran vdout0_122ck1740 FIND v(dout0_122) AT=875.025n

.meas tran vdout0_123ck1740 FIND v(dout0_123) AT=875.025n

.meas tran vdout0_124ck1740 FIND v(dout0_124) AT=875.025n

.meas tran vdout0_125ck1740 FIND v(dout0_125) AT=875.025n

.meas tran vdout0_126ck1740 FIND v(dout0_126) AT=875.025n

.meas tran vdout0_127ck1740 FIND v(dout0_127) AT=875.025n

.meas tran vdout0_0ck1870 FIND v(dout0_0) AT=940.025n

.meas tran vdout0_1ck1870 FIND v(dout0_1) AT=940.025n

.meas tran vdout0_2ck1870 FIND v(dout0_2) AT=940.025n

.meas tran vdout0_3ck1870 FIND v(dout0_3) AT=940.025n

.meas tran vdout0_4ck1870 FIND v(dout0_4) AT=940.025n

.meas tran vdout0_5ck1870 FIND v(dout0_5) AT=940.025n

.meas tran vdout0_6ck1870 FIND v(dout0_6) AT=940.025n

.meas tran vdout0_7ck1870 FIND v(dout0_7) AT=940.025n

.meas tran vdout0_8ck1870 FIND v(dout0_8) AT=940.025n

.meas tran vdout0_9ck1870 FIND v(dout0_9) AT=940.025n

.meas tran vdout0_10ck1870 FIND v(dout0_10) AT=940.025n

.meas tran vdout0_11ck1870 FIND v(dout0_11) AT=940.025n

.meas tran vdout0_12ck1870 FIND v(dout0_12) AT=940.025n

.meas tran vdout0_13ck1870 FIND v(dout0_13) AT=940.025n

.meas tran vdout0_14ck1870 FIND v(dout0_14) AT=940.025n

.meas tran vdout0_15ck1870 FIND v(dout0_15) AT=940.025n

.meas tran vdout0_16ck1870 FIND v(dout0_16) AT=940.025n

.meas tran vdout0_17ck1870 FIND v(dout0_17) AT=940.025n

.meas tran vdout0_18ck1870 FIND v(dout0_18) AT=940.025n

.meas tran vdout0_19ck1870 FIND v(dout0_19) AT=940.025n

.meas tran vdout0_20ck1870 FIND v(dout0_20) AT=940.025n

.meas tran vdout0_21ck1870 FIND v(dout0_21) AT=940.025n

.meas tran vdout0_22ck1870 FIND v(dout0_22) AT=940.025n

.meas tran vdout0_23ck1870 FIND v(dout0_23) AT=940.025n

.meas tran vdout0_24ck1870 FIND v(dout0_24) AT=940.025n

.meas tran vdout0_25ck1870 FIND v(dout0_25) AT=940.025n

.meas tran vdout0_26ck1870 FIND v(dout0_26) AT=940.025n

.meas tran vdout0_27ck1870 FIND v(dout0_27) AT=940.025n

.meas tran vdout0_28ck1870 FIND v(dout0_28) AT=940.025n

.meas tran vdout0_29ck1870 FIND v(dout0_29) AT=940.025n

.meas tran vdout0_30ck1870 FIND v(dout0_30) AT=940.025n

.meas tran vdout0_31ck1870 FIND v(dout0_31) AT=940.025n

.meas tran vdout0_32ck1870 FIND v(dout0_32) AT=940.025n

.meas tran vdout0_33ck1870 FIND v(dout0_33) AT=940.025n

.meas tran vdout0_34ck1870 FIND v(dout0_34) AT=940.025n

.meas tran vdout0_35ck1870 FIND v(dout0_35) AT=940.025n

.meas tran vdout0_36ck1870 FIND v(dout0_36) AT=940.025n

.meas tran vdout0_37ck1870 FIND v(dout0_37) AT=940.025n

.meas tran vdout0_38ck1870 FIND v(dout0_38) AT=940.025n

.meas tran vdout0_39ck1870 FIND v(dout0_39) AT=940.025n

.meas tran vdout0_40ck1870 FIND v(dout0_40) AT=940.025n

.meas tran vdout0_41ck1870 FIND v(dout0_41) AT=940.025n

.meas tran vdout0_42ck1870 FIND v(dout0_42) AT=940.025n

.meas tran vdout0_43ck1870 FIND v(dout0_43) AT=940.025n

.meas tran vdout0_44ck1870 FIND v(dout0_44) AT=940.025n

.meas tran vdout0_45ck1870 FIND v(dout0_45) AT=940.025n

.meas tran vdout0_46ck1870 FIND v(dout0_46) AT=940.025n

.meas tran vdout0_47ck1870 FIND v(dout0_47) AT=940.025n

.meas tran vdout0_48ck1870 FIND v(dout0_48) AT=940.025n

.meas tran vdout0_49ck1870 FIND v(dout0_49) AT=940.025n

.meas tran vdout0_50ck1870 FIND v(dout0_50) AT=940.025n

.meas tran vdout0_51ck1870 FIND v(dout0_51) AT=940.025n

.meas tran vdout0_52ck1870 FIND v(dout0_52) AT=940.025n

.meas tran vdout0_53ck1870 FIND v(dout0_53) AT=940.025n

.meas tran vdout0_54ck1870 FIND v(dout0_54) AT=940.025n

.meas tran vdout0_55ck1870 FIND v(dout0_55) AT=940.025n

.meas tran vdout0_56ck1870 FIND v(dout0_56) AT=940.025n

.meas tran vdout0_57ck1870 FIND v(dout0_57) AT=940.025n

.meas tran vdout0_58ck1870 FIND v(dout0_58) AT=940.025n

.meas tran vdout0_59ck1870 FIND v(dout0_59) AT=940.025n

.meas tran vdout0_60ck1870 FIND v(dout0_60) AT=940.025n

.meas tran vdout0_61ck1870 FIND v(dout0_61) AT=940.025n

.meas tran vdout0_62ck1870 FIND v(dout0_62) AT=940.025n

.meas tran vdout0_63ck1870 FIND v(dout0_63) AT=940.025n

.meas tran vdout0_64ck1870 FIND v(dout0_64) AT=940.025n

.meas tran vdout0_65ck1870 FIND v(dout0_65) AT=940.025n

.meas tran vdout0_66ck1870 FIND v(dout0_66) AT=940.025n

.meas tran vdout0_67ck1870 FIND v(dout0_67) AT=940.025n

.meas tran vdout0_68ck1870 FIND v(dout0_68) AT=940.025n

.meas tran vdout0_69ck1870 FIND v(dout0_69) AT=940.025n

.meas tran vdout0_70ck1870 FIND v(dout0_70) AT=940.025n

.meas tran vdout0_71ck1870 FIND v(dout0_71) AT=940.025n

.meas tran vdout0_72ck1870 FIND v(dout0_72) AT=940.025n

.meas tran vdout0_73ck1870 FIND v(dout0_73) AT=940.025n

.meas tran vdout0_74ck1870 FIND v(dout0_74) AT=940.025n

.meas tran vdout0_75ck1870 FIND v(dout0_75) AT=940.025n

.meas tran vdout0_76ck1870 FIND v(dout0_76) AT=940.025n

.meas tran vdout0_77ck1870 FIND v(dout0_77) AT=940.025n

.meas tran vdout0_78ck1870 FIND v(dout0_78) AT=940.025n

.meas tran vdout0_79ck1870 FIND v(dout0_79) AT=940.025n

.meas tran vdout0_80ck1870 FIND v(dout0_80) AT=940.025n

.meas tran vdout0_81ck1870 FIND v(dout0_81) AT=940.025n

.meas tran vdout0_82ck1870 FIND v(dout0_82) AT=940.025n

.meas tran vdout0_83ck1870 FIND v(dout0_83) AT=940.025n

.meas tran vdout0_84ck1870 FIND v(dout0_84) AT=940.025n

.meas tran vdout0_85ck1870 FIND v(dout0_85) AT=940.025n

.meas tran vdout0_86ck1870 FIND v(dout0_86) AT=940.025n

.meas tran vdout0_87ck1870 FIND v(dout0_87) AT=940.025n

.meas tran vdout0_88ck1870 FIND v(dout0_88) AT=940.025n

.meas tran vdout0_89ck1870 FIND v(dout0_89) AT=940.025n

.meas tran vdout0_90ck1870 FIND v(dout0_90) AT=940.025n

.meas tran vdout0_91ck1870 FIND v(dout0_91) AT=940.025n

.meas tran vdout0_92ck1870 FIND v(dout0_92) AT=940.025n

.meas tran vdout0_93ck1870 FIND v(dout0_93) AT=940.025n

.meas tran vdout0_94ck1870 FIND v(dout0_94) AT=940.025n

.meas tran vdout0_95ck1870 FIND v(dout0_95) AT=940.025n

.meas tran vdout0_96ck1870 FIND v(dout0_96) AT=940.025n

.meas tran vdout0_97ck1870 FIND v(dout0_97) AT=940.025n

.meas tran vdout0_98ck1870 FIND v(dout0_98) AT=940.025n

.meas tran vdout0_99ck1870 FIND v(dout0_99) AT=940.025n

.meas tran vdout0_100ck1870 FIND v(dout0_100) AT=940.025n

.meas tran vdout0_101ck1870 FIND v(dout0_101) AT=940.025n

.meas tran vdout0_102ck1870 FIND v(dout0_102) AT=940.025n

.meas tran vdout0_103ck1870 FIND v(dout0_103) AT=940.025n

.meas tran vdout0_104ck1870 FIND v(dout0_104) AT=940.025n

.meas tran vdout0_105ck1870 FIND v(dout0_105) AT=940.025n

.meas tran vdout0_106ck1870 FIND v(dout0_106) AT=940.025n

.meas tran vdout0_107ck1870 FIND v(dout0_107) AT=940.025n

.meas tran vdout0_108ck1870 FIND v(dout0_108) AT=940.025n

.meas tran vdout0_109ck1870 FIND v(dout0_109) AT=940.025n

.meas tran vdout0_110ck1870 FIND v(dout0_110) AT=940.025n

.meas tran vdout0_111ck1870 FIND v(dout0_111) AT=940.025n

.meas tran vdout0_112ck1870 FIND v(dout0_112) AT=940.025n

.meas tran vdout0_113ck1870 FIND v(dout0_113) AT=940.025n

.meas tran vdout0_114ck1870 FIND v(dout0_114) AT=940.025n

.meas tran vdout0_115ck1870 FIND v(dout0_115) AT=940.025n

.meas tran vdout0_116ck1870 FIND v(dout0_116) AT=940.025n

.meas tran vdout0_117ck1870 FIND v(dout0_117) AT=940.025n

.meas tran vdout0_118ck1870 FIND v(dout0_118) AT=940.025n

.meas tran vdout0_119ck1870 FIND v(dout0_119) AT=940.025n

.meas tran vdout0_120ck1870 FIND v(dout0_120) AT=940.025n

.meas tran vdout0_121ck1870 FIND v(dout0_121) AT=940.025n

.meas tran vdout0_122ck1870 FIND v(dout0_122) AT=940.025n

.meas tran vdout0_123ck1870 FIND v(dout0_123) AT=940.025n

.meas tran vdout0_124ck1870 FIND v(dout0_124) AT=940.025n

.meas tran vdout0_125ck1870 FIND v(dout0_125) AT=940.025n

.meas tran vdout0_126ck1870 FIND v(dout0_126) AT=940.025n

.meas tran vdout0_127ck1870 FIND v(dout0_127) AT=940.025n

.meas tran vdout0_0ck1890 FIND v(dout0_0) AT=950.025n

.meas tran vdout0_1ck1890 FIND v(dout0_1) AT=950.025n

.meas tran vdout0_2ck1890 FIND v(dout0_2) AT=950.025n

.meas tran vdout0_3ck1890 FIND v(dout0_3) AT=950.025n

.meas tran vdout0_4ck1890 FIND v(dout0_4) AT=950.025n

.meas tran vdout0_5ck1890 FIND v(dout0_5) AT=950.025n

.meas tran vdout0_6ck1890 FIND v(dout0_6) AT=950.025n

.meas tran vdout0_7ck1890 FIND v(dout0_7) AT=950.025n

.meas tran vdout0_8ck1890 FIND v(dout0_8) AT=950.025n

.meas tran vdout0_9ck1890 FIND v(dout0_9) AT=950.025n

.meas tran vdout0_10ck1890 FIND v(dout0_10) AT=950.025n

.meas tran vdout0_11ck1890 FIND v(dout0_11) AT=950.025n

.meas tran vdout0_12ck1890 FIND v(dout0_12) AT=950.025n

.meas tran vdout0_13ck1890 FIND v(dout0_13) AT=950.025n

.meas tran vdout0_14ck1890 FIND v(dout0_14) AT=950.025n

.meas tran vdout0_15ck1890 FIND v(dout0_15) AT=950.025n

.meas tran vdout0_16ck1890 FIND v(dout0_16) AT=950.025n

.meas tran vdout0_17ck1890 FIND v(dout0_17) AT=950.025n

.meas tran vdout0_18ck1890 FIND v(dout0_18) AT=950.025n

.meas tran vdout0_19ck1890 FIND v(dout0_19) AT=950.025n

.meas tran vdout0_20ck1890 FIND v(dout0_20) AT=950.025n

.meas tran vdout0_21ck1890 FIND v(dout0_21) AT=950.025n

.meas tran vdout0_22ck1890 FIND v(dout0_22) AT=950.025n

.meas tran vdout0_23ck1890 FIND v(dout0_23) AT=950.025n

.meas tran vdout0_24ck1890 FIND v(dout0_24) AT=950.025n

.meas tran vdout0_25ck1890 FIND v(dout0_25) AT=950.025n

.meas tran vdout0_26ck1890 FIND v(dout0_26) AT=950.025n

.meas tran vdout0_27ck1890 FIND v(dout0_27) AT=950.025n

.meas tran vdout0_28ck1890 FIND v(dout0_28) AT=950.025n

.meas tran vdout0_29ck1890 FIND v(dout0_29) AT=950.025n

.meas tran vdout0_30ck1890 FIND v(dout0_30) AT=950.025n

.meas tran vdout0_31ck1890 FIND v(dout0_31) AT=950.025n

.meas tran vdout0_32ck1890 FIND v(dout0_32) AT=950.025n

.meas tran vdout0_33ck1890 FIND v(dout0_33) AT=950.025n

.meas tran vdout0_34ck1890 FIND v(dout0_34) AT=950.025n

.meas tran vdout0_35ck1890 FIND v(dout0_35) AT=950.025n

.meas tran vdout0_36ck1890 FIND v(dout0_36) AT=950.025n

.meas tran vdout0_37ck1890 FIND v(dout0_37) AT=950.025n

.meas tran vdout0_38ck1890 FIND v(dout0_38) AT=950.025n

.meas tran vdout0_39ck1890 FIND v(dout0_39) AT=950.025n

.meas tran vdout0_40ck1890 FIND v(dout0_40) AT=950.025n

.meas tran vdout0_41ck1890 FIND v(dout0_41) AT=950.025n

.meas tran vdout0_42ck1890 FIND v(dout0_42) AT=950.025n

.meas tran vdout0_43ck1890 FIND v(dout0_43) AT=950.025n

.meas tran vdout0_44ck1890 FIND v(dout0_44) AT=950.025n

.meas tran vdout0_45ck1890 FIND v(dout0_45) AT=950.025n

.meas tran vdout0_46ck1890 FIND v(dout0_46) AT=950.025n

.meas tran vdout0_47ck1890 FIND v(dout0_47) AT=950.025n

.meas tran vdout0_48ck1890 FIND v(dout0_48) AT=950.025n

.meas tran vdout0_49ck1890 FIND v(dout0_49) AT=950.025n

.meas tran vdout0_50ck1890 FIND v(dout0_50) AT=950.025n

.meas tran vdout0_51ck1890 FIND v(dout0_51) AT=950.025n

.meas tran vdout0_52ck1890 FIND v(dout0_52) AT=950.025n

.meas tran vdout0_53ck1890 FIND v(dout0_53) AT=950.025n

.meas tran vdout0_54ck1890 FIND v(dout0_54) AT=950.025n

.meas tran vdout0_55ck1890 FIND v(dout0_55) AT=950.025n

.meas tran vdout0_56ck1890 FIND v(dout0_56) AT=950.025n

.meas tran vdout0_57ck1890 FIND v(dout0_57) AT=950.025n

.meas tran vdout0_58ck1890 FIND v(dout0_58) AT=950.025n

.meas tran vdout0_59ck1890 FIND v(dout0_59) AT=950.025n

.meas tran vdout0_60ck1890 FIND v(dout0_60) AT=950.025n

.meas tran vdout0_61ck1890 FIND v(dout0_61) AT=950.025n

.meas tran vdout0_62ck1890 FIND v(dout0_62) AT=950.025n

.meas tran vdout0_63ck1890 FIND v(dout0_63) AT=950.025n

.meas tran vdout0_64ck1890 FIND v(dout0_64) AT=950.025n

.meas tran vdout0_65ck1890 FIND v(dout0_65) AT=950.025n

.meas tran vdout0_66ck1890 FIND v(dout0_66) AT=950.025n

.meas tran vdout0_67ck1890 FIND v(dout0_67) AT=950.025n

.meas tran vdout0_68ck1890 FIND v(dout0_68) AT=950.025n

.meas tran vdout0_69ck1890 FIND v(dout0_69) AT=950.025n

.meas tran vdout0_70ck1890 FIND v(dout0_70) AT=950.025n

.meas tran vdout0_71ck1890 FIND v(dout0_71) AT=950.025n

.meas tran vdout0_72ck1890 FIND v(dout0_72) AT=950.025n

.meas tran vdout0_73ck1890 FIND v(dout0_73) AT=950.025n

.meas tran vdout0_74ck1890 FIND v(dout0_74) AT=950.025n

.meas tran vdout0_75ck1890 FIND v(dout0_75) AT=950.025n

.meas tran vdout0_76ck1890 FIND v(dout0_76) AT=950.025n

.meas tran vdout0_77ck1890 FIND v(dout0_77) AT=950.025n

.meas tran vdout0_78ck1890 FIND v(dout0_78) AT=950.025n

.meas tran vdout0_79ck1890 FIND v(dout0_79) AT=950.025n

.meas tran vdout0_80ck1890 FIND v(dout0_80) AT=950.025n

.meas tran vdout0_81ck1890 FIND v(dout0_81) AT=950.025n

.meas tran vdout0_82ck1890 FIND v(dout0_82) AT=950.025n

.meas tran vdout0_83ck1890 FIND v(dout0_83) AT=950.025n

.meas tran vdout0_84ck1890 FIND v(dout0_84) AT=950.025n

.meas tran vdout0_85ck1890 FIND v(dout0_85) AT=950.025n

.meas tran vdout0_86ck1890 FIND v(dout0_86) AT=950.025n

.meas tran vdout0_87ck1890 FIND v(dout0_87) AT=950.025n

.meas tran vdout0_88ck1890 FIND v(dout0_88) AT=950.025n

.meas tran vdout0_89ck1890 FIND v(dout0_89) AT=950.025n

.meas tran vdout0_90ck1890 FIND v(dout0_90) AT=950.025n

.meas tran vdout0_91ck1890 FIND v(dout0_91) AT=950.025n

.meas tran vdout0_92ck1890 FIND v(dout0_92) AT=950.025n

.meas tran vdout0_93ck1890 FIND v(dout0_93) AT=950.025n

.meas tran vdout0_94ck1890 FIND v(dout0_94) AT=950.025n

.meas tran vdout0_95ck1890 FIND v(dout0_95) AT=950.025n

.meas tran vdout0_96ck1890 FIND v(dout0_96) AT=950.025n

.meas tran vdout0_97ck1890 FIND v(dout0_97) AT=950.025n

.meas tran vdout0_98ck1890 FIND v(dout0_98) AT=950.025n

.meas tran vdout0_99ck1890 FIND v(dout0_99) AT=950.025n

.meas tran vdout0_100ck1890 FIND v(dout0_100) AT=950.025n

.meas tran vdout0_101ck1890 FIND v(dout0_101) AT=950.025n

.meas tran vdout0_102ck1890 FIND v(dout0_102) AT=950.025n

.meas tran vdout0_103ck1890 FIND v(dout0_103) AT=950.025n

.meas tran vdout0_104ck1890 FIND v(dout0_104) AT=950.025n

.meas tran vdout0_105ck1890 FIND v(dout0_105) AT=950.025n

.meas tran vdout0_106ck1890 FIND v(dout0_106) AT=950.025n

.meas tran vdout0_107ck1890 FIND v(dout0_107) AT=950.025n

.meas tran vdout0_108ck1890 FIND v(dout0_108) AT=950.025n

.meas tran vdout0_109ck1890 FIND v(dout0_109) AT=950.025n

.meas tran vdout0_110ck1890 FIND v(dout0_110) AT=950.025n

.meas tran vdout0_111ck1890 FIND v(dout0_111) AT=950.025n

.meas tran vdout0_112ck1890 FIND v(dout0_112) AT=950.025n

.meas tran vdout0_113ck1890 FIND v(dout0_113) AT=950.025n

.meas tran vdout0_114ck1890 FIND v(dout0_114) AT=950.025n

.meas tran vdout0_115ck1890 FIND v(dout0_115) AT=950.025n

.meas tran vdout0_116ck1890 FIND v(dout0_116) AT=950.025n

.meas tran vdout0_117ck1890 FIND v(dout0_117) AT=950.025n

.meas tran vdout0_118ck1890 FIND v(dout0_118) AT=950.025n

.meas tran vdout0_119ck1890 FIND v(dout0_119) AT=950.025n

.meas tran vdout0_120ck1890 FIND v(dout0_120) AT=950.025n

.meas tran vdout0_121ck1890 FIND v(dout0_121) AT=950.025n

.meas tran vdout0_122ck1890 FIND v(dout0_122) AT=950.025n

.meas tran vdout0_123ck1890 FIND v(dout0_123) AT=950.025n

.meas tran vdout0_124ck1890 FIND v(dout0_124) AT=950.025n

.meas tran vdout0_125ck1890 FIND v(dout0_125) AT=950.025n

.meas tran vdout0_126ck1890 FIND v(dout0_126) AT=950.025n

.meas tran vdout0_127ck1890 FIND v(dout0_127) AT=950.025n

.meas tran vdout0_0ck1900 FIND v(dout0_0) AT=955.025n

.meas tran vdout0_1ck1900 FIND v(dout0_1) AT=955.025n

.meas tran vdout0_2ck1900 FIND v(dout0_2) AT=955.025n

.meas tran vdout0_3ck1900 FIND v(dout0_3) AT=955.025n

.meas tran vdout0_4ck1900 FIND v(dout0_4) AT=955.025n

.meas tran vdout0_5ck1900 FIND v(dout0_5) AT=955.025n

.meas tran vdout0_6ck1900 FIND v(dout0_6) AT=955.025n

.meas tran vdout0_7ck1900 FIND v(dout0_7) AT=955.025n

.meas tran vdout0_8ck1900 FIND v(dout0_8) AT=955.025n

.meas tran vdout0_9ck1900 FIND v(dout0_9) AT=955.025n

.meas tran vdout0_10ck1900 FIND v(dout0_10) AT=955.025n

.meas tran vdout0_11ck1900 FIND v(dout0_11) AT=955.025n

.meas tran vdout0_12ck1900 FIND v(dout0_12) AT=955.025n

.meas tran vdout0_13ck1900 FIND v(dout0_13) AT=955.025n

.meas tran vdout0_14ck1900 FIND v(dout0_14) AT=955.025n

.meas tran vdout0_15ck1900 FIND v(dout0_15) AT=955.025n

.meas tran vdout0_16ck1900 FIND v(dout0_16) AT=955.025n

.meas tran vdout0_17ck1900 FIND v(dout0_17) AT=955.025n

.meas tran vdout0_18ck1900 FIND v(dout0_18) AT=955.025n

.meas tran vdout0_19ck1900 FIND v(dout0_19) AT=955.025n

.meas tran vdout0_20ck1900 FIND v(dout0_20) AT=955.025n

.meas tran vdout0_21ck1900 FIND v(dout0_21) AT=955.025n

.meas tran vdout0_22ck1900 FIND v(dout0_22) AT=955.025n

.meas tran vdout0_23ck1900 FIND v(dout0_23) AT=955.025n

.meas tran vdout0_24ck1900 FIND v(dout0_24) AT=955.025n

.meas tran vdout0_25ck1900 FIND v(dout0_25) AT=955.025n

.meas tran vdout0_26ck1900 FIND v(dout0_26) AT=955.025n

.meas tran vdout0_27ck1900 FIND v(dout0_27) AT=955.025n

.meas tran vdout0_28ck1900 FIND v(dout0_28) AT=955.025n

.meas tran vdout0_29ck1900 FIND v(dout0_29) AT=955.025n

.meas tran vdout0_30ck1900 FIND v(dout0_30) AT=955.025n

.meas tran vdout0_31ck1900 FIND v(dout0_31) AT=955.025n

.meas tran vdout0_32ck1900 FIND v(dout0_32) AT=955.025n

.meas tran vdout0_33ck1900 FIND v(dout0_33) AT=955.025n

.meas tran vdout0_34ck1900 FIND v(dout0_34) AT=955.025n

.meas tran vdout0_35ck1900 FIND v(dout0_35) AT=955.025n

.meas tran vdout0_36ck1900 FIND v(dout0_36) AT=955.025n

.meas tran vdout0_37ck1900 FIND v(dout0_37) AT=955.025n

.meas tran vdout0_38ck1900 FIND v(dout0_38) AT=955.025n

.meas tran vdout0_39ck1900 FIND v(dout0_39) AT=955.025n

.meas tran vdout0_40ck1900 FIND v(dout0_40) AT=955.025n

.meas tran vdout0_41ck1900 FIND v(dout0_41) AT=955.025n

.meas tran vdout0_42ck1900 FIND v(dout0_42) AT=955.025n

.meas tran vdout0_43ck1900 FIND v(dout0_43) AT=955.025n

.meas tran vdout0_44ck1900 FIND v(dout0_44) AT=955.025n

.meas tran vdout0_45ck1900 FIND v(dout0_45) AT=955.025n

.meas tran vdout0_46ck1900 FIND v(dout0_46) AT=955.025n

.meas tran vdout0_47ck1900 FIND v(dout0_47) AT=955.025n

.meas tran vdout0_48ck1900 FIND v(dout0_48) AT=955.025n

.meas tran vdout0_49ck1900 FIND v(dout0_49) AT=955.025n

.meas tran vdout0_50ck1900 FIND v(dout0_50) AT=955.025n

.meas tran vdout0_51ck1900 FIND v(dout0_51) AT=955.025n

.meas tran vdout0_52ck1900 FIND v(dout0_52) AT=955.025n

.meas tran vdout0_53ck1900 FIND v(dout0_53) AT=955.025n

.meas tran vdout0_54ck1900 FIND v(dout0_54) AT=955.025n

.meas tran vdout0_55ck1900 FIND v(dout0_55) AT=955.025n

.meas tran vdout0_56ck1900 FIND v(dout0_56) AT=955.025n

.meas tran vdout0_57ck1900 FIND v(dout0_57) AT=955.025n

.meas tran vdout0_58ck1900 FIND v(dout0_58) AT=955.025n

.meas tran vdout0_59ck1900 FIND v(dout0_59) AT=955.025n

.meas tran vdout0_60ck1900 FIND v(dout0_60) AT=955.025n

.meas tran vdout0_61ck1900 FIND v(dout0_61) AT=955.025n

.meas tran vdout0_62ck1900 FIND v(dout0_62) AT=955.025n

.meas tran vdout0_63ck1900 FIND v(dout0_63) AT=955.025n

.meas tran vdout0_64ck1900 FIND v(dout0_64) AT=955.025n

.meas tran vdout0_65ck1900 FIND v(dout0_65) AT=955.025n

.meas tran vdout0_66ck1900 FIND v(dout0_66) AT=955.025n

.meas tran vdout0_67ck1900 FIND v(dout0_67) AT=955.025n

.meas tran vdout0_68ck1900 FIND v(dout0_68) AT=955.025n

.meas tran vdout0_69ck1900 FIND v(dout0_69) AT=955.025n

.meas tran vdout0_70ck1900 FIND v(dout0_70) AT=955.025n

.meas tran vdout0_71ck1900 FIND v(dout0_71) AT=955.025n

.meas tran vdout0_72ck1900 FIND v(dout0_72) AT=955.025n

.meas tran vdout0_73ck1900 FIND v(dout0_73) AT=955.025n

.meas tran vdout0_74ck1900 FIND v(dout0_74) AT=955.025n

.meas tran vdout0_75ck1900 FIND v(dout0_75) AT=955.025n

.meas tran vdout0_76ck1900 FIND v(dout0_76) AT=955.025n

.meas tran vdout0_77ck1900 FIND v(dout0_77) AT=955.025n

.meas tran vdout0_78ck1900 FIND v(dout0_78) AT=955.025n

.meas tran vdout0_79ck1900 FIND v(dout0_79) AT=955.025n

.meas tran vdout0_80ck1900 FIND v(dout0_80) AT=955.025n

.meas tran vdout0_81ck1900 FIND v(dout0_81) AT=955.025n

.meas tran vdout0_82ck1900 FIND v(dout0_82) AT=955.025n

.meas tran vdout0_83ck1900 FIND v(dout0_83) AT=955.025n

.meas tran vdout0_84ck1900 FIND v(dout0_84) AT=955.025n

.meas tran vdout0_85ck1900 FIND v(dout0_85) AT=955.025n

.meas tran vdout0_86ck1900 FIND v(dout0_86) AT=955.025n

.meas tran vdout0_87ck1900 FIND v(dout0_87) AT=955.025n

.meas tran vdout0_88ck1900 FIND v(dout0_88) AT=955.025n

.meas tran vdout0_89ck1900 FIND v(dout0_89) AT=955.025n

.meas tran vdout0_90ck1900 FIND v(dout0_90) AT=955.025n

.meas tran vdout0_91ck1900 FIND v(dout0_91) AT=955.025n

.meas tran vdout0_92ck1900 FIND v(dout0_92) AT=955.025n

.meas tran vdout0_93ck1900 FIND v(dout0_93) AT=955.025n

.meas tran vdout0_94ck1900 FIND v(dout0_94) AT=955.025n

.meas tran vdout0_95ck1900 FIND v(dout0_95) AT=955.025n

.meas tran vdout0_96ck1900 FIND v(dout0_96) AT=955.025n

.meas tran vdout0_97ck1900 FIND v(dout0_97) AT=955.025n

.meas tran vdout0_98ck1900 FIND v(dout0_98) AT=955.025n

.meas tran vdout0_99ck1900 FIND v(dout0_99) AT=955.025n

.meas tran vdout0_100ck1900 FIND v(dout0_100) AT=955.025n

.meas tran vdout0_101ck1900 FIND v(dout0_101) AT=955.025n

.meas tran vdout0_102ck1900 FIND v(dout0_102) AT=955.025n

.meas tran vdout0_103ck1900 FIND v(dout0_103) AT=955.025n

.meas tran vdout0_104ck1900 FIND v(dout0_104) AT=955.025n

.meas tran vdout0_105ck1900 FIND v(dout0_105) AT=955.025n

.meas tran vdout0_106ck1900 FIND v(dout0_106) AT=955.025n

.meas tran vdout0_107ck1900 FIND v(dout0_107) AT=955.025n

.meas tran vdout0_108ck1900 FIND v(dout0_108) AT=955.025n

.meas tran vdout0_109ck1900 FIND v(dout0_109) AT=955.025n

.meas tran vdout0_110ck1900 FIND v(dout0_110) AT=955.025n

.meas tran vdout0_111ck1900 FIND v(dout0_111) AT=955.025n

.meas tran vdout0_112ck1900 FIND v(dout0_112) AT=955.025n

.meas tran vdout0_113ck1900 FIND v(dout0_113) AT=955.025n

.meas tran vdout0_114ck1900 FIND v(dout0_114) AT=955.025n

.meas tran vdout0_115ck1900 FIND v(dout0_115) AT=955.025n

.meas tran vdout0_116ck1900 FIND v(dout0_116) AT=955.025n

.meas tran vdout0_117ck1900 FIND v(dout0_117) AT=955.025n

.meas tran vdout0_118ck1900 FIND v(dout0_118) AT=955.025n

.meas tran vdout0_119ck1900 FIND v(dout0_119) AT=955.025n

.meas tran vdout0_120ck1900 FIND v(dout0_120) AT=955.025n

.meas tran vdout0_121ck1900 FIND v(dout0_121) AT=955.025n

.meas tran vdout0_122ck1900 FIND v(dout0_122) AT=955.025n

.meas tran vdout0_123ck1900 FIND v(dout0_123) AT=955.025n

.meas tran vdout0_124ck1900 FIND v(dout0_124) AT=955.025n

.meas tran vdout0_125ck1900 FIND v(dout0_125) AT=955.025n

.meas tran vdout0_126ck1900 FIND v(dout0_126) AT=955.025n

.meas tran vdout0_127ck1900 FIND v(dout0_127) AT=955.025n

.meas tran vdout0_0ck1930 FIND v(dout0_0) AT=970.025n

.meas tran vdout0_1ck1930 FIND v(dout0_1) AT=970.025n

.meas tran vdout0_2ck1930 FIND v(dout0_2) AT=970.025n

.meas tran vdout0_3ck1930 FIND v(dout0_3) AT=970.025n

.meas tran vdout0_4ck1930 FIND v(dout0_4) AT=970.025n

.meas tran vdout0_5ck1930 FIND v(dout0_5) AT=970.025n

.meas tran vdout0_6ck1930 FIND v(dout0_6) AT=970.025n

.meas tran vdout0_7ck1930 FIND v(dout0_7) AT=970.025n

.meas tran vdout0_8ck1930 FIND v(dout0_8) AT=970.025n

.meas tran vdout0_9ck1930 FIND v(dout0_9) AT=970.025n

.meas tran vdout0_10ck1930 FIND v(dout0_10) AT=970.025n

.meas tran vdout0_11ck1930 FIND v(dout0_11) AT=970.025n

.meas tran vdout0_12ck1930 FIND v(dout0_12) AT=970.025n

.meas tran vdout0_13ck1930 FIND v(dout0_13) AT=970.025n

.meas tran vdout0_14ck1930 FIND v(dout0_14) AT=970.025n

.meas tran vdout0_15ck1930 FIND v(dout0_15) AT=970.025n

.meas tran vdout0_16ck1930 FIND v(dout0_16) AT=970.025n

.meas tran vdout0_17ck1930 FIND v(dout0_17) AT=970.025n

.meas tran vdout0_18ck1930 FIND v(dout0_18) AT=970.025n

.meas tran vdout0_19ck1930 FIND v(dout0_19) AT=970.025n

.meas tran vdout0_20ck1930 FIND v(dout0_20) AT=970.025n

.meas tran vdout0_21ck1930 FIND v(dout0_21) AT=970.025n

.meas tran vdout0_22ck1930 FIND v(dout0_22) AT=970.025n

.meas tran vdout0_23ck1930 FIND v(dout0_23) AT=970.025n

.meas tran vdout0_24ck1930 FIND v(dout0_24) AT=970.025n

.meas tran vdout0_25ck1930 FIND v(dout0_25) AT=970.025n

.meas tran vdout0_26ck1930 FIND v(dout0_26) AT=970.025n

.meas tran vdout0_27ck1930 FIND v(dout0_27) AT=970.025n

.meas tran vdout0_28ck1930 FIND v(dout0_28) AT=970.025n

.meas tran vdout0_29ck1930 FIND v(dout0_29) AT=970.025n

.meas tran vdout0_30ck1930 FIND v(dout0_30) AT=970.025n

.meas tran vdout0_31ck1930 FIND v(dout0_31) AT=970.025n

.meas tran vdout0_32ck1930 FIND v(dout0_32) AT=970.025n

.meas tran vdout0_33ck1930 FIND v(dout0_33) AT=970.025n

.meas tran vdout0_34ck1930 FIND v(dout0_34) AT=970.025n

.meas tran vdout0_35ck1930 FIND v(dout0_35) AT=970.025n

.meas tran vdout0_36ck1930 FIND v(dout0_36) AT=970.025n

.meas tran vdout0_37ck1930 FIND v(dout0_37) AT=970.025n

.meas tran vdout0_38ck1930 FIND v(dout0_38) AT=970.025n

.meas tran vdout0_39ck1930 FIND v(dout0_39) AT=970.025n

.meas tran vdout0_40ck1930 FIND v(dout0_40) AT=970.025n

.meas tran vdout0_41ck1930 FIND v(dout0_41) AT=970.025n

.meas tran vdout0_42ck1930 FIND v(dout0_42) AT=970.025n

.meas tran vdout0_43ck1930 FIND v(dout0_43) AT=970.025n

.meas tran vdout0_44ck1930 FIND v(dout0_44) AT=970.025n

.meas tran vdout0_45ck1930 FIND v(dout0_45) AT=970.025n

.meas tran vdout0_46ck1930 FIND v(dout0_46) AT=970.025n

.meas tran vdout0_47ck1930 FIND v(dout0_47) AT=970.025n

.meas tran vdout0_48ck1930 FIND v(dout0_48) AT=970.025n

.meas tran vdout0_49ck1930 FIND v(dout0_49) AT=970.025n

.meas tran vdout0_50ck1930 FIND v(dout0_50) AT=970.025n

.meas tran vdout0_51ck1930 FIND v(dout0_51) AT=970.025n

.meas tran vdout0_52ck1930 FIND v(dout0_52) AT=970.025n

.meas tran vdout0_53ck1930 FIND v(dout0_53) AT=970.025n

.meas tran vdout0_54ck1930 FIND v(dout0_54) AT=970.025n

.meas tran vdout0_55ck1930 FIND v(dout0_55) AT=970.025n

.meas tran vdout0_56ck1930 FIND v(dout0_56) AT=970.025n

.meas tran vdout0_57ck1930 FIND v(dout0_57) AT=970.025n

.meas tran vdout0_58ck1930 FIND v(dout0_58) AT=970.025n

.meas tran vdout0_59ck1930 FIND v(dout0_59) AT=970.025n

.meas tran vdout0_60ck1930 FIND v(dout0_60) AT=970.025n

.meas tran vdout0_61ck1930 FIND v(dout0_61) AT=970.025n

.meas tran vdout0_62ck1930 FIND v(dout0_62) AT=970.025n

.meas tran vdout0_63ck1930 FIND v(dout0_63) AT=970.025n

.meas tran vdout0_64ck1930 FIND v(dout0_64) AT=970.025n

.meas tran vdout0_65ck1930 FIND v(dout0_65) AT=970.025n

.meas tran vdout0_66ck1930 FIND v(dout0_66) AT=970.025n

.meas tran vdout0_67ck1930 FIND v(dout0_67) AT=970.025n

.meas tran vdout0_68ck1930 FIND v(dout0_68) AT=970.025n

.meas tran vdout0_69ck1930 FIND v(dout0_69) AT=970.025n

.meas tran vdout0_70ck1930 FIND v(dout0_70) AT=970.025n

.meas tran vdout0_71ck1930 FIND v(dout0_71) AT=970.025n

.meas tran vdout0_72ck1930 FIND v(dout0_72) AT=970.025n

.meas tran vdout0_73ck1930 FIND v(dout0_73) AT=970.025n

.meas tran vdout0_74ck1930 FIND v(dout0_74) AT=970.025n

.meas tran vdout0_75ck1930 FIND v(dout0_75) AT=970.025n

.meas tran vdout0_76ck1930 FIND v(dout0_76) AT=970.025n

.meas tran vdout0_77ck1930 FIND v(dout0_77) AT=970.025n

.meas tran vdout0_78ck1930 FIND v(dout0_78) AT=970.025n

.meas tran vdout0_79ck1930 FIND v(dout0_79) AT=970.025n

.meas tran vdout0_80ck1930 FIND v(dout0_80) AT=970.025n

.meas tran vdout0_81ck1930 FIND v(dout0_81) AT=970.025n

.meas tran vdout0_82ck1930 FIND v(dout0_82) AT=970.025n

.meas tran vdout0_83ck1930 FIND v(dout0_83) AT=970.025n

.meas tran vdout0_84ck1930 FIND v(dout0_84) AT=970.025n

.meas tran vdout0_85ck1930 FIND v(dout0_85) AT=970.025n

.meas tran vdout0_86ck1930 FIND v(dout0_86) AT=970.025n

.meas tran vdout0_87ck1930 FIND v(dout0_87) AT=970.025n

.meas tran vdout0_88ck1930 FIND v(dout0_88) AT=970.025n

.meas tran vdout0_89ck1930 FIND v(dout0_89) AT=970.025n

.meas tran vdout0_90ck1930 FIND v(dout0_90) AT=970.025n

.meas tran vdout0_91ck1930 FIND v(dout0_91) AT=970.025n

.meas tran vdout0_92ck1930 FIND v(dout0_92) AT=970.025n

.meas tran vdout0_93ck1930 FIND v(dout0_93) AT=970.025n

.meas tran vdout0_94ck1930 FIND v(dout0_94) AT=970.025n

.meas tran vdout0_95ck1930 FIND v(dout0_95) AT=970.025n

.meas tran vdout0_96ck1930 FIND v(dout0_96) AT=970.025n

.meas tran vdout0_97ck1930 FIND v(dout0_97) AT=970.025n

.meas tran vdout0_98ck1930 FIND v(dout0_98) AT=970.025n

.meas tran vdout0_99ck1930 FIND v(dout0_99) AT=970.025n

.meas tran vdout0_100ck1930 FIND v(dout0_100) AT=970.025n

.meas tran vdout0_101ck1930 FIND v(dout0_101) AT=970.025n

.meas tran vdout0_102ck1930 FIND v(dout0_102) AT=970.025n

.meas tran vdout0_103ck1930 FIND v(dout0_103) AT=970.025n

.meas tran vdout0_104ck1930 FIND v(dout0_104) AT=970.025n

.meas tran vdout0_105ck1930 FIND v(dout0_105) AT=970.025n

.meas tran vdout0_106ck1930 FIND v(dout0_106) AT=970.025n

.meas tran vdout0_107ck1930 FIND v(dout0_107) AT=970.025n

.meas tran vdout0_108ck1930 FIND v(dout0_108) AT=970.025n

.meas tran vdout0_109ck1930 FIND v(dout0_109) AT=970.025n

.meas tran vdout0_110ck1930 FIND v(dout0_110) AT=970.025n

.meas tran vdout0_111ck1930 FIND v(dout0_111) AT=970.025n

.meas tran vdout0_112ck1930 FIND v(dout0_112) AT=970.025n

.meas tran vdout0_113ck1930 FIND v(dout0_113) AT=970.025n

.meas tran vdout0_114ck1930 FIND v(dout0_114) AT=970.025n

.meas tran vdout0_115ck1930 FIND v(dout0_115) AT=970.025n

.meas tran vdout0_116ck1930 FIND v(dout0_116) AT=970.025n

.meas tran vdout0_117ck1930 FIND v(dout0_117) AT=970.025n

.meas tran vdout0_118ck1930 FIND v(dout0_118) AT=970.025n

.meas tran vdout0_119ck1930 FIND v(dout0_119) AT=970.025n

.meas tran vdout0_120ck1930 FIND v(dout0_120) AT=970.025n

.meas tran vdout0_121ck1930 FIND v(dout0_121) AT=970.025n

.meas tran vdout0_122ck1930 FIND v(dout0_122) AT=970.025n

.meas tran vdout0_123ck1930 FIND v(dout0_123) AT=970.025n

.meas tran vdout0_124ck1930 FIND v(dout0_124) AT=970.025n

.meas tran vdout0_125ck1930 FIND v(dout0_125) AT=970.025n

.meas tran vdout0_126ck1930 FIND v(dout0_126) AT=970.025n

.meas tran vdout0_127ck1930 FIND v(dout0_127) AT=970.025n

.meas tran vdout0_0ck1960 FIND v(dout0_0) AT=985.025n

.meas tran vdout0_1ck1960 FIND v(dout0_1) AT=985.025n

.meas tran vdout0_2ck1960 FIND v(dout0_2) AT=985.025n

.meas tran vdout0_3ck1960 FIND v(dout0_3) AT=985.025n

.meas tran vdout0_4ck1960 FIND v(dout0_4) AT=985.025n

.meas tran vdout0_5ck1960 FIND v(dout0_5) AT=985.025n

.meas tran vdout0_6ck1960 FIND v(dout0_6) AT=985.025n

.meas tran vdout0_7ck1960 FIND v(dout0_7) AT=985.025n

.meas tran vdout0_8ck1960 FIND v(dout0_8) AT=985.025n

.meas tran vdout0_9ck1960 FIND v(dout0_9) AT=985.025n

.meas tran vdout0_10ck1960 FIND v(dout0_10) AT=985.025n

.meas tran vdout0_11ck1960 FIND v(dout0_11) AT=985.025n

.meas tran vdout0_12ck1960 FIND v(dout0_12) AT=985.025n

.meas tran vdout0_13ck1960 FIND v(dout0_13) AT=985.025n

.meas tran vdout0_14ck1960 FIND v(dout0_14) AT=985.025n

.meas tran vdout0_15ck1960 FIND v(dout0_15) AT=985.025n

.meas tran vdout0_16ck1960 FIND v(dout0_16) AT=985.025n

.meas tran vdout0_17ck1960 FIND v(dout0_17) AT=985.025n

.meas tran vdout0_18ck1960 FIND v(dout0_18) AT=985.025n

.meas tran vdout0_19ck1960 FIND v(dout0_19) AT=985.025n

.meas tran vdout0_20ck1960 FIND v(dout0_20) AT=985.025n

.meas tran vdout0_21ck1960 FIND v(dout0_21) AT=985.025n

.meas tran vdout0_22ck1960 FIND v(dout0_22) AT=985.025n

.meas tran vdout0_23ck1960 FIND v(dout0_23) AT=985.025n

.meas tran vdout0_24ck1960 FIND v(dout0_24) AT=985.025n

.meas tran vdout0_25ck1960 FIND v(dout0_25) AT=985.025n

.meas tran vdout0_26ck1960 FIND v(dout0_26) AT=985.025n

.meas tran vdout0_27ck1960 FIND v(dout0_27) AT=985.025n

.meas tran vdout0_28ck1960 FIND v(dout0_28) AT=985.025n

.meas tran vdout0_29ck1960 FIND v(dout0_29) AT=985.025n

.meas tran vdout0_30ck1960 FIND v(dout0_30) AT=985.025n

.meas tran vdout0_31ck1960 FIND v(dout0_31) AT=985.025n

.meas tran vdout0_32ck1960 FIND v(dout0_32) AT=985.025n

.meas tran vdout0_33ck1960 FIND v(dout0_33) AT=985.025n

.meas tran vdout0_34ck1960 FIND v(dout0_34) AT=985.025n

.meas tran vdout0_35ck1960 FIND v(dout0_35) AT=985.025n

.meas tran vdout0_36ck1960 FIND v(dout0_36) AT=985.025n

.meas tran vdout0_37ck1960 FIND v(dout0_37) AT=985.025n

.meas tran vdout0_38ck1960 FIND v(dout0_38) AT=985.025n

.meas tran vdout0_39ck1960 FIND v(dout0_39) AT=985.025n

.meas tran vdout0_40ck1960 FIND v(dout0_40) AT=985.025n

.meas tran vdout0_41ck1960 FIND v(dout0_41) AT=985.025n

.meas tran vdout0_42ck1960 FIND v(dout0_42) AT=985.025n

.meas tran vdout0_43ck1960 FIND v(dout0_43) AT=985.025n

.meas tran vdout0_44ck1960 FIND v(dout0_44) AT=985.025n

.meas tran vdout0_45ck1960 FIND v(dout0_45) AT=985.025n

.meas tran vdout0_46ck1960 FIND v(dout0_46) AT=985.025n

.meas tran vdout0_47ck1960 FIND v(dout0_47) AT=985.025n

.meas tran vdout0_48ck1960 FIND v(dout0_48) AT=985.025n

.meas tran vdout0_49ck1960 FIND v(dout0_49) AT=985.025n

.meas tran vdout0_50ck1960 FIND v(dout0_50) AT=985.025n

.meas tran vdout0_51ck1960 FIND v(dout0_51) AT=985.025n

.meas tran vdout0_52ck1960 FIND v(dout0_52) AT=985.025n

.meas tran vdout0_53ck1960 FIND v(dout0_53) AT=985.025n

.meas tran vdout0_54ck1960 FIND v(dout0_54) AT=985.025n

.meas tran vdout0_55ck1960 FIND v(dout0_55) AT=985.025n

.meas tran vdout0_56ck1960 FIND v(dout0_56) AT=985.025n

.meas tran vdout0_57ck1960 FIND v(dout0_57) AT=985.025n

.meas tran vdout0_58ck1960 FIND v(dout0_58) AT=985.025n

.meas tran vdout0_59ck1960 FIND v(dout0_59) AT=985.025n

.meas tran vdout0_60ck1960 FIND v(dout0_60) AT=985.025n

.meas tran vdout0_61ck1960 FIND v(dout0_61) AT=985.025n

.meas tran vdout0_62ck1960 FIND v(dout0_62) AT=985.025n

.meas tran vdout0_63ck1960 FIND v(dout0_63) AT=985.025n

.meas tran vdout0_64ck1960 FIND v(dout0_64) AT=985.025n

.meas tran vdout0_65ck1960 FIND v(dout0_65) AT=985.025n

.meas tran vdout0_66ck1960 FIND v(dout0_66) AT=985.025n

.meas tran vdout0_67ck1960 FIND v(dout0_67) AT=985.025n

.meas tran vdout0_68ck1960 FIND v(dout0_68) AT=985.025n

.meas tran vdout0_69ck1960 FIND v(dout0_69) AT=985.025n

.meas tran vdout0_70ck1960 FIND v(dout0_70) AT=985.025n

.meas tran vdout0_71ck1960 FIND v(dout0_71) AT=985.025n

.meas tran vdout0_72ck1960 FIND v(dout0_72) AT=985.025n

.meas tran vdout0_73ck1960 FIND v(dout0_73) AT=985.025n

.meas tran vdout0_74ck1960 FIND v(dout0_74) AT=985.025n

.meas tran vdout0_75ck1960 FIND v(dout0_75) AT=985.025n

.meas tran vdout0_76ck1960 FIND v(dout0_76) AT=985.025n

.meas tran vdout0_77ck1960 FIND v(dout0_77) AT=985.025n

.meas tran vdout0_78ck1960 FIND v(dout0_78) AT=985.025n

.meas tran vdout0_79ck1960 FIND v(dout0_79) AT=985.025n

.meas tran vdout0_80ck1960 FIND v(dout0_80) AT=985.025n

.meas tran vdout0_81ck1960 FIND v(dout0_81) AT=985.025n

.meas tran vdout0_82ck1960 FIND v(dout0_82) AT=985.025n

.meas tran vdout0_83ck1960 FIND v(dout0_83) AT=985.025n

.meas tran vdout0_84ck1960 FIND v(dout0_84) AT=985.025n

.meas tran vdout0_85ck1960 FIND v(dout0_85) AT=985.025n

.meas tran vdout0_86ck1960 FIND v(dout0_86) AT=985.025n

.meas tran vdout0_87ck1960 FIND v(dout0_87) AT=985.025n

.meas tran vdout0_88ck1960 FIND v(dout0_88) AT=985.025n

.meas tran vdout0_89ck1960 FIND v(dout0_89) AT=985.025n

.meas tran vdout0_90ck1960 FIND v(dout0_90) AT=985.025n

.meas tran vdout0_91ck1960 FIND v(dout0_91) AT=985.025n

.meas tran vdout0_92ck1960 FIND v(dout0_92) AT=985.025n

.meas tran vdout0_93ck1960 FIND v(dout0_93) AT=985.025n

.meas tran vdout0_94ck1960 FIND v(dout0_94) AT=985.025n

.meas tran vdout0_95ck1960 FIND v(dout0_95) AT=985.025n

.meas tran vdout0_96ck1960 FIND v(dout0_96) AT=985.025n

.meas tran vdout0_97ck1960 FIND v(dout0_97) AT=985.025n

.meas tran vdout0_98ck1960 FIND v(dout0_98) AT=985.025n

.meas tran vdout0_99ck1960 FIND v(dout0_99) AT=985.025n

.meas tran vdout0_100ck1960 FIND v(dout0_100) AT=985.025n

.meas tran vdout0_101ck1960 FIND v(dout0_101) AT=985.025n

.meas tran vdout0_102ck1960 FIND v(dout0_102) AT=985.025n

.meas tran vdout0_103ck1960 FIND v(dout0_103) AT=985.025n

.meas tran vdout0_104ck1960 FIND v(dout0_104) AT=985.025n

.meas tran vdout0_105ck1960 FIND v(dout0_105) AT=985.025n

.meas tran vdout0_106ck1960 FIND v(dout0_106) AT=985.025n

.meas tran vdout0_107ck1960 FIND v(dout0_107) AT=985.025n

.meas tran vdout0_108ck1960 FIND v(dout0_108) AT=985.025n

.meas tran vdout0_109ck1960 FIND v(dout0_109) AT=985.025n

.meas tran vdout0_110ck1960 FIND v(dout0_110) AT=985.025n

.meas tran vdout0_111ck1960 FIND v(dout0_111) AT=985.025n

.meas tran vdout0_112ck1960 FIND v(dout0_112) AT=985.025n

.meas tran vdout0_113ck1960 FIND v(dout0_113) AT=985.025n

.meas tran vdout0_114ck1960 FIND v(dout0_114) AT=985.025n

.meas tran vdout0_115ck1960 FIND v(dout0_115) AT=985.025n

.meas tran vdout0_116ck1960 FIND v(dout0_116) AT=985.025n

.meas tran vdout0_117ck1960 FIND v(dout0_117) AT=985.025n

.meas tran vdout0_118ck1960 FIND v(dout0_118) AT=985.025n

.meas tran vdout0_119ck1960 FIND v(dout0_119) AT=985.025n

.meas tran vdout0_120ck1960 FIND v(dout0_120) AT=985.025n

.meas tran vdout0_121ck1960 FIND v(dout0_121) AT=985.025n

.meas tran vdout0_122ck1960 FIND v(dout0_122) AT=985.025n

.meas tran vdout0_123ck1960 FIND v(dout0_123) AT=985.025n

.meas tran vdout0_124ck1960 FIND v(dout0_124) AT=985.025n

.meas tran vdout0_125ck1960 FIND v(dout0_125) AT=985.025n

.meas tran vdout0_126ck1960 FIND v(dout0_126) AT=985.025n

.meas tran vdout0_127ck1960 FIND v(dout0_127) AT=985.025n

.meas tran vdout0_0ck2000 FIND v(dout0_0) AT=1005.025n

.meas tran vdout0_1ck2000 FIND v(dout0_1) AT=1005.025n

.meas tran vdout0_2ck2000 FIND v(dout0_2) AT=1005.025n

.meas tran vdout0_3ck2000 FIND v(dout0_3) AT=1005.025n

.meas tran vdout0_4ck2000 FIND v(dout0_4) AT=1005.025n

.meas tran vdout0_5ck2000 FIND v(dout0_5) AT=1005.025n

.meas tran vdout0_6ck2000 FIND v(dout0_6) AT=1005.025n

.meas tran vdout0_7ck2000 FIND v(dout0_7) AT=1005.025n

.meas tran vdout0_8ck2000 FIND v(dout0_8) AT=1005.025n

.meas tran vdout0_9ck2000 FIND v(dout0_9) AT=1005.025n

.meas tran vdout0_10ck2000 FIND v(dout0_10) AT=1005.025n

.meas tran vdout0_11ck2000 FIND v(dout0_11) AT=1005.025n

.meas tran vdout0_12ck2000 FIND v(dout0_12) AT=1005.025n

.meas tran vdout0_13ck2000 FIND v(dout0_13) AT=1005.025n

.meas tran vdout0_14ck2000 FIND v(dout0_14) AT=1005.025n

.meas tran vdout0_15ck2000 FIND v(dout0_15) AT=1005.025n

.meas tran vdout0_16ck2000 FIND v(dout0_16) AT=1005.025n

.meas tran vdout0_17ck2000 FIND v(dout0_17) AT=1005.025n

.meas tran vdout0_18ck2000 FIND v(dout0_18) AT=1005.025n

.meas tran vdout0_19ck2000 FIND v(dout0_19) AT=1005.025n

.meas tran vdout0_20ck2000 FIND v(dout0_20) AT=1005.025n

.meas tran vdout0_21ck2000 FIND v(dout0_21) AT=1005.025n

.meas tran vdout0_22ck2000 FIND v(dout0_22) AT=1005.025n

.meas tran vdout0_23ck2000 FIND v(dout0_23) AT=1005.025n

.meas tran vdout0_24ck2000 FIND v(dout0_24) AT=1005.025n

.meas tran vdout0_25ck2000 FIND v(dout0_25) AT=1005.025n

.meas tran vdout0_26ck2000 FIND v(dout0_26) AT=1005.025n

.meas tran vdout0_27ck2000 FIND v(dout0_27) AT=1005.025n

.meas tran vdout0_28ck2000 FIND v(dout0_28) AT=1005.025n

.meas tran vdout0_29ck2000 FIND v(dout0_29) AT=1005.025n

.meas tran vdout0_30ck2000 FIND v(dout0_30) AT=1005.025n

.meas tran vdout0_31ck2000 FIND v(dout0_31) AT=1005.025n

.meas tran vdout0_32ck2000 FIND v(dout0_32) AT=1005.025n

.meas tran vdout0_33ck2000 FIND v(dout0_33) AT=1005.025n

.meas tran vdout0_34ck2000 FIND v(dout0_34) AT=1005.025n

.meas tran vdout0_35ck2000 FIND v(dout0_35) AT=1005.025n

.meas tran vdout0_36ck2000 FIND v(dout0_36) AT=1005.025n

.meas tran vdout0_37ck2000 FIND v(dout0_37) AT=1005.025n

.meas tran vdout0_38ck2000 FIND v(dout0_38) AT=1005.025n

.meas tran vdout0_39ck2000 FIND v(dout0_39) AT=1005.025n

.meas tran vdout0_40ck2000 FIND v(dout0_40) AT=1005.025n

.meas tran vdout0_41ck2000 FIND v(dout0_41) AT=1005.025n

.meas tran vdout0_42ck2000 FIND v(dout0_42) AT=1005.025n

.meas tran vdout0_43ck2000 FIND v(dout0_43) AT=1005.025n

.meas tran vdout0_44ck2000 FIND v(dout0_44) AT=1005.025n

.meas tran vdout0_45ck2000 FIND v(dout0_45) AT=1005.025n

.meas tran vdout0_46ck2000 FIND v(dout0_46) AT=1005.025n

.meas tran vdout0_47ck2000 FIND v(dout0_47) AT=1005.025n

.meas tran vdout0_48ck2000 FIND v(dout0_48) AT=1005.025n

.meas tran vdout0_49ck2000 FIND v(dout0_49) AT=1005.025n

.meas tran vdout0_50ck2000 FIND v(dout0_50) AT=1005.025n

.meas tran vdout0_51ck2000 FIND v(dout0_51) AT=1005.025n

.meas tran vdout0_52ck2000 FIND v(dout0_52) AT=1005.025n

.meas tran vdout0_53ck2000 FIND v(dout0_53) AT=1005.025n

.meas tran vdout0_54ck2000 FIND v(dout0_54) AT=1005.025n

.meas tran vdout0_55ck2000 FIND v(dout0_55) AT=1005.025n

.meas tran vdout0_56ck2000 FIND v(dout0_56) AT=1005.025n

.meas tran vdout0_57ck2000 FIND v(dout0_57) AT=1005.025n

.meas tran vdout0_58ck2000 FIND v(dout0_58) AT=1005.025n

.meas tran vdout0_59ck2000 FIND v(dout0_59) AT=1005.025n

.meas tran vdout0_60ck2000 FIND v(dout0_60) AT=1005.025n

.meas tran vdout0_61ck2000 FIND v(dout0_61) AT=1005.025n

.meas tran vdout0_62ck2000 FIND v(dout0_62) AT=1005.025n

.meas tran vdout0_63ck2000 FIND v(dout0_63) AT=1005.025n

.meas tran vdout0_64ck2000 FIND v(dout0_64) AT=1005.025n

.meas tran vdout0_65ck2000 FIND v(dout0_65) AT=1005.025n

.meas tran vdout0_66ck2000 FIND v(dout0_66) AT=1005.025n

.meas tran vdout0_67ck2000 FIND v(dout0_67) AT=1005.025n

.meas tran vdout0_68ck2000 FIND v(dout0_68) AT=1005.025n

.meas tran vdout0_69ck2000 FIND v(dout0_69) AT=1005.025n

.meas tran vdout0_70ck2000 FIND v(dout0_70) AT=1005.025n

.meas tran vdout0_71ck2000 FIND v(dout0_71) AT=1005.025n

.meas tran vdout0_72ck2000 FIND v(dout0_72) AT=1005.025n

.meas tran vdout0_73ck2000 FIND v(dout0_73) AT=1005.025n

.meas tran vdout0_74ck2000 FIND v(dout0_74) AT=1005.025n

.meas tran vdout0_75ck2000 FIND v(dout0_75) AT=1005.025n

.meas tran vdout0_76ck2000 FIND v(dout0_76) AT=1005.025n

.meas tran vdout0_77ck2000 FIND v(dout0_77) AT=1005.025n

.meas tran vdout0_78ck2000 FIND v(dout0_78) AT=1005.025n

.meas tran vdout0_79ck2000 FIND v(dout0_79) AT=1005.025n

.meas tran vdout0_80ck2000 FIND v(dout0_80) AT=1005.025n

.meas tran vdout0_81ck2000 FIND v(dout0_81) AT=1005.025n

.meas tran vdout0_82ck2000 FIND v(dout0_82) AT=1005.025n

.meas tran vdout0_83ck2000 FIND v(dout0_83) AT=1005.025n

.meas tran vdout0_84ck2000 FIND v(dout0_84) AT=1005.025n

.meas tran vdout0_85ck2000 FIND v(dout0_85) AT=1005.025n

.meas tran vdout0_86ck2000 FIND v(dout0_86) AT=1005.025n

.meas tran vdout0_87ck2000 FIND v(dout0_87) AT=1005.025n

.meas tran vdout0_88ck2000 FIND v(dout0_88) AT=1005.025n

.meas tran vdout0_89ck2000 FIND v(dout0_89) AT=1005.025n

.meas tran vdout0_90ck2000 FIND v(dout0_90) AT=1005.025n

.meas tran vdout0_91ck2000 FIND v(dout0_91) AT=1005.025n

.meas tran vdout0_92ck2000 FIND v(dout0_92) AT=1005.025n

.meas tran vdout0_93ck2000 FIND v(dout0_93) AT=1005.025n

.meas tran vdout0_94ck2000 FIND v(dout0_94) AT=1005.025n

.meas tran vdout0_95ck2000 FIND v(dout0_95) AT=1005.025n

.meas tran vdout0_96ck2000 FIND v(dout0_96) AT=1005.025n

.meas tran vdout0_97ck2000 FIND v(dout0_97) AT=1005.025n

.meas tran vdout0_98ck2000 FIND v(dout0_98) AT=1005.025n

.meas tran vdout0_99ck2000 FIND v(dout0_99) AT=1005.025n

.meas tran vdout0_100ck2000 FIND v(dout0_100) AT=1005.025n

.meas tran vdout0_101ck2000 FIND v(dout0_101) AT=1005.025n

.meas tran vdout0_102ck2000 FIND v(dout0_102) AT=1005.025n

.meas tran vdout0_103ck2000 FIND v(dout0_103) AT=1005.025n

.meas tran vdout0_104ck2000 FIND v(dout0_104) AT=1005.025n

.meas tran vdout0_105ck2000 FIND v(dout0_105) AT=1005.025n

.meas tran vdout0_106ck2000 FIND v(dout0_106) AT=1005.025n

.meas tran vdout0_107ck2000 FIND v(dout0_107) AT=1005.025n

.meas tran vdout0_108ck2000 FIND v(dout0_108) AT=1005.025n

.meas tran vdout0_109ck2000 FIND v(dout0_109) AT=1005.025n

.meas tran vdout0_110ck2000 FIND v(dout0_110) AT=1005.025n

.meas tran vdout0_111ck2000 FIND v(dout0_111) AT=1005.025n

.meas tran vdout0_112ck2000 FIND v(dout0_112) AT=1005.025n

.meas tran vdout0_113ck2000 FIND v(dout0_113) AT=1005.025n

.meas tran vdout0_114ck2000 FIND v(dout0_114) AT=1005.025n

.meas tran vdout0_115ck2000 FIND v(dout0_115) AT=1005.025n

.meas tran vdout0_116ck2000 FIND v(dout0_116) AT=1005.025n

.meas tran vdout0_117ck2000 FIND v(dout0_117) AT=1005.025n

.meas tran vdout0_118ck2000 FIND v(dout0_118) AT=1005.025n

.meas tran vdout0_119ck2000 FIND v(dout0_119) AT=1005.025n

.meas tran vdout0_120ck2000 FIND v(dout0_120) AT=1005.025n

.meas tran vdout0_121ck2000 FIND v(dout0_121) AT=1005.025n

.meas tran vdout0_122ck2000 FIND v(dout0_122) AT=1005.025n

.meas tran vdout0_123ck2000 FIND v(dout0_123) AT=1005.025n

.meas tran vdout0_124ck2000 FIND v(dout0_124) AT=1005.025n

.meas tran vdout0_125ck2000 FIND v(dout0_125) AT=1005.025n

.meas tran vdout0_126ck2000 FIND v(dout0_126) AT=1005.025n

.meas tran vdout0_127ck2000 FIND v(dout0_127) AT=1005.025n

.meas tran vdout0_0ck2030 FIND v(dout0_0) AT=1020.025n

.meas tran vdout0_1ck2030 FIND v(dout0_1) AT=1020.025n

.meas tran vdout0_2ck2030 FIND v(dout0_2) AT=1020.025n

.meas tran vdout0_3ck2030 FIND v(dout0_3) AT=1020.025n

.meas tran vdout0_4ck2030 FIND v(dout0_4) AT=1020.025n

.meas tran vdout0_5ck2030 FIND v(dout0_5) AT=1020.025n

.meas tran vdout0_6ck2030 FIND v(dout0_6) AT=1020.025n

.meas tran vdout0_7ck2030 FIND v(dout0_7) AT=1020.025n

.meas tran vdout0_8ck2030 FIND v(dout0_8) AT=1020.025n

.meas tran vdout0_9ck2030 FIND v(dout0_9) AT=1020.025n

.meas tran vdout0_10ck2030 FIND v(dout0_10) AT=1020.025n

.meas tran vdout0_11ck2030 FIND v(dout0_11) AT=1020.025n

.meas tran vdout0_12ck2030 FIND v(dout0_12) AT=1020.025n

.meas tran vdout0_13ck2030 FIND v(dout0_13) AT=1020.025n

.meas tran vdout0_14ck2030 FIND v(dout0_14) AT=1020.025n

.meas tran vdout0_15ck2030 FIND v(dout0_15) AT=1020.025n

.meas tran vdout0_16ck2030 FIND v(dout0_16) AT=1020.025n

.meas tran vdout0_17ck2030 FIND v(dout0_17) AT=1020.025n

.meas tran vdout0_18ck2030 FIND v(dout0_18) AT=1020.025n

.meas tran vdout0_19ck2030 FIND v(dout0_19) AT=1020.025n

.meas tran vdout0_20ck2030 FIND v(dout0_20) AT=1020.025n

.meas tran vdout0_21ck2030 FIND v(dout0_21) AT=1020.025n

.meas tran vdout0_22ck2030 FIND v(dout0_22) AT=1020.025n

.meas tran vdout0_23ck2030 FIND v(dout0_23) AT=1020.025n

.meas tran vdout0_24ck2030 FIND v(dout0_24) AT=1020.025n

.meas tran vdout0_25ck2030 FIND v(dout0_25) AT=1020.025n

.meas tran vdout0_26ck2030 FIND v(dout0_26) AT=1020.025n

.meas tran vdout0_27ck2030 FIND v(dout0_27) AT=1020.025n

.meas tran vdout0_28ck2030 FIND v(dout0_28) AT=1020.025n

.meas tran vdout0_29ck2030 FIND v(dout0_29) AT=1020.025n

.meas tran vdout0_30ck2030 FIND v(dout0_30) AT=1020.025n

.meas tran vdout0_31ck2030 FIND v(dout0_31) AT=1020.025n

.meas tran vdout0_32ck2030 FIND v(dout0_32) AT=1020.025n

.meas tran vdout0_33ck2030 FIND v(dout0_33) AT=1020.025n

.meas tran vdout0_34ck2030 FIND v(dout0_34) AT=1020.025n

.meas tran vdout0_35ck2030 FIND v(dout0_35) AT=1020.025n

.meas tran vdout0_36ck2030 FIND v(dout0_36) AT=1020.025n

.meas tran vdout0_37ck2030 FIND v(dout0_37) AT=1020.025n

.meas tran vdout0_38ck2030 FIND v(dout0_38) AT=1020.025n

.meas tran vdout0_39ck2030 FIND v(dout0_39) AT=1020.025n

.meas tran vdout0_40ck2030 FIND v(dout0_40) AT=1020.025n

.meas tran vdout0_41ck2030 FIND v(dout0_41) AT=1020.025n

.meas tran vdout0_42ck2030 FIND v(dout0_42) AT=1020.025n

.meas tran vdout0_43ck2030 FIND v(dout0_43) AT=1020.025n

.meas tran vdout0_44ck2030 FIND v(dout0_44) AT=1020.025n

.meas tran vdout0_45ck2030 FIND v(dout0_45) AT=1020.025n

.meas tran vdout0_46ck2030 FIND v(dout0_46) AT=1020.025n

.meas tran vdout0_47ck2030 FIND v(dout0_47) AT=1020.025n

.meas tran vdout0_48ck2030 FIND v(dout0_48) AT=1020.025n

.meas tran vdout0_49ck2030 FIND v(dout0_49) AT=1020.025n

.meas tran vdout0_50ck2030 FIND v(dout0_50) AT=1020.025n

.meas tran vdout0_51ck2030 FIND v(dout0_51) AT=1020.025n

.meas tran vdout0_52ck2030 FIND v(dout0_52) AT=1020.025n

.meas tran vdout0_53ck2030 FIND v(dout0_53) AT=1020.025n

.meas tran vdout0_54ck2030 FIND v(dout0_54) AT=1020.025n

.meas tran vdout0_55ck2030 FIND v(dout0_55) AT=1020.025n

.meas tran vdout0_56ck2030 FIND v(dout0_56) AT=1020.025n

.meas tran vdout0_57ck2030 FIND v(dout0_57) AT=1020.025n

.meas tran vdout0_58ck2030 FIND v(dout0_58) AT=1020.025n

.meas tran vdout0_59ck2030 FIND v(dout0_59) AT=1020.025n

.meas tran vdout0_60ck2030 FIND v(dout0_60) AT=1020.025n

.meas tran vdout0_61ck2030 FIND v(dout0_61) AT=1020.025n

.meas tran vdout0_62ck2030 FIND v(dout0_62) AT=1020.025n

.meas tran vdout0_63ck2030 FIND v(dout0_63) AT=1020.025n

.meas tran vdout0_64ck2030 FIND v(dout0_64) AT=1020.025n

.meas tran vdout0_65ck2030 FIND v(dout0_65) AT=1020.025n

.meas tran vdout0_66ck2030 FIND v(dout0_66) AT=1020.025n

.meas tran vdout0_67ck2030 FIND v(dout0_67) AT=1020.025n

.meas tran vdout0_68ck2030 FIND v(dout0_68) AT=1020.025n

.meas tran vdout0_69ck2030 FIND v(dout0_69) AT=1020.025n

.meas tran vdout0_70ck2030 FIND v(dout0_70) AT=1020.025n

.meas tran vdout0_71ck2030 FIND v(dout0_71) AT=1020.025n

.meas tran vdout0_72ck2030 FIND v(dout0_72) AT=1020.025n

.meas tran vdout0_73ck2030 FIND v(dout0_73) AT=1020.025n

.meas tran vdout0_74ck2030 FIND v(dout0_74) AT=1020.025n

.meas tran vdout0_75ck2030 FIND v(dout0_75) AT=1020.025n

.meas tran vdout0_76ck2030 FIND v(dout0_76) AT=1020.025n

.meas tran vdout0_77ck2030 FIND v(dout0_77) AT=1020.025n

.meas tran vdout0_78ck2030 FIND v(dout0_78) AT=1020.025n

.meas tran vdout0_79ck2030 FIND v(dout0_79) AT=1020.025n

.meas tran vdout0_80ck2030 FIND v(dout0_80) AT=1020.025n

.meas tran vdout0_81ck2030 FIND v(dout0_81) AT=1020.025n

.meas tran vdout0_82ck2030 FIND v(dout0_82) AT=1020.025n

.meas tran vdout0_83ck2030 FIND v(dout0_83) AT=1020.025n

.meas tran vdout0_84ck2030 FIND v(dout0_84) AT=1020.025n

.meas tran vdout0_85ck2030 FIND v(dout0_85) AT=1020.025n

.meas tran vdout0_86ck2030 FIND v(dout0_86) AT=1020.025n

.meas tran vdout0_87ck2030 FIND v(dout0_87) AT=1020.025n

.meas tran vdout0_88ck2030 FIND v(dout0_88) AT=1020.025n

.meas tran vdout0_89ck2030 FIND v(dout0_89) AT=1020.025n

.meas tran vdout0_90ck2030 FIND v(dout0_90) AT=1020.025n

.meas tran vdout0_91ck2030 FIND v(dout0_91) AT=1020.025n

.meas tran vdout0_92ck2030 FIND v(dout0_92) AT=1020.025n

.meas tran vdout0_93ck2030 FIND v(dout0_93) AT=1020.025n

.meas tran vdout0_94ck2030 FIND v(dout0_94) AT=1020.025n

.meas tran vdout0_95ck2030 FIND v(dout0_95) AT=1020.025n

.meas tran vdout0_96ck2030 FIND v(dout0_96) AT=1020.025n

.meas tran vdout0_97ck2030 FIND v(dout0_97) AT=1020.025n

.meas tran vdout0_98ck2030 FIND v(dout0_98) AT=1020.025n

.meas tran vdout0_99ck2030 FIND v(dout0_99) AT=1020.025n

.meas tran vdout0_100ck2030 FIND v(dout0_100) AT=1020.025n

.meas tran vdout0_101ck2030 FIND v(dout0_101) AT=1020.025n

.meas tran vdout0_102ck2030 FIND v(dout0_102) AT=1020.025n

.meas tran vdout0_103ck2030 FIND v(dout0_103) AT=1020.025n

.meas tran vdout0_104ck2030 FIND v(dout0_104) AT=1020.025n

.meas tran vdout0_105ck2030 FIND v(dout0_105) AT=1020.025n

.meas tran vdout0_106ck2030 FIND v(dout0_106) AT=1020.025n

.meas tran vdout0_107ck2030 FIND v(dout0_107) AT=1020.025n

.meas tran vdout0_108ck2030 FIND v(dout0_108) AT=1020.025n

.meas tran vdout0_109ck2030 FIND v(dout0_109) AT=1020.025n

.meas tran vdout0_110ck2030 FIND v(dout0_110) AT=1020.025n

.meas tran vdout0_111ck2030 FIND v(dout0_111) AT=1020.025n

.meas tran vdout0_112ck2030 FIND v(dout0_112) AT=1020.025n

.meas tran vdout0_113ck2030 FIND v(dout0_113) AT=1020.025n

.meas tran vdout0_114ck2030 FIND v(dout0_114) AT=1020.025n

.meas tran vdout0_115ck2030 FIND v(dout0_115) AT=1020.025n

.meas tran vdout0_116ck2030 FIND v(dout0_116) AT=1020.025n

.meas tran vdout0_117ck2030 FIND v(dout0_117) AT=1020.025n

.meas tran vdout0_118ck2030 FIND v(dout0_118) AT=1020.025n

.meas tran vdout0_119ck2030 FIND v(dout0_119) AT=1020.025n

.meas tran vdout0_120ck2030 FIND v(dout0_120) AT=1020.025n

.meas tran vdout0_121ck2030 FIND v(dout0_121) AT=1020.025n

.meas tran vdout0_122ck2030 FIND v(dout0_122) AT=1020.025n

.meas tran vdout0_123ck2030 FIND v(dout0_123) AT=1020.025n

.meas tran vdout0_124ck2030 FIND v(dout0_124) AT=1020.025n

.meas tran vdout0_125ck2030 FIND v(dout0_125) AT=1020.025n

.meas tran vdout0_126ck2030 FIND v(dout0_126) AT=1020.025n

.meas tran vdout0_127ck2030 FIND v(dout0_127) AT=1020.025n

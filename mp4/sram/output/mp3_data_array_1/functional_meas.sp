.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_0ck60 FIND v(dout0_0) AT=35.025n

.meas tran vdout0_1ck60 FIND v(dout0_1) AT=35.025n

.meas tran vdout0_2ck60 FIND v(dout0_2) AT=35.025n

.meas tran vdout0_3ck60 FIND v(dout0_3) AT=35.025n

.meas tran vdout0_4ck60 FIND v(dout0_4) AT=35.025n

.meas tran vdout0_5ck60 FIND v(dout0_5) AT=35.025n

.meas tran vdout0_6ck60 FIND v(dout0_6) AT=35.025n

.meas tran vdout0_7ck60 FIND v(dout0_7) AT=35.025n

.meas tran vdout0_8ck60 FIND v(dout0_8) AT=35.025n

.meas tran vdout0_9ck60 FIND v(dout0_9) AT=35.025n

.meas tran vdout0_10ck60 FIND v(dout0_10) AT=35.025n

.meas tran vdout0_11ck60 FIND v(dout0_11) AT=35.025n

.meas tran vdout0_12ck60 FIND v(dout0_12) AT=35.025n

.meas tran vdout0_13ck60 FIND v(dout0_13) AT=35.025n

.meas tran vdout0_14ck60 FIND v(dout0_14) AT=35.025n

.meas tran vdout0_15ck60 FIND v(dout0_15) AT=35.025n

.meas tran vdout0_16ck60 FIND v(dout0_16) AT=35.025n

.meas tran vdout0_17ck60 FIND v(dout0_17) AT=35.025n

.meas tran vdout0_18ck60 FIND v(dout0_18) AT=35.025n

.meas tran vdout0_19ck60 FIND v(dout0_19) AT=35.025n

.meas tran vdout0_20ck60 FIND v(dout0_20) AT=35.025n

.meas tran vdout0_21ck60 FIND v(dout0_21) AT=35.025n

.meas tran vdout0_22ck60 FIND v(dout0_22) AT=35.025n

.meas tran vdout0_23ck60 FIND v(dout0_23) AT=35.025n

.meas tran vdout0_24ck60 FIND v(dout0_24) AT=35.025n

.meas tran vdout0_25ck60 FIND v(dout0_25) AT=35.025n

.meas tran vdout0_26ck60 FIND v(dout0_26) AT=35.025n

.meas tran vdout0_27ck60 FIND v(dout0_27) AT=35.025n

.meas tran vdout0_28ck60 FIND v(dout0_28) AT=35.025n

.meas tran vdout0_29ck60 FIND v(dout0_29) AT=35.025n

.meas tran vdout0_30ck60 FIND v(dout0_30) AT=35.025n

.meas tran vdout0_31ck60 FIND v(dout0_31) AT=35.025n

.meas tran vdout0_32ck60 FIND v(dout0_32) AT=35.025n

.meas tran vdout0_33ck60 FIND v(dout0_33) AT=35.025n

.meas tran vdout0_34ck60 FIND v(dout0_34) AT=35.025n

.meas tran vdout0_35ck60 FIND v(dout0_35) AT=35.025n

.meas tran vdout0_36ck60 FIND v(dout0_36) AT=35.025n

.meas tran vdout0_37ck60 FIND v(dout0_37) AT=35.025n

.meas tran vdout0_38ck60 FIND v(dout0_38) AT=35.025n

.meas tran vdout0_39ck60 FIND v(dout0_39) AT=35.025n

.meas tran vdout0_40ck60 FIND v(dout0_40) AT=35.025n

.meas tran vdout0_41ck60 FIND v(dout0_41) AT=35.025n

.meas tran vdout0_42ck60 FIND v(dout0_42) AT=35.025n

.meas tran vdout0_43ck60 FIND v(dout0_43) AT=35.025n

.meas tran vdout0_44ck60 FIND v(dout0_44) AT=35.025n

.meas tran vdout0_45ck60 FIND v(dout0_45) AT=35.025n

.meas tran vdout0_46ck60 FIND v(dout0_46) AT=35.025n

.meas tran vdout0_47ck60 FIND v(dout0_47) AT=35.025n

.meas tran vdout0_48ck60 FIND v(dout0_48) AT=35.025n

.meas tran vdout0_49ck60 FIND v(dout0_49) AT=35.025n

.meas tran vdout0_50ck60 FIND v(dout0_50) AT=35.025n

.meas tran vdout0_51ck60 FIND v(dout0_51) AT=35.025n

.meas tran vdout0_52ck60 FIND v(dout0_52) AT=35.025n

.meas tran vdout0_53ck60 FIND v(dout0_53) AT=35.025n

.meas tran vdout0_54ck60 FIND v(dout0_54) AT=35.025n

.meas tran vdout0_55ck60 FIND v(dout0_55) AT=35.025n

.meas tran vdout0_56ck60 FIND v(dout0_56) AT=35.025n

.meas tran vdout0_57ck60 FIND v(dout0_57) AT=35.025n

.meas tran vdout0_58ck60 FIND v(dout0_58) AT=35.025n

.meas tran vdout0_59ck60 FIND v(dout0_59) AT=35.025n

.meas tran vdout0_60ck60 FIND v(dout0_60) AT=35.025n

.meas tran vdout0_61ck60 FIND v(dout0_61) AT=35.025n

.meas tran vdout0_62ck60 FIND v(dout0_62) AT=35.025n

.meas tran vdout0_63ck60 FIND v(dout0_63) AT=35.025n

.meas tran vdout0_64ck60 FIND v(dout0_64) AT=35.025n

.meas tran vdout0_65ck60 FIND v(dout0_65) AT=35.025n

.meas tran vdout0_66ck60 FIND v(dout0_66) AT=35.025n

.meas tran vdout0_67ck60 FIND v(dout0_67) AT=35.025n

.meas tran vdout0_68ck60 FIND v(dout0_68) AT=35.025n

.meas tran vdout0_69ck60 FIND v(dout0_69) AT=35.025n

.meas tran vdout0_70ck60 FIND v(dout0_70) AT=35.025n

.meas tran vdout0_71ck60 FIND v(dout0_71) AT=35.025n

.meas tran vdout0_72ck60 FIND v(dout0_72) AT=35.025n

.meas tran vdout0_73ck60 FIND v(dout0_73) AT=35.025n

.meas tran vdout0_74ck60 FIND v(dout0_74) AT=35.025n

.meas tran vdout0_75ck60 FIND v(dout0_75) AT=35.025n

.meas tran vdout0_76ck60 FIND v(dout0_76) AT=35.025n

.meas tran vdout0_77ck60 FIND v(dout0_77) AT=35.025n

.meas tran vdout0_78ck60 FIND v(dout0_78) AT=35.025n

.meas tran vdout0_79ck60 FIND v(dout0_79) AT=35.025n

.meas tran vdout0_80ck60 FIND v(dout0_80) AT=35.025n

.meas tran vdout0_81ck60 FIND v(dout0_81) AT=35.025n

.meas tran vdout0_82ck60 FIND v(dout0_82) AT=35.025n

.meas tran vdout0_83ck60 FIND v(dout0_83) AT=35.025n

.meas tran vdout0_84ck60 FIND v(dout0_84) AT=35.025n

.meas tran vdout0_85ck60 FIND v(dout0_85) AT=35.025n

.meas tran vdout0_86ck60 FIND v(dout0_86) AT=35.025n

.meas tran vdout0_87ck60 FIND v(dout0_87) AT=35.025n

.meas tran vdout0_88ck60 FIND v(dout0_88) AT=35.025n

.meas tran vdout0_89ck60 FIND v(dout0_89) AT=35.025n

.meas tran vdout0_90ck60 FIND v(dout0_90) AT=35.025n

.meas tran vdout0_91ck60 FIND v(dout0_91) AT=35.025n

.meas tran vdout0_92ck60 FIND v(dout0_92) AT=35.025n

.meas tran vdout0_93ck60 FIND v(dout0_93) AT=35.025n

.meas tran vdout0_94ck60 FIND v(dout0_94) AT=35.025n

.meas tran vdout0_95ck60 FIND v(dout0_95) AT=35.025n

.meas tran vdout0_96ck60 FIND v(dout0_96) AT=35.025n

.meas tran vdout0_97ck60 FIND v(dout0_97) AT=35.025n

.meas tran vdout0_98ck60 FIND v(dout0_98) AT=35.025n

.meas tran vdout0_99ck60 FIND v(dout0_99) AT=35.025n

.meas tran vdout0_100ck60 FIND v(dout0_100) AT=35.025n

.meas tran vdout0_101ck60 FIND v(dout0_101) AT=35.025n

.meas tran vdout0_102ck60 FIND v(dout0_102) AT=35.025n

.meas tran vdout0_103ck60 FIND v(dout0_103) AT=35.025n

.meas tran vdout0_104ck60 FIND v(dout0_104) AT=35.025n

.meas tran vdout0_105ck60 FIND v(dout0_105) AT=35.025n

.meas tran vdout0_106ck60 FIND v(dout0_106) AT=35.025n

.meas tran vdout0_107ck60 FIND v(dout0_107) AT=35.025n

.meas tran vdout0_108ck60 FIND v(dout0_108) AT=35.025n

.meas tran vdout0_109ck60 FIND v(dout0_109) AT=35.025n

.meas tran vdout0_110ck60 FIND v(dout0_110) AT=35.025n

.meas tran vdout0_111ck60 FIND v(dout0_111) AT=35.025n

.meas tran vdout0_112ck60 FIND v(dout0_112) AT=35.025n

.meas tran vdout0_113ck60 FIND v(dout0_113) AT=35.025n

.meas tran vdout0_114ck60 FIND v(dout0_114) AT=35.025n

.meas tran vdout0_115ck60 FIND v(dout0_115) AT=35.025n

.meas tran vdout0_116ck60 FIND v(dout0_116) AT=35.025n

.meas tran vdout0_117ck60 FIND v(dout0_117) AT=35.025n

.meas tran vdout0_118ck60 FIND v(dout0_118) AT=35.025n

.meas tran vdout0_119ck60 FIND v(dout0_119) AT=35.025n

.meas tran vdout0_120ck60 FIND v(dout0_120) AT=35.025n

.meas tran vdout0_121ck60 FIND v(dout0_121) AT=35.025n

.meas tran vdout0_122ck60 FIND v(dout0_122) AT=35.025n

.meas tran vdout0_123ck60 FIND v(dout0_123) AT=35.025n

.meas tran vdout0_124ck60 FIND v(dout0_124) AT=35.025n

.meas tran vdout0_125ck60 FIND v(dout0_125) AT=35.025n

.meas tran vdout0_126ck60 FIND v(dout0_126) AT=35.025n

.meas tran vdout0_127ck60 FIND v(dout0_127) AT=35.025n

.meas tran vdout0_0ck70 FIND v(dout0_0) AT=40.025n

.meas tran vdout0_1ck70 FIND v(dout0_1) AT=40.025n

.meas tran vdout0_2ck70 FIND v(dout0_2) AT=40.025n

.meas tran vdout0_3ck70 FIND v(dout0_3) AT=40.025n

.meas tran vdout0_4ck70 FIND v(dout0_4) AT=40.025n

.meas tran vdout0_5ck70 FIND v(dout0_5) AT=40.025n

.meas tran vdout0_6ck70 FIND v(dout0_6) AT=40.025n

.meas tran vdout0_7ck70 FIND v(dout0_7) AT=40.025n

.meas tran vdout0_8ck70 FIND v(dout0_8) AT=40.025n

.meas tran vdout0_9ck70 FIND v(dout0_9) AT=40.025n

.meas tran vdout0_10ck70 FIND v(dout0_10) AT=40.025n

.meas tran vdout0_11ck70 FIND v(dout0_11) AT=40.025n

.meas tran vdout0_12ck70 FIND v(dout0_12) AT=40.025n

.meas tran vdout0_13ck70 FIND v(dout0_13) AT=40.025n

.meas tran vdout0_14ck70 FIND v(dout0_14) AT=40.025n

.meas tran vdout0_15ck70 FIND v(dout0_15) AT=40.025n

.meas tran vdout0_16ck70 FIND v(dout0_16) AT=40.025n

.meas tran vdout0_17ck70 FIND v(dout0_17) AT=40.025n

.meas tran vdout0_18ck70 FIND v(dout0_18) AT=40.025n

.meas tran vdout0_19ck70 FIND v(dout0_19) AT=40.025n

.meas tran vdout0_20ck70 FIND v(dout0_20) AT=40.025n

.meas tran vdout0_21ck70 FIND v(dout0_21) AT=40.025n

.meas tran vdout0_22ck70 FIND v(dout0_22) AT=40.025n

.meas tran vdout0_23ck70 FIND v(dout0_23) AT=40.025n

.meas tran vdout0_24ck70 FIND v(dout0_24) AT=40.025n

.meas tran vdout0_25ck70 FIND v(dout0_25) AT=40.025n

.meas tran vdout0_26ck70 FIND v(dout0_26) AT=40.025n

.meas tran vdout0_27ck70 FIND v(dout0_27) AT=40.025n

.meas tran vdout0_28ck70 FIND v(dout0_28) AT=40.025n

.meas tran vdout0_29ck70 FIND v(dout0_29) AT=40.025n

.meas tran vdout0_30ck70 FIND v(dout0_30) AT=40.025n

.meas tran vdout0_31ck70 FIND v(dout0_31) AT=40.025n

.meas tran vdout0_32ck70 FIND v(dout0_32) AT=40.025n

.meas tran vdout0_33ck70 FIND v(dout0_33) AT=40.025n

.meas tran vdout0_34ck70 FIND v(dout0_34) AT=40.025n

.meas tran vdout0_35ck70 FIND v(dout0_35) AT=40.025n

.meas tran vdout0_36ck70 FIND v(dout0_36) AT=40.025n

.meas tran vdout0_37ck70 FIND v(dout0_37) AT=40.025n

.meas tran vdout0_38ck70 FIND v(dout0_38) AT=40.025n

.meas tran vdout0_39ck70 FIND v(dout0_39) AT=40.025n

.meas tran vdout0_40ck70 FIND v(dout0_40) AT=40.025n

.meas tran vdout0_41ck70 FIND v(dout0_41) AT=40.025n

.meas tran vdout0_42ck70 FIND v(dout0_42) AT=40.025n

.meas tran vdout0_43ck70 FIND v(dout0_43) AT=40.025n

.meas tran vdout0_44ck70 FIND v(dout0_44) AT=40.025n

.meas tran vdout0_45ck70 FIND v(dout0_45) AT=40.025n

.meas tran vdout0_46ck70 FIND v(dout0_46) AT=40.025n

.meas tran vdout0_47ck70 FIND v(dout0_47) AT=40.025n

.meas tran vdout0_48ck70 FIND v(dout0_48) AT=40.025n

.meas tran vdout0_49ck70 FIND v(dout0_49) AT=40.025n

.meas tran vdout0_50ck70 FIND v(dout0_50) AT=40.025n

.meas tran vdout0_51ck70 FIND v(dout0_51) AT=40.025n

.meas tran vdout0_52ck70 FIND v(dout0_52) AT=40.025n

.meas tran vdout0_53ck70 FIND v(dout0_53) AT=40.025n

.meas tran vdout0_54ck70 FIND v(dout0_54) AT=40.025n

.meas tran vdout0_55ck70 FIND v(dout0_55) AT=40.025n

.meas tran vdout0_56ck70 FIND v(dout0_56) AT=40.025n

.meas tran vdout0_57ck70 FIND v(dout0_57) AT=40.025n

.meas tran vdout0_58ck70 FIND v(dout0_58) AT=40.025n

.meas tran vdout0_59ck70 FIND v(dout0_59) AT=40.025n

.meas tran vdout0_60ck70 FIND v(dout0_60) AT=40.025n

.meas tran vdout0_61ck70 FIND v(dout0_61) AT=40.025n

.meas tran vdout0_62ck70 FIND v(dout0_62) AT=40.025n

.meas tran vdout0_63ck70 FIND v(dout0_63) AT=40.025n

.meas tran vdout0_64ck70 FIND v(dout0_64) AT=40.025n

.meas tran vdout0_65ck70 FIND v(dout0_65) AT=40.025n

.meas tran vdout0_66ck70 FIND v(dout0_66) AT=40.025n

.meas tran vdout0_67ck70 FIND v(dout0_67) AT=40.025n

.meas tran vdout0_68ck70 FIND v(dout0_68) AT=40.025n

.meas tran vdout0_69ck70 FIND v(dout0_69) AT=40.025n

.meas tran vdout0_70ck70 FIND v(dout0_70) AT=40.025n

.meas tran vdout0_71ck70 FIND v(dout0_71) AT=40.025n

.meas tran vdout0_72ck70 FIND v(dout0_72) AT=40.025n

.meas tran vdout0_73ck70 FIND v(dout0_73) AT=40.025n

.meas tran vdout0_74ck70 FIND v(dout0_74) AT=40.025n

.meas tran vdout0_75ck70 FIND v(dout0_75) AT=40.025n

.meas tran vdout0_76ck70 FIND v(dout0_76) AT=40.025n

.meas tran vdout0_77ck70 FIND v(dout0_77) AT=40.025n

.meas tran vdout0_78ck70 FIND v(dout0_78) AT=40.025n

.meas tran vdout0_79ck70 FIND v(dout0_79) AT=40.025n

.meas tran vdout0_80ck70 FIND v(dout0_80) AT=40.025n

.meas tran vdout0_81ck70 FIND v(dout0_81) AT=40.025n

.meas tran vdout0_82ck70 FIND v(dout0_82) AT=40.025n

.meas tran vdout0_83ck70 FIND v(dout0_83) AT=40.025n

.meas tran vdout0_84ck70 FIND v(dout0_84) AT=40.025n

.meas tran vdout0_85ck70 FIND v(dout0_85) AT=40.025n

.meas tran vdout0_86ck70 FIND v(dout0_86) AT=40.025n

.meas tran vdout0_87ck70 FIND v(dout0_87) AT=40.025n

.meas tran vdout0_88ck70 FIND v(dout0_88) AT=40.025n

.meas tran vdout0_89ck70 FIND v(dout0_89) AT=40.025n

.meas tran vdout0_90ck70 FIND v(dout0_90) AT=40.025n

.meas tran vdout0_91ck70 FIND v(dout0_91) AT=40.025n

.meas tran vdout0_92ck70 FIND v(dout0_92) AT=40.025n

.meas tran vdout0_93ck70 FIND v(dout0_93) AT=40.025n

.meas tran vdout0_94ck70 FIND v(dout0_94) AT=40.025n

.meas tran vdout0_95ck70 FIND v(dout0_95) AT=40.025n

.meas tran vdout0_96ck70 FIND v(dout0_96) AT=40.025n

.meas tran vdout0_97ck70 FIND v(dout0_97) AT=40.025n

.meas tran vdout0_98ck70 FIND v(dout0_98) AT=40.025n

.meas tran vdout0_99ck70 FIND v(dout0_99) AT=40.025n

.meas tran vdout0_100ck70 FIND v(dout0_100) AT=40.025n

.meas tran vdout0_101ck70 FIND v(dout0_101) AT=40.025n

.meas tran vdout0_102ck70 FIND v(dout0_102) AT=40.025n

.meas tran vdout0_103ck70 FIND v(dout0_103) AT=40.025n

.meas tran vdout0_104ck70 FIND v(dout0_104) AT=40.025n

.meas tran vdout0_105ck70 FIND v(dout0_105) AT=40.025n

.meas tran vdout0_106ck70 FIND v(dout0_106) AT=40.025n

.meas tran vdout0_107ck70 FIND v(dout0_107) AT=40.025n

.meas tran vdout0_108ck70 FIND v(dout0_108) AT=40.025n

.meas tran vdout0_109ck70 FIND v(dout0_109) AT=40.025n

.meas tran vdout0_110ck70 FIND v(dout0_110) AT=40.025n

.meas tran vdout0_111ck70 FIND v(dout0_111) AT=40.025n

.meas tran vdout0_112ck70 FIND v(dout0_112) AT=40.025n

.meas tran vdout0_113ck70 FIND v(dout0_113) AT=40.025n

.meas tran vdout0_114ck70 FIND v(dout0_114) AT=40.025n

.meas tran vdout0_115ck70 FIND v(dout0_115) AT=40.025n

.meas tran vdout0_116ck70 FIND v(dout0_116) AT=40.025n

.meas tran vdout0_117ck70 FIND v(dout0_117) AT=40.025n

.meas tran vdout0_118ck70 FIND v(dout0_118) AT=40.025n

.meas tran vdout0_119ck70 FIND v(dout0_119) AT=40.025n

.meas tran vdout0_120ck70 FIND v(dout0_120) AT=40.025n

.meas tran vdout0_121ck70 FIND v(dout0_121) AT=40.025n

.meas tran vdout0_122ck70 FIND v(dout0_122) AT=40.025n

.meas tran vdout0_123ck70 FIND v(dout0_123) AT=40.025n

.meas tran vdout0_124ck70 FIND v(dout0_124) AT=40.025n

.meas tran vdout0_125ck70 FIND v(dout0_125) AT=40.025n

.meas tran vdout0_126ck70 FIND v(dout0_126) AT=40.025n

.meas tran vdout0_127ck70 FIND v(dout0_127) AT=40.025n

.meas tran vdout0_0ck90 FIND v(dout0_0) AT=50.025n

.meas tran vdout0_1ck90 FIND v(dout0_1) AT=50.025n

.meas tran vdout0_2ck90 FIND v(dout0_2) AT=50.025n

.meas tran vdout0_3ck90 FIND v(dout0_3) AT=50.025n

.meas tran vdout0_4ck90 FIND v(dout0_4) AT=50.025n

.meas tran vdout0_5ck90 FIND v(dout0_5) AT=50.025n

.meas tran vdout0_6ck90 FIND v(dout0_6) AT=50.025n

.meas tran vdout0_7ck90 FIND v(dout0_7) AT=50.025n

.meas tran vdout0_8ck90 FIND v(dout0_8) AT=50.025n

.meas tran vdout0_9ck90 FIND v(dout0_9) AT=50.025n

.meas tran vdout0_10ck90 FIND v(dout0_10) AT=50.025n

.meas tran vdout0_11ck90 FIND v(dout0_11) AT=50.025n

.meas tran vdout0_12ck90 FIND v(dout0_12) AT=50.025n

.meas tran vdout0_13ck90 FIND v(dout0_13) AT=50.025n

.meas tran vdout0_14ck90 FIND v(dout0_14) AT=50.025n

.meas tran vdout0_15ck90 FIND v(dout0_15) AT=50.025n

.meas tran vdout0_16ck90 FIND v(dout0_16) AT=50.025n

.meas tran vdout0_17ck90 FIND v(dout0_17) AT=50.025n

.meas tran vdout0_18ck90 FIND v(dout0_18) AT=50.025n

.meas tran vdout0_19ck90 FIND v(dout0_19) AT=50.025n

.meas tran vdout0_20ck90 FIND v(dout0_20) AT=50.025n

.meas tran vdout0_21ck90 FIND v(dout0_21) AT=50.025n

.meas tran vdout0_22ck90 FIND v(dout0_22) AT=50.025n

.meas tran vdout0_23ck90 FIND v(dout0_23) AT=50.025n

.meas tran vdout0_24ck90 FIND v(dout0_24) AT=50.025n

.meas tran vdout0_25ck90 FIND v(dout0_25) AT=50.025n

.meas tran vdout0_26ck90 FIND v(dout0_26) AT=50.025n

.meas tran vdout0_27ck90 FIND v(dout0_27) AT=50.025n

.meas tran vdout0_28ck90 FIND v(dout0_28) AT=50.025n

.meas tran vdout0_29ck90 FIND v(dout0_29) AT=50.025n

.meas tran vdout0_30ck90 FIND v(dout0_30) AT=50.025n

.meas tran vdout0_31ck90 FIND v(dout0_31) AT=50.025n

.meas tran vdout0_32ck90 FIND v(dout0_32) AT=50.025n

.meas tran vdout0_33ck90 FIND v(dout0_33) AT=50.025n

.meas tran vdout0_34ck90 FIND v(dout0_34) AT=50.025n

.meas tran vdout0_35ck90 FIND v(dout0_35) AT=50.025n

.meas tran vdout0_36ck90 FIND v(dout0_36) AT=50.025n

.meas tran vdout0_37ck90 FIND v(dout0_37) AT=50.025n

.meas tran vdout0_38ck90 FIND v(dout0_38) AT=50.025n

.meas tran vdout0_39ck90 FIND v(dout0_39) AT=50.025n

.meas tran vdout0_40ck90 FIND v(dout0_40) AT=50.025n

.meas tran vdout0_41ck90 FIND v(dout0_41) AT=50.025n

.meas tran vdout0_42ck90 FIND v(dout0_42) AT=50.025n

.meas tran vdout0_43ck90 FIND v(dout0_43) AT=50.025n

.meas tran vdout0_44ck90 FIND v(dout0_44) AT=50.025n

.meas tran vdout0_45ck90 FIND v(dout0_45) AT=50.025n

.meas tran vdout0_46ck90 FIND v(dout0_46) AT=50.025n

.meas tran vdout0_47ck90 FIND v(dout0_47) AT=50.025n

.meas tran vdout0_48ck90 FIND v(dout0_48) AT=50.025n

.meas tran vdout0_49ck90 FIND v(dout0_49) AT=50.025n

.meas tran vdout0_50ck90 FIND v(dout0_50) AT=50.025n

.meas tran vdout0_51ck90 FIND v(dout0_51) AT=50.025n

.meas tran vdout0_52ck90 FIND v(dout0_52) AT=50.025n

.meas tran vdout0_53ck90 FIND v(dout0_53) AT=50.025n

.meas tran vdout0_54ck90 FIND v(dout0_54) AT=50.025n

.meas tran vdout0_55ck90 FIND v(dout0_55) AT=50.025n

.meas tran vdout0_56ck90 FIND v(dout0_56) AT=50.025n

.meas tran vdout0_57ck90 FIND v(dout0_57) AT=50.025n

.meas tran vdout0_58ck90 FIND v(dout0_58) AT=50.025n

.meas tran vdout0_59ck90 FIND v(dout0_59) AT=50.025n

.meas tran vdout0_60ck90 FIND v(dout0_60) AT=50.025n

.meas tran vdout0_61ck90 FIND v(dout0_61) AT=50.025n

.meas tran vdout0_62ck90 FIND v(dout0_62) AT=50.025n

.meas tran vdout0_63ck90 FIND v(dout0_63) AT=50.025n

.meas tran vdout0_64ck90 FIND v(dout0_64) AT=50.025n

.meas tran vdout0_65ck90 FIND v(dout0_65) AT=50.025n

.meas tran vdout0_66ck90 FIND v(dout0_66) AT=50.025n

.meas tran vdout0_67ck90 FIND v(dout0_67) AT=50.025n

.meas tran vdout0_68ck90 FIND v(dout0_68) AT=50.025n

.meas tran vdout0_69ck90 FIND v(dout0_69) AT=50.025n

.meas tran vdout0_70ck90 FIND v(dout0_70) AT=50.025n

.meas tran vdout0_71ck90 FIND v(dout0_71) AT=50.025n

.meas tran vdout0_72ck90 FIND v(dout0_72) AT=50.025n

.meas tran vdout0_73ck90 FIND v(dout0_73) AT=50.025n

.meas tran vdout0_74ck90 FIND v(dout0_74) AT=50.025n

.meas tran vdout0_75ck90 FIND v(dout0_75) AT=50.025n

.meas tran vdout0_76ck90 FIND v(dout0_76) AT=50.025n

.meas tran vdout0_77ck90 FIND v(dout0_77) AT=50.025n

.meas tran vdout0_78ck90 FIND v(dout0_78) AT=50.025n

.meas tran vdout0_79ck90 FIND v(dout0_79) AT=50.025n

.meas tran vdout0_80ck90 FIND v(dout0_80) AT=50.025n

.meas tran vdout0_81ck90 FIND v(dout0_81) AT=50.025n

.meas tran vdout0_82ck90 FIND v(dout0_82) AT=50.025n

.meas tran vdout0_83ck90 FIND v(dout0_83) AT=50.025n

.meas tran vdout0_84ck90 FIND v(dout0_84) AT=50.025n

.meas tran vdout0_85ck90 FIND v(dout0_85) AT=50.025n

.meas tran vdout0_86ck90 FIND v(dout0_86) AT=50.025n

.meas tran vdout0_87ck90 FIND v(dout0_87) AT=50.025n

.meas tran vdout0_88ck90 FIND v(dout0_88) AT=50.025n

.meas tran vdout0_89ck90 FIND v(dout0_89) AT=50.025n

.meas tran vdout0_90ck90 FIND v(dout0_90) AT=50.025n

.meas tran vdout0_91ck90 FIND v(dout0_91) AT=50.025n

.meas tran vdout0_92ck90 FIND v(dout0_92) AT=50.025n

.meas tran vdout0_93ck90 FIND v(dout0_93) AT=50.025n

.meas tran vdout0_94ck90 FIND v(dout0_94) AT=50.025n

.meas tran vdout0_95ck90 FIND v(dout0_95) AT=50.025n

.meas tran vdout0_96ck90 FIND v(dout0_96) AT=50.025n

.meas tran vdout0_97ck90 FIND v(dout0_97) AT=50.025n

.meas tran vdout0_98ck90 FIND v(dout0_98) AT=50.025n

.meas tran vdout0_99ck90 FIND v(dout0_99) AT=50.025n

.meas tran vdout0_100ck90 FIND v(dout0_100) AT=50.025n

.meas tran vdout0_101ck90 FIND v(dout0_101) AT=50.025n

.meas tran vdout0_102ck90 FIND v(dout0_102) AT=50.025n

.meas tran vdout0_103ck90 FIND v(dout0_103) AT=50.025n

.meas tran vdout0_104ck90 FIND v(dout0_104) AT=50.025n

.meas tran vdout0_105ck90 FIND v(dout0_105) AT=50.025n

.meas tran vdout0_106ck90 FIND v(dout0_106) AT=50.025n

.meas tran vdout0_107ck90 FIND v(dout0_107) AT=50.025n

.meas tran vdout0_108ck90 FIND v(dout0_108) AT=50.025n

.meas tran vdout0_109ck90 FIND v(dout0_109) AT=50.025n

.meas tran vdout0_110ck90 FIND v(dout0_110) AT=50.025n

.meas tran vdout0_111ck90 FIND v(dout0_111) AT=50.025n

.meas tran vdout0_112ck90 FIND v(dout0_112) AT=50.025n

.meas tran vdout0_113ck90 FIND v(dout0_113) AT=50.025n

.meas tran vdout0_114ck90 FIND v(dout0_114) AT=50.025n

.meas tran vdout0_115ck90 FIND v(dout0_115) AT=50.025n

.meas tran vdout0_116ck90 FIND v(dout0_116) AT=50.025n

.meas tran vdout0_117ck90 FIND v(dout0_117) AT=50.025n

.meas tran vdout0_118ck90 FIND v(dout0_118) AT=50.025n

.meas tran vdout0_119ck90 FIND v(dout0_119) AT=50.025n

.meas tran vdout0_120ck90 FIND v(dout0_120) AT=50.025n

.meas tran vdout0_121ck90 FIND v(dout0_121) AT=50.025n

.meas tran vdout0_122ck90 FIND v(dout0_122) AT=50.025n

.meas tran vdout0_123ck90 FIND v(dout0_123) AT=50.025n

.meas tran vdout0_124ck90 FIND v(dout0_124) AT=50.025n

.meas tran vdout0_125ck90 FIND v(dout0_125) AT=50.025n

.meas tran vdout0_126ck90 FIND v(dout0_126) AT=50.025n

.meas tran vdout0_127ck90 FIND v(dout0_127) AT=50.025n

.meas tran vdout0_0ck110 FIND v(dout0_0) AT=60.025n

.meas tran vdout0_1ck110 FIND v(dout0_1) AT=60.025n

.meas tran vdout0_2ck110 FIND v(dout0_2) AT=60.025n

.meas tran vdout0_3ck110 FIND v(dout0_3) AT=60.025n

.meas tran vdout0_4ck110 FIND v(dout0_4) AT=60.025n

.meas tran vdout0_5ck110 FIND v(dout0_5) AT=60.025n

.meas tran vdout0_6ck110 FIND v(dout0_6) AT=60.025n

.meas tran vdout0_7ck110 FIND v(dout0_7) AT=60.025n

.meas tran vdout0_8ck110 FIND v(dout0_8) AT=60.025n

.meas tran vdout0_9ck110 FIND v(dout0_9) AT=60.025n

.meas tran vdout0_10ck110 FIND v(dout0_10) AT=60.025n

.meas tran vdout0_11ck110 FIND v(dout0_11) AT=60.025n

.meas tran vdout0_12ck110 FIND v(dout0_12) AT=60.025n

.meas tran vdout0_13ck110 FIND v(dout0_13) AT=60.025n

.meas tran vdout0_14ck110 FIND v(dout0_14) AT=60.025n

.meas tran vdout0_15ck110 FIND v(dout0_15) AT=60.025n

.meas tran vdout0_16ck110 FIND v(dout0_16) AT=60.025n

.meas tran vdout0_17ck110 FIND v(dout0_17) AT=60.025n

.meas tran vdout0_18ck110 FIND v(dout0_18) AT=60.025n

.meas tran vdout0_19ck110 FIND v(dout0_19) AT=60.025n

.meas tran vdout0_20ck110 FIND v(dout0_20) AT=60.025n

.meas tran vdout0_21ck110 FIND v(dout0_21) AT=60.025n

.meas tran vdout0_22ck110 FIND v(dout0_22) AT=60.025n

.meas tran vdout0_23ck110 FIND v(dout0_23) AT=60.025n

.meas tran vdout0_24ck110 FIND v(dout0_24) AT=60.025n

.meas tran vdout0_25ck110 FIND v(dout0_25) AT=60.025n

.meas tran vdout0_26ck110 FIND v(dout0_26) AT=60.025n

.meas tran vdout0_27ck110 FIND v(dout0_27) AT=60.025n

.meas tran vdout0_28ck110 FIND v(dout0_28) AT=60.025n

.meas tran vdout0_29ck110 FIND v(dout0_29) AT=60.025n

.meas tran vdout0_30ck110 FIND v(dout0_30) AT=60.025n

.meas tran vdout0_31ck110 FIND v(dout0_31) AT=60.025n

.meas tran vdout0_32ck110 FIND v(dout0_32) AT=60.025n

.meas tran vdout0_33ck110 FIND v(dout0_33) AT=60.025n

.meas tran vdout0_34ck110 FIND v(dout0_34) AT=60.025n

.meas tran vdout0_35ck110 FIND v(dout0_35) AT=60.025n

.meas tran vdout0_36ck110 FIND v(dout0_36) AT=60.025n

.meas tran vdout0_37ck110 FIND v(dout0_37) AT=60.025n

.meas tran vdout0_38ck110 FIND v(dout0_38) AT=60.025n

.meas tran vdout0_39ck110 FIND v(dout0_39) AT=60.025n

.meas tran vdout0_40ck110 FIND v(dout0_40) AT=60.025n

.meas tran vdout0_41ck110 FIND v(dout0_41) AT=60.025n

.meas tran vdout0_42ck110 FIND v(dout0_42) AT=60.025n

.meas tran vdout0_43ck110 FIND v(dout0_43) AT=60.025n

.meas tran vdout0_44ck110 FIND v(dout0_44) AT=60.025n

.meas tran vdout0_45ck110 FIND v(dout0_45) AT=60.025n

.meas tran vdout0_46ck110 FIND v(dout0_46) AT=60.025n

.meas tran vdout0_47ck110 FIND v(dout0_47) AT=60.025n

.meas tran vdout0_48ck110 FIND v(dout0_48) AT=60.025n

.meas tran vdout0_49ck110 FIND v(dout0_49) AT=60.025n

.meas tran vdout0_50ck110 FIND v(dout0_50) AT=60.025n

.meas tran vdout0_51ck110 FIND v(dout0_51) AT=60.025n

.meas tran vdout0_52ck110 FIND v(dout0_52) AT=60.025n

.meas tran vdout0_53ck110 FIND v(dout0_53) AT=60.025n

.meas tran vdout0_54ck110 FIND v(dout0_54) AT=60.025n

.meas tran vdout0_55ck110 FIND v(dout0_55) AT=60.025n

.meas tran vdout0_56ck110 FIND v(dout0_56) AT=60.025n

.meas tran vdout0_57ck110 FIND v(dout0_57) AT=60.025n

.meas tran vdout0_58ck110 FIND v(dout0_58) AT=60.025n

.meas tran vdout0_59ck110 FIND v(dout0_59) AT=60.025n

.meas tran vdout0_60ck110 FIND v(dout0_60) AT=60.025n

.meas tran vdout0_61ck110 FIND v(dout0_61) AT=60.025n

.meas tran vdout0_62ck110 FIND v(dout0_62) AT=60.025n

.meas tran vdout0_63ck110 FIND v(dout0_63) AT=60.025n

.meas tran vdout0_64ck110 FIND v(dout0_64) AT=60.025n

.meas tran vdout0_65ck110 FIND v(dout0_65) AT=60.025n

.meas tran vdout0_66ck110 FIND v(dout0_66) AT=60.025n

.meas tran vdout0_67ck110 FIND v(dout0_67) AT=60.025n

.meas tran vdout0_68ck110 FIND v(dout0_68) AT=60.025n

.meas tran vdout0_69ck110 FIND v(dout0_69) AT=60.025n

.meas tran vdout0_70ck110 FIND v(dout0_70) AT=60.025n

.meas tran vdout0_71ck110 FIND v(dout0_71) AT=60.025n

.meas tran vdout0_72ck110 FIND v(dout0_72) AT=60.025n

.meas tran vdout0_73ck110 FIND v(dout0_73) AT=60.025n

.meas tran vdout0_74ck110 FIND v(dout0_74) AT=60.025n

.meas tran vdout0_75ck110 FIND v(dout0_75) AT=60.025n

.meas tran vdout0_76ck110 FIND v(dout0_76) AT=60.025n

.meas tran vdout0_77ck110 FIND v(dout0_77) AT=60.025n

.meas tran vdout0_78ck110 FIND v(dout0_78) AT=60.025n

.meas tran vdout0_79ck110 FIND v(dout0_79) AT=60.025n

.meas tran vdout0_80ck110 FIND v(dout0_80) AT=60.025n

.meas tran vdout0_81ck110 FIND v(dout0_81) AT=60.025n

.meas tran vdout0_82ck110 FIND v(dout0_82) AT=60.025n

.meas tran vdout0_83ck110 FIND v(dout0_83) AT=60.025n

.meas tran vdout0_84ck110 FIND v(dout0_84) AT=60.025n

.meas tran vdout0_85ck110 FIND v(dout0_85) AT=60.025n

.meas tran vdout0_86ck110 FIND v(dout0_86) AT=60.025n

.meas tran vdout0_87ck110 FIND v(dout0_87) AT=60.025n

.meas tran vdout0_88ck110 FIND v(dout0_88) AT=60.025n

.meas tran vdout0_89ck110 FIND v(dout0_89) AT=60.025n

.meas tran vdout0_90ck110 FIND v(dout0_90) AT=60.025n

.meas tran vdout0_91ck110 FIND v(dout0_91) AT=60.025n

.meas tran vdout0_92ck110 FIND v(dout0_92) AT=60.025n

.meas tran vdout0_93ck110 FIND v(dout0_93) AT=60.025n

.meas tran vdout0_94ck110 FIND v(dout0_94) AT=60.025n

.meas tran vdout0_95ck110 FIND v(dout0_95) AT=60.025n

.meas tran vdout0_96ck110 FIND v(dout0_96) AT=60.025n

.meas tran vdout0_97ck110 FIND v(dout0_97) AT=60.025n

.meas tran vdout0_98ck110 FIND v(dout0_98) AT=60.025n

.meas tran vdout0_99ck110 FIND v(dout0_99) AT=60.025n

.meas tran vdout0_100ck110 FIND v(dout0_100) AT=60.025n

.meas tran vdout0_101ck110 FIND v(dout0_101) AT=60.025n

.meas tran vdout0_102ck110 FIND v(dout0_102) AT=60.025n

.meas tran vdout0_103ck110 FIND v(dout0_103) AT=60.025n

.meas tran vdout0_104ck110 FIND v(dout0_104) AT=60.025n

.meas tran vdout0_105ck110 FIND v(dout0_105) AT=60.025n

.meas tran vdout0_106ck110 FIND v(dout0_106) AT=60.025n

.meas tran vdout0_107ck110 FIND v(dout0_107) AT=60.025n

.meas tran vdout0_108ck110 FIND v(dout0_108) AT=60.025n

.meas tran vdout0_109ck110 FIND v(dout0_109) AT=60.025n

.meas tran vdout0_110ck110 FIND v(dout0_110) AT=60.025n

.meas tran vdout0_111ck110 FIND v(dout0_111) AT=60.025n

.meas tran vdout0_112ck110 FIND v(dout0_112) AT=60.025n

.meas tran vdout0_113ck110 FIND v(dout0_113) AT=60.025n

.meas tran vdout0_114ck110 FIND v(dout0_114) AT=60.025n

.meas tran vdout0_115ck110 FIND v(dout0_115) AT=60.025n

.meas tran vdout0_116ck110 FIND v(dout0_116) AT=60.025n

.meas tran vdout0_117ck110 FIND v(dout0_117) AT=60.025n

.meas tran vdout0_118ck110 FIND v(dout0_118) AT=60.025n

.meas tran vdout0_119ck110 FIND v(dout0_119) AT=60.025n

.meas tran vdout0_120ck110 FIND v(dout0_120) AT=60.025n

.meas tran vdout0_121ck110 FIND v(dout0_121) AT=60.025n

.meas tran vdout0_122ck110 FIND v(dout0_122) AT=60.025n

.meas tran vdout0_123ck110 FIND v(dout0_123) AT=60.025n

.meas tran vdout0_124ck110 FIND v(dout0_124) AT=60.025n

.meas tran vdout0_125ck110 FIND v(dout0_125) AT=60.025n

.meas tran vdout0_126ck110 FIND v(dout0_126) AT=60.025n

.meas tran vdout0_127ck110 FIND v(dout0_127) AT=60.025n

.meas tran vdout0_0ck130 FIND v(dout0_0) AT=70.025n

.meas tran vdout0_1ck130 FIND v(dout0_1) AT=70.025n

.meas tran vdout0_2ck130 FIND v(dout0_2) AT=70.025n

.meas tran vdout0_3ck130 FIND v(dout0_3) AT=70.025n

.meas tran vdout0_4ck130 FIND v(dout0_4) AT=70.025n

.meas tran vdout0_5ck130 FIND v(dout0_5) AT=70.025n

.meas tran vdout0_6ck130 FIND v(dout0_6) AT=70.025n

.meas tran vdout0_7ck130 FIND v(dout0_7) AT=70.025n

.meas tran vdout0_8ck130 FIND v(dout0_8) AT=70.025n

.meas tran vdout0_9ck130 FIND v(dout0_9) AT=70.025n

.meas tran vdout0_10ck130 FIND v(dout0_10) AT=70.025n

.meas tran vdout0_11ck130 FIND v(dout0_11) AT=70.025n

.meas tran vdout0_12ck130 FIND v(dout0_12) AT=70.025n

.meas tran vdout0_13ck130 FIND v(dout0_13) AT=70.025n

.meas tran vdout0_14ck130 FIND v(dout0_14) AT=70.025n

.meas tran vdout0_15ck130 FIND v(dout0_15) AT=70.025n

.meas tran vdout0_16ck130 FIND v(dout0_16) AT=70.025n

.meas tran vdout0_17ck130 FIND v(dout0_17) AT=70.025n

.meas tran vdout0_18ck130 FIND v(dout0_18) AT=70.025n

.meas tran vdout0_19ck130 FIND v(dout0_19) AT=70.025n

.meas tran vdout0_20ck130 FIND v(dout0_20) AT=70.025n

.meas tran vdout0_21ck130 FIND v(dout0_21) AT=70.025n

.meas tran vdout0_22ck130 FIND v(dout0_22) AT=70.025n

.meas tran vdout0_23ck130 FIND v(dout0_23) AT=70.025n

.meas tran vdout0_24ck130 FIND v(dout0_24) AT=70.025n

.meas tran vdout0_25ck130 FIND v(dout0_25) AT=70.025n

.meas tran vdout0_26ck130 FIND v(dout0_26) AT=70.025n

.meas tran vdout0_27ck130 FIND v(dout0_27) AT=70.025n

.meas tran vdout0_28ck130 FIND v(dout0_28) AT=70.025n

.meas tran vdout0_29ck130 FIND v(dout0_29) AT=70.025n

.meas tran vdout0_30ck130 FIND v(dout0_30) AT=70.025n

.meas tran vdout0_31ck130 FIND v(dout0_31) AT=70.025n

.meas tran vdout0_32ck130 FIND v(dout0_32) AT=70.025n

.meas tran vdout0_33ck130 FIND v(dout0_33) AT=70.025n

.meas tran vdout0_34ck130 FIND v(dout0_34) AT=70.025n

.meas tran vdout0_35ck130 FIND v(dout0_35) AT=70.025n

.meas tran vdout0_36ck130 FIND v(dout0_36) AT=70.025n

.meas tran vdout0_37ck130 FIND v(dout0_37) AT=70.025n

.meas tran vdout0_38ck130 FIND v(dout0_38) AT=70.025n

.meas tran vdout0_39ck130 FIND v(dout0_39) AT=70.025n

.meas tran vdout0_40ck130 FIND v(dout0_40) AT=70.025n

.meas tran vdout0_41ck130 FIND v(dout0_41) AT=70.025n

.meas tran vdout0_42ck130 FIND v(dout0_42) AT=70.025n

.meas tran vdout0_43ck130 FIND v(dout0_43) AT=70.025n

.meas tran vdout0_44ck130 FIND v(dout0_44) AT=70.025n

.meas tran vdout0_45ck130 FIND v(dout0_45) AT=70.025n

.meas tran vdout0_46ck130 FIND v(dout0_46) AT=70.025n

.meas tran vdout0_47ck130 FIND v(dout0_47) AT=70.025n

.meas tran vdout0_48ck130 FIND v(dout0_48) AT=70.025n

.meas tran vdout0_49ck130 FIND v(dout0_49) AT=70.025n

.meas tran vdout0_50ck130 FIND v(dout0_50) AT=70.025n

.meas tran vdout0_51ck130 FIND v(dout0_51) AT=70.025n

.meas tran vdout0_52ck130 FIND v(dout0_52) AT=70.025n

.meas tran vdout0_53ck130 FIND v(dout0_53) AT=70.025n

.meas tran vdout0_54ck130 FIND v(dout0_54) AT=70.025n

.meas tran vdout0_55ck130 FIND v(dout0_55) AT=70.025n

.meas tran vdout0_56ck130 FIND v(dout0_56) AT=70.025n

.meas tran vdout0_57ck130 FIND v(dout0_57) AT=70.025n

.meas tran vdout0_58ck130 FIND v(dout0_58) AT=70.025n

.meas tran vdout0_59ck130 FIND v(dout0_59) AT=70.025n

.meas tran vdout0_60ck130 FIND v(dout0_60) AT=70.025n

.meas tran vdout0_61ck130 FIND v(dout0_61) AT=70.025n

.meas tran vdout0_62ck130 FIND v(dout0_62) AT=70.025n

.meas tran vdout0_63ck130 FIND v(dout0_63) AT=70.025n

.meas tran vdout0_64ck130 FIND v(dout0_64) AT=70.025n

.meas tran vdout0_65ck130 FIND v(dout0_65) AT=70.025n

.meas tran vdout0_66ck130 FIND v(dout0_66) AT=70.025n

.meas tran vdout0_67ck130 FIND v(dout0_67) AT=70.025n

.meas tran vdout0_68ck130 FIND v(dout0_68) AT=70.025n

.meas tran vdout0_69ck130 FIND v(dout0_69) AT=70.025n

.meas tran vdout0_70ck130 FIND v(dout0_70) AT=70.025n

.meas tran vdout0_71ck130 FIND v(dout0_71) AT=70.025n

.meas tran vdout0_72ck130 FIND v(dout0_72) AT=70.025n

.meas tran vdout0_73ck130 FIND v(dout0_73) AT=70.025n

.meas tran vdout0_74ck130 FIND v(dout0_74) AT=70.025n

.meas tran vdout0_75ck130 FIND v(dout0_75) AT=70.025n

.meas tran vdout0_76ck130 FIND v(dout0_76) AT=70.025n

.meas tran vdout0_77ck130 FIND v(dout0_77) AT=70.025n

.meas tran vdout0_78ck130 FIND v(dout0_78) AT=70.025n

.meas tran vdout0_79ck130 FIND v(dout0_79) AT=70.025n

.meas tran vdout0_80ck130 FIND v(dout0_80) AT=70.025n

.meas tran vdout0_81ck130 FIND v(dout0_81) AT=70.025n

.meas tran vdout0_82ck130 FIND v(dout0_82) AT=70.025n

.meas tran vdout0_83ck130 FIND v(dout0_83) AT=70.025n

.meas tran vdout0_84ck130 FIND v(dout0_84) AT=70.025n

.meas tran vdout0_85ck130 FIND v(dout0_85) AT=70.025n

.meas tran vdout0_86ck130 FIND v(dout0_86) AT=70.025n

.meas tran vdout0_87ck130 FIND v(dout0_87) AT=70.025n

.meas tran vdout0_88ck130 FIND v(dout0_88) AT=70.025n

.meas tran vdout0_89ck130 FIND v(dout0_89) AT=70.025n

.meas tran vdout0_90ck130 FIND v(dout0_90) AT=70.025n

.meas tran vdout0_91ck130 FIND v(dout0_91) AT=70.025n

.meas tran vdout0_92ck130 FIND v(dout0_92) AT=70.025n

.meas tran vdout0_93ck130 FIND v(dout0_93) AT=70.025n

.meas tran vdout0_94ck130 FIND v(dout0_94) AT=70.025n

.meas tran vdout0_95ck130 FIND v(dout0_95) AT=70.025n

.meas tran vdout0_96ck130 FIND v(dout0_96) AT=70.025n

.meas tran vdout0_97ck130 FIND v(dout0_97) AT=70.025n

.meas tran vdout0_98ck130 FIND v(dout0_98) AT=70.025n

.meas tran vdout0_99ck130 FIND v(dout0_99) AT=70.025n

.meas tran vdout0_100ck130 FIND v(dout0_100) AT=70.025n

.meas tran vdout0_101ck130 FIND v(dout0_101) AT=70.025n

.meas tran vdout0_102ck130 FIND v(dout0_102) AT=70.025n

.meas tran vdout0_103ck130 FIND v(dout0_103) AT=70.025n

.meas tran vdout0_104ck130 FIND v(dout0_104) AT=70.025n

.meas tran vdout0_105ck130 FIND v(dout0_105) AT=70.025n

.meas tran vdout0_106ck130 FIND v(dout0_106) AT=70.025n

.meas tran vdout0_107ck130 FIND v(dout0_107) AT=70.025n

.meas tran vdout0_108ck130 FIND v(dout0_108) AT=70.025n

.meas tran vdout0_109ck130 FIND v(dout0_109) AT=70.025n

.meas tran vdout0_110ck130 FIND v(dout0_110) AT=70.025n

.meas tran vdout0_111ck130 FIND v(dout0_111) AT=70.025n

.meas tran vdout0_112ck130 FIND v(dout0_112) AT=70.025n

.meas tran vdout0_113ck130 FIND v(dout0_113) AT=70.025n

.meas tran vdout0_114ck130 FIND v(dout0_114) AT=70.025n

.meas tran vdout0_115ck130 FIND v(dout0_115) AT=70.025n

.meas tran vdout0_116ck130 FIND v(dout0_116) AT=70.025n

.meas tran vdout0_117ck130 FIND v(dout0_117) AT=70.025n

.meas tran vdout0_118ck130 FIND v(dout0_118) AT=70.025n

.meas tran vdout0_119ck130 FIND v(dout0_119) AT=70.025n

.meas tran vdout0_120ck130 FIND v(dout0_120) AT=70.025n

.meas tran vdout0_121ck130 FIND v(dout0_121) AT=70.025n

.meas tran vdout0_122ck130 FIND v(dout0_122) AT=70.025n

.meas tran vdout0_123ck130 FIND v(dout0_123) AT=70.025n

.meas tran vdout0_124ck130 FIND v(dout0_124) AT=70.025n

.meas tran vdout0_125ck130 FIND v(dout0_125) AT=70.025n

.meas tran vdout0_126ck130 FIND v(dout0_126) AT=70.025n

.meas tran vdout0_127ck130 FIND v(dout0_127) AT=70.025n

.meas tran vdout0_0ck150 FIND v(dout0_0) AT=80.025n

.meas tran vdout0_1ck150 FIND v(dout0_1) AT=80.025n

.meas tran vdout0_2ck150 FIND v(dout0_2) AT=80.025n

.meas tran vdout0_3ck150 FIND v(dout0_3) AT=80.025n

.meas tran vdout0_4ck150 FIND v(dout0_4) AT=80.025n

.meas tran vdout0_5ck150 FIND v(dout0_5) AT=80.025n

.meas tran vdout0_6ck150 FIND v(dout0_6) AT=80.025n

.meas tran vdout0_7ck150 FIND v(dout0_7) AT=80.025n

.meas tran vdout0_8ck150 FIND v(dout0_8) AT=80.025n

.meas tran vdout0_9ck150 FIND v(dout0_9) AT=80.025n

.meas tran vdout0_10ck150 FIND v(dout0_10) AT=80.025n

.meas tran vdout0_11ck150 FIND v(dout0_11) AT=80.025n

.meas tran vdout0_12ck150 FIND v(dout0_12) AT=80.025n

.meas tran vdout0_13ck150 FIND v(dout0_13) AT=80.025n

.meas tran vdout0_14ck150 FIND v(dout0_14) AT=80.025n

.meas tran vdout0_15ck150 FIND v(dout0_15) AT=80.025n

.meas tran vdout0_16ck150 FIND v(dout0_16) AT=80.025n

.meas tran vdout0_17ck150 FIND v(dout0_17) AT=80.025n

.meas tran vdout0_18ck150 FIND v(dout0_18) AT=80.025n

.meas tran vdout0_19ck150 FIND v(dout0_19) AT=80.025n

.meas tran vdout0_20ck150 FIND v(dout0_20) AT=80.025n

.meas tran vdout0_21ck150 FIND v(dout0_21) AT=80.025n

.meas tran vdout0_22ck150 FIND v(dout0_22) AT=80.025n

.meas tran vdout0_23ck150 FIND v(dout0_23) AT=80.025n

.meas tran vdout0_24ck150 FIND v(dout0_24) AT=80.025n

.meas tran vdout0_25ck150 FIND v(dout0_25) AT=80.025n

.meas tran vdout0_26ck150 FIND v(dout0_26) AT=80.025n

.meas tran vdout0_27ck150 FIND v(dout0_27) AT=80.025n

.meas tran vdout0_28ck150 FIND v(dout0_28) AT=80.025n

.meas tran vdout0_29ck150 FIND v(dout0_29) AT=80.025n

.meas tran vdout0_30ck150 FIND v(dout0_30) AT=80.025n

.meas tran vdout0_31ck150 FIND v(dout0_31) AT=80.025n

.meas tran vdout0_32ck150 FIND v(dout0_32) AT=80.025n

.meas tran vdout0_33ck150 FIND v(dout0_33) AT=80.025n

.meas tran vdout0_34ck150 FIND v(dout0_34) AT=80.025n

.meas tran vdout0_35ck150 FIND v(dout0_35) AT=80.025n

.meas tran vdout0_36ck150 FIND v(dout0_36) AT=80.025n

.meas tran vdout0_37ck150 FIND v(dout0_37) AT=80.025n

.meas tran vdout0_38ck150 FIND v(dout0_38) AT=80.025n

.meas tran vdout0_39ck150 FIND v(dout0_39) AT=80.025n

.meas tran vdout0_40ck150 FIND v(dout0_40) AT=80.025n

.meas tran vdout0_41ck150 FIND v(dout0_41) AT=80.025n

.meas tran vdout0_42ck150 FIND v(dout0_42) AT=80.025n

.meas tran vdout0_43ck150 FIND v(dout0_43) AT=80.025n

.meas tran vdout0_44ck150 FIND v(dout0_44) AT=80.025n

.meas tran vdout0_45ck150 FIND v(dout0_45) AT=80.025n

.meas tran vdout0_46ck150 FIND v(dout0_46) AT=80.025n

.meas tran vdout0_47ck150 FIND v(dout0_47) AT=80.025n

.meas tran vdout0_48ck150 FIND v(dout0_48) AT=80.025n

.meas tran vdout0_49ck150 FIND v(dout0_49) AT=80.025n

.meas tran vdout0_50ck150 FIND v(dout0_50) AT=80.025n

.meas tran vdout0_51ck150 FIND v(dout0_51) AT=80.025n

.meas tran vdout0_52ck150 FIND v(dout0_52) AT=80.025n

.meas tran vdout0_53ck150 FIND v(dout0_53) AT=80.025n

.meas tran vdout0_54ck150 FIND v(dout0_54) AT=80.025n

.meas tran vdout0_55ck150 FIND v(dout0_55) AT=80.025n

.meas tran vdout0_56ck150 FIND v(dout0_56) AT=80.025n

.meas tran vdout0_57ck150 FIND v(dout0_57) AT=80.025n

.meas tran vdout0_58ck150 FIND v(dout0_58) AT=80.025n

.meas tran vdout0_59ck150 FIND v(dout0_59) AT=80.025n

.meas tran vdout0_60ck150 FIND v(dout0_60) AT=80.025n

.meas tran vdout0_61ck150 FIND v(dout0_61) AT=80.025n

.meas tran vdout0_62ck150 FIND v(dout0_62) AT=80.025n

.meas tran vdout0_63ck150 FIND v(dout0_63) AT=80.025n

.meas tran vdout0_64ck150 FIND v(dout0_64) AT=80.025n

.meas tran vdout0_65ck150 FIND v(dout0_65) AT=80.025n

.meas tran vdout0_66ck150 FIND v(dout0_66) AT=80.025n

.meas tran vdout0_67ck150 FIND v(dout0_67) AT=80.025n

.meas tran vdout0_68ck150 FIND v(dout0_68) AT=80.025n

.meas tran vdout0_69ck150 FIND v(dout0_69) AT=80.025n

.meas tran vdout0_70ck150 FIND v(dout0_70) AT=80.025n

.meas tran vdout0_71ck150 FIND v(dout0_71) AT=80.025n

.meas tran vdout0_72ck150 FIND v(dout0_72) AT=80.025n

.meas tran vdout0_73ck150 FIND v(dout0_73) AT=80.025n

.meas tran vdout0_74ck150 FIND v(dout0_74) AT=80.025n

.meas tran vdout0_75ck150 FIND v(dout0_75) AT=80.025n

.meas tran vdout0_76ck150 FIND v(dout0_76) AT=80.025n

.meas tran vdout0_77ck150 FIND v(dout0_77) AT=80.025n

.meas tran vdout0_78ck150 FIND v(dout0_78) AT=80.025n

.meas tran vdout0_79ck150 FIND v(dout0_79) AT=80.025n

.meas tran vdout0_80ck150 FIND v(dout0_80) AT=80.025n

.meas tran vdout0_81ck150 FIND v(dout0_81) AT=80.025n

.meas tran vdout0_82ck150 FIND v(dout0_82) AT=80.025n

.meas tran vdout0_83ck150 FIND v(dout0_83) AT=80.025n

.meas tran vdout0_84ck150 FIND v(dout0_84) AT=80.025n

.meas tran vdout0_85ck150 FIND v(dout0_85) AT=80.025n

.meas tran vdout0_86ck150 FIND v(dout0_86) AT=80.025n

.meas tran vdout0_87ck150 FIND v(dout0_87) AT=80.025n

.meas tran vdout0_88ck150 FIND v(dout0_88) AT=80.025n

.meas tran vdout0_89ck150 FIND v(dout0_89) AT=80.025n

.meas tran vdout0_90ck150 FIND v(dout0_90) AT=80.025n

.meas tran vdout0_91ck150 FIND v(dout0_91) AT=80.025n

.meas tran vdout0_92ck150 FIND v(dout0_92) AT=80.025n

.meas tran vdout0_93ck150 FIND v(dout0_93) AT=80.025n

.meas tran vdout0_94ck150 FIND v(dout0_94) AT=80.025n

.meas tran vdout0_95ck150 FIND v(dout0_95) AT=80.025n

.meas tran vdout0_96ck150 FIND v(dout0_96) AT=80.025n

.meas tran vdout0_97ck150 FIND v(dout0_97) AT=80.025n

.meas tran vdout0_98ck150 FIND v(dout0_98) AT=80.025n

.meas tran vdout0_99ck150 FIND v(dout0_99) AT=80.025n

.meas tran vdout0_100ck150 FIND v(dout0_100) AT=80.025n

.meas tran vdout0_101ck150 FIND v(dout0_101) AT=80.025n

.meas tran vdout0_102ck150 FIND v(dout0_102) AT=80.025n

.meas tran vdout0_103ck150 FIND v(dout0_103) AT=80.025n

.meas tran vdout0_104ck150 FIND v(dout0_104) AT=80.025n

.meas tran vdout0_105ck150 FIND v(dout0_105) AT=80.025n

.meas tran vdout0_106ck150 FIND v(dout0_106) AT=80.025n

.meas tran vdout0_107ck150 FIND v(dout0_107) AT=80.025n

.meas tran vdout0_108ck150 FIND v(dout0_108) AT=80.025n

.meas tran vdout0_109ck150 FIND v(dout0_109) AT=80.025n

.meas tran vdout0_110ck150 FIND v(dout0_110) AT=80.025n

.meas tran vdout0_111ck150 FIND v(dout0_111) AT=80.025n

.meas tran vdout0_112ck150 FIND v(dout0_112) AT=80.025n

.meas tran vdout0_113ck150 FIND v(dout0_113) AT=80.025n

.meas tran vdout0_114ck150 FIND v(dout0_114) AT=80.025n

.meas tran vdout0_115ck150 FIND v(dout0_115) AT=80.025n

.meas tran vdout0_116ck150 FIND v(dout0_116) AT=80.025n

.meas tran vdout0_117ck150 FIND v(dout0_117) AT=80.025n

.meas tran vdout0_118ck150 FIND v(dout0_118) AT=80.025n

.meas tran vdout0_119ck150 FIND v(dout0_119) AT=80.025n

.meas tran vdout0_120ck150 FIND v(dout0_120) AT=80.025n

.meas tran vdout0_121ck150 FIND v(dout0_121) AT=80.025n

.meas tran vdout0_122ck150 FIND v(dout0_122) AT=80.025n

.meas tran vdout0_123ck150 FIND v(dout0_123) AT=80.025n

.meas tran vdout0_124ck150 FIND v(dout0_124) AT=80.025n

.meas tran vdout0_125ck150 FIND v(dout0_125) AT=80.025n

.meas tran vdout0_126ck150 FIND v(dout0_126) AT=80.025n

.meas tran vdout0_127ck150 FIND v(dout0_127) AT=80.025n

.meas tran vdout0_0ck200 FIND v(dout0_0) AT=105.025n

.meas tran vdout0_1ck200 FIND v(dout0_1) AT=105.025n

.meas tran vdout0_2ck200 FIND v(dout0_2) AT=105.025n

.meas tran vdout0_3ck200 FIND v(dout0_3) AT=105.025n

.meas tran vdout0_4ck200 FIND v(dout0_4) AT=105.025n

.meas tran vdout0_5ck200 FIND v(dout0_5) AT=105.025n

.meas tran vdout0_6ck200 FIND v(dout0_6) AT=105.025n

.meas tran vdout0_7ck200 FIND v(dout0_7) AT=105.025n

.meas tran vdout0_8ck200 FIND v(dout0_8) AT=105.025n

.meas tran vdout0_9ck200 FIND v(dout0_9) AT=105.025n

.meas tran vdout0_10ck200 FIND v(dout0_10) AT=105.025n

.meas tran vdout0_11ck200 FIND v(dout0_11) AT=105.025n

.meas tran vdout0_12ck200 FIND v(dout0_12) AT=105.025n

.meas tran vdout0_13ck200 FIND v(dout0_13) AT=105.025n

.meas tran vdout0_14ck200 FIND v(dout0_14) AT=105.025n

.meas tran vdout0_15ck200 FIND v(dout0_15) AT=105.025n

.meas tran vdout0_16ck200 FIND v(dout0_16) AT=105.025n

.meas tran vdout0_17ck200 FIND v(dout0_17) AT=105.025n

.meas tran vdout0_18ck200 FIND v(dout0_18) AT=105.025n

.meas tran vdout0_19ck200 FIND v(dout0_19) AT=105.025n

.meas tran vdout0_20ck200 FIND v(dout0_20) AT=105.025n

.meas tran vdout0_21ck200 FIND v(dout0_21) AT=105.025n

.meas tran vdout0_22ck200 FIND v(dout0_22) AT=105.025n

.meas tran vdout0_23ck200 FIND v(dout0_23) AT=105.025n

.meas tran vdout0_24ck200 FIND v(dout0_24) AT=105.025n

.meas tran vdout0_25ck200 FIND v(dout0_25) AT=105.025n

.meas tran vdout0_26ck200 FIND v(dout0_26) AT=105.025n

.meas tran vdout0_27ck200 FIND v(dout0_27) AT=105.025n

.meas tran vdout0_28ck200 FIND v(dout0_28) AT=105.025n

.meas tran vdout0_29ck200 FIND v(dout0_29) AT=105.025n

.meas tran vdout0_30ck200 FIND v(dout0_30) AT=105.025n

.meas tran vdout0_31ck200 FIND v(dout0_31) AT=105.025n

.meas tran vdout0_32ck200 FIND v(dout0_32) AT=105.025n

.meas tran vdout0_33ck200 FIND v(dout0_33) AT=105.025n

.meas tran vdout0_34ck200 FIND v(dout0_34) AT=105.025n

.meas tran vdout0_35ck200 FIND v(dout0_35) AT=105.025n

.meas tran vdout0_36ck200 FIND v(dout0_36) AT=105.025n

.meas tran vdout0_37ck200 FIND v(dout0_37) AT=105.025n

.meas tran vdout0_38ck200 FIND v(dout0_38) AT=105.025n

.meas tran vdout0_39ck200 FIND v(dout0_39) AT=105.025n

.meas tran vdout0_40ck200 FIND v(dout0_40) AT=105.025n

.meas tran vdout0_41ck200 FIND v(dout0_41) AT=105.025n

.meas tran vdout0_42ck200 FIND v(dout0_42) AT=105.025n

.meas tran vdout0_43ck200 FIND v(dout0_43) AT=105.025n

.meas tran vdout0_44ck200 FIND v(dout0_44) AT=105.025n

.meas tran vdout0_45ck200 FIND v(dout0_45) AT=105.025n

.meas tran vdout0_46ck200 FIND v(dout0_46) AT=105.025n

.meas tran vdout0_47ck200 FIND v(dout0_47) AT=105.025n

.meas tran vdout0_48ck200 FIND v(dout0_48) AT=105.025n

.meas tran vdout0_49ck200 FIND v(dout0_49) AT=105.025n

.meas tran vdout0_50ck200 FIND v(dout0_50) AT=105.025n

.meas tran vdout0_51ck200 FIND v(dout0_51) AT=105.025n

.meas tran vdout0_52ck200 FIND v(dout0_52) AT=105.025n

.meas tran vdout0_53ck200 FIND v(dout0_53) AT=105.025n

.meas tran vdout0_54ck200 FIND v(dout0_54) AT=105.025n

.meas tran vdout0_55ck200 FIND v(dout0_55) AT=105.025n

.meas tran vdout0_56ck200 FIND v(dout0_56) AT=105.025n

.meas tran vdout0_57ck200 FIND v(dout0_57) AT=105.025n

.meas tran vdout0_58ck200 FIND v(dout0_58) AT=105.025n

.meas tran vdout0_59ck200 FIND v(dout0_59) AT=105.025n

.meas tran vdout0_60ck200 FIND v(dout0_60) AT=105.025n

.meas tran vdout0_61ck200 FIND v(dout0_61) AT=105.025n

.meas tran vdout0_62ck200 FIND v(dout0_62) AT=105.025n

.meas tran vdout0_63ck200 FIND v(dout0_63) AT=105.025n

.meas tran vdout0_64ck200 FIND v(dout0_64) AT=105.025n

.meas tran vdout0_65ck200 FIND v(dout0_65) AT=105.025n

.meas tran vdout0_66ck200 FIND v(dout0_66) AT=105.025n

.meas tran vdout0_67ck200 FIND v(dout0_67) AT=105.025n

.meas tran vdout0_68ck200 FIND v(dout0_68) AT=105.025n

.meas tran vdout0_69ck200 FIND v(dout0_69) AT=105.025n

.meas tran vdout0_70ck200 FIND v(dout0_70) AT=105.025n

.meas tran vdout0_71ck200 FIND v(dout0_71) AT=105.025n

.meas tran vdout0_72ck200 FIND v(dout0_72) AT=105.025n

.meas tran vdout0_73ck200 FIND v(dout0_73) AT=105.025n

.meas tran vdout0_74ck200 FIND v(dout0_74) AT=105.025n

.meas tran vdout0_75ck200 FIND v(dout0_75) AT=105.025n

.meas tran vdout0_76ck200 FIND v(dout0_76) AT=105.025n

.meas tran vdout0_77ck200 FIND v(dout0_77) AT=105.025n

.meas tran vdout0_78ck200 FIND v(dout0_78) AT=105.025n

.meas tran vdout0_79ck200 FIND v(dout0_79) AT=105.025n

.meas tran vdout0_80ck200 FIND v(dout0_80) AT=105.025n

.meas tran vdout0_81ck200 FIND v(dout0_81) AT=105.025n

.meas tran vdout0_82ck200 FIND v(dout0_82) AT=105.025n

.meas tran vdout0_83ck200 FIND v(dout0_83) AT=105.025n

.meas tran vdout0_84ck200 FIND v(dout0_84) AT=105.025n

.meas tran vdout0_85ck200 FIND v(dout0_85) AT=105.025n

.meas tran vdout0_86ck200 FIND v(dout0_86) AT=105.025n

.meas tran vdout0_87ck200 FIND v(dout0_87) AT=105.025n

.meas tran vdout0_88ck200 FIND v(dout0_88) AT=105.025n

.meas tran vdout0_89ck200 FIND v(dout0_89) AT=105.025n

.meas tran vdout0_90ck200 FIND v(dout0_90) AT=105.025n

.meas tran vdout0_91ck200 FIND v(dout0_91) AT=105.025n

.meas tran vdout0_92ck200 FIND v(dout0_92) AT=105.025n

.meas tran vdout0_93ck200 FIND v(dout0_93) AT=105.025n

.meas tran vdout0_94ck200 FIND v(dout0_94) AT=105.025n

.meas tran vdout0_95ck200 FIND v(dout0_95) AT=105.025n

.meas tran vdout0_96ck200 FIND v(dout0_96) AT=105.025n

.meas tran vdout0_97ck200 FIND v(dout0_97) AT=105.025n

.meas tran vdout0_98ck200 FIND v(dout0_98) AT=105.025n

.meas tran vdout0_99ck200 FIND v(dout0_99) AT=105.025n

.meas tran vdout0_100ck200 FIND v(dout0_100) AT=105.025n

.meas tran vdout0_101ck200 FIND v(dout0_101) AT=105.025n

.meas tran vdout0_102ck200 FIND v(dout0_102) AT=105.025n

.meas tran vdout0_103ck200 FIND v(dout0_103) AT=105.025n

.meas tran vdout0_104ck200 FIND v(dout0_104) AT=105.025n

.meas tran vdout0_105ck200 FIND v(dout0_105) AT=105.025n

.meas tran vdout0_106ck200 FIND v(dout0_106) AT=105.025n

.meas tran vdout0_107ck200 FIND v(dout0_107) AT=105.025n

.meas tran vdout0_108ck200 FIND v(dout0_108) AT=105.025n

.meas tran vdout0_109ck200 FIND v(dout0_109) AT=105.025n

.meas tran vdout0_110ck200 FIND v(dout0_110) AT=105.025n

.meas tran vdout0_111ck200 FIND v(dout0_111) AT=105.025n

.meas tran vdout0_112ck200 FIND v(dout0_112) AT=105.025n

.meas tran vdout0_113ck200 FIND v(dout0_113) AT=105.025n

.meas tran vdout0_114ck200 FIND v(dout0_114) AT=105.025n

.meas tran vdout0_115ck200 FIND v(dout0_115) AT=105.025n

.meas tran vdout0_116ck200 FIND v(dout0_116) AT=105.025n

.meas tran vdout0_117ck200 FIND v(dout0_117) AT=105.025n

.meas tran vdout0_118ck200 FIND v(dout0_118) AT=105.025n

.meas tran vdout0_119ck200 FIND v(dout0_119) AT=105.025n

.meas tran vdout0_120ck200 FIND v(dout0_120) AT=105.025n

.meas tran vdout0_121ck200 FIND v(dout0_121) AT=105.025n

.meas tran vdout0_122ck200 FIND v(dout0_122) AT=105.025n

.meas tran vdout0_123ck200 FIND v(dout0_123) AT=105.025n

.meas tran vdout0_124ck200 FIND v(dout0_124) AT=105.025n

.meas tran vdout0_125ck200 FIND v(dout0_125) AT=105.025n

.meas tran vdout0_126ck200 FIND v(dout0_126) AT=105.025n

.meas tran vdout0_127ck200 FIND v(dout0_127) AT=105.025n

.meas tran vdout0_0ck230 FIND v(dout0_0) AT=120.025n

.meas tran vdout0_1ck230 FIND v(dout0_1) AT=120.025n

.meas tran vdout0_2ck230 FIND v(dout0_2) AT=120.025n

.meas tran vdout0_3ck230 FIND v(dout0_3) AT=120.025n

.meas tran vdout0_4ck230 FIND v(dout0_4) AT=120.025n

.meas tran vdout0_5ck230 FIND v(dout0_5) AT=120.025n

.meas tran vdout0_6ck230 FIND v(dout0_6) AT=120.025n

.meas tran vdout0_7ck230 FIND v(dout0_7) AT=120.025n

.meas tran vdout0_8ck230 FIND v(dout0_8) AT=120.025n

.meas tran vdout0_9ck230 FIND v(dout0_9) AT=120.025n

.meas tran vdout0_10ck230 FIND v(dout0_10) AT=120.025n

.meas tran vdout0_11ck230 FIND v(dout0_11) AT=120.025n

.meas tran vdout0_12ck230 FIND v(dout0_12) AT=120.025n

.meas tran vdout0_13ck230 FIND v(dout0_13) AT=120.025n

.meas tran vdout0_14ck230 FIND v(dout0_14) AT=120.025n

.meas tran vdout0_15ck230 FIND v(dout0_15) AT=120.025n

.meas tran vdout0_16ck230 FIND v(dout0_16) AT=120.025n

.meas tran vdout0_17ck230 FIND v(dout0_17) AT=120.025n

.meas tran vdout0_18ck230 FIND v(dout0_18) AT=120.025n

.meas tran vdout0_19ck230 FIND v(dout0_19) AT=120.025n

.meas tran vdout0_20ck230 FIND v(dout0_20) AT=120.025n

.meas tran vdout0_21ck230 FIND v(dout0_21) AT=120.025n

.meas tran vdout0_22ck230 FIND v(dout0_22) AT=120.025n

.meas tran vdout0_23ck230 FIND v(dout0_23) AT=120.025n

.meas tran vdout0_24ck230 FIND v(dout0_24) AT=120.025n

.meas tran vdout0_25ck230 FIND v(dout0_25) AT=120.025n

.meas tran vdout0_26ck230 FIND v(dout0_26) AT=120.025n

.meas tran vdout0_27ck230 FIND v(dout0_27) AT=120.025n

.meas tran vdout0_28ck230 FIND v(dout0_28) AT=120.025n

.meas tran vdout0_29ck230 FIND v(dout0_29) AT=120.025n

.meas tran vdout0_30ck230 FIND v(dout0_30) AT=120.025n

.meas tran vdout0_31ck230 FIND v(dout0_31) AT=120.025n

.meas tran vdout0_32ck230 FIND v(dout0_32) AT=120.025n

.meas tran vdout0_33ck230 FIND v(dout0_33) AT=120.025n

.meas tran vdout0_34ck230 FIND v(dout0_34) AT=120.025n

.meas tran vdout0_35ck230 FIND v(dout0_35) AT=120.025n

.meas tran vdout0_36ck230 FIND v(dout0_36) AT=120.025n

.meas tran vdout0_37ck230 FIND v(dout0_37) AT=120.025n

.meas tran vdout0_38ck230 FIND v(dout0_38) AT=120.025n

.meas tran vdout0_39ck230 FIND v(dout0_39) AT=120.025n

.meas tran vdout0_40ck230 FIND v(dout0_40) AT=120.025n

.meas tran vdout0_41ck230 FIND v(dout0_41) AT=120.025n

.meas tran vdout0_42ck230 FIND v(dout0_42) AT=120.025n

.meas tran vdout0_43ck230 FIND v(dout0_43) AT=120.025n

.meas tran vdout0_44ck230 FIND v(dout0_44) AT=120.025n

.meas tran vdout0_45ck230 FIND v(dout0_45) AT=120.025n

.meas tran vdout0_46ck230 FIND v(dout0_46) AT=120.025n

.meas tran vdout0_47ck230 FIND v(dout0_47) AT=120.025n

.meas tran vdout0_48ck230 FIND v(dout0_48) AT=120.025n

.meas tran vdout0_49ck230 FIND v(dout0_49) AT=120.025n

.meas tran vdout0_50ck230 FIND v(dout0_50) AT=120.025n

.meas tran vdout0_51ck230 FIND v(dout0_51) AT=120.025n

.meas tran vdout0_52ck230 FIND v(dout0_52) AT=120.025n

.meas tran vdout0_53ck230 FIND v(dout0_53) AT=120.025n

.meas tran vdout0_54ck230 FIND v(dout0_54) AT=120.025n

.meas tran vdout0_55ck230 FIND v(dout0_55) AT=120.025n

.meas tran vdout0_56ck230 FIND v(dout0_56) AT=120.025n

.meas tran vdout0_57ck230 FIND v(dout0_57) AT=120.025n

.meas tran vdout0_58ck230 FIND v(dout0_58) AT=120.025n

.meas tran vdout0_59ck230 FIND v(dout0_59) AT=120.025n

.meas tran vdout0_60ck230 FIND v(dout0_60) AT=120.025n

.meas tran vdout0_61ck230 FIND v(dout0_61) AT=120.025n

.meas tran vdout0_62ck230 FIND v(dout0_62) AT=120.025n

.meas tran vdout0_63ck230 FIND v(dout0_63) AT=120.025n

.meas tran vdout0_64ck230 FIND v(dout0_64) AT=120.025n

.meas tran vdout0_65ck230 FIND v(dout0_65) AT=120.025n

.meas tran vdout0_66ck230 FIND v(dout0_66) AT=120.025n

.meas tran vdout0_67ck230 FIND v(dout0_67) AT=120.025n

.meas tran vdout0_68ck230 FIND v(dout0_68) AT=120.025n

.meas tran vdout0_69ck230 FIND v(dout0_69) AT=120.025n

.meas tran vdout0_70ck230 FIND v(dout0_70) AT=120.025n

.meas tran vdout0_71ck230 FIND v(dout0_71) AT=120.025n

.meas tran vdout0_72ck230 FIND v(dout0_72) AT=120.025n

.meas tran vdout0_73ck230 FIND v(dout0_73) AT=120.025n

.meas tran vdout0_74ck230 FIND v(dout0_74) AT=120.025n

.meas tran vdout0_75ck230 FIND v(dout0_75) AT=120.025n

.meas tran vdout0_76ck230 FIND v(dout0_76) AT=120.025n

.meas tran vdout0_77ck230 FIND v(dout0_77) AT=120.025n

.meas tran vdout0_78ck230 FIND v(dout0_78) AT=120.025n

.meas tran vdout0_79ck230 FIND v(dout0_79) AT=120.025n

.meas tran vdout0_80ck230 FIND v(dout0_80) AT=120.025n

.meas tran vdout0_81ck230 FIND v(dout0_81) AT=120.025n

.meas tran vdout0_82ck230 FIND v(dout0_82) AT=120.025n

.meas tran vdout0_83ck230 FIND v(dout0_83) AT=120.025n

.meas tran vdout0_84ck230 FIND v(dout0_84) AT=120.025n

.meas tran vdout0_85ck230 FIND v(dout0_85) AT=120.025n

.meas tran vdout0_86ck230 FIND v(dout0_86) AT=120.025n

.meas tran vdout0_87ck230 FIND v(dout0_87) AT=120.025n

.meas tran vdout0_88ck230 FIND v(dout0_88) AT=120.025n

.meas tran vdout0_89ck230 FIND v(dout0_89) AT=120.025n

.meas tran vdout0_90ck230 FIND v(dout0_90) AT=120.025n

.meas tran vdout0_91ck230 FIND v(dout0_91) AT=120.025n

.meas tran vdout0_92ck230 FIND v(dout0_92) AT=120.025n

.meas tran vdout0_93ck230 FIND v(dout0_93) AT=120.025n

.meas tran vdout0_94ck230 FIND v(dout0_94) AT=120.025n

.meas tran vdout0_95ck230 FIND v(dout0_95) AT=120.025n

.meas tran vdout0_96ck230 FIND v(dout0_96) AT=120.025n

.meas tran vdout0_97ck230 FIND v(dout0_97) AT=120.025n

.meas tran vdout0_98ck230 FIND v(dout0_98) AT=120.025n

.meas tran vdout0_99ck230 FIND v(dout0_99) AT=120.025n

.meas tran vdout0_100ck230 FIND v(dout0_100) AT=120.025n

.meas tran vdout0_101ck230 FIND v(dout0_101) AT=120.025n

.meas tran vdout0_102ck230 FIND v(dout0_102) AT=120.025n

.meas tran vdout0_103ck230 FIND v(dout0_103) AT=120.025n

.meas tran vdout0_104ck230 FIND v(dout0_104) AT=120.025n

.meas tran vdout0_105ck230 FIND v(dout0_105) AT=120.025n

.meas tran vdout0_106ck230 FIND v(dout0_106) AT=120.025n

.meas tran vdout0_107ck230 FIND v(dout0_107) AT=120.025n

.meas tran vdout0_108ck230 FIND v(dout0_108) AT=120.025n

.meas tran vdout0_109ck230 FIND v(dout0_109) AT=120.025n

.meas tran vdout0_110ck230 FIND v(dout0_110) AT=120.025n

.meas tran vdout0_111ck230 FIND v(dout0_111) AT=120.025n

.meas tran vdout0_112ck230 FIND v(dout0_112) AT=120.025n

.meas tran vdout0_113ck230 FIND v(dout0_113) AT=120.025n

.meas tran vdout0_114ck230 FIND v(dout0_114) AT=120.025n

.meas tran vdout0_115ck230 FIND v(dout0_115) AT=120.025n

.meas tran vdout0_116ck230 FIND v(dout0_116) AT=120.025n

.meas tran vdout0_117ck230 FIND v(dout0_117) AT=120.025n

.meas tran vdout0_118ck230 FIND v(dout0_118) AT=120.025n

.meas tran vdout0_119ck230 FIND v(dout0_119) AT=120.025n

.meas tran vdout0_120ck230 FIND v(dout0_120) AT=120.025n

.meas tran vdout0_121ck230 FIND v(dout0_121) AT=120.025n

.meas tran vdout0_122ck230 FIND v(dout0_122) AT=120.025n

.meas tran vdout0_123ck230 FIND v(dout0_123) AT=120.025n

.meas tran vdout0_124ck230 FIND v(dout0_124) AT=120.025n

.meas tran vdout0_125ck230 FIND v(dout0_125) AT=120.025n

.meas tran vdout0_126ck230 FIND v(dout0_126) AT=120.025n

.meas tran vdout0_127ck230 FIND v(dout0_127) AT=120.025n

.meas tran vdout0_0ck250 FIND v(dout0_0) AT=130.025n

.meas tran vdout0_1ck250 FIND v(dout0_1) AT=130.025n

.meas tran vdout0_2ck250 FIND v(dout0_2) AT=130.025n

.meas tran vdout0_3ck250 FIND v(dout0_3) AT=130.025n

.meas tran vdout0_4ck250 FIND v(dout0_4) AT=130.025n

.meas tran vdout0_5ck250 FIND v(dout0_5) AT=130.025n

.meas tran vdout0_6ck250 FIND v(dout0_6) AT=130.025n

.meas tran vdout0_7ck250 FIND v(dout0_7) AT=130.025n

.meas tran vdout0_8ck250 FIND v(dout0_8) AT=130.025n

.meas tran vdout0_9ck250 FIND v(dout0_9) AT=130.025n

.meas tran vdout0_10ck250 FIND v(dout0_10) AT=130.025n

.meas tran vdout0_11ck250 FIND v(dout0_11) AT=130.025n

.meas tran vdout0_12ck250 FIND v(dout0_12) AT=130.025n

.meas tran vdout0_13ck250 FIND v(dout0_13) AT=130.025n

.meas tran vdout0_14ck250 FIND v(dout0_14) AT=130.025n

.meas tran vdout0_15ck250 FIND v(dout0_15) AT=130.025n

.meas tran vdout0_16ck250 FIND v(dout0_16) AT=130.025n

.meas tran vdout0_17ck250 FIND v(dout0_17) AT=130.025n

.meas tran vdout0_18ck250 FIND v(dout0_18) AT=130.025n

.meas tran vdout0_19ck250 FIND v(dout0_19) AT=130.025n

.meas tran vdout0_20ck250 FIND v(dout0_20) AT=130.025n

.meas tran vdout0_21ck250 FIND v(dout0_21) AT=130.025n

.meas tran vdout0_22ck250 FIND v(dout0_22) AT=130.025n

.meas tran vdout0_23ck250 FIND v(dout0_23) AT=130.025n

.meas tran vdout0_24ck250 FIND v(dout0_24) AT=130.025n

.meas tran vdout0_25ck250 FIND v(dout0_25) AT=130.025n

.meas tran vdout0_26ck250 FIND v(dout0_26) AT=130.025n

.meas tran vdout0_27ck250 FIND v(dout0_27) AT=130.025n

.meas tran vdout0_28ck250 FIND v(dout0_28) AT=130.025n

.meas tran vdout0_29ck250 FIND v(dout0_29) AT=130.025n

.meas tran vdout0_30ck250 FIND v(dout0_30) AT=130.025n

.meas tran vdout0_31ck250 FIND v(dout0_31) AT=130.025n

.meas tran vdout0_32ck250 FIND v(dout0_32) AT=130.025n

.meas tran vdout0_33ck250 FIND v(dout0_33) AT=130.025n

.meas tran vdout0_34ck250 FIND v(dout0_34) AT=130.025n

.meas tran vdout0_35ck250 FIND v(dout0_35) AT=130.025n

.meas tran vdout0_36ck250 FIND v(dout0_36) AT=130.025n

.meas tran vdout0_37ck250 FIND v(dout0_37) AT=130.025n

.meas tran vdout0_38ck250 FIND v(dout0_38) AT=130.025n

.meas tran vdout0_39ck250 FIND v(dout0_39) AT=130.025n

.meas tran vdout0_40ck250 FIND v(dout0_40) AT=130.025n

.meas tran vdout0_41ck250 FIND v(dout0_41) AT=130.025n

.meas tran vdout0_42ck250 FIND v(dout0_42) AT=130.025n

.meas tran vdout0_43ck250 FIND v(dout0_43) AT=130.025n

.meas tran vdout0_44ck250 FIND v(dout0_44) AT=130.025n

.meas tran vdout0_45ck250 FIND v(dout0_45) AT=130.025n

.meas tran vdout0_46ck250 FIND v(dout0_46) AT=130.025n

.meas tran vdout0_47ck250 FIND v(dout0_47) AT=130.025n

.meas tran vdout0_48ck250 FIND v(dout0_48) AT=130.025n

.meas tran vdout0_49ck250 FIND v(dout0_49) AT=130.025n

.meas tran vdout0_50ck250 FIND v(dout0_50) AT=130.025n

.meas tran vdout0_51ck250 FIND v(dout0_51) AT=130.025n

.meas tran vdout0_52ck250 FIND v(dout0_52) AT=130.025n

.meas tran vdout0_53ck250 FIND v(dout0_53) AT=130.025n

.meas tran vdout0_54ck250 FIND v(dout0_54) AT=130.025n

.meas tran vdout0_55ck250 FIND v(dout0_55) AT=130.025n

.meas tran vdout0_56ck250 FIND v(dout0_56) AT=130.025n

.meas tran vdout0_57ck250 FIND v(dout0_57) AT=130.025n

.meas tran vdout0_58ck250 FIND v(dout0_58) AT=130.025n

.meas tran vdout0_59ck250 FIND v(dout0_59) AT=130.025n

.meas tran vdout0_60ck250 FIND v(dout0_60) AT=130.025n

.meas tran vdout0_61ck250 FIND v(dout0_61) AT=130.025n

.meas tran vdout0_62ck250 FIND v(dout0_62) AT=130.025n

.meas tran vdout0_63ck250 FIND v(dout0_63) AT=130.025n

.meas tran vdout0_64ck250 FIND v(dout0_64) AT=130.025n

.meas tran vdout0_65ck250 FIND v(dout0_65) AT=130.025n

.meas tran vdout0_66ck250 FIND v(dout0_66) AT=130.025n

.meas tran vdout0_67ck250 FIND v(dout0_67) AT=130.025n

.meas tran vdout0_68ck250 FIND v(dout0_68) AT=130.025n

.meas tran vdout0_69ck250 FIND v(dout0_69) AT=130.025n

.meas tran vdout0_70ck250 FIND v(dout0_70) AT=130.025n

.meas tran vdout0_71ck250 FIND v(dout0_71) AT=130.025n

.meas tran vdout0_72ck250 FIND v(dout0_72) AT=130.025n

.meas tran vdout0_73ck250 FIND v(dout0_73) AT=130.025n

.meas tran vdout0_74ck250 FIND v(dout0_74) AT=130.025n

.meas tran vdout0_75ck250 FIND v(dout0_75) AT=130.025n

.meas tran vdout0_76ck250 FIND v(dout0_76) AT=130.025n

.meas tran vdout0_77ck250 FIND v(dout0_77) AT=130.025n

.meas tran vdout0_78ck250 FIND v(dout0_78) AT=130.025n

.meas tran vdout0_79ck250 FIND v(dout0_79) AT=130.025n

.meas tran vdout0_80ck250 FIND v(dout0_80) AT=130.025n

.meas tran vdout0_81ck250 FIND v(dout0_81) AT=130.025n

.meas tran vdout0_82ck250 FIND v(dout0_82) AT=130.025n

.meas tran vdout0_83ck250 FIND v(dout0_83) AT=130.025n

.meas tran vdout0_84ck250 FIND v(dout0_84) AT=130.025n

.meas tran vdout0_85ck250 FIND v(dout0_85) AT=130.025n

.meas tran vdout0_86ck250 FIND v(dout0_86) AT=130.025n

.meas tran vdout0_87ck250 FIND v(dout0_87) AT=130.025n

.meas tran vdout0_88ck250 FIND v(dout0_88) AT=130.025n

.meas tran vdout0_89ck250 FIND v(dout0_89) AT=130.025n

.meas tran vdout0_90ck250 FIND v(dout0_90) AT=130.025n

.meas tran vdout0_91ck250 FIND v(dout0_91) AT=130.025n

.meas tran vdout0_92ck250 FIND v(dout0_92) AT=130.025n

.meas tran vdout0_93ck250 FIND v(dout0_93) AT=130.025n

.meas tran vdout0_94ck250 FIND v(dout0_94) AT=130.025n

.meas tran vdout0_95ck250 FIND v(dout0_95) AT=130.025n

.meas tran vdout0_96ck250 FIND v(dout0_96) AT=130.025n

.meas tran vdout0_97ck250 FIND v(dout0_97) AT=130.025n

.meas tran vdout0_98ck250 FIND v(dout0_98) AT=130.025n

.meas tran vdout0_99ck250 FIND v(dout0_99) AT=130.025n

.meas tran vdout0_100ck250 FIND v(dout0_100) AT=130.025n

.meas tran vdout0_101ck250 FIND v(dout0_101) AT=130.025n

.meas tran vdout0_102ck250 FIND v(dout0_102) AT=130.025n

.meas tran vdout0_103ck250 FIND v(dout0_103) AT=130.025n

.meas tran vdout0_104ck250 FIND v(dout0_104) AT=130.025n

.meas tran vdout0_105ck250 FIND v(dout0_105) AT=130.025n

.meas tran vdout0_106ck250 FIND v(dout0_106) AT=130.025n

.meas tran vdout0_107ck250 FIND v(dout0_107) AT=130.025n

.meas tran vdout0_108ck250 FIND v(dout0_108) AT=130.025n

.meas tran vdout0_109ck250 FIND v(dout0_109) AT=130.025n

.meas tran vdout0_110ck250 FIND v(dout0_110) AT=130.025n

.meas tran vdout0_111ck250 FIND v(dout0_111) AT=130.025n

.meas tran vdout0_112ck250 FIND v(dout0_112) AT=130.025n

.meas tran vdout0_113ck250 FIND v(dout0_113) AT=130.025n

.meas tran vdout0_114ck250 FIND v(dout0_114) AT=130.025n

.meas tran vdout0_115ck250 FIND v(dout0_115) AT=130.025n

.meas tran vdout0_116ck250 FIND v(dout0_116) AT=130.025n

.meas tran vdout0_117ck250 FIND v(dout0_117) AT=130.025n

.meas tran vdout0_118ck250 FIND v(dout0_118) AT=130.025n

.meas tran vdout0_119ck250 FIND v(dout0_119) AT=130.025n

.meas tran vdout0_120ck250 FIND v(dout0_120) AT=130.025n

.meas tran vdout0_121ck250 FIND v(dout0_121) AT=130.025n

.meas tran vdout0_122ck250 FIND v(dout0_122) AT=130.025n

.meas tran vdout0_123ck250 FIND v(dout0_123) AT=130.025n

.meas tran vdout0_124ck250 FIND v(dout0_124) AT=130.025n

.meas tran vdout0_125ck250 FIND v(dout0_125) AT=130.025n

.meas tran vdout0_126ck250 FIND v(dout0_126) AT=130.025n

.meas tran vdout0_127ck250 FIND v(dout0_127) AT=130.025n

.meas tran vdout0_0ck260 FIND v(dout0_0) AT=135.025n

.meas tran vdout0_1ck260 FIND v(dout0_1) AT=135.025n

.meas tran vdout0_2ck260 FIND v(dout0_2) AT=135.025n

.meas tran vdout0_3ck260 FIND v(dout0_3) AT=135.025n

.meas tran vdout0_4ck260 FIND v(dout0_4) AT=135.025n

.meas tran vdout0_5ck260 FIND v(dout0_5) AT=135.025n

.meas tran vdout0_6ck260 FIND v(dout0_6) AT=135.025n

.meas tran vdout0_7ck260 FIND v(dout0_7) AT=135.025n

.meas tran vdout0_8ck260 FIND v(dout0_8) AT=135.025n

.meas tran vdout0_9ck260 FIND v(dout0_9) AT=135.025n

.meas tran vdout0_10ck260 FIND v(dout0_10) AT=135.025n

.meas tran vdout0_11ck260 FIND v(dout0_11) AT=135.025n

.meas tran vdout0_12ck260 FIND v(dout0_12) AT=135.025n

.meas tran vdout0_13ck260 FIND v(dout0_13) AT=135.025n

.meas tran vdout0_14ck260 FIND v(dout0_14) AT=135.025n

.meas tran vdout0_15ck260 FIND v(dout0_15) AT=135.025n

.meas tran vdout0_16ck260 FIND v(dout0_16) AT=135.025n

.meas tran vdout0_17ck260 FIND v(dout0_17) AT=135.025n

.meas tran vdout0_18ck260 FIND v(dout0_18) AT=135.025n

.meas tran vdout0_19ck260 FIND v(dout0_19) AT=135.025n

.meas tran vdout0_20ck260 FIND v(dout0_20) AT=135.025n

.meas tran vdout0_21ck260 FIND v(dout0_21) AT=135.025n

.meas tran vdout0_22ck260 FIND v(dout0_22) AT=135.025n

.meas tran vdout0_23ck260 FIND v(dout0_23) AT=135.025n

.meas tran vdout0_24ck260 FIND v(dout0_24) AT=135.025n

.meas tran vdout0_25ck260 FIND v(dout0_25) AT=135.025n

.meas tran vdout0_26ck260 FIND v(dout0_26) AT=135.025n

.meas tran vdout0_27ck260 FIND v(dout0_27) AT=135.025n

.meas tran vdout0_28ck260 FIND v(dout0_28) AT=135.025n

.meas tran vdout0_29ck260 FIND v(dout0_29) AT=135.025n

.meas tran vdout0_30ck260 FIND v(dout0_30) AT=135.025n

.meas tran vdout0_31ck260 FIND v(dout0_31) AT=135.025n

.meas tran vdout0_32ck260 FIND v(dout0_32) AT=135.025n

.meas tran vdout0_33ck260 FIND v(dout0_33) AT=135.025n

.meas tran vdout0_34ck260 FIND v(dout0_34) AT=135.025n

.meas tran vdout0_35ck260 FIND v(dout0_35) AT=135.025n

.meas tran vdout0_36ck260 FIND v(dout0_36) AT=135.025n

.meas tran vdout0_37ck260 FIND v(dout0_37) AT=135.025n

.meas tran vdout0_38ck260 FIND v(dout0_38) AT=135.025n

.meas tran vdout0_39ck260 FIND v(dout0_39) AT=135.025n

.meas tran vdout0_40ck260 FIND v(dout0_40) AT=135.025n

.meas tran vdout0_41ck260 FIND v(dout0_41) AT=135.025n

.meas tran vdout0_42ck260 FIND v(dout0_42) AT=135.025n

.meas tran vdout0_43ck260 FIND v(dout0_43) AT=135.025n

.meas tran vdout0_44ck260 FIND v(dout0_44) AT=135.025n

.meas tran vdout0_45ck260 FIND v(dout0_45) AT=135.025n

.meas tran vdout0_46ck260 FIND v(dout0_46) AT=135.025n

.meas tran vdout0_47ck260 FIND v(dout0_47) AT=135.025n

.meas tran vdout0_48ck260 FIND v(dout0_48) AT=135.025n

.meas tran vdout0_49ck260 FIND v(dout0_49) AT=135.025n

.meas tran vdout0_50ck260 FIND v(dout0_50) AT=135.025n

.meas tran vdout0_51ck260 FIND v(dout0_51) AT=135.025n

.meas tran vdout0_52ck260 FIND v(dout0_52) AT=135.025n

.meas tran vdout0_53ck260 FIND v(dout0_53) AT=135.025n

.meas tran vdout0_54ck260 FIND v(dout0_54) AT=135.025n

.meas tran vdout0_55ck260 FIND v(dout0_55) AT=135.025n

.meas tran vdout0_56ck260 FIND v(dout0_56) AT=135.025n

.meas tran vdout0_57ck260 FIND v(dout0_57) AT=135.025n

.meas tran vdout0_58ck260 FIND v(dout0_58) AT=135.025n

.meas tran vdout0_59ck260 FIND v(dout0_59) AT=135.025n

.meas tran vdout0_60ck260 FIND v(dout0_60) AT=135.025n

.meas tran vdout0_61ck260 FIND v(dout0_61) AT=135.025n

.meas tran vdout0_62ck260 FIND v(dout0_62) AT=135.025n

.meas tran vdout0_63ck260 FIND v(dout0_63) AT=135.025n

.meas tran vdout0_64ck260 FIND v(dout0_64) AT=135.025n

.meas tran vdout0_65ck260 FIND v(dout0_65) AT=135.025n

.meas tran vdout0_66ck260 FIND v(dout0_66) AT=135.025n

.meas tran vdout0_67ck260 FIND v(dout0_67) AT=135.025n

.meas tran vdout0_68ck260 FIND v(dout0_68) AT=135.025n

.meas tran vdout0_69ck260 FIND v(dout0_69) AT=135.025n

.meas tran vdout0_70ck260 FIND v(dout0_70) AT=135.025n

.meas tran vdout0_71ck260 FIND v(dout0_71) AT=135.025n

.meas tran vdout0_72ck260 FIND v(dout0_72) AT=135.025n

.meas tran vdout0_73ck260 FIND v(dout0_73) AT=135.025n

.meas tran vdout0_74ck260 FIND v(dout0_74) AT=135.025n

.meas tran vdout0_75ck260 FIND v(dout0_75) AT=135.025n

.meas tran vdout0_76ck260 FIND v(dout0_76) AT=135.025n

.meas tran vdout0_77ck260 FIND v(dout0_77) AT=135.025n

.meas tran vdout0_78ck260 FIND v(dout0_78) AT=135.025n

.meas tran vdout0_79ck260 FIND v(dout0_79) AT=135.025n

.meas tran vdout0_80ck260 FIND v(dout0_80) AT=135.025n

.meas tran vdout0_81ck260 FIND v(dout0_81) AT=135.025n

.meas tran vdout0_82ck260 FIND v(dout0_82) AT=135.025n

.meas tran vdout0_83ck260 FIND v(dout0_83) AT=135.025n

.meas tran vdout0_84ck260 FIND v(dout0_84) AT=135.025n

.meas tran vdout0_85ck260 FIND v(dout0_85) AT=135.025n

.meas tran vdout0_86ck260 FIND v(dout0_86) AT=135.025n

.meas tran vdout0_87ck260 FIND v(dout0_87) AT=135.025n

.meas tran vdout0_88ck260 FIND v(dout0_88) AT=135.025n

.meas tran vdout0_89ck260 FIND v(dout0_89) AT=135.025n

.meas tran vdout0_90ck260 FIND v(dout0_90) AT=135.025n

.meas tran vdout0_91ck260 FIND v(dout0_91) AT=135.025n

.meas tran vdout0_92ck260 FIND v(dout0_92) AT=135.025n

.meas tran vdout0_93ck260 FIND v(dout0_93) AT=135.025n

.meas tran vdout0_94ck260 FIND v(dout0_94) AT=135.025n

.meas tran vdout0_95ck260 FIND v(dout0_95) AT=135.025n

.meas tran vdout0_96ck260 FIND v(dout0_96) AT=135.025n

.meas tran vdout0_97ck260 FIND v(dout0_97) AT=135.025n

.meas tran vdout0_98ck260 FIND v(dout0_98) AT=135.025n

.meas tran vdout0_99ck260 FIND v(dout0_99) AT=135.025n

.meas tran vdout0_100ck260 FIND v(dout0_100) AT=135.025n

.meas tran vdout0_101ck260 FIND v(dout0_101) AT=135.025n

.meas tran vdout0_102ck260 FIND v(dout0_102) AT=135.025n

.meas tran vdout0_103ck260 FIND v(dout0_103) AT=135.025n

.meas tran vdout0_104ck260 FIND v(dout0_104) AT=135.025n

.meas tran vdout0_105ck260 FIND v(dout0_105) AT=135.025n

.meas tran vdout0_106ck260 FIND v(dout0_106) AT=135.025n

.meas tran vdout0_107ck260 FIND v(dout0_107) AT=135.025n

.meas tran vdout0_108ck260 FIND v(dout0_108) AT=135.025n

.meas tran vdout0_109ck260 FIND v(dout0_109) AT=135.025n

.meas tran vdout0_110ck260 FIND v(dout0_110) AT=135.025n

.meas tran vdout0_111ck260 FIND v(dout0_111) AT=135.025n

.meas tran vdout0_112ck260 FIND v(dout0_112) AT=135.025n

.meas tran vdout0_113ck260 FIND v(dout0_113) AT=135.025n

.meas tran vdout0_114ck260 FIND v(dout0_114) AT=135.025n

.meas tran vdout0_115ck260 FIND v(dout0_115) AT=135.025n

.meas tran vdout0_116ck260 FIND v(dout0_116) AT=135.025n

.meas tran vdout0_117ck260 FIND v(dout0_117) AT=135.025n

.meas tran vdout0_118ck260 FIND v(dout0_118) AT=135.025n

.meas tran vdout0_119ck260 FIND v(dout0_119) AT=135.025n

.meas tran vdout0_120ck260 FIND v(dout0_120) AT=135.025n

.meas tran vdout0_121ck260 FIND v(dout0_121) AT=135.025n

.meas tran vdout0_122ck260 FIND v(dout0_122) AT=135.025n

.meas tran vdout0_123ck260 FIND v(dout0_123) AT=135.025n

.meas tran vdout0_124ck260 FIND v(dout0_124) AT=135.025n

.meas tran vdout0_125ck260 FIND v(dout0_125) AT=135.025n

.meas tran vdout0_126ck260 FIND v(dout0_126) AT=135.025n

.meas tran vdout0_127ck260 FIND v(dout0_127) AT=135.025n

.meas tran vdout0_0ck270 FIND v(dout0_0) AT=140.025n

.meas tran vdout0_1ck270 FIND v(dout0_1) AT=140.025n

.meas tran vdout0_2ck270 FIND v(dout0_2) AT=140.025n

.meas tran vdout0_3ck270 FIND v(dout0_3) AT=140.025n

.meas tran vdout0_4ck270 FIND v(dout0_4) AT=140.025n

.meas tran vdout0_5ck270 FIND v(dout0_5) AT=140.025n

.meas tran vdout0_6ck270 FIND v(dout0_6) AT=140.025n

.meas tran vdout0_7ck270 FIND v(dout0_7) AT=140.025n

.meas tran vdout0_8ck270 FIND v(dout0_8) AT=140.025n

.meas tran vdout0_9ck270 FIND v(dout0_9) AT=140.025n

.meas tran vdout0_10ck270 FIND v(dout0_10) AT=140.025n

.meas tran vdout0_11ck270 FIND v(dout0_11) AT=140.025n

.meas tran vdout0_12ck270 FIND v(dout0_12) AT=140.025n

.meas tran vdout0_13ck270 FIND v(dout0_13) AT=140.025n

.meas tran vdout0_14ck270 FIND v(dout0_14) AT=140.025n

.meas tran vdout0_15ck270 FIND v(dout0_15) AT=140.025n

.meas tran vdout0_16ck270 FIND v(dout0_16) AT=140.025n

.meas tran vdout0_17ck270 FIND v(dout0_17) AT=140.025n

.meas tran vdout0_18ck270 FIND v(dout0_18) AT=140.025n

.meas tran vdout0_19ck270 FIND v(dout0_19) AT=140.025n

.meas tran vdout0_20ck270 FIND v(dout0_20) AT=140.025n

.meas tran vdout0_21ck270 FIND v(dout0_21) AT=140.025n

.meas tran vdout0_22ck270 FIND v(dout0_22) AT=140.025n

.meas tran vdout0_23ck270 FIND v(dout0_23) AT=140.025n

.meas tran vdout0_24ck270 FIND v(dout0_24) AT=140.025n

.meas tran vdout0_25ck270 FIND v(dout0_25) AT=140.025n

.meas tran vdout0_26ck270 FIND v(dout0_26) AT=140.025n

.meas tran vdout0_27ck270 FIND v(dout0_27) AT=140.025n

.meas tran vdout0_28ck270 FIND v(dout0_28) AT=140.025n

.meas tran vdout0_29ck270 FIND v(dout0_29) AT=140.025n

.meas tran vdout0_30ck270 FIND v(dout0_30) AT=140.025n

.meas tran vdout0_31ck270 FIND v(dout0_31) AT=140.025n

.meas tran vdout0_32ck270 FIND v(dout0_32) AT=140.025n

.meas tran vdout0_33ck270 FIND v(dout0_33) AT=140.025n

.meas tran vdout0_34ck270 FIND v(dout0_34) AT=140.025n

.meas tran vdout0_35ck270 FIND v(dout0_35) AT=140.025n

.meas tran vdout0_36ck270 FIND v(dout0_36) AT=140.025n

.meas tran vdout0_37ck270 FIND v(dout0_37) AT=140.025n

.meas tran vdout0_38ck270 FIND v(dout0_38) AT=140.025n

.meas tran vdout0_39ck270 FIND v(dout0_39) AT=140.025n

.meas tran vdout0_40ck270 FIND v(dout0_40) AT=140.025n

.meas tran vdout0_41ck270 FIND v(dout0_41) AT=140.025n

.meas tran vdout0_42ck270 FIND v(dout0_42) AT=140.025n

.meas tran vdout0_43ck270 FIND v(dout0_43) AT=140.025n

.meas tran vdout0_44ck270 FIND v(dout0_44) AT=140.025n

.meas tran vdout0_45ck270 FIND v(dout0_45) AT=140.025n

.meas tran vdout0_46ck270 FIND v(dout0_46) AT=140.025n

.meas tran vdout0_47ck270 FIND v(dout0_47) AT=140.025n

.meas tran vdout0_48ck270 FIND v(dout0_48) AT=140.025n

.meas tran vdout0_49ck270 FIND v(dout0_49) AT=140.025n

.meas tran vdout0_50ck270 FIND v(dout0_50) AT=140.025n

.meas tran vdout0_51ck270 FIND v(dout0_51) AT=140.025n

.meas tran vdout0_52ck270 FIND v(dout0_52) AT=140.025n

.meas tran vdout0_53ck270 FIND v(dout0_53) AT=140.025n

.meas tran vdout0_54ck270 FIND v(dout0_54) AT=140.025n

.meas tran vdout0_55ck270 FIND v(dout0_55) AT=140.025n

.meas tran vdout0_56ck270 FIND v(dout0_56) AT=140.025n

.meas tran vdout0_57ck270 FIND v(dout0_57) AT=140.025n

.meas tran vdout0_58ck270 FIND v(dout0_58) AT=140.025n

.meas tran vdout0_59ck270 FIND v(dout0_59) AT=140.025n

.meas tran vdout0_60ck270 FIND v(dout0_60) AT=140.025n

.meas tran vdout0_61ck270 FIND v(dout0_61) AT=140.025n

.meas tran vdout0_62ck270 FIND v(dout0_62) AT=140.025n

.meas tran vdout0_63ck270 FIND v(dout0_63) AT=140.025n

.meas tran vdout0_64ck270 FIND v(dout0_64) AT=140.025n

.meas tran vdout0_65ck270 FIND v(dout0_65) AT=140.025n

.meas tran vdout0_66ck270 FIND v(dout0_66) AT=140.025n

.meas tran vdout0_67ck270 FIND v(dout0_67) AT=140.025n

.meas tran vdout0_68ck270 FIND v(dout0_68) AT=140.025n

.meas tran vdout0_69ck270 FIND v(dout0_69) AT=140.025n

.meas tran vdout0_70ck270 FIND v(dout0_70) AT=140.025n

.meas tran vdout0_71ck270 FIND v(dout0_71) AT=140.025n

.meas tran vdout0_72ck270 FIND v(dout0_72) AT=140.025n

.meas tran vdout0_73ck270 FIND v(dout0_73) AT=140.025n

.meas tran vdout0_74ck270 FIND v(dout0_74) AT=140.025n

.meas tran vdout0_75ck270 FIND v(dout0_75) AT=140.025n

.meas tran vdout0_76ck270 FIND v(dout0_76) AT=140.025n

.meas tran vdout0_77ck270 FIND v(dout0_77) AT=140.025n

.meas tran vdout0_78ck270 FIND v(dout0_78) AT=140.025n

.meas tran vdout0_79ck270 FIND v(dout0_79) AT=140.025n

.meas tran vdout0_80ck270 FIND v(dout0_80) AT=140.025n

.meas tran vdout0_81ck270 FIND v(dout0_81) AT=140.025n

.meas tran vdout0_82ck270 FIND v(dout0_82) AT=140.025n

.meas tran vdout0_83ck270 FIND v(dout0_83) AT=140.025n

.meas tran vdout0_84ck270 FIND v(dout0_84) AT=140.025n

.meas tran vdout0_85ck270 FIND v(dout0_85) AT=140.025n

.meas tran vdout0_86ck270 FIND v(dout0_86) AT=140.025n

.meas tran vdout0_87ck270 FIND v(dout0_87) AT=140.025n

.meas tran vdout0_88ck270 FIND v(dout0_88) AT=140.025n

.meas tran vdout0_89ck270 FIND v(dout0_89) AT=140.025n

.meas tran vdout0_90ck270 FIND v(dout0_90) AT=140.025n

.meas tran vdout0_91ck270 FIND v(dout0_91) AT=140.025n

.meas tran vdout0_92ck270 FIND v(dout0_92) AT=140.025n

.meas tran vdout0_93ck270 FIND v(dout0_93) AT=140.025n

.meas tran vdout0_94ck270 FIND v(dout0_94) AT=140.025n

.meas tran vdout0_95ck270 FIND v(dout0_95) AT=140.025n

.meas tran vdout0_96ck270 FIND v(dout0_96) AT=140.025n

.meas tran vdout0_97ck270 FIND v(dout0_97) AT=140.025n

.meas tran vdout0_98ck270 FIND v(dout0_98) AT=140.025n

.meas tran vdout0_99ck270 FIND v(dout0_99) AT=140.025n

.meas tran vdout0_100ck270 FIND v(dout0_100) AT=140.025n

.meas tran vdout0_101ck270 FIND v(dout0_101) AT=140.025n

.meas tran vdout0_102ck270 FIND v(dout0_102) AT=140.025n

.meas tran vdout0_103ck270 FIND v(dout0_103) AT=140.025n

.meas tran vdout0_104ck270 FIND v(dout0_104) AT=140.025n

.meas tran vdout0_105ck270 FIND v(dout0_105) AT=140.025n

.meas tran vdout0_106ck270 FIND v(dout0_106) AT=140.025n

.meas tran vdout0_107ck270 FIND v(dout0_107) AT=140.025n

.meas tran vdout0_108ck270 FIND v(dout0_108) AT=140.025n

.meas tran vdout0_109ck270 FIND v(dout0_109) AT=140.025n

.meas tran vdout0_110ck270 FIND v(dout0_110) AT=140.025n

.meas tran vdout0_111ck270 FIND v(dout0_111) AT=140.025n

.meas tran vdout0_112ck270 FIND v(dout0_112) AT=140.025n

.meas tran vdout0_113ck270 FIND v(dout0_113) AT=140.025n

.meas tran vdout0_114ck270 FIND v(dout0_114) AT=140.025n

.meas tran vdout0_115ck270 FIND v(dout0_115) AT=140.025n

.meas tran vdout0_116ck270 FIND v(dout0_116) AT=140.025n

.meas tran vdout0_117ck270 FIND v(dout0_117) AT=140.025n

.meas tran vdout0_118ck270 FIND v(dout0_118) AT=140.025n

.meas tran vdout0_119ck270 FIND v(dout0_119) AT=140.025n

.meas tran vdout0_120ck270 FIND v(dout0_120) AT=140.025n

.meas tran vdout0_121ck270 FIND v(dout0_121) AT=140.025n

.meas tran vdout0_122ck270 FIND v(dout0_122) AT=140.025n

.meas tran vdout0_123ck270 FIND v(dout0_123) AT=140.025n

.meas tran vdout0_124ck270 FIND v(dout0_124) AT=140.025n

.meas tran vdout0_125ck270 FIND v(dout0_125) AT=140.025n

.meas tran vdout0_126ck270 FIND v(dout0_126) AT=140.025n

.meas tran vdout0_127ck270 FIND v(dout0_127) AT=140.025n

.meas tran vdout0_0ck310 FIND v(dout0_0) AT=160.025n

.meas tran vdout0_1ck310 FIND v(dout0_1) AT=160.025n

.meas tran vdout0_2ck310 FIND v(dout0_2) AT=160.025n

.meas tran vdout0_3ck310 FIND v(dout0_3) AT=160.025n

.meas tran vdout0_4ck310 FIND v(dout0_4) AT=160.025n

.meas tran vdout0_5ck310 FIND v(dout0_5) AT=160.025n

.meas tran vdout0_6ck310 FIND v(dout0_6) AT=160.025n

.meas tran vdout0_7ck310 FIND v(dout0_7) AT=160.025n

.meas tran vdout0_8ck310 FIND v(dout0_8) AT=160.025n

.meas tran vdout0_9ck310 FIND v(dout0_9) AT=160.025n

.meas tran vdout0_10ck310 FIND v(dout0_10) AT=160.025n

.meas tran vdout0_11ck310 FIND v(dout0_11) AT=160.025n

.meas tran vdout0_12ck310 FIND v(dout0_12) AT=160.025n

.meas tran vdout0_13ck310 FIND v(dout0_13) AT=160.025n

.meas tran vdout0_14ck310 FIND v(dout0_14) AT=160.025n

.meas tran vdout0_15ck310 FIND v(dout0_15) AT=160.025n

.meas tran vdout0_16ck310 FIND v(dout0_16) AT=160.025n

.meas tran vdout0_17ck310 FIND v(dout0_17) AT=160.025n

.meas tran vdout0_18ck310 FIND v(dout0_18) AT=160.025n

.meas tran vdout0_19ck310 FIND v(dout0_19) AT=160.025n

.meas tran vdout0_20ck310 FIND v(dout0_20) AT=160.025n

.meas tran vdout0_21ck310 FIND v(dout0_21) AT=160.025n

.meas tran vdout0_22ck310 FIND v(dout0_22) AT=160.025n

.meas tran vdout0_23ck310 FIND v(dout0_23) AT=160.025n

.meas tran vdout0_24ck310 FIND v(dout0_24) AT=160.025n

.meas tran vdout0_25ck310 FIND v(dout0_25) AT=160.025n

.meas tran vdout0_26ck310 FIND v(dout0_26) AT=160.025n

.meas tran vdout0_27ck310 FIND v(dout0_27) AT=160.025n

.meas tran vdout0_28ck310 FIND v(dout0_28) AT=160.025n

.meas tran vdout0_29ck310 FIND v(dout0_29) AT=160.025n

.meas tran vdout0_30ck310 FIND v(dout0_30) AT=160.025n

.meas tran vdout0_31ck310 FIND v(dout0_31) AT=160.025n

.meas tran vdout0_32ck310 FIND v(dout0_32) AT=160.025n

.meas tran vdout0_33ck310 FIND v(dout0_33) AT=160.025n

.meas tran vdout0_34ck310 FIND v(dout0_34) AT=160.025n

.meas tran vdout0_35ck310 FIND v(dout0_35) AT=160.025n

.meas tran vdout0_36ck310 FIND v(dout0_36) AT=160.025n

.meas tran vdout0_37ck310 FIND v(dout0_37) AT=160.025n

.meas tran vdout0_38ck310 FIND v(dout0_38) AT=160.025n

.meas tran vdout0_39ck310 FIND v(dout0_39) AT=160.025n

.meas tran vdout0_40ck310 FIND v(dout0_40) AT=160.025n

.meas tran vdout0_41ck310 FIND v(dout0_41) AT=160.025n

.meas tran vdout0_42ck310 FIND v(dout0_42) AT=160.025n

.meas tran vdout0_43ck310 FIND v(dout0_43) AT=160.025n

.meas tran vdout0_44ck310 FIND v(dout0_44) AT=160.025n

.meas tran vdout0_45ck310 FIND v(dout0_45) AT=160.025n

.meas tran vdout0_46ck310 FIND v(dout0_46) AT=160.025n

.meas tran vdout0_47ck310 FIND v(dout0_47) AT=160.025n

.meas tran vdout0_48ck310 FIND v(dout0_48) AT=160.025n

.meas tran vdout0_49ck310 FIND v(dout0_49) AT=160.025n

.meas tran vdout0_50ck310 FIND v(dout0_50) AT=160.025n

.meas tran vdout0_51ck310 FIND v(dout0_51) AT=160.025n

.meas tran vdout0_52ck310 FIND v(dout0_52) AT=160.025n

.meas tran vdout0_53ck310 FIND v(dout0_53) AT=160.025n

.meas tran vdout0_54ck310 FIND v(dout0_54) AT=160.025n

.meas tran vdout0_55ck310 FIND v(dout0_55) AT=160.025n

.meas tran vdout0_56ck310 FIND v(dout0_56) AT=160.025n

.meas tran vdout0_57ck310 FIND v(dout0_57) AT=160.025n

.meas tran vdout0_58ck310 FIND v(dout0_58) AT=160.025n

.meas tran vdout0_59ck310 FIND v(dout0_59) AT=160.025n

.meas tran vdout0_60ck310 FIND v(dout0_60) AT=160.025n

.meas tran vdout0_61ck310 FIND v(dout0_61) AT=160.025n

.meas tran vdout0_62ck310 FIND v(dout0_62) AT=160.025n

.meas tran vdout0_63ck310 FIND v(dout0_63) AT=160.025n

.meas tran vdout0_64ck310 FIND v(dout0_64) AT=160.025n

.meas tran vdout0_65ck310 FIND v(dout0_65) AT=160.025n

.meas tran vdout0_66ck310 FIND v(dout0_66) AT=160.025n

.meas tran vdout0_67ck310 FIND v(dout0_67) AT=160.025n

.meas tran vdout0_68ck310 FIND v(dout0_68) AT=160.025n

.meas tran vdout0_69ck310 FIND v(dout0_69) AT=160.025n

.meas tran vdout0_70ck310 FIND v(dout0_70) AT=160.025n

.meas tran vdout0_71ck310 FIND v(dout0_71) AT=160.025n

.meas tran vdout0_72ck310 FIND v(dout0_72) AT=160.025n

.meas tran vdout0_73ck310 FIND v(dout0_73) AT=160.025n

.meas tran vdout0_74ck310 FIND v(dout0_74) AT=160.025n

.meas tran vdout0_75ck310 FIND v(dout0_75) AT=160.025n

.meas tran vdout0_76ck310 FIND v(dout0_76) AT=160.025n

.meas tran vdout0_77ck310 FIND v(dout0_77) AT=160.025n

.meas tran vdout0_78ck310 FIND v(dout0_78) AT=160.025n

.meas tran vdout0_79ck310 FIND v(dout0_79) AT=160.025n

.meas tran vdout0_80ck310 FIND v(dout0_80) AT=160.025n

.meas tran vdout0_81ck310 FIND v(dout0_81) AT=160.025n

.meas tran vdout0_82ck310 FIND v(dout0_82) AT=160.025n

.meas tran vdout0_83ck310 FIND v(dout0_83) AT=160.025n

.meas tran vdout0_84ck310 FIND v(dout0_84) AT=160.025n

.meas tran vdout0_85ck310 FIND v(dout0_85) AT=160.025n

.meas tran vdout0_86ck310 FIND v(dout0_86) AT=160.025n

.meas tran vdout0_87ck310 FIND v(dout0_87) AT=160.025n

.meas tran vdout0_88ck310 FIND v(dout0_88) AT=160.025n

.meas tran vdout0_89ck310 FIND v(dout0_89) AT=160.025n

.meas tran vdout0_90ck310 FIND v(dout0_90) AT=160.025n

.meas tran vdout0_91ck310 FIND v(dout0_91) AT=160.025n

.meas tran vdout0_92ck310 FIND v(dout0_92) AT=160.025n

.meas tran vdout0_93ck310 FIND v(dout0_93) AT=160.025n

.meas tran vdout0_94ck310 FIND v(dout0_94) AT=160.025n

.meas tran vdout0_95ck310 FIND v(dout0_95) AT=160.025n

.meas tran vdout0_96ck310 FIND v(dout0_96) AT=160.025n

.meas tran vdout0_97ck310 FIND v(dout0_97) AT=160.025n

.meas tran vdout0_98ck310 FIND v(dout0_98) AT=160.025n

.meas tran vdout0_99ck310 FIND v(dout0_99) AT=160.025n

.meas tran vdout0_100ck310 FIND v(dout0_100) AT=160.025n

.meas tran vdout0_101ck310 FIND v(dout0_101) AT=160.025n

.meas tran vdout0_102ck310 FIND v(dout0_102) AT=160.025n

.meas tran vdout0_103ck310 FIND v(dout0_103) AT=160.025n

.meas tran vdout0_104ck310 FIND v(dout0_104) AT=160.025n

.meas tran vdout0_105ck310 FIND v(dout0_105) AT=160.025n

.meas tran vdout0_106ck310 FIND v(dout0_106) AT=160.025n

.meas tran vdout0_107ck310 FIND v(dout0_107) AT=160.025n

.meas tran vdout0_108ck310 FIND v(dout0_108) AT=160.025n

.meas tran vdout0_109ck310 FIND v(dout0_109) AT=160.025n

.meas tran vdout0_110ck310 FIND v(dout0_110) AT=160.025n

.meas tran vdout0_111ck310 FIND v(dout0_111) AT=160.025n

.meas tran vdout0_112ck310 FIND v(dout0_112) AT=160.025n

.meas tran vdout0_113ck310 FIND v(dout0_113) AT=160.025n

.meas tran vdout0_114ck310 FIND v(dout0_114) AT=160.025n

.meas tran vdout0_115ck310 FIND v(dout0_115) AT=160.025n

.meas tran vdout0_116ck310 FIND v(dout0_116) AT=160.025n

.meas tran vdout0_117ck310 FIND v(dout0_117) AT=160.025n

.meas tran vdout0_118ck310 FIND v(dout0_118) AT=160.025n

.meas tran vdout0_119ck310 FIND v(dout0_119) AT=160.025n

.meas tran vdout0_120ck310 FIND v(dout0_120) AT=160.025n

.meas tran vdout0_121ck310 FIND v(dout0_121) AT=160.025n

.meas tran vdout0_122ck310 FIND v(dout0_122) AT=160.025n

.meas tran vdout0_123ck310 FIND v(dout0_123) AT=160.025n

.meas tran vdout0_124ck310 FIND v(dout0_124) AT=160.025n

.meas tran vdout0_125ck310 FIND v(dout0_125) AT=160.025n

.meas tran vdout0_126ck310 FIND v(dout0_126) AT=160.025n

.meas tran vdout0_127ck310 FIND v(dout0_127) AT=160.025n

.meas tran vdout0_0ck350 FIND v(dout0_0) AT=180.025n

.meas tran vdout0_1ck350 FIND v(dout0_1) AT=180.025n

.meas tran vdout0_2ck350 FIND v(dout0_2) AT=180.025n

.meas tran vdout0_3ck350 FIND v(dout0_3) AT=180.025n

.meas tran vdout0_4ck350 FIND v(dout0_4) AT=180.025n

.meas tran vdout0_5ck350 FIND v(dout0_5) AT=180.025n

.meas tran vdout0_6ck350 FIND v(dout0_6) AT=180.025n

.meas tran vdout0_7ck350 FIND v(dout0_7) AT=180.025n

.meas tran vdout0_8ck350 FIND v(dout0_8) AT=180.025n

.meas tran vdout0_9ck350 FIND v(dout0_9) AT=180.025n

.meas tran vdout0_10ck350 FIND v(dout0_10) AT=180.025n

.meas tran vdout0_11ck350 FIND v(dout0_11) AT=180.025n

.meas tran vdout0_12ck350 FIND v(dout0_12) AT=180.025n

.meas tran vdout0_13ck350 FIND v(dout0_13) AT=180.025n

.meas tran vdout0_14ck350 FIND v(dout0_14) AT=180.025n

.meas tran vdout0_15ck350 FIND v(dout0_15) AT=180.025n

.meas tran vdout0_16ck350 FIND v(dout0_16) AT=180.025n

.meas tran vdout0_17ck350 FIND v(dout0_17) AT=180.025n

.meas tran vdout0_18ck350 FIND v(dout0_18) AT=180.025n

.meas tran vdout0_19ck350 FIND v(dout0_19) AT=180.025n

.meas tran vdout0_20ck350 FIND v(dout0_20) AT=180.025n

.meas tran vdout0_21ck350 FIND v(dout0_21) AT=180.025n

.meas tran vdout0_22ck350 FIND v(dout0_22) AT=180.025n

.meas tran vdout0_23ck350 FIND v(dout0_23) AT=180.025n

.meas tran vdout0_24ck350 FIND v(dout0_24) AT=180.025n

.meas tran vdout0_25ck350 FIND v(dout0_25) AT=180.025n

.meas tran vdout0_26ck350 FIND v(dout0_26) AT=180.025n

.meas tran vdout0_27ck350 FIND v(dout0_27) AT=180.025n

.meas tran vdout0_28ck350 FIND v(dout0_28) AT=180.025n

.meas tran vdout0_29ck350 FIND v(dout0_29) AT=180.025n

.meas tran vdout0_30ck350 FIND v(dout0_30) AT=180.025n

.meas tran vdout0_31ck350 FIND v(dout0_31) AT=180.025n

.meas tran vdout0_32ck350 FIND v(dout0_32) AT=180.025n

.meas tran vdout0_33ck350 FIND v(dout0_33) AT=180.025n

.meas tran vdout0_34ck350 FIND v(dout0_34) AT=180.025n

.meas tran vdout0_35ck350 FIND v(dout0_35) AT=180.025n

.meas tran vdout0_36ck350 FIND v(dout0_36) AT=180.025n

.meas tran vdout0_37ck350 FIND v(dout0_37) AT=180.025n

.meas tran vdout0_38ck350 FIND v(dout0_38) AT=180.025n

.meas tran vdout0_39ck350 FIND v(dout0_39) AT=180.025n

.meas tran vdout0_40ck350 FIND v(dout0_40) AT=180.025n

.meas tran vdout0_41ck350 FIND v(dout0_41) AT=180.025n

.meas tran vdout0_42ck350 FIND v(dout0_42) AT=180.025n

.meas tran vdout0_43ck350 FIND v(dout0_43) AT=180.025n

.meas tran vdout0_44ck350 FIND v(dout0_44) AT=180.025n

.meas tran vdout0_45ck350 FIND v(dout0_45) AT=180.025n

.meas tran vdout0_46ck350 FIND v(dout0_46) AT=180.025n

.meas tran vdout0_47ck350 FIND v(dout0_47) AT=180.025n

.meas tran vdout0_48ck350 FIND v(dout0_48) AT=180.025n

.meas tran vdout0_49ck350 FIND v(dout0_49) AT=180.025n

.meas tran vdout0_50ck350 FIND v(dout0_50) AT=180.025n

.meas tran vdout0_51ck350 FIND v(dout0_51) AT=180.025n

.meas tran vdout0_52ck350 FIND v(dout0_52) AT=180.025n

.meas tran vdout0_53ck350 FIND v(dout0_53) AT=180.025n

.meas tran vdout0_54ck350 FIND v(dout0_54) AT=180.025n

.meas tran vdout0_55ck350 FIND v(dout0_55) AT=180.025n

.meas tran vdout0_56ck350 FIND v(dout0_56) AT=180.025n

.meas tran vdout0_57ck350 FIND v(dout0_57) AT=180.025n

.meas tran vdout0_58ck350 FIND v(dout0_58) AT=180.025n

.meas tran vdout0_59ck350 FIND v(dout0_59) AT=180.025n

.meas tran vdout0_60ck350 FIND v(dout0_60) AT=180.025n

.meas tran vdout0_61ck350 FIND v(dout0_61) AT=180.025n

.meas tran vdout0_62ck350 FIND v(dout0_62) AT=180.025n

.meas tran vdout0_63ck350 FIND v(dout0_63) AT=180.025n

.meas tran vdout0_64ck350 FIND v(dout0_64) AT=180.025n

.meas tran vdout0_65ck350 FIND v(dout0_65) AT=180.025n

.meas tran vdout0_66ck350 FIND v(dout0_66) AT=180.025n

.meas tran vdout0_67ck350 FIND v(dout0_67) AT=180.025n

.meas tran vdout0_68ck350 FIND v(dout0_68) AT=180.025n

.meas tran vdout0_69ck350 FIND v(dout0_69) AT=180.025n

.meas tran vdout0_70ck350 FIND v(dout0_70) AT=180.025n

.meas tran vdout0_71ck350 FIND v(dout0_71) AT=180.025n

.meas tran vdout0_72ck350 FIND v(dout0_72) AT=180.025n

.meas tran vdout0_73ck350 FIND v(dout0_73) AT=180.025n

.meas tran vdout0_74ck350 FIND v(dout0_74) AT=180.025n

.meas tran vdout0_75ck350 FIND v(dout0_75) AT=180.025n

.meas tran vdout0_76ck350 FIND v(dout0_76) AT=180.025n

.meas tran vdout0_77ck350 FIND v(dout0_77) AT=180.025n

.meas tran vdout0_78ck350 FIND v(dout0_78) AT=180.025n

.meas tran vdout0_79ck350 FIND v(dout0_79) AT=180.025n

.meas tran vdout0_80ck350 FIND v(dout0_80) AT=180.025n

.meas tran vdout0_81ck350 FIND v(dout0_81) AT=180.025n

.meas tran vdout0_82ck350 FIND v(dout0_82) AT=180.025n

.meas tran vdout0_83ck350 FIND v(dout0_83) AT=180.025n

.meas tran vdout0_84ck350 FIND v(dout0_84) AT=180.025n

.meas tran vdout0_85ck350 FIND v(dout0_85) AT=180.025n

.meas tran vdout0_86ck350 FIND v(dout0_86) AT=180.025n

.meas tran vdout0_87ck350 FIND v(dout0_87) AT=180.025n

.meas tran vdout0_88ck350 FIND v(dout0_88) AT=180.025n

.meas tran vdout0_89ck350 FIND v(dout0_89) AT=180.025n

.meas tran vdout0_90ck350 FIND v(dout0_90) AT=180.025n

.meas tran vdout0_91ck350 FIND v(dout0_91) AT=180.025n

.meas tran vdout0_92ck350 FIND v(dout0_92) AT=180.025n

.meas tran vdout0_93ck350 FIND v(dout0_93) AT=180.025n

.meas tran vdout0_94ck350 FIND v(dout0_94) AT=180.025n

.meas tran vdout0_95ck350 FIND v(dout0_95) AT=180.025n

.meas tran vdout0_96ck350 FIND v(dout0_96) AT=180.025n

.meas tran vdout0_97ck350 FIND v(dout0_97) AT=180.025n

.meas tran vdout0_98ck350 FIND v(dout0_98) AT=180.025n

.meas tran vdout0_99ck350 FIND v(dout0_99) AT=180.025n

.meas tran vdout0_100ck350 FIND v(dout0_100) AT=180.025n

.meas tran vdout0_101ck350 FIND v(dout0_101) AT=180.025n

.meas tran vdout0_102ck350 FIND v(dout0_102) AT=180.025n

.meas tran vdout0_103ck350 FIND v(dout0_103) AT=180.025n

.meas tran vdout0_104ck350 FIND v(dout0_104) AT=180.025n

.meas tran vdout0_105ck350 FIND v(dout0_105) AT=180.025n

.meas tran vdout0_106ck350 FIND v(dout0_106) AT=180.025n

.meas tran vdout0_107ck350 FIND v(dout0_107) AT=180.025n

.meas tran vdout0_108ck350 FIND v(dout0_108) AT=180.025n

.meas tran vdout0_109ck350 FIND v(dout0_109) AT=180.025n

.meas tran vdout0_110ck350 FIND v(dout0_110) AT=180.025n

.meas tran vdout0_111ck350 FIND v(dout0_111) AT=180.025n

.meas tran vdout0_112ck350 FIND v(dout0_112) AT=180.025n

.meas tran vdout0_113ck350 FIND v(dout0_113) AT=180.025n

.meas tran vdout0_114ck350 FIND v(dout0_114) AT=180.025n

.meas tran vdout0_115ck350 FIND v(dout0_115) AT=180.025n

.meas tran vdout0_116ck350 FIND v(dout0_116) AT=180.025n

.meas tran vdout0_117ck350 FIND v(dout0_117) AT=180.025n

.meas tran vdout0_118ck350 FIND v(dout0_118) AT=180.025n

.meas tran vdout0_119ck350 FIND v(dout0_119) AT=180.025n

.meas tran vdout0_120ck350 FIND v(dout0_120) AT=180.025n

.meas tran vdout0_121ck350 FIND v(dout0_121) AT=180.025n

.meas tran vdout0_122ck350 FIND v(dout0_122) AT=180.025n

.meas tran vdout0_123ck350 FIND v(dout0_123) AT=180.025n

.meas tran vdout0_124ck350 FIND v(dout0_124) AT=180.025n

.meas tran vdout0_125ck350 FIND v(dout0_125) AT=180.025n

.meas tran vdout0_126ck350 FIND v(dout0_126) AT=180.025n

.meas tran vdout0_127ck350 FIND v(dout0_127) AT=180.025n

.meas tran vdout0_0ck380 FIND v(dout0_0) AT=195.025n

.meas tran vdout0_1ck380 FIND v(dout0_1) AT=195.025n

.meas tran vdout0_2ck380 FIND v(dout0_2) AT=195.025n

.meas tran vdout0_3ck380 FIND v(dout0_3) AT=195.025n

.meas tran vdout0_4ck380 FIND v(dout0_4) AT=195.025n

.meas tran vdout0_5ck380 FIND v(dout0_5) AT=195.025n

.meas tran vdout0_6ck380 FIND v(dout0_6) AT=195.025n

.meas tran vdout0_7ck380 FIND v(dout0_7) AT=195.025n

.meas tran vdout0_8ck380 FIND v(dout0_8) AT=195.025n

.meas tran vdout0_9ck380 FIND v(dout0_9) AT=195.025n

.meas tran vdout0_10ck380 FIND v(dout0_10) AT=195.025n

.meas tran vdout0_11ck380 FIND v(dout0_11) AT=195.025n

.meas tran vdout0_12ck380 FIND v(dout0_12) AT=195.025n

.meas tran vdout0_13ck380 FIND v(dout0_13) AT=195.025n

.meas tran vdout0_14ck380 FIND v(dout0_14) AT=195.025n

.meas tran vdout0_15ck380 FIND v(dout0_15) AT=195.025n

.meas tran vdout0_16ck380 FIND v(dout0_16) AT=195.025n

.meas tran vdout0_17ck380 FIND v(dout0_17) AT=195.025n

.meas tran vdout0_18ck380 FIND v(dout0_18) AT=195.025n

.meas tran vdout0_19ck380 FIND v(dout0_19) AT=195.025n

.meas tran vdout0_20ck380 FIND v(dout0_20) AT=195.025n

.meas tran vdout0_21ck380 FIND v(dout0_21) AT=195.025n

.meas tran vdout0_22ck380 FIND v(dout0_22) AT=195.025n

.meas tran vdout0_23ck380 FIND v(dout0_23) AT=195.025n

.meas tran vdout0_24ck380 FIND v(dout0_24) AT=195.025n

.meas tran vdout0_25ck380 FIND v(dout0_25) AT=195.025n

.meas tran vdout0_26ck380 FIND v(dout0_26) AT=195.025n

.meas tran vdout0_27ck380 FIND v(dout0_27) AT=195.025n

.meas tran vdout0_28ck380 FIND v(dout0_28) AT=195.025n

.meas tran vdout0_29ck380 FIND v(dout0_29) AT=195.025n

.meas tran vdout0_30ck380 FIND v(dout0_30) AT=195.025n

.meas tran vdout0_31ck380 FIND v(dout0_31) AT=195.025n

.meas tran vdout0_32ck380 FIND v(dout0_32) AT=195.025n

.meas tran vdout0_33ck380 FIND v(dout0_33) AT=195.025n

.meas tran vdout0_34ck380 FIND v(dout0_34) AT=195.025n

.meas tran vdout0_35ck380 FIND v(dout0_35) AT=195.025n

.meas tran vdout0_36ck380 FIND v(dout0_36) AT=195.025n

.meas tran vdout0_37ck380 FIND v(dout0_37) AT=195.025n

.meas tran vdout0_38ck380 FIND v(dout0_38) AT=195.025n

.meas tran vdout0_39ck380 FIND v(dout0_39) AT=195.025n

.meas tran vdout0_40ck380 FIND v(dout0_40) AT=195.025n

.meas tran vdout0_41ck380 FIND v(dout0_41) AT=195.025n

.meas tran vdout0_42ck380 FIND v(dout0_42) AT=195.025n

.meas tran vdout0_43ck380 FIND v(dout0_43) AT=195.025n

.meas tran vdout0_44ck380 FIND v(dout0_44) AT=195.025n

.meas tran vdout0_45ck380 FIND v(dout0_45) AT=195.025n

.meas tran vdout0_46ck380 FIND v(dout0_46) AT=195.025n

.meas tran vdout0_47ck380 FIND v(dout0_47) AT=195.025n

.meas tran vdout0_48ck380 FIND v(dout0_48) AT=195.025n

.meas tran vdout0_49ck380 FIND v(dout0_49) AT=195.025n

.meas tran vdout0_50ck380 FIND v(dout0_50) AT=195.025n

.meas tran vdout0_51ck380 FIND v(dout0_51) AT=195.025n

.meas tran vdout0_52ck380 FIND v(dout0_52) AT=195.025n

.meas tran vdout0_53ck380 FIND v(dout0_53) AT=195.025n

.meas tran vdout0_54ck380 FIND v(dout0_54) AT=195.025n

.meas tran vdout0_55ck380 FIND v(dout0_55) AT=195.025n

.meas tran vdout0_56ck380 FIND v(dout0_56) AT=195.025n

.meas tran vdout0_57ck380 FIND v(dout0_57) AT=195.025n

.meas tran vdout0_58ck380 FIND v(dout0_58) AT=195.025n

.meas tran vdout0_59ck380 FIND v(dout0_59) AT=195.025n

.meas tran vdout0_60ck380 FIND v(dout0_60) AT=195.025n

.meas tran vdout0_61ck380 FIND v(dout0_61) AT=195.025n

.meas tran vdout0_62ck380 FIND v(dout0_62) AT=195.025n

.meas tran vdout0_63ck380 FIND v(dout0_63) AT=195.025n

.meas tran vdout0_64ck380 FIND v(dout0_64) AT=195.025n

.meas tran vdout0_65ck380 FIND v(dout0_65) AT=195.025n

.meas tran vdout0_66ck380 FIND v(dout0_66) AT=195.025n

.meas tran vdout0_67ck380 FIND v(dout0_67) AT=195.025n

.meas tran vdout0_68ck380 FIND v(dout0_68) AT=195.025n

.meas tran vdout0_69ck380 FIND v(dout0_69) AT=195.025n

.meas tran vdout0_70ck380 FIND v(dout0_70) AT=195.025n

.meas tran vdout0_71ck380 FIND v(dout0_71) AT=195.025n

.meas tran vdout0_72ck380 FIND v(dout0_72) AT=195.025n

.meas tran vdout0_73ck380 FIND v(dout0_73) AT=195.025n

.meas tran vdout0_74ck380 FIND v(dout0_74) AT=195.025n

.meas tran vdout0_75ck380 FIND v(dout0_75) AT=195.025n

.meas tran vdout0_76ck380 FIND v(dout0_76) AT=195.025n

.meas tran vdout0_77ck380 FIND v(dout0_77) AT=195.025n

.meas tran vdout0_78ck380 FIND v(dout0_78) AT=195.025n

.meas tran vdout0_79ck380 FIND v(dout0_79) AT=195.025n

.meas tran vdout0_80ck380 FIND v(dout0_80) AT=195.025n

.meas tran vdout0_81ck380 FIND v(dout0_81) AT=195.025n

.meas tran vdout0_82ck380 FIND v(dout0_82) AT=195.025n

.meas tran vdout0_83ck380 FIND v(dout0_83) AT=195.025n

.meas tran vdout0_84ck380 FIND v(dout0_84) AT=195.025n

.meas tran vdout0_85ck380 FIND v(dout0_85) AT=195.025n

.meas tran vdout0_86ck380 FIND v(dout0_86) AT=195.025n

.meas tran vdout0_87ck380 FIND v(dout0_87) AT=195.025n

.meas tran vdout0_88ck380 FIND v(dout0_88) AT=195.025n

.meas tran vdout0_89ck380 FIND v(dout0_89) AT=195.025n

.meas tran vdout0_90ck380 FIND v(dout0_90) AT=195.025n

.meas tran vdout0_91ck380 FIND v(dout0_91) AT=195.025n

.meas tran vdout0_92ck380 FIND v(dout0_92) AT=195.025n

.meas tran vdout0_93ck380 FIND v(dout0_93) AT=195.025n

.meas tran vdout0_94ck380 FIND v(dout0_94) AT=195.025n

.meas tran vdout0_95ck380 FIND v(dout0_95) AT=195.025n

.meas tran vdout0_96ck380 FIND v(dout0_96) AT=195.025n

.meas tran vdout0_97ck380 FIND v(dout0_97) AT=195.025n

.meas tran vdout0_98ck380 FIND v(dout0_98) AT=195.025n

.meas tran vdout0_99ck380 FIND v(dout0_99) AT=195.025n

.meas tran vdout0_100ck380 FIND v(dout0_100) AT=195.025n

.meas tran vdout0_101ck380 FIND v(dout0_101) AT=195.025n

.meas tran vdout0_102ck380 FIND v(dout0_102) AT=195.025n

.meas tran vdout0_103ck380 FIND v(dout0_103) AT=195.025n

.meas tran vdout0_104ck380 FIND v(dout0_104) AT=195.025n

.meas tran vdout0_105ck380 FIND v(dout0_105) AT=195.025n

.meas tran vdout0_106ck380 FIND v(dout0_106) AT=195.025n

.meas tran vdout0_107ck380 FIND v(dout0_107) AT=195.025n

.meas tran vdout0_108ck380 FIND v(dout0_108) AT=195.025n

.meas tran vdout0_109ck380 FIND v(dout0_109) AT=195.025n

.meas tran vdout0_110ck380 FIND v(dout0_110) AT=195.025n

.meas tran vdout0_111ck380 FIND v(dout0_111) AT=195.025n

.meas tran vdout0_112ck380 FIND v(dout0_112) AT=195.025n

.meas tran vdout0_113ck380 FIND v(dout0_113) AT=195.025n

.meas tran vdout0_114ck380 FIND v(dout0_114) AT=195.025n

.meas tran vdout0_115ck380 FIND v(dout0_115) AT=195.025n

.meas tran vdout0_116ck380 FIND v(dout0_116) AT=195.025n

.meas tran vdout0_117ck380 FIND v(dout0_117) AT=195.025n

.meas tran vdout0_118ck380 FIND v(dout0_118) AT=195.025n

.meas tran vdout0_119ck380 FIND v(dout0_119) AT=195.025n

.meas tran vdout0_120ck380 FIND v(dout0_120) AT=195.025n

.meas tran vdout0_121ck380 FIND v(dout0_121) AT=195.025n

.meas tran vdout0_122ck380 FIND v(dout0_122) AT=195.025n

.meas tran vdout0_123ck380 FIND v(dout0_123) AT=195.025n

.meas tran vdout0_124ck380 FIND v(dout0_124) AT=195.025n

.meas tran vdout0_125ck380 FIND v(dout0_125) AT=195.025n

.meas tran vdout0_126ck380 FIND v(dout0_126) AT=195.025n

.meas tran vdout0_127ck380 FIND v(dout0_127) AT=195.025n

.meas tran vdout0_0ck390 FIND v(dout0_0) AT=200.025n

.meas tran vdout0_1ck390 FIND v(dout0_1) AT=200.025n

.meas tran vdout0_2ck390 FIND v(dout0_2) AT=200.025n

.meas tran vdout0_3ck390 FIND v(dout0_3) AT=200.025n

.meas tran vdout0_4ck390 FIND v(dout0_4) AT=200.025n

.meas tran vdout0_5ck390 FIND v(dout0_5) AT=200.025n

.meas tran vdout0_6ck390 FIND v(dout0_6) AT=200.025n

.meas tran vdout0_7ck390 FIND v(dout0_7) AT=200.025n

.meas tran vdout0_8ck390 FIND v(dout0_8) AT=200.025n

.meas tran vdout0_9ck390 FIND v(dout0_9) AT=200.025n

.meas tran vdout0_10ck390 FIND v(dout0_10) AT=200.025n

.meas tran vdout0_11ck390 FIND v(dout0_11) AT=200.025n

.meas tran vdout0_12ck390 FIND v(dout0_12) AT=200.025n

.meas tran vdout0_13ck390 FIND v(dout0_13) AT=200.025n

.meas tran vdout0_14ck390 FIND v(dout0_14) AT=200.025n

.meas tran vdout0_15ck390 FIND v(dout0_15) AT=200.025n

.meas tran vdout0_16ck390 FIND v(dout0_16) AT=200.025n

.meas tran vdout0_17ck390 FIND v(dout0_17) AT=200.025n

.meas tran vdout0_18ck390 FIND v(dout0_18) AT=200.025n

.meas tran vdout0_19ck390 FIND v(dout0_19) AT=200.025n

.meas tran vdout0_20ck390 FIND v(dout0_20) AT=200.025n

.meas tran vdout0_21ck390 FIND v(dout0_21) AT=200.025n

.meas tran vdout0_22ck390 FIND v(dout0_22) AT=200.025n

.meas tran vdout0_23ck390 FIND v(dout0_23) AT=200.025n

.meas tran vdout0_24ck390 FIND v(dout0_24) AT=200.025n

.meas tran vdout0_25ck390 FIND v(dout0_25) AT=200.025n

.meas tran vdout0_26ck390 FIND v(dout0_26) AT=200.025n

.meas tran vdout0_27ck390 FIND v(dout0_27) AT=200.025n

.meas tran vdout0_28ck390 FIND v(dout0_28) AT=200.025n

.meas tran vdout0_29ck390 FIND v(dout0_29) AT=200.025n

.meas tran vdout0_30ck390 FIND v(dout0_30) AT=200.025n

.meas tran vdout0_31ck390 FIND v(dout0_31) AT=200.025n

.meas tran vdout0_32ck390 FIND v(dout0_32) AT=200.025n

.meas tran vdout0_33ck390 FIND v(dout0_33) AT=200.025n

.meas tran vdout0_34ck390 FIND v(dout0_34) AT=200.025n

.meas tran vdout0_35ck390 FIND v(dout0_35) AT=200.025n

.meas tran vdout0_36ck390 FIND v(dout0_36) AT=200.025n

.meas tran vdout0_37ck390 FIND v(dout0_37) AT=200.025n

.meas tran vdout0_38ck390 FIND v(dout0_38) AT=200.025n

.meas tran vdout0_39ck390 FIND v(dout0_39) AT=200.025n

.meas tran vdout0_40ck390 FIND v(dout0_40) AT=200.025n

.meas tran vdout0_41ck390 FIND v(dout0_41) AT=200.025n

.meas tran vdout0_42ck390 FIND v(dout0_42) AT=200.025n

.meas tran vdout0_43ck390 FIND v(dout0_43) AT=200.025n

.meas tran vdout0_44ck390 FIND v(dout0_44) AT=200.025n

.meas tran vdout0_45ck390 FIND v(dout0_45) AT=200.025n

.meas tran vdout0_46ck390 FIND v(dout0_46) AT=200.025n

.meas tran vdout0_47ck390 FIND v(dout0_47) AT=200.025n

.meas tran vdout0_48ck390 FIND v(dout0_48) AT=200.025n

.meas tran vdout0_49ck390 FIND v(dout0_49) AT=200.025n

.meas tran vdout0_50ck390 FIND v(dout0_50) AT=200.025n

.meas tran vdout0_51ck390 FIND v(dout0_51) AT=200.025n

.meas tran vdout0_52ck390 FIND v(dout0_52) AT=200.025n

.meas tran vdout0_53ck390 FIND v(dout0_53) AT=200.025n

.meas tran vdout0_54ck390 FIND v(dout0_54) AT=200.025n

.meas tran vdout0_55ck390 FIND v(dout0_55) AT=200.025n

.meas tran vdout0_56ck390 FIND v(dout0_56) AT=200.025n

.meas tran vdout0_57ck390 FIND v(dout0_57) AT=200.025n

.meas tran vdout0_58ck390 FIND v(dout0_58) AT=200.025n

.meas tran vdout0_59ck390 FIND v(dout0_59) AT=200.025n

.meas tran vdout0_60ck390 FIND v(dout0_60) AT=200.025n

.meas tran vdout0_61ck390 FIND v(dout0_61) AT=200.025n

.meas tran vdout0_62ck390 FIND v(dout0_62) AT=200.025n

.meas tran vdout0_63ck390 FIND v(dout0_63) AT=200.025n

.meas tran vdout0_64ck390 FIND v(dout0_64) AT=200.025n

.meas tran vdout0_65ck390 FIND v(dout0_65) AT=200.025n

.meas tran vdout0_66ck390 FIND v(dout0_66) AT=200.025n

.meas tran vdout0_67ck390 FIND v(dout0_67) AT=200.025n

.meas tran vdout0_68ck390 FIND v(dout0_68) AT=200.025n

.meas tran vdout0_69ck390 FIND v(dout0_69) AT=200.025n

.meas tran vdout0_70ck390 FIND v(dout0_70) AT=200.025n

.meas tran vdout0_71ck390 FIND v(dout0_71) AT=200.025n

.meas tran vdout0_72ck390 FIND v(dout0_72) AT=200.025n

.meas tran vdout0_73ck390 FIND v(dout0_73) AT=200.025n

.meas tran vdout0_74ck390 FIND v(dout0_74) AT=200.025n

.meas tran vdout0_75ck390 FIND v(dout0_75) AT=200.025n

.meas tran vdout0_76ck390 FIND v(dout0_76) AT=200.025n

.meas tran vdout0_77ck390 FIND v(dout0_77) AT=200.025n

.meas tran vdout0_78ck390 FIND v(dout0_78) AT=200.025n

.meas tran vdout0_79ck390 FIND v(dout0_79) AT=200.025n

.meas tran vdout0_80ck390 FIND v(dout0_80) AT=200.025n

.meas tran vdout0_81ck390 FIND v(dout0_81) AT=200.025n

.meas tran vdout0_82ck390 FIND v(dout0_82) AT=200.025n

.meas tran vdout0_83ck390 FIND v(dout0_83) AT=200.025n

.meas tran vdout0_84ck390 FIND v(dout0_84) AT=200.025n

.meas tran vdout0_85ck390 FIND v(dout0_85) AT=200.025n

.meas tran vdout0_86ck390 FIND v(dout0_86) AT=200.025n

.meas tran vdout0_87ck390 FIND v(dout0_87) AT=200.025n

.meas tran vdout0_88ck390 FIND v(dout0_88) AT=200.025n

.meas tran vdout0_89ck390 FIND v(dout0_89) AT=200.025n

.meas tran vdout0_90ck390 FIND v(dout0_90) AT=200.025n

.meas tran vdout0_91ck390 FIND v(dout0_91) AT=200.025n

.meas tran vdout0_92ck390 FIND v(dout0_92) AT=200.025n

.meas tran vdout0_93ck390 FIND v(dout0_93) AT=200.025n

.meas tran vdout0_94ck390 FIND v(dout0_94) AT=200.025n

.meas tran vdout0_95ck390 FIND v(dout0_95) AT=200.025n

.meas tran vdout0_96ck390 FIND v(dout0_96) AT=200.025n

.meas tran vdout0_97ck390 FIND v(dout0_97) AT=200.025n

.meas tran vdout0_98ck390 FIND v(dout0_98) AT=200.025n

.meas tran vdout0_99ck390 FIND v(dout0_99) AT=200.025n

.meas tran vdout0_100ck390 FIND v(dout0_100) AT=200.025n

.meas tran vdout0_101ck390 FIND v(dout0_101) AT=200.025n

.meas tran vdout0_102ck390 FIND v(dout0_102) AT=200.025n

.meas tran vdout0_103ck390 FIND v(dout0_103) AT=200.025n

.meas tran vdout0_104ck390 FIND v(dout0_104) AT=200.025n

.meas tran vdout0_105ck390 FIND v(dout0_105) AT=200.025n

.meas tran vdout0_106ck390 FIND v(dout0_106) AT=200.025n

.meas tran vdout0_107ck390 FIND v(dout0_107) AT=200.025n

.meas tran vdout0_108ck390 FIND v(dout0_108) AT=200.025n

.meas tran vdout0_109ck390 FIND v(dout0_109) AT=200.025n

.meas tran vdout0_110ck390 FIND v(dout0_110) AT=200.025n

.meas tran vdout0_111ck390 FIND v(dout0_111) AT=200.025n

.meas tran vdout0_112ck390 FIND v(dout0_112) AT=200.025n

.meas tran vdout0_113ck390 FIND v(dout0_113) AT=200.025n

.meas tran vdout0_114ck390 FIND v(dout0_114) AT=200.025n

.meas tran vdout0_115ck390 FIND v(dout0_115) AT=200.025n

.meas tran vdout0_116ck390 FIND v(dout0_116) AT=200.025n

.meas tran vdout0_117ck390 FIND v(dout0_117) AT=200.025n

.meas tran vdout0_118ck390 FIND v(dout0_118) AT=200.025n

.meas tran vdout0_119ck390 FIND v(dout0_119) AT=200.025n

.meas tran vdout0_120ck390 FIND v(dout0_120) AT=200.025n

.meas tran vdout0_121ck390 FIND v(dout0_121) AT=200.025n

.meas tran vdout0_122ck390 FIND v(dout0_122) AT=200.025n

.meas tran vdout0_123ck390 FIND v(dout0_123) AT=200.025n

.meas tran vdout0_124ck390 FIND v(dout0_124) AT=200.025n

.meas tran vdout0_125ck390 FIND v(dout0_125) AT=200.025n

.meas tran vdout0_126ck390 FIND v(dout0_126) AT=200.025n

.meas tran vdout0_127ck390 FIND v(dout0_127) AT=200.025n

.meas tran vdout0_0ck400 FIND v(dout0_0) AT=205.025n

.meas tran vdout0_1ck400 FIND v(dout0_1) AT=205.025n

.meas tran vdout0_2ck400 FIND v(dout0_2) AT=205.025n

.meas tran vdout0_3ck400 FIND v(dout0_3) AT=205.025n

.meas tran vdout0_4ck400 FIND v(dout0_4) AT=205.025n

.meas tran vdout0_5ck400 FIND v(dout0_5) AT=205.025n

.meas tran vdout0_6ck400 FIND v(dout0_6) AT=205.025n

.meas tran vdout0_7ck400 FIND v(dout0_7) AT=205.025n

.meas tran vdout0_8ck400 FIND v(dout0_8) AT=205.025n

.meas tran vdout0_9ck400 FIND v(dout0_9) AT=205.025n

.meas tran vdout0_10ck400 FIND v(dout0_10) AT=205.025n

.meas tran vdout0_11ck400 FIND v(dout0_11) AT=205.025n

.meas tran vdout0_12ck400 FIND v(dout0_12) AT=205.025n

.meas tran vdout0_13ck400 FIND v(dout0_13) AT=205.025n

.meas tran vdout0_14ck400 FIND v(dout0_14) AT=205.025n

.meas tran vdout0_15ck400 FIND v(dout0_15) AT=205.025n

.meas tran vdout0_16ck400 FIND v(dout0_16) AT=205.025n

.meas tran vdout0_17ck400 FIND v(dout0_17) AT=205.025n

.meas tran vdout0_18ck400 FIND v(dout0_18) AT=205.025n

.meas tran vdout0_19ck400 FIND v(dout0_19) AT=205.025n

.meas tran vdout0_20ck400 FIND v(dout0_20) AT=205.025n

.meas tran vdout0_21ck400 FIND v(dout0_21) AT=205.025n

.meas tran vdout0_22ck400 FIND v(dout0_22) AT=205.025n

.meas tran vdout0_23ck400 FIND v(dout0_23) AT=205.025n

.meas tran vdout0_24ck400 FIND v(dout0_24) AT=205.025n

.meas tran vdout0_25ck400 FIND v(dout0_25) AT=205.025n

.meas tran vdout0_26ck400 FIND v(dout0_26) AT=205.025n

.meas tran vdout0_27ck400 FIND v(dout0_27) AT=205.025n

.meas tran vdout0_28ck400 FIND v(dout0_28) AT=205.025n

.meas tran vdout0_29ck400 FIND v(dout0_29) AT=205.025n

.meas tran vdout0_30ck400 FIND v(dout0_30) AT=205.025n

.meas tran vdout0_31ck400 FIND v(dout0_31) AT=205.025n

.meas tran vdout0_32ck400 FIND v(dout0_32) AT=205.025n

.meas tran vdout0_33ck400 FIND v(dout0_33) AT=205.025n

.meas tran vdout0_34ck400 FIND v(dout0_34) AT=205.025n

.meas tran vdout0_35ck400 FIND v(dout0_35) AT=205.025n

.meas tran vdout0_36ck400 FIND v(dout0_36) AT=205.025n

.meas tran vdout0_37ck400 FIND v(dout0_37) AT=205.025n

.meas tran vdout0_38ck400 FIND v(dout0_38) AT=205.025n

.meas tran vdout0_39ck400 FIND v(dout0_39) AT=205.025n

.meas tran vdout0_40ck400 FIND v(dout0_40) AT=205.025n

.meas tran vdout0_41ck400 FIND v(dout0_41) AT=205.025n

.meas tran vdout0_42ck400 FIND v(dout0_42) AT=205.025n

.meas tran vdout0_43ck400 FIND v(dout0_43) AT=205.025n

.meas tran vdout0_44ck400 FIND v(dout0_44) AT=205.025n

.meas tran vdout0_45ck400 FIND v(dout0_45) AT=205.025n

.meas tran vdout0_46ck400 FIND v(dout0_46) AT=205.025n

.meas tran vdout0_47ck400 FIND v(dout0_47) AT=205.025n

.meas tran vdout0_48ck400 FIND v(dout0_48) AT=205.025n

.meas tran vdout0_49ck400 FIND v(dout0_49) AT=205.025n

.meas tran vdout0_50ck400 FIND v(dout0_50) AT=205.025n

.meas tran vdout0_51ck400 FIND v(dout0_51) AT=205.025n

.meas tran vdout0_52ck400 FIND v(dout0_52) AT=205.025n

.meas tran vdout0_53ck400 FIND v(dout0_53) AT=205.025n

.meas tran vdout0_54ck400 FIND v(dout0_54) AT=205.025n

.meas tran vdout0_55ck400 FIND v(dout0_55) AT=205.025n

.meas tran vdout0_56ck400 FIND v(dout0_56) AT=205.025n

.meas tran vdout0_57ck400 FIND v(dout0_57) AT=205.025n

.meas tran vdout0_58ck400 FIND v(dout0_58) AT=205.025n

.meas tran vdout0_59ck400 FIND v(dout0_59) AT=205.025n

.meas tran vdout0_60ck400 FIND v(dout0_60) AT=205.025n

.meas tran vdout0_61ck400 FIND v(dout0_61) AT=205.025n

.meas tran vdout0_62ck400 FIND v(dout0_62) AT=205.025n

.meas tran vdout0_63ck400 FIND v(dout0_63) AT=205.025n

.meas tran vdout0_64ck400 FIND v(dout0_64) AT=205.025n

.meas tran vdout0_65ck400 FIND v(dout0_65) AT=205.025n

.meas tran vdout0_66ck400 FIND v(dout0_66) AT=205.025n

.meas tran vdout0_67ck400 FIND v(dout0_67) AT=205.025n

.meas tran vdout0_68ck400 FIND v(dout0_68) AT=205.025n

.meas tran vdout0_69ck400 FIND v(dout0_69) AT=205.025n

.meas tran vdout0_70ck400 FIND v(dout0_70) AT=205.025n

.meas tran vdout0_71ck400 FIND v(dout0_71) AT=205.025n

.meas tran vdout0_72ck400 FIND v(dout0_72) AT=205.025n

.meas tran vdout0_73ck400 FIND v(dout0_73) AT=205.025n

.meas tran vdout0_74ck400 FIND v(dout0_74) AT=205.025n

.meas tran vdout0_75ck400 FIND v(dout0_75) AT=205.025n

.meas tran vdout0_76ck400 FIND v(dout0_76) AT=205.025n

.meas tran vdout0_77ck400 FIND v(dout0_77) AT=205.025n

.meas tran vdout0_78ck400 FIND v(dout0_78) AT=205.025n

.meas tran vdout0_79ck400 FIND v(dout0_79) AT=205.025n

.meas tran vdout0_80ck400 FIND v(dout0_80) AT=205.025n

.meas tran vdout0_81ck400 FIND v(dout0_81) AT=205.025n

.meas tran vdout0_82ck400 FIND v(dout0_82) AT=205.025n

.meas tran vdout0_83ck400 FIND v(dout0_83) AT=205.025n

.meas tran vdout0_84ck400 FIND v(dout0_84) AT=205.025n

.meas tran vdout0_85ck400 FIND v(dout0_85) AT=205.025n

.meas tran vdout0_86ck400 FIND v(dout0_86) AT=205.025n

.meas tran vdout0_87ck400 FIND v(dout0_87) AT=205.025n

.meas tran vdout0_88ck400 FIND v(dout0_88) AT=205.025n

.meas tran vdout0_89ck400 FIND v(dout0_89) AT=205.025n

.meas tran vdout0_90ck400 FIND v(dout0_90) AT=205.025n

.meas tran vdout0_91ck400 FIND v(dout0_91) AT=205.025n

.meas tran vdout0_92ck400 FIND v(dout0_92) AT=205.025n

.meas tran vdout0_93ck400 FIND v(dout0_93) AT=205.025n

.meas tran vdout0_94ck400 FIND v(dout0_94) AT=205.025n

.meas tran vdout0_95ck400 FIND v(dout0_95) AT=205.025n

.meas tran vdout0_96ck400 FIND v(dout0_96) AT=205.025n

.meas tran vdout0_97ck400 FIND v(dout0_97) AT=205.025n

.meas tran vdout0_98ck400 FIND v(dout0_98) AT=205.025n

.meas tran vdout0_99ck400 FIND v(dout0_99) AT=205.025n

.meas tran vdout0_100ck400 FIND v(dout0_100) AT=205.025n

.meas tran vdout0_101ck400 FIND v(dout0_101) AT=205.025n

.meas tran vdout0_102ck400 FIND v(dout0_102) AT=205.025n

.meas tran vdout0_103ck400 FIND v(dout0_103) AT=205.025n

.meas tran vdout0_104ck400 FIND v(dout0_104) AT=205.025n

.meas tran vdout0_105ck400 FIND v(dout0_105) AT=205.025n

.meas tran vdout0_106ck400 FIND v(dout0_106) AT=205.025n

.meas tran vdout0_107ck400 FIND v(dout0_107) AT=205.025n

.meas tran vdout0_108ck400 FIND v(dout0_108) AT=205.025n

.meas tran vdout0_109ck400 FIND v(dout0_109) AT=205.025n

.meas tran vdout0_110ck400 FIND v(dout0_110) AT=205.025n

.meas tran vdout0_111ck400 FIND v(dout0_111) AT=205.025n

.meas tran vdout0_112ck400 FIND v(dout0_112) AT=205.025n

.meas tran vdout0_113ck400 FIND v(dout0_113) AT=205.025n

.meas tran vdout0_114ck400 FIND v(dout0_114) AT=205.025n

.meas tran vdout0_115ck400 FIND v(dout0_115) AT=205.025n

.meas tran vdout0_116ck400 FIND v(dout0_116) AT=205.025n

.meas tran vdout0_117ck400 FIND v(dout0_117) AT=205.025n

.meas tran vdout0_118ck400 FIND v(dout0_118) AT=205.025n

.meas tran vdout0_119ck400 FIND v(dout0_119) AT=205.025n

.meas tran vdout0_120ck400 FIND v(dout0_120) AT=205.025n

.meas tran vdout0_121ck400 FIND v(dout0_121) AT=205.025n

.meas tran vdout0_122ck400 FIND v(dout0_122) AT=205.025n

.meas tran vdout0_123ck400 FIND v(dout0_123) AT=205.025n

.meas tran vdout0_124ck400 FIND v(dout0_124) AT=205.025n

.meas tran vdout0_125ck400 FIND v(dout0_125) AT=205.025n

.meas tran vdout0_126ck400 FIND v(dout0_126) AT=205.025n

.meas tran vdout0_127ck400 FIND v(dout0_127) AT=205.025n

.meas tran vdout0_0ck410 FIND v(dout0_0) AT=210.025n

.meas tran vdout0_1ck410 FIND v(dout0_1) AT=210.025n

.meas tran vdout0_2ck410 FIND v(dout0_2) AT=210.025n

.meas tran vdout0_3ck410 FIND v(dout0_3) AT=210.025n

.meas tran vdout0_4ck410 FIND v(dout0_4) AT=210.025n

.meas tran vdout0_5ck410 FIND v(dout0_5) AT=210.025n

.meas tran vdout0_6ck410 FIND v(dout0_6) AT=210.025n

.meas tran vdout0_7ck410 FIND v(dout0_7) AT=210.025n

.meas tran vdout0_8ck410 FIND v(dout0_8) AT=210.025n

.meas tran vdout0_9ck410 FIND v(dout0_9) AT=210.025n

.meas tran vdout0_10ck410 FIND v(dout0_10) AT=210.025n

.meas tran vdout0_11ck410 FIND v(dout0_11) AT=210.025n

.meas tran vdout0_12ck410 FIND v(dout0_12) AT=210.025n

.meas tran vdout0_13ck410 FIND v(dout0_13) AT=210.025n

.meas tran vdout0_14ck410 FIND v(dout0_14) AT=210.025n

.meas tran vdout0_15ck410 FIND v(dout0_15) AT=210.025n

.meas tran vdout0_16ck410 FIND v(dout0_16) AT=210.025n

.meas tran vdout0_17ck410 FIND v(dout0_17) AT=210.025n

.meas tran vdout0_18ck410 FIND v(dout0_18) AT=210.025n

.meas tran vdout0_19ck410 FIND v(dout0_19) AT=210.025n

.meas tran vdout0_20ck410 FIND v(dout0_20) AT=210.025n

.meas tran vdout0_21ck410 FIND v(dout0_21) AT=210.025n

.meas tran vdout0_22ck410 FIND v(dout0_22) AT=210.025n

.meas tran vdout0_23ck410 FIND v(dout0_23) AT=210.025n

.meas tran vdout0_24ck410 FIND v(dout0_24) AT=210.025n

.meas tran vdout0_25ck410 FIND v(dout0_25) AT=210.025n

.meas tran vdout0_26ck410 FIND v(dout0_26) AT=210.025n

.meas tran vdout0_27ck410 FIND v(dout0_27) AT=210.025n

.meas tran vdout0_28ck410 FIND v(dout0_28) AT=210.025n

.meas tran vdout0_29ck410 FIND v(dout0_29) AT=210.025n

.meas tran vdout0_30ck410 FIND v(dout0_30) AT=210.025n

.meas tran vdout0_31ck410 FIND v(dout0_31) AT=210.025n

.meas tran vdout0_32ck410 FIND v(dout0_32) AT=210.025n

.meas tran vdout0_33ck410 FIND v(dout0_33) AT=210.025n

.meas tran vdout0_34ck410 FIND v(dout0_34) AT=210.025n

.meas tran vdout0_35ck410 FIND v(dout0_35) AT=210.025n

.meas tran vdout0_36ck410 FIND v(dout0_36) AT=210.025n

.meas tran vdout0_37ck410 FIND v(dout0_37) AT=210.025n

.meas tran vdout0_38ck410 FIND v(dout0_38) AT=210.025n

.meas tran vdout0_39ck410 FIND v(dout0_39) AT=210.025n

.meas tran vdout0_40ck410 FIND v(dout0_40) AT=210.025n

.meas tran vdout0_41ck410 FIND v(dout0_41) AT=210.025n

.meas tran vdout0_42ck410 FIND v(dout0_42) AT=210.025n

.meas tran vdout0_43ck410 FIND v(dout0_43) AT=210.025n

.meas tran vdout0_44ck410 FIND v(dout0_44) AT=210.025n

.meas tran vdout0_45ck410 FIND v(dout0_45) AT=210.025n

.meas tran vdout0_46ck410 FIND v(dout0_46) AT=210.025n

.meas tran vdout0_47ck410 FIND v(dout0_47) AT=210.025n

.meas tran vdout0_48ck410 FIND v(dout0_48) AT=210.025n

.meas tran vdout0_49ck410 FIND v(dout0_49) AT=210.025n

.meas tran vdout0_50ck410 FIND v(dout0_50) AT=210.025n

.meas tran vdout0_51ck410 FIND v(dout0_51) AT=210.025n

.meas tran vdout0_52ck410 FIND v(dout0_52) AT=210.025n

.meas tran vdout0_53ck410 FIND v(dout0_53) AT=210.025n

.meas tran vdout0_54ck410 FIND v(dout0_54) AT=210.025n

.meas tran vdout0_55ck410 FIND v(dout0_55) AT=210.025n

.meas tran vdout0_56ck410 FIND v(dout0_56) AT=210.025n

.meas tran vdout0_57ck410 FIND v(dout0_57) AT=210.025n

.meas tran vdout0_58ck410 FIND v(dout0_58) AT=210.025n

.meas tran vdout0_59ck410 FIND v(dout0_59) AT=210.025n

.meas tran vdout0_60ck410 FIND v(dout0_60) AT=210.025n

.meas tran vdout0_61ck410 FIND v(dout0_61) AT=210.025n

.meas tran vdout0_62ck410 FIND v(dout0_62) AT=210.025n

.meas tran vdout0_63ck410 FIND v(dout0_63) AT=210.025n

.meas tran vdout0_64ck410 FIND v(dout0_64) AT=210.025n

.meas tran vdout0_65ck410 FIND v(dout0_65) AT=210.025n

.meas tran vdout0_66ck410 FIND v(dout0_66) AT=210.025n

.meas tran vdout0_67ck410 FIND v(dout0_67) AT=210.025n

.meas tran vdout0_68ck410 FIND v(dout0_68) AT=210.025n

.meas tran vdout0_69ck410 FIND v(dout0_69) AT=210.025n

.meas tran vdout0_70ck410 FIND v(dout0_70) AT=210.025n

.meas tran vdout0_71ck410 FIND v(dout0_71) AT=210.025n

.meas tran vdout0_72ck410 FIND v(dout0_72) AT=210.025n

.meas tran vdout0_73ck410 FIND v(dout0_73) AT=210.025n

.meas tran vdout0_74ck410 FIND v(dout0_74) AT=210.025n

.meas tran vdout0_75ck410 FIND v(dout0_75) AT=210.025n

.meas tran vdout0_76ck410 FIND v(dout0_76) AT=210.025n

.meas tran vdout0_77ck410 FIND v(dout0_77) AT=210.025n

.meas tran vdout0_78ck410 FIND v(dout0_78) AT=210.025n

.meas tran vdout0_79ck410 FIND v(dout0_79) AT=210.025n

.meas tran vdout0_80ck410 FIND v(dout0_80) AT=210.025n

.meas tran vdout0_81ck410 FIND v(dout0_81) AT=210.025n

.meas tran vdout0_82ck410 FIND v(dout0_82) AT=210.025n

.meas tran vdout0_83ck410 FIND v(dout0_83) AT=210.025n

.meas tran vdout0_84ck410 FIND v(dout0_84) AT=210.025n

.meas tran vdout0_85ck410 FIND v(dout0_85) AT=210.025n

.meas tran vdout0_86ck410 FIND v(dout0_86) AT=210.025n

.meas tran vdout0_87ck410 FIND v(dout0_87) AT=210.025n

.meas tran vdout0_88ck410 FIND v(dout0_88) AT=210.025n

.meas tran vdout0_89ck410 FIND v(dout0_89) AT=210.025n

.meas tran vdout0_90ck410 FIND v(dout0_90) AT=210.025n

.meas tran vdout0_91ck410 FIND v(dout0_91) AT=210.025n

.meas tran vdout0_92ck410 FIND v(dout0_92) AT=210.025n

.meas tran vdout0_93ck410 FIND v(dout0_93) AT=210.025n

.meas tran vdout0_94ck410 FIND v(dout0_94) AT=210.025n

.meas tran vdout0_95ck410 FIND v(dout0_95) AT=210.025n

.meas tran vdout0_96ck410 FIND v(dout0_96) AT=210.025n

.meas tran vdout0_97ck410 FIND v(dout0_97) AT=210.025n

.meas tran vdout0_98ck410 FIND v(dout0_98) AT=210.025n

.meas tran vdout0_99ck410 FIND v(dout0_99) AT=210.025n

.meas tran vdout0_100ck410 FIND v(dout0_100) AT=210.025n

.meas tran vdout0_101ck410 FIND v(dout0_101) AT=210.025n

.meas tran vdout0_102ck410 FIND v(dout0_102) AT=210.025n

.meas tran vdout0_103ck410 FIND v(dout0_103) AT=210.025n

.meas tran vdout0_104ck410 FIND v(dout0_104) AT=210.025n

.meas tran vdout0_105ck410 FIND v(dout0_105) AT=210.025n

.meas tran vdout0_106ck410 FIND v(dout0_106) AT=210.025n

.meas tran vdout0_107ck410 FIND v(dout0_107) AT=210.025n

.meas tran vdout0_108ck410 FIND v(dout0_108) AT=210.025n

.meas tran vdout0_109ck410 FIND v(dout0_109) AT=210.025n

.meas tran vdout0_110ck410 FIND v(dout0_110) AT=210.025n

.meas tran vdout0_111ck410 FIND v(dout0_111) AT=210.025n

.meas tran vdout0_112ck410 FIND v(dout0_112) AT=210.025n

.meas tran vdout0_113ck410 FIND v(dout0_113) AT=210.025n

.meas tran vdout0_114ck410 FIND v(dout0_114) AT=210.025n

.meas tran vdout0_115ck410 FIND v(dout0_115) AT=210.025n

.meas tran vdout0_116ck410 FIND v(dout0_116) AT=210.025n

.meas tran vdout0_117ck410 FIND v(dout0_117) AT=210.025n

.meas tran vdout0_118ck410 FIND v(dout0_118) AT=210.025n

.meas tran vdout0_119ck410 FIND v(dout0_119) AT=210.025n

.meas tran vdout0_120ck410 FIND v(dout0_120) AT=210.025n

.meas tran vdout0_121ck410 FIND v(dout0_121) AT=210.025n

.meas tran vdout0_122ck410 FIND v(dout0_122) AT=210.025n

.meas tran vdout0_123ck410 FIND v(dout0_123) AT=210.025n

.meas tran vdout0_124ck410 FIND v(dout0_124) AT=210.025n

.meas tran vdout0_125ck410 FIND v(dout0_125) AT=210.025n

.meas tran vdout0_126ck410 FIND v(dout0_126) AT=210.025n

.meas tran vdout0_127ck410 FIND v(dout0_127) AT=210.025n

.meas tran vdout0_0ck430 FIND v(dout0_0) AT=220.025n

.meas tran vdout0_1ck430 FIND v(dout0_1) AT=220.025n

.meas tran vdout0_2ck430 FIND v(dout0_2) AT=220.025n

.meas tran vdout0_3ck430 FIND v(dout0_3) AT=220.025n

.meas tran vdout0_4ck430 FIND v(dout0_4) AT=220.025n

.meas tran vdout0_5ck430 FIND v(dout0_5) AT=220.025n

.meas tran vdout0_6ck430 FIND v(dout0_6) AT=220.025n

.meas tran vdout0_7ck430 FIND v(dout0_7) AT=220.025n

.meas tran vdout0_8ck430 FIND v(dout0_8) AT=220.025n

.meas tran vdout0_9ck430 FIND v(dout0_9) AT=220.025n

.meas tran vdout0_10ck430 FIND v(dout0_10) AT=220.025n

.meas tran vdout0_11ck430 FIND v(dout0_11) AT=220.025n

.meas tran vdout0_12ck430 FIND v(dout0_12) AT=220.025n

.meas tran vdout0_13ck430 FIND v(dout0_13) AT=220.025n

.meas tran vdout0_14ck430 FIND v(dout0_14) AT=220.025n

.meas tran vdout0_15ck430 FIND v(dout0_15) AT=220.025n

.meas tran vdout0_16ck430 FIND v(dout0_16) AT=220.025n

.meas tran vdout0_17ck430 FIND v(dout0_17) AT=220.025n

.meas tran vdout0_18ck430 FIND v(dout0_18) AT=220.025n

.meas tran vdout0_19ck430 FIND v(dout0_19) AT=220.025n

.meas tran vdout0_20ck430 FIND v(dout0_20) AT=220.025n

.meas tran vdout0_21ck430 FIND v(dout0_21) AT=220.025n

.meas tran vdout0_22ck430 FIND v(dout0_22) AT=220.025n

.meas tran vdout0_23ck430 FIND v(dout0_23) AT=220.025n

.meas tran vdout0_24ck430 FIND v(dout0_24) AT=220.025n

.meas tran vdout0_25ck430 FIND v(dout0_25) AT=220.025n

.meas tran vdout0_26ck430 FIND v(dout0_26) AT=220.025n

.meas tran vdout0_27ck430 FIND v(dout0_27) AT=220.025n

.meas tran vdout0_28ck430 FIND v(dout0_28) AT=220.025n

.meas tran vdout0_29ck430 FIND v(dout0_29) AT=220.025n

.meas tran vdout0_30ck430 FIND v(dout0_30) AT=220.025n

.meas tran vdout0_31ck430 FIND v(dout0_31) AT=220.025n

.meas tran vdout0_32ck430 FIND v(dout0_32) AT=220.025n

.meas tran vdout0_33ck430 FIND v(dout0_33) AT=220.025n

.meas tran vdout0_34ck430 FIND v(dout0_34) AT=220.025n

.meas tran vdout0_35ck430 FIND v(dout0_35) AT=220.025n

.meas tran vdout0_36ck430 FIND v(dout0_36) AT=220.025n

.meas tran vdout0_37ck430 FIND v(dout0_37) AT=220.025n

.meas tran vdout0_38ck430 FIND v(dout0_38) AT=220.025n

.meas tran vdout0_39ck430 FIND v(dout0_39) AT=220.025n

.meas tran vdout0_40ck430 FIND v(dout0_40) AT=220.025n

.meas tran vdout0_41ck430 FIND v(dout0_41) AT=220.025n

.meas tran vdout0_42ck430 FIND v(dout0_42) AT=220.025n

.meas tran vdout0_43ck430 FIND v(dout0_43) AT=220.025n

.meas tran vdout0_44ck430 FIND v(dout0_44) AT=220.025n

.meas tran vdout0_45ck430 FIND v(dout0_45) AT=220.025n

.meas tran vdout0_46ck430 FIND v(dout0_46) AT=220.025n

.meas tran vdout0_47ck430 FIND v(dout0_47) AT=220.025n

.meas tran vdout0_48ck430 FIND v(dout0_48) AT=220.025n

.meas tran vdout0_49ck430 FIND v(dout0_49) AT=220.025n

.meas tran vdout0_50ck430 FIND v(dout0_50) AT=220.025n

.meas tran vdout0_51ck430 FIND v(dout0_51) AT=220.025n

.meas tran vdout0_52ck430 FIND v(dout0_52) AT=220.025n

.meas tran vdout0_53ck430 FIND v(dout0_53) AT=220.025n

.meas tran vdout0_54ck430 FIND v(dout0_54) AT=220.025n

.meas tran vdout0_55ck430 FIND v(dout0_55) AT=220.025n

.meas tran vdout0_56ck430 FIND v(dout0_56) AT=220.025n

.meas tran vdout0_57ck430 FIND v(dout0_57) AT=220.025n

.meas tran vdout0_58ck430 FIND v(dout0_58) AT=220.025n

.meas tran vdout0_59ck430 FIND v(dout0_59) AT=220.025n

.meas tran vdout0_60ck430 FIND v(dout0_60) AT=220.025n

.meas tran vdout0_61ck430 FIND v(dout0_61) AT=220.025n

.meas tran vdout0_62ck430 FIND v(dout0_62) AT=220.025n

.meas tran vdout0_63ck430 FIND v(dout0_63) AT=220.025n

.meas tran vdout0_64ck430 FIND v(dout0_64) AT=220.025n

.meas tran vdout0_65ck430 FIND v(dout0_65) AT=220.025n

.meas tran vdout0_66ck430 FIND v(dout0_66) AT=220.025n

.meas tran vdout0_67ck430 FIND v(dout0_67) AT=220.025n

.meas tran vdout0_68ck430 FIND v(dout0_68) AT=220.025n

.meas tran vdout0_69ck430 FIND v(dout0_69) AT=220.025n

.meas tran vdout0_70ck430 FIND v(dout0_70) AT=220.025n

.meas tran vdout0_71ck430 FIND v(dout0_71) AT=220.025n

.meas tran vdout0_72ck430 FIND v(dout0_72) AT=220.025n

.meas tran vdout0_73ck430 FIND v(dout0_73) AT=220.025n

.meas tran vdout0_74ck430 FIND v(dout0_74) AT=220.025n

.meas tran vdout0_75ck430 FIND v(dout0_75) AT=220.025n

.meas tran vdout0_76ck430 FIND v(dout0_76) AT=220.025n

.meas tran vdout0_77ck430 FIND v(dout0_77) AT=220.025n

.meas tran vdout0_78ck430 FIND v(dout0_78) AT=220.025n

.meas tran vdout0_79ck430 FIND v(dout0_79) AT=220.025n

.meas tran vdout0_80ck430 FIND v(dout0_80) AT=220.025n

.meas tran vdout0_81ck430 FIND v(dout0_81) AT=220.025n

.meas tran vdout0_82ck430 FIND v(dout0_82) AT=220.025n

.meas tran vdout0_83ck430 FIND v(dout0_83) AT=220.025n

.meas tran vdout0_84ck430 FIND v(dout0_84) AT=220.025n

.meas tran vdout0_85ck430 FIND v(dout0_85) AT=220.025n

.meas tran vdout0_86ck430 FIND v(dout0_86) AT=220.025n

.meas tran vdout0_87ck430 FIND v(dout0_87) AT=220.025n

.meas tran vdout0_88ck430 FIND v(dout0_88) AT=220.025n

.meas tran vdout0_89ck430 FIND v(dout0_89) AT=220.025n

.meas tran vdout0_90ck430 FIND v(dout0_90) AT=220.025n

.meas tran vdout0_91ck430 FIND v(dout0_91) AT=220.025n

.meas tran vdout0_92ck430 FIND v(dout0_92) AT=220.025n

.meas tran vdout0_93ck430 FIND v(dout0_93) AT=220.025n

.meas tran vdout0_94ck430 FIND v(dout0_94) AT=220.025n

.meas tran vdout0_95ck430 FIND v(dout0_95) AT=220.025n

.meas tran vdout0_96ck430 FIND v(dout0_96) AT=220.025n

.meas tran vdout0_97ck430 FIND v(dout0_97) AT=220.025n

.meas tran vdout0_98ck430 FIND v(dout0_98) AT=220.025n

.meas tran vdout0_99ck430 FIND v(dout0_99) AT=220.025n

.meas tran vdout0_100ck430 FIND v(dout0_100) AT=220.025n

.meas tran vdout0_101ck430 FIND v(dout0_101) AT=220.025n

.meas tran vdout0_102ck430 FIND v(dout0_102) AT=220.025n

.meas tran vdout0_103ck430 FIND v(dout0_103) AT=220.025n

.meas tran vdout0_104ck430 FIND v(dout0_104) AT=220.025n

.meas tran vdout0_105ck430 FIND v(dout0_105) AT=220.025n

.meas tran vdout0_106ck430 FIND v(dout0_106) AT=220.025n

.meas tran vdout0_107ck430 FIND v(dout0_107) AT=220.025n

.meas tran vdout0_108ck430 FIND v(dout0_108) AT=220.025n

.meas tran vdout0_109ck430 FIND v(dout0_109) AT=220.025n

.meas tran vdout0_110ck430 FIND v(dout0_110) AT=220.025n

.meas tran vdout0_111ck430 FIND v(dout0_111) AT=220.025n

.meas tran vdout0_112ck430 FIND v(dout0_112) AT=220.025n

.meas tran vdout0_113ck430 FIND v(dout0_113) AT=220.025n

.meas tran vdout0_114ck430 FIND v(dout0_114) AT=220.025n

.meas tran vdout0_115ck430 FIND v(dout0_115) AT=220.025n

.meas tran vdout0_116ck430 FIND v(dout0_116) AT=220.025n

.meas tran vdout0_117ck430 FIND v(dout0_117) AT=220.025n

.meas tran vdout0_118ck430 FIND v(dout0_118) AT=220.025n

.meas tran vdout0_119ck430 FIND v(dout0_119) AT=220.025n

.meas tran vdout0_120ck430 FIND v(dout0_120) AT=220.025n

.meas tran vdout0_121ck430 FIND v(dout0_121) AT=220.025n

.meas tran vdout0_122ck430 FIND v(dout0_122) AT=220.025n

.meas tran vdout0_123ck430 FIND v(dout0_123) AT=220.025n

.meas tran vdout0_124ck430 FIND v(dout0_124) AT=220.025n

.meas tran vdout0_125ck430 FIND v(dout0_125) AT=220.025n

.meas tran vdout0_126ck430 FIND v(dout0_126) AT=220.025n

.meas tran vdout0_127ck430 FIND v(dout0_127) AT=220.025n

.meas tran vdout0_0ck440 FIND v(dout0_0) AT=225.025n

.meas tran vdout0_1ck440 FIND v(dout0_1) AT=225.025n

.meas tran vdout0_2ck440 FIND v(dout0_2) AT=225.025n

.meas tran vdout0_3ck440 FIND v(dout0_3) AT=225.025n

.meas tran vdout0_4ck440 FIND v(dout0_4) AT=225.025n

.meas tran vdout0_5ck440 FIND v(dout0_5) AT=225.025n

.meas tran vdout0_6ck440 FIND v(dout0_6) AT=225.025n

.meas tran vdout0_7ck440 FIND v(dout0_7) AT=225.025n

.meas tran vdout0_8ck440 FIND v(dout0_8) AT=225.025n

.meas tran vdout0_9ck440 FIND v(dout0_9) AT=225.025n

.meas tran vdout0_10ck440 FIND v(dout0_10) AT=225.025n

.meas tran vdout0_11ck440 FIND v(dout0_11) AT=225.025n

.meas tran vdout0_12ck440 FIND v(dout0_12) AT=225.025n

.meas tran vdout0_13ck440 FIND v(dout0_13) AT=225.025n

.meas tran vdout0_14ck440 FIND v(dout0_14) AT=225.025n

.meas tran vdout0_15ck440 FIND v(dout0_15) AT=225.025n

.meas tran vdout0_16ck440 FIND v(dout0_16) AT=225.025n

.meas tran vdout0_17ck440 FIND v(dout0_17) AT=225.025n

.meas tran vdout0_18ck440 FIND v(dout0_18) AT=225.025n

.meas tran vdout0_19ck440 FIND v(dout0_19) AT=225.025n

.meas tran vdout0_20ck440 FIND v(dout0_20) AT=225.025n

.meas tran vdout0_21ck440 FIND v(dout0_21) AT=225.025n

.meas tran vdout0_22ck440 FIND v(dout0_22) AT=225.025n

.meas tran vdout0_23ck440 FIND v(dout0_23) AT=225.025n

.meas tran vdout0_24ck440 FIND v(dout0_24) AT=225.025n

.meas tran vdout0_25ck440 FIND v(dout0_25) AT=225.025n

.meas tran vdout0_26ck440 FIND v(dout0_26) AT=225.025n

.meas tran vdout0_27ck440 FIND v(dout0_27) AT=225.025n

.meas tran vdout0_28ck440 FIND v(dout0_28) AT=225.025n

.meas tran vdout0_29ck440 FIND v(dout0_29) AT=225.025n

.meas tran vdout0_30ck440 FIND v(dout0_30) AT=225.025n

.meas tran vdout0_31ck440 FIND v(dout0_31) AT=225.025n

.meas tran vdout0_32ck440 FIND v(dout0_32) AT=225.025n

.meas tran vdout0_33ck440 FIND v(dout0_33) AT=225.025n

.meas tran vdout0_34ck440 FIND v(dout0_34) AT=225.025n

.meas tran vdout0_35ck440 FIND v(dout0_35) AT=225.025n

.meas tran vdout0_36ck440 FIND v(dout0_36) AT=225.025n

.meas tran vdout0_37ck440 FIND v(dout0_37) AT=225.025n

.meas tran vdout0_38ck440 FIND v(dout0_38) AT=225.025n

.meas tran vdout0_39ck440 FIND v(dout0_39) AT=225.025n

.meas tran vdout0_40ck440 FIND v(dout0_40) AT=225.025n

.meas tran vdout0_41ck440 FIND v(dout0_41) AT=225.025n

.meas tran vdout0_42ck440 FIND v(dout0_42) AT=225.025n

.meas tran vdout0_43ck440 FIND v(dout0_43) AT=225.025n

.meas tran vdout0_44ck440 FIND v(dout0_44) AT=225.025n

.meas tran vdout0_45ck440 FIND v(dout0_45) AT=225.025n

.meas tran vdout0_46ck440 FIND v(dout0_46) AT=225.025n

.meas tran vdout0_47ck440 FIND v(dout0_47) AT=225.025n

.meas tran vdout0_48ck440 FIND v(dout0_48) AT=225.025n

.meas tran vdout0_49ck440 FIND v(dout0_49) AT=225.025n

.meas tran vdout0_50ck440 FIND v(dout0_50) AT=225.025n

.meas tran vdout0_51ck440 FIND v(dout0_51) AT=225.025n

.meas tran vdout0_52ck440 FIND v(dout0_52) AT=225.025n

.meas tran vdout0_53ck440 FIND v(dout0_53) AT=225.025n

.meas tran vdout0_54ck440 FIND v(dout0_54) AT=225.025n

.meas tran vdout0_55ck440 FIND v(dout0_55) AT=225.025n

.meas tran vdout0_56ck440 FIND v(dout0_56) AT=225.025n

.meas tran vdout0_57ck440 FIND v(dout0_57) AT=225.025n

.meas tran vdout0_58ck440 FIND v(dout0_58) AT=225.025n

.meas tran vdout0_59ck440 FIND v(dout0_59) AT=225.025n

.meas tran vdout0_60ck440 FIND v(dout0_60) AT=225.025n

.meas tran vdout0_61ck440 FIND v(dout0_61) AT=225.025n

.meas tran vdout0_62ck440 FIND v(dout0_62) AT=225.025n

.meas tran vdout0_63ck440 FIND v(dout0_63) AT=225.025n

.meas tran vdout0_64ck440 FIND v(dout0_64) AT=225.025n

.meas tran vdout0_65ck440 FIND v(dout0_65) AT=225.025n

.meas tran vdout0_66ck440 FIND v(dout0_66) AT=225.025n

.meas tran vdout0_67ck440 FIND v(dout0_67) AT=225.025n

.meas tran vdout0_68ck440 FIND v(dout0_68) AT=225.025n

.meas tran vdout0_69ck440 FIND v(dout0_69) AT=225.025n

.meas tran vdout0_70ck440 FIND v(dout0_70) AT=225.025n

.meas tran vdout0_71ck440 FIND v(dout0_71) AT=225.025n

.meas tran vdout0_72ck440 FIND v(dout0_72) AT=225.025n

.meas tran vdout0_73ck440 FIND v(dout0_73) AT=225.025n

.meas tran vdout0_74ck440 FIND v(dout0_74) AT=225.025n

.meas tran vdout0_75ck440 FIND v(dout0_75) AT=225.025n

.meas tran vdout0_76ck440 FIND v(dout0_76) AT=225.025n

.meas tran vdout0_77ck440 FIND v(dout0_77) AT=225.025n

.meas tran vdout0_78ck440 FIND v(dout0_78) AT=225.025n

.meas tran vdout0_79ck440 FIND v(dout0_79) AT=225.025n

.meas tran vdout0_80ck440 FIND v(dout0_80) AT=225.025n

.meas tran vdout0_81ck440 FIND v(dout0_81) AT=225.025n

.meas tran vdout0_82ck440 FIND v(dout0_82) AT=225.025n

.meas tran vdout0_83ck440 FIND v(dout0_83) AT=225.025n

.meas tran vdout0_84ck440 FIND v(dout0_84) AT=225.025n

.meas tran vdout0_85ck440 FIND v(dout0_85) AT=225.025n

.meas tran vdout0_86ck440 FIND v(dout0_86) AT=225.025n

.meas tran vdout0_87ck440 FIND v(dout0_87) AT=225.025n

.meas tran vdout0_88ck440 FIND v(dout0_88) AT=225.025n

.meas tran vdout0_89ck440 FIND v(dout0_89) AT=225.025n

.meas tran vdout0_90ck440 FIND v(dout0_90) AT=225.025n

.meas tran vdout0_91ck440 FIND v(dout0_91) AT=225.025n

.meas tran vdout0_92ck440 FIND v(dout0_92) AT=225.025n

.meas tran vdout0_93ck440 FIND v(dout0_93) AT=225.025n

.meas tran vdout0_94ck440 FIND v(dout0_94) AT=225.025n

.meas tran vdout0_95ck440 FIND v(dout0_95) AT=225.025n

.meas tran vdout0_96ck440 FIND v(dout0_96) AT=225.025n

.meas tran vdout0_97ck440 FIND v(dout0_97) AT=225.025n

.meas tran vdout0_98ck440 FIND v(dout0_98) AT=225.025n

.meas tran vdout0_99ck440 FIND v(dout0_99) AT=225.025n

.meas tran vdout0_100ck440 FIND v(dout0_100) AT=225.025n

.meas tran vdout0_101ck440 FIND v(dout0_101) AT=225.025n

.meas tran vdout0_102ck440 FIND v(dout0_102) AT=225.025n

.meas tran vdout0_103ck440 FIND v(dout0_103) AT=225.025n

.meas tran vdout0_104ck440 FIND v(dout0_104) AT=225.025n

.meas tran vdout0_105ck440 FIND v(dout0_105) AT=225.025n

.meas tran vdout0_106ck440 FIND v(dout0_106) AT=225.025n

.meas tran vdout0_107ck440 FIND v(dout0_107) AT=225.025n

.meas tran vdout0_108ck440 FIND v(dout0_108) AT=225.025n

.meas tran vdout0_109ck440 FIND v(dout0_109) AT=225.025n

.meas tran vdout0_110ck440 FIND v(dout0_110) AT=225.025n

.meas tran vdout0_111ck440 FIND v(dout0_111) AT=225.025n

.meas tran vdout0_112ck440 FIND v(dout0_112) AT=225.025n

.meas tran vdout0_113ck440 FIND v(dout0_113) AT=225.025n

.meas tran vdout0_114ck440 FIND v(dout0_114) AT=225.025n

.meas tran vdout0_115ck440 FIND v(dout0_115) AT=225.025n

.meas tran vdout0_116ck440 FIND v(dout0_116) AT=225.025n

.meas tran vdout0_117ck440 FIND v(dout0_117) AT=225.025n

.meas tran vdout0_118ck440 FIND v(dout0_118) AT=225.025n

.meas tran vdout0_119ck440 FIND v(dout0_119) AT=225.025n

.meas tran vdout0_120ck440 FIND v(dout0_120) AT=225.025n

.meas tran vdout0_121ck440 FIND v(dout0_121) AT=225.025n

.meas tran vdout0_122ck440 FIND v(dout0_122) AT=225.025n

.meas tran vdout0_123ck440 FIND v(dout0_123) AT=225.025n

.meas tran vdout0_124ck440 FIND v(dout0_124) AT=225.025n

.meas tran vdout0_125ck440 FIND v(dout0_125) AT=225.025n

.meas tran vdout0_126ck440 FIND v(dout0_126) AT=225.025n

.meas tran vdout0_127ck440 FIND v(dout0_127) AT=225.025n

.meas tran vdout0_0ck450 FIND v(dout0_0) AT=230.025n

.meas tran vdout0_1ck450 FIND v(dout0_1) AT=230.025n

.meas tran vdout0_2ck450 FIND v(dout0_2) AT=230.025n

.meas tran vdout0_3ck450 FIND v(dout0_3) AT=230.025n

.meas tran vdout0_4ck450 FIND v(dout0_4) AT=230.025n

.meas tran vdout0_5ck450 FIND v(dout0_5) AT=230.025n

.meas tran vdout0_6ck450 FIND v(dout0_6) AT=230.025n

.meas tran vdout0_7ck450 FIND v(dout0_7) AT=230.025n

.meas tran vdout0_8ck450 FIND v(dout0_8) AT=230.025n

.meas tran vdout0_9ck450 FIND v(dout0_9) AT=230.025n

.meas tran vdout0_10ck450 FIND v(dout0_10) AT=230.025n

.meas tran vdout0_11ck450 FIND v(dout0_11) AT=230.025n

.meas tran vdout0_12ck450 FIND v(dout0_12) AT=230.025n

.meas tran vdout0_13ck450 FIND v(dout0_13) AT=230.025n

.meas tran vdout0_14ck450 FIND v(dout0_14) AT=230.025n

.meas tran vdout0_15ck450 FIND v(dout0_15) AT=230.025n

.meas tran vdout0_16ck450 FIND v(dout0_16) AT=230.025n

.meas tran vdout0_17ck450 FIND v(dout0_17) AT=230.025n

.meas tran vdout0_18ck450 FIND v(dout0_18) AT=230.025n

.meas tran vdout0_19ck450 FIND v(dout0_19) AT=230.025n

.meas tran vdout0_20ck450 FIND v(dout0_20) AT=230.025n

.meas tran vdout0_21ck450 FIND v(dout0_21) AT=230.025n

.meas tran vdout0_22ck450 FIND v(dout0_22) AT=230.025n

.meas tran vdout0_23ck450 FIND v(dout0_23) AT=230.025n

.meas tran vdout0_24ck450 FIND v(dout0_24) AT=230.025n

.meas tran vdout0_25ck450 FIND v(dout0_25) AT=230.025n

.meas tran vdout0_26ck450 FIND v(dout0_26) AT=230.025n

.meas tran vdout0_27ck450 FIND v(dout0_27) AT=230.025n

.meas tran vdout0_28ck450 FIND v(dout0_28) AT=230.025n

.meas tran vdout0_29ck450 FIND v(dout0_29) AT=230.025n

.meas tran vdout0_30ck450 FIND v(dout0_30) AT=230.025n

.meas tran vdout0_31ck450 FIND v(dout0_31) AT=230.025n

.meas tran vdout0_32ck450 FIND v(dout0_32) AT=230.025n

.meas tran vdout0_33ck450 FIND v(dout0_33) AT=230.025n

.meas tran vdout0_34ck450 FIND v(dout0_34) AT=230.025n

.meas tran vdout0_35ck450 FIND v(dout0_35) AT=230.025n

.meas tran vdout0_36ck450 FIND v(dout0_36) AT=230.025n

.meas tran vdout0_37ck450 FIND v(dout0_37) AT=230.025n

.meas tran vdout0_38ck450 FIND v(dout0_38) AT=230.025n

.meas tran vdout0_39ck450 FIND v(dout0_39) AT=230.025n

.meas tran vdout0_40ck450 FIND v(dout0_40) AT=230.025n

.meas tran vdout0_41ck450 FIND v(dout0_41) AT=230.025n

.meas tran vdout0_42ck450 FIND v(dout0_42) AT=230.025n

.meas tran vdout0_43ck450 FIND v(dout0_43) AT=230.025n

.meas tran vdout0_44ck450 FIND v(dout0_44) AT=230.025n

.meas tran vdout0_45ck450 FIND v(dout0_45) AT=230.025n

.meas tran vdout0_46ck450 FIND v(dout0_46) AT=230.025n

.meas tran vdout0_47ck450 FIND v(dout0_47) AT=230.025n

.meas tran vdout0_48ck450 FIND v(dout0_48) AT=230.025n

.meas tran vdout0_49ck450 FIND v(dout0_49) AT=230.025n

.meas tran vdout0_50ck450 FIND v(dout0_50) AT=230.025n

.meas tran vdout0_51ck450 FIND v(dout0_51) AT=230.025n

.meas tran vdout0_52ck450 FIND v(dout0_52) AT=230.025n

.meas tran vdout0_53ck450 FIND v(dout0_53) AT=230.025n

.meas tran vdout0_54ck450 FIND v(dout0_54) AT=230.025n

.meas tran vdout0_55ck450 FIND v(dout0_55) AT=230.025n

.meas tran vdout0_56ck450 FIND v(dout0_56) AT=230.025n

.meas tran vdout0_57ck450 FIND v(dout0_57) AT=230.025n

.meas tran vdout0_58ck450 FIND v(dout0_58) AT=230.025n

.meas tran vdout0_59ck450 FIND v(dout0_59) AT=230.025n

.meas tran vdout0_60ck450 FIND v(dout0_60) AT=230.025n

.meas tran vdout0_61ck450 FIND v(dout0_61) AT=230.025n

.meas tran vdout0_62ck450 FIND v(dout0_62) AT=230.025n

.meas tran vdout0_63ck450 FIND v(dout0_63) AT=230.025n

.meas tran vdout0_64ck450 FIND v(dout0_64) AT=230.025n

.meas tran vdout0_65ck450 FIND v(dout0_65) AT=230.025n

.meas tran vdout0_66ck450 FIND v(dout0_66) AT=230.025n

.meas tran vdout0_67ck450 FIND v(dout0_67) AT=230.025n

.meas tran vdout0_68ck450 FIND v(dout0_68) AT=230.025n

.meas tran vdout0_69ck450 FIND v(dout0_69) AT=230.025n

.meas tran vdout0_70ck450 FIND v(dout0_70) AT=230.025n

.meas tran vdout0_71ck450 FIND v(dout0_71) AT=230.025n

.meas tran vdout0_72ck450 FIND v(dout0_72) AT=230.025n

.meas tran vdout0_73ck450 FIND v(dout0_73) AT=230.025n

.meas tran vdout0_74ck450 FIND v(dout0_74) AT=230.025n

.meas tran vdout0_75ck450 FIND v(dout0_75) AT=230.025n

.meas tran vdout0_76ck450 FIND v(dout0_76) AT=230.025n

.meas tran vdout0_77ck450 FIND v(dout0_77) AT=230.025n

.meas tran vdout0_78ck450 FIND v(dout0_78) AT=230.025n

.meas tran vdout0_79ck450 FIND v(dout0_79) AT=230.025n

.meas tran vdout0_80ck450 FIND v(dout0_80) AT=230.025n

.meas tran vdout0_81ck450 FIND v(dout0_81) AT=230.025n

.meas tran vdout0_82ck450 FIND v(dout0_82) AT=230.025n

.meas tran vdout0_83ck450 FIND v(dout0_83) AT=230.025n

.meas tran vdout0_84ck450 FIND v(dout0_84) AT=230.025n

.meas tran vdout0_85ck450 FIND v(dout0_85) AT=230.025n

.meas tran vdout0_86ck450 FIND v(dout0_86) AT=230.025n

.meas tran vdout0_87ck450 FIND v(dout0_87) AT=230.025n

.meas tran vdout0_88ck450 FIND v(dout0_88) AT=230.025n

.meas tran vdout0_89ck450 FIND v(dout0_89) AT=230.025n

.meas tran vdout0_90ck450 FIND v(dout0_90) AT=230.025n

.meas tran vdout0_91ck450 FIND v(dout0_91) AT=230.025n

.meas tran vdout0_92ck450 FIND v(dout0_92) AT=230.025n

.meas tran vdout0_93ck450 FIND v(dout0_93) AT=230.025n

.meas tran vdout0_94ck450 FIND v(dout0_94) AT=230.025n

.meas tran vdout0_95ck450 FIND v(dout0_95) AT=230.025n

.meas tran vdout0_96ck450 FIND v(dout0_96) AT=230.025n

.meas tran vdout0_97ck450 FIND v(dout0_97) AT=230.025n

.meas tran vdout0_98ck450 FIND v(dout0_98) AT=230.025n

.meas tran vdout0_99ck450 FIND v(dout0_99) AT=230.025n

.meas tran vdout0_100ck450 FIND v(dout0_100) AT=230.025n

.meas tran vdout0_101ck450 FIND v(dout0_101) AT=230.025n

.meas tran vdout0_102ck450 FIND v(dout0_102) AT=230.025n

.meas tran vdout0_103ck450 FIND v(dout0_103) AT=230.025n

.meas tran vdout0_104ck450 FIND v(dout0_104) AT=230.025n

.meas tran vdout0_105ck450 FIND v(dout0_105) AT=230.025n

.meas tran vdout0_106ck450 FIND v(dout0_106) AT=230.025n

.meas tran vdout0_107ck450 FIND v(dout0_107) AT=230.025n

.meas tran vdout0_108ck450 FIND v(dout0_108) AT=230.025n

.meas tran vdout0_109ck450 FIND v(dout0_109) AT=230.025n

.meas tran vdout0_110ck450 FIND v(dout0_110) AT=230.025n

.meas tran vdout0_111ck450 FIND v(dout0_111) AT=230.025n

.meas tran vdout0_112ck450 FIND v(dout0_112) AT=230.025n

.meas tran vdout0_113ck450 FIND v(dout0_113) AT=230.025n

.meas tran vdout0_114ck450 FIND v(dout0_114) AT=230.025n

.meas tran vdout0_115ck450 FIND v(dout0_115) AT=230.025n

.meas tran vdout0_116ck450 FIND v(dout0_116) AT=230.025n

.meas tran vdout0_117ck450 FIND v(dout0_117) AT=230.025n

.meas tran vdout0_118ck450 FIND v(dout0_118) AT=230.025n

.meas tran vdout0_119ck450 FIND v(dout0_119) AT=230.025n

.meas tran vdout0_120ck450 FIND v(dout0_120) AT=230.025n

.meas tran vdout0_121ck450 FIND v(dout0_121) AT=230.025n

.meas tran vdout0_122ck450 FIND v(dout0_122) AT=230.025n

.meas tran vdout0_123ck450 FIND v(dout0_123) AT=230.025n

.meas tran vdout0_124ck450 FIND v(dout0_124) AT=230.025n

.meas tran vdout0_125ck450 FIND v(dout0_125) AT=230.025n

.meas tran vdout0_126ck450 FIND v(dout0_126) AT=230.025n

.meas tran vdout0_127ck450 FIND v(dout0_127) AT=230.025n

.meas tran vdout0_0ck490 FIND v(dout0_0) AT=250.025n

.meas tran vdout0_1ck490 FIND v(dout0_1) AT=250.025n

.meas tran vdout0_2ck490 FIND v(dout0_2) AT=250.025n

.meas tran vdout0_3ck490 FIND v(dout0_3) AT=250.025n

.meas tran vdout0_4ck490 FIND v(dout0_4) AT=250.025n

.meas tran vdout0_5ck490 FIND v(dout0_5) AT=250.025n

.meas tran vdout0_6ck490 FIND v(dout0_6) AT=250.025n

.meas tran vdout0_7ck490 FIND v(dout0_7) AT=250.025n

.meas tran vdout0_8ck490 FIND v(dout0_8) AT=250.025n

.meas tran vdout0_9ck490 FIND v(dout0_9) AT=250.025n

.meas tran vdout0_10ck490 FIND v(dout0_10) AT=250.025n

.meas tran vdout0_11ck490 FIND v(dout0_11) AT=250.025n

.meas tran vdout0_12ck490 FIND v(dout0_12) AT=250.025n

.meas tran vdout0_13ck490 FIND v(dout0_13) AT=250.025n

.meas tran vdout0_14ck490 FIND v(dout0_14) AT=250.025n

.meas tran vdout0_15ck490 FIND v(dout0_15) AT=250.025n

.meas tran vdout0_16ck490 FIND v(dout0_16) AT=250.025n

.meas tran vdout0_17ck490 FIND v(dout0_17) AT=250.025n

.meas tran vdout0_18ck490 FIND v(dout0_18) AT=250.025n

.meas tran vdout0_19ck490 FIND v(dout0_19) AT=250.025n

.meas tran vdout0_20ck490 FIND v(dout0_20) AT=250.025n

.meas tran vdout0_21ck490 FIND v(dout0_21) AT=250.025n

.meas tran vdout0_22ck490 FIND v(dout0_22) AT=250.025n

.meas tran vdout0_23ck490 FIND v(dout0_23) AT=250.025n

.meas tran vdout0_24ck490 FIND v(dout0_24) AT=250.025n

.meas tran vdout0_25ck490 FIND v(dout0_25) AT=250.025n

.meas tran vdout0_26ck490 FIND v(dout0_26) AT=250.025n

.meas tran vdout0_27ck490 FIND v(dout0_27) AT=250.025n

.meas tran vdout0_28ck490 FIND v(dout0_28) AT=250.025n

.meas tran vdout0_29ck490 FIND v(dout0_29) AT=250.025n

.meas tran vdout0_30ck490 FIND v(dout0_30) AT=250.025n

.meas tran vdout0_31ck490 FIND v(dout0_31) AT=250.025n

.meas tran vdout0_32ck490 FIND v(dout0_32) AT=250.025n

.meas tran vdout0_33ck490 FIND v(dout0_33) AT=250.025n

.meas tran vdout0_34ck490 FIND v(dout0_34) AT=250.025n

.meas tran vdout0_35ck490 FIND v(dout0_35) AT=250.025n

.meas tran vdout0_36ck490 FIND v(dout0_36) AT=250.025n

.meas tran vdout0_37ck490 FIND v(dout0_37) AT=250.025n

.meas tran vdout0_38ck490 FIND v(dout0_38) AT=250.025n

.meas tran vdout0_39ck490 FIND v(dout0_39) AT=250.025n

.meas tran vdout0_40ck490 FIND v(dout0_40) AT=250.025n

.meas tran vdout0_41ck490 FIND v(dout0_41) AT=250.025n

.meas tran vdout0_42ck490 FIND v(dout0_42) AT=250.025n

.meas tran vdout0_43ck490 FIND v(dout0_43) AT=250.025n

.meas tran vdout0_44ck490 FIND v(dout0_44) AT=250.025n

.meas tran vdout0_45ck490 FIND v(dout0_45) AT=250.025n

.meas tran vdout0_46ck490 FIND v(dout0_46) AT=250.025n

.meas tran vdout0_47ck490 FIND v(dout0_47) AT=250.025n

.meas tran vdout0_48ck490 FIND v(dout0_48) AT=250.025n

.meas tran vdout0_49ck490 FIND v(dout0_49) AT=250.025n

.meas tran vdout0_50ck490 FIND v(dout0_50) AT=250.025n

.meas tran vdout0_51ck490 FIND v(dout0_51) AT=250.025n

.meas tran vdout0_52ck490 FIND v(dout0_52) AT=250.025n

.meas tran vdout0_53ck490 FIND v(dout0_53) AT=250.025n

.meas tran vdout0_54ck490 FIND v(dout0_54) AT=250.025n

.meas tran vdout0_55ck490 FIND v(dout0_55) AT=250.025n

.meas tran vdout0_56ck490 FIND v(dout0_56) AT=250.025n

.meas tran vdout0_57ck490 FIND v(dout0_57) AT=250.025n

.meas tran vdout0_58ck490 FIND v(dout0_58) AT=250.025n

.meas tran vdout0_59ck490 FIND v(dout0_59) AT=250.025n

.meas tran vdout0_60ck490 FIND v(dout0_60) AT=250.025n

.meas tran vdout0_61ck490 FIND v(dout0_61) AT=250.025n

.meas tran vdout0_62ck490 FIND v(dout0_62) AT=250.025n

.meas tran vdout0_63ck490 FIND v(dout0_63) AT=250.025n

.meas tran vdout0_64ck490 FIND v(dout0_64) AT=250.025n

.meas tran vdout0_65ck490 FIND v(dout0_65) AT=250.025n

.meas tran vdout0_66ck490 FIND v(dout0_66) AT=250.025n

.meas tran vdout0_67ck490 FIND v(dout0_67) AT=250.025n

.meas tran vdout0_68ck490 FIND v(dout0_68) AT=250.025n

.meas tran vdout0_69ck490 FIND v(dout0_69) AT=250.025n

.meas tran vdout0_70ck490 FIND v(dout0_70) AT=250.025n

.meas tran vdout0_71ck490 FIND v(dout0_71) AT=250.025n

.meas tran vdout0_72ck490 FIND v(dout0_72) AT=250.025n

.meas tran vdout0_73ck490 FIND v(dout0_73) AT=250.025n

.meas tran vdout0_74ck490 FIND v(dout0_74) AT=250.025n

.meas tran vdout0_75ck490 FIND v(dout0_75) AT=250.025n

.meas tran vdout0_76ck490 FIND v(dout0_76) AT=250.025n

.meas tran vdout0_77ck490 FIND v(dout0_77) AT=250.025n

.meas tran vdout0_78ck490 FIND v(dout0_78) AT=250.025n

.meas tran vdout0_79ck490 FIND v(dout0_79) AT=250.025n

.meas tran vdout0_80ck490 FIND v(dout0_80) AT=250.025n

.meas tran vdout0_81ck490 FIND v(dout0_81) AT=250.025n

.meas tran vdout0_82ck490 FIND v(dout0_82) AT=250.025n

.meas tran vdout0_83ck490 FIND v(dout0_83) AT=250.025n

.meas tran vdout0_84ck490 FIND v(dout0_84) AT=250.025n

.meas tran vdout0_85ck490 FIND v(dout0_85) AT=250.025n

.meas tran vdout0_86ck490 FIND v(dout0_86) AT=250.025n

.meas tran vdout0_87ck490 FIND v(dout0_87) AT=250.025n

.meas tran vdout0_88ck490 FIND v(dout0_88) AT=250.025n

.meas tran vdout0_89ck490 FIND v(dout0_89) AT=250.025n

.meas tran vdout0_90ck490 FIND v(dout0_90) AT=250.025n

.meas tran vdout0_91ck490 FIND v(dout0_91) AT=250.025n

.meas tran vdout0_92ck490 FIND v(dout0_92) AT=250.025n

.meas tran vdout0_93ck490 FIND v(dout0_93) AT=250.025n

.meas tran vdout0_94ck490 FIND v(dout0_94) AT=250.025n

.meas tran vdout0_95ck490 FIND v(dout0_95) AT=250.025n

.meas tran vdout0_96ck490 FIND v(dout0_96) AT=250.025n

.meas tran vdout0_97ck490 FIND v(dout0_97) AT=250.025n

.meas tran vdout0_98ck490 FIND v(dout0_98) AT=250.025n

.meas tran vdout0_99ck490 FIND v(dout0_99) AT=250.025n

.meas tran vdout0_100ck490 FIND v(dout0_100) AT=250.025n

.meas tran vdout0_101ck490 FIND v(dout0_101) AT=250.025n

.meas tran vdout0_102ck490 FIND v(dout0_102) AT=250.025n

.meas tran vdout0_103ck490 FIND v(dout0_103) AT=250.025n

.meas tran vdout0_104ck490 FIND v(dout0_104) AT=250.025n

.meas tran vdout0_105ck490 FIND v(dout0_105) AT=250.025n

.meas tran vdout0_106ck490 FIND v(dout0_106) AT=250.025n

.meas tran vdout0_107ck490 FIND v(dout0_107) AT=250.025n

.meas tran vdout0_108ck490 FIND v(dout0_108) AT=250.025n

.meas tran vdout0_109ck490 FIND v(dout0_109) AT=250.025n

.meas tran vdout0_110ck490 FIND v(dout0_110) AT=250.025n

.meas tran vdout0_111ck490 FIND v(dout0_111) AT=250.025n

.meas tran vdout0_112ck490 FIND v(dout0_112) AT=250.025n

.meas tran vdout0_113ck490 FIND v(dout0_113) AT=250.025n

.meas tran vdout0_114ck490 FIND v(dout0_114) AT=250.025n

.meas tran vdout0_115ck490 FIND v(dout0_115) AT=250.025n

.meas tran vdout0_116ck490 FIND v(dout0_116) AT=250.025n

.meas tran vdout0_117ck490 FIND v(dout0_117) AT=250.025n

.meas tran vdout0_118ck490 FIND v(dout0_118) AT=250.025n

.meas tran vdout0_119ck490 FIND v(dout0_119) AT=250.025n

.meas tran vdout0_120ck490 FIND v(dout0_120) AT=250.025n

.meas tran vdout0_121ck490 FIND v(dout0_121) AT=250.025n

.meas tran vdout0_122ck490 FIND v(dout0_122) AT=250.025n

.meas tran vdout0_123ck490 FIND v(dout0_123) AT=250.025n

.meas tran vdout0_124ck490 FIND v(dout0_124) AT=250.025n

.meas tran vdout0_125ck490 FIND v(dout0_125) AT=250.025n

.meas tran vdout0_126ck490 FIND v(dout0_126) AT=250.025n

.meas tran vdout0_127ck490 FIND v(dout0_127) AT=250.025n

.meas tran vdout0_0ck500 FIND v(dout0_0) AT=255.025n

.meas tran vdout0_1ck500 FIND v(dout0_1) AT=255.025n

.meas tran vdout0_2ck500 FIND v(dout0_2) AT=255.025n

.meas tran vdout0_3ck500 FIND v(dout0_3) AT=255.025n

.meas tran vdout0_4ck500 FIND v(dout0_4) AT=255.025n

.meas tran vdout0_5ck500 FIND v(dout0_5) AT=255.025n

.meas tran vdout0_6ck500 FIND v(dout0_6) AT=255.025n

.meas tran vdout0_7ck500 FIND v(dout0_7) AT=255.025n

.meas tran vdout0_8ck500 FIND v(dout0_8) AT=255.025n

.meas tran vdout0_9ck500 FIND v(dout0_9) AT=255.025n

.meas tran vdout0_10ck500 FIND v(dout0_10) AT=255.025n

.meas tran vdout0_11ck500 FIND v(dout0_11) AT=255.025n

.meas tran vdout0_12ck500 FIND v(dout0_12) AT=255.025n

.meas tran vdout0_13ck500 FIND v(dout0_13) AT=255.025n

.meas tran vdout0_14ck500 FIND v(dout0_14) AT=255.025n

.meas tran vdout0_15ck500 FIND v(dout0_15) AT=255.025n

.meas tran vdout0_16ck500 FIND v(dout0_16) AT=255.025n

.meas tran vdout0_17ck500 FIND v(dout0_17) AT=255.025n

.meas tran vdout0_18ck500 FIND v(dout0_18) AT=255.025n

.meas tran vdout0_19ck500 FIND v(dout0_19) AT=255.025n

.meas tran vdout0_20ck500 FIND v(dout0_20) AT=255.025n

.meas tran vdout0_21ck500 FIND v(dout0_21) AT=255.025n

.meas tran vdout0_22ck500 FIND v(dout0_22) AT=255.025n

.meas tran vdout0_23ck500 FIND v(dout0_23) AT=255.025n

.meas tran vdout0_24ck500 FIND v(dout0_24) AT=255.025n

.meas tran vdout0_25ck500 FIND v(dout0_25) AT=255.025n

.meas tran vdout0_26ck500 FIND v(dout0_26) AT=255.025n

.meas tran vdout0_27ck500 FIND v(dout0_27) AT=255.025n

.meas tran vdout0_28ck500 FIND v(dout0_28) AT=255.025n

.meas tran vdout0_29ck500 FIND v(dout0_29) AT=255.025n

.meas tran vdout0_30ck500 FIND v(dout0_30) AT=255.025n

.meas tran vdout0_31ck500 FIND v(dout0_31) AT=255.025n

.meas tran vdout0_32ck500 FIND v(dout0_32) AT=255.025n

.meas tran vdout0_33ck500 FIND v(dout0_33) AT=255.025n

.meas tran vdout0_34ck500 FIND v(dout0_34) AT=255.025n

.meas tran vdout0_35ck500 FIND v(dout0_35) AT=255.025n

.meas tran vdout0_36ck500 FIND v(dout0_36) AT=255.025n

.meas tran vdout0_37ck500 FIND v(dout0_37) AT=255.025n

.meas tran vdout0_38ck500 FIND v(dout0_38) AT=255.025n

.meas tran vdout0_39ck500 FIND v(dout0_39) AT=255.025n

.meas tran vdout0_40ck500 FIND v(dout0_40) AT=255.025n

.meas tran vdout0_41ck500 FIND v(dout0_41) AT=255.025n

.meas tran vdout0_42ck500 FIND v(dout0_42) AT=255.025n

.meas tran vdout0_43ck500 FIND v(dout0_43) AT=255.025n

.meas tran vdout0_44ck500 FIND v(dout0_44) AT=255.025n

.meas tran vdout0_45ck500 FIND v(dout0_45) AT=255.025n

.meas tran vdout0_46ck500 FIND v(dout0_46) AT=255.025n

.meas tran vdout0_47ck500 FIND v(dout0_47) AT=255.025n

.meas tran vdout0_48ck500 FIND v(dout0_48) AT=255.025n

.meas tran vdout0_49ck500 FIND v(dout0_49) AT=255.025n

.meas tran vdout0_50ck500 FIND v(dout0_50) AT=255.025n

.meas tran vdout0_51ck500 FIND v(dout0_51) AT=255.025n

.meas tran vdout0_52ck500 FIND v(dout0_52) AT=255.025n

.meas tran vdout0_53ck500 FIND v(dout0_53) AT=255.025n

.meas tran vdout0_54ck500 FIND v(dout0_54) AT=255.025n

.meas tran vdout0_55ck500 FIND v(dout0_55) AT=255.025n

.meas tran vdout0_56ck500 FIND v(dout0_56) AT=255.025n

.meas tran vdout0_57ck500 FIND v(dout0_57) AT=255.025n

.meas tran vdout0_58ck500 FIND v(dout0_58) AT=255.025n

.meas tran vdout0_59ck500 FIND v(dout0_59) AT=255.025n

.meas tran vdout0_60ck500 FIND v(dout0_60) AT=255.025n

.meas tran vdout0_61ck500 FIND v(dout0_61) AT=255.025n

.meas tran vdout0_62ck500 FIND v(dout0_62) AT=255.025n

.meas tran vdout0_63ck500 FIND v(dout0_63) AT=255.025n

.meas tran vdout0_64ck500 FIND v(dout0_64) AT=255.025n

.meas tran vdout0_65ck500 FIND v(dout0_65) AT=255.025n

.meas tran vdout0_66ck500 FIND v(dout0_66) AT=255.025n

.meas tran vdout0_67ck500 FIND v(dout0_67) AT=255.025n

.meas tran vdout0_68ck500 FIND v(dout0_68) AT=255.025n

.meas tran vdout0_69ck500 FIND v(dout0_69) AT=255.025n

.meas tran vdout0_70ck500 FIND v(dout0_70) AT=255.025n

.meas tran vdout0_71ck500 FIND v(dout0_71) AT=255.025n

.meas tran vdout0_72ck500 FIND v(dout0_72) AT=255.025n

.meas tran vdout0_73ck500 FIND v(dout0_73) AT=255.025n

.meas tran vdout0_74ck500 FIND v(dout0_74) AT=255.025n

.meas tran vdout0_75ck500 FIND v(dout0_75) AT=255.025n

.meas tran vdout0_76ck500 FIND v(dout0_76) AT=255.025n

.meas tran vdout0_77ck500 FIND v(dout0_77) AT=255.025n

.meas tran vdout0_78ck500 FIND v(dout0_78) AT=255.025n

.meas tran vdout0_79ck500 FIND v(dout0_79) AT=255.025n

.meas tran vdout0_80ck500 FIND v(dout0_80) AT=255.025n

.meas tran vdout0_81ck500 FIND v(dout0_81) AT=255.025n

.meas tran vdout0_82ck500 FIND v(dout0_82) AT=255.025n

.meas tran vdout0_83ck500 FIND v(dout0_83) AT=255.025n

.meas tran vdout0_84ck500 FIND v(dout0_84) AT=255.025n

.meas tran vdout0_85ck500 FIND v(dout0_85) AT=255.025n

.meas tran vdout0_86ck500 FIND v(dout0_86) AT=255.025n

.meas tran vdout0_87ck500 FIND v(dout0_87) AT=255.025n

.meas tran vdout0_88ck500 FIND v(dout0_88) AT=255.025n

.meas tran vdout0_89ck500 FIND v(dout0_89) AT=255.025n

.meas tran vdout0_90ck500 FIND v(dout0_90) AT=255.025n

.meas tran vdout0_91ck500 FIND v(dout0_91) AT=255.025n

.meas tran vdout0_92ck500 FIND v(dout0_92) AT=255.025n

.meas tran vdout0_93ck500 FIND v(dout0_93) AT=255.025n

.meas tran vdout0_94ck500 FIND v(dout0_94) AT=255.025n

.meas tran vdout0_95ck500 FIND v(dout0_95) AT=255.025n

.meas tran vdout0_96ck500 FIND v(dout0_96) AT=255.025n

.meas tran vdout0_97ck500 FIND v(dout0_97) AT=255.025n

.meas tran vdout0_98ck500 FIND v(dout0_98) AT=255.025n

.meas tran vdout0_99ck500 FIND v(dout0_99) AT=255.025n

.meas tran vdout0_100ck500 FIND v(dout0_100) AT=255.025n

.meas tran vdout0_101ck500 FIND v(dout0_101) AT=255.025n

.meas tran vdout0_102ck500 FIND v(dout0_102) AT=255.025n

.meas tran vdout0_103ck500 FIND v(dout0_103) AT=255.025n

.meas tran vdout0_104ck500 FIND v(dout0_104) AT=255.025n

.meas tran vdout0_105ck500 FIND v(dout0_105) AT=255.025n

.meas tran vdout0_106ck500 FIND v(dout0_106) AT=255.025n

.meas tran vdout0_107ck500 FIND v(dout0_107) AT=255.025n

.meas tran vdout0_108ck500 FIND v(dout0_108) AT=255.025n

.meas tran vdout0_109ck500 FIND v(dout0_109) AT=255.025n

.meas tran vdout0_110ck500 FIND v(dout0_110) AT=255.025n

.meas tran vdout0_111ck500 FIND v(dout0_111) AT=255.025n

.meas tran vdout0_112ck500 FIND v(dout0_112) AT=255.025n

.meas tran vdout0_113ck500 FIND v(dout0_113) AT=255.025n

.meas tran vdout0_114ck500 FIND v(dout0_114) AT=255.025n

.meas tran vdout0_115ck500 FIND v(dout0_115) AT=255.025n

.meas tran vdout0_116ck500 FIND v(dout0_116) AT=255.025n

.meas tran vdout0_117ck500 FIND v(dout0_117) AT=255.025n

.meas tran vdout0_118ck500 FIND v(dout0_118) AT=255.025n

.meas tran vdout0_119ck500 FIND v(dout0_119) AT=255.025n

.meas tran vdout0_120ck500 FIND v(dout0_120) AT=255.025n

.meas tran vdout0_121ck500 FIND v(dout0_121) AT=255.025n

.meas tran vdout0_122ck500 FIND v(dout0_122) AT=255.025n

.meas tran vdout0_123ck500 FIND v(dout0_123) AT=255.025n

.meas tran vdout0_124ck500 FIND v(dout0_124) AT=255.025n

.meas tran vdout0_125ck500 FIND v(dout0_125) AT=255.025n

.meas tran vdout0_126ck500 FIND v(dout0_126) AT=255.025n

.meas tran vdout0_127ck500 FIND v(dout0_127) AT=255.025n

.meas tran vdout0_0ck510 FIND v(dout0_0) AT=260.025n

.meas tran vdout0_1ck510 FIND v(dout0_1) AT=260.025n

.meas tran vdout0_2ck510 FIND v(dout0_2) AT=260.025n

.meas tran vdout0_3ck510 FIND v(dout0_3) AT=260.025n

.meas tran vdout0_4ck510 FIND v(dout0_4) AT=260.025n

.meas tran vdout0_5ck510 FIND v(dout0_5) AT=260.025n

.meas tran vdout0_6ck510 FIND v(dout0_6) AT=260.025n

.meas tran vdout0_7ck510 FIND v(dout0_7) AT=260.025n

.meas tran vdout0_8ck510 FIND v(dout0_8) AT=260.025n

.meas tran vdout0_9ck510 FIND v(dout0_9) AT=260.025n

.meas tran vdout0_10ck510 FIND v(dout0_10) AT=260.025n

.meas tran vdout0_11ck510 FIND v(dout0_11) AT=260.025n

.meas tran vdout0_12ck510 FIND v(dout0_12) AT=260.025n

.meas tran vdout0_13ck510 FIND v(dout0_13) AT=260.025n

.meas tran vdout0_14ck510 FIND v(dout0_14) AT=260.025n

.meas tran vdout0_15ck510 FIND v(dout0_15) AT=260.025n

.meas tran vdout0_16ck510 FIND v(dout0_16) AT=260.025n

.meas tran vdout0_17ck510 FIND v(dout0_17) AT=260.025n

.meas tran vdout0_18ck510 FIND v(dout0_18) AT=260.025n

.meas tran vdout0_19ck510 FIND v(dout0_19) AT=260.025n

.meas tran vdout0_20ck510 FIND v(dout0_20) AT=260.025n

.meas tran vdout0_21ck510 FIND v(dout0_21) AT=260.025n

.meas tran vdout0_22ck510 FIND v(dout0_22) AT=260.025n

.meas tran vdout0_23ck510 FIND v(dout0_23) AT=260.025n

.meas tran vdout0_24ck510 FIND v(dout0_24) AT=260.025n

.meas tran vdout0_25ck510 FIND v(dout0_25) AT=260.025n

.meas tran vdout0_26ck510 FIND v(dout0_26) AT=260.025n

.meas tran vdout0_27ck510 FIND v(dout0_27) AT=260.025n

.meas tran vdout0_28ck510 FIND v(dout0_28) AT=260.025n

.meas tran vdout0_29ck510 FIND v(dout0_29) AT=260.025n

.meas tran vdout0_30ck510 FIND v(dout0_30) AT=260.025n

.meas tran vdout0_31ck510 FIND v(dout0_31) AT=260.025n

.meas tran vdout0_32ck510 FIND v(dout0_32) AT=260.025n

.meas tran vdout0_33ck510 FIND v(dout0_33) AT=260.025n

.meas tran vdout0_34ck510 FIND v(dout0_34) AT=260.025n

.meas tran vdout0_35ck510 FIND v(dout0_35) AT=260.025n

.meas tran vdout0_36ck510 FIND v(dout0_36) AT=260.025n

.meas tran vdout0_37ck510 FIND v(dout0_37) AT=260.025n

.meas tran vdout0_38ck510 FIND v(dout0_38) AT=260.025n

.meas tran vdout0_39ck510 FIND v(dout0_39) AT=260.025n

.meas tran vdout0_40ck510 FIND v(dout0_40) AT=260.025n

.meas tran vdout0_41ck510 FIND v(dout0_41) AT=260.025n

.meas tran vdout0_42ck510 FIND v(dout0_42) AT=260.025n

.meas tran vdout0_43ck510 FIND v(dout0_43) AT=260.025n

.meas tran vdout0_44ck510 FIND v(dout0_44) AT=260.025n

.meas tran vdout0_45ck510 FIND v(dout0_45) AT=260.025n

.meas tran vdout0_46ck510 FIND v(dout0_46) AT=260.025n

.meas tran vdout0_47ck510 FIND v(dout0_47) AT=260.025n

.meas tran vdout0_48ck510 FIND v(dout0_48) AT=260.025n

.meas tran vdout0_49ck510 FIND v(dout0_49) AT=260.025n

.meas tran vdout0_50ck510 FIND v(dout0_50) AT=260.025n

.meas tran vdout0_51ck510 FIND v(dout0_51) AT=260.025n

.meas tran vdout0_52ck510 FIND v(dout0_52) AT=260.025n

.meas tran vdout0_53ck510 FIND v(dout0_53) AT=260.025n

.meas tran vdout0_54ck510 FIND v(dout0_54) AT=260.025n

.meas tran vdout0_55ck510 FIND v(dout0_55) AT=260.025n

.meas tran vdout0_56ck510 FIND v(dout0_56) AT=260.025n

.meas tran vdout0_57ck510 FIND v(dout0_57) AT=260.025n

.meas tran vdout0_58ck510 FIND v(dout0_58) AT=260.025n

.meas tran vdout0_59ck510 FIND v(dout0_59) AT=260.025n

.meas tran vdout0_60ck510 FIND v(dout0_60) AT=260.025n

.meas tran vdout0_61ck510 FIND v(dout0_61) AT=260.025n

.meas tran vdout0_62ck510 FIND v(dout0_62) AT=260.025n

.meas tran vdout0_63ck510 FIND v(dout0_63) AT=260.025n

.meas tran vdout0_64ck510 FIND v(dout0_64) AT=260.025n

.meas tran vdout0_65ck510 FIND v(dout0_65) AT=260.025n

.meas tran vdout0_66ck510 FIND v(dout0_66) AT=260.025n

.meas tran vdout0_67ck510 FIND v(dout0_67) AT=260.025n

.meas tran vdout0_68ck510 FIND v(dout0_68) AT=260.025n

.meas tran vdout0_69ck510 FIND v(dout0_69) AT=260.025n

.meas tran vdout0_70ck510 FIND v(dout0_70) AT=260.025n

.meas tran vdout0_71ck510 FIND v(dout0_71) AT=260.025n

.meas tran vdout0_72ck510 FIND v(dout0_72) AT=260.025n

.meas tran vdout0_73ck510 FIND v(dout0_73) AT=260.025n

.meas tran vdout0_74ck510 FIND v(dout0_74) AT=260.025n

.meas tran vdout0_75ck510 FIND v(dout0_75) AT=260.025n

.meas tran vdout0_76ck510 FIND v(dout0_76) AT=260.025n

.meas tran vdout0_77ck510 FIND v(dout0_77) AT=260.025n

.meas tran vdout0_78ck510 FIND v(dout0_78) AT=260.025n

.meas tran vdout0_79ck510 FIND v(dout0_79) AT=260.025n

.meas tran vdout0_80ck510 FIND v(dout0_80) AT=260.025n

.meas tran vdout0_81ck510 FIND v(dout0_81) AT=260.025n

.meas tran vdout0_82ck510 FIND v(dout0_82) AT=260.025n

.meas tran vdout0_83ck510 FIND v(dout0_83) AT=260.025n

.meas tran vdout0_84ck510 FIND v(dout0_84) AT=260.025n

.meas tran vdout0_85ck510 FIND v(dout0_85) AT=260.025n

.meas tran vdout0_86ck510 FIND v(dout0_86) AT=260.025n

.meas tran vdout0_87ck510 FIND v(dout0_87) AT=260.025n

.meas tran vdout0_88ck510 FIND v(dout0_88) AT=260.025n

.meas tran vdout0_89ck510 FIND v(dout0_89) AT=260.025n

.meas tran vdout0_90ck510 FIND v(dout0_90) AT=260.025n

.meas tran vdout0_91ck510 FIND v(dout0_91) AT=260.025n

.meas tran vdout0_92ck510 FIND v(dout0_92) AT=260.025n

.meas tran vdout0_93ck510 FIND v(dout0_93) AT=260.025n

.meas tran vdout0_94ck510 FIND v(dout0_94) AT=260.025n

.meas tran vdout0_95ck510 FIND v(dout0_95) AT=260.025n

.meas tran vdout0_96ck510 FIND v(dout0_96) AT=260.025n

.meas tran vdout0_97ck510 FIND v(dout0_97) AT=260.025n

.meas tran vdout0_98ck510 FIND v(dout0_98) AT=260.025n

.meas tran vdout0_99ck510 FIND v(dout0_99) AT=260.025n

.meas tran vdout0_100ck510 FIND v(dout0_100) AT=260.025n

.meas tran vdout0_101ck510 FIND v(dout0_101) AT=260.025n

.meas tran vdout0_102ck510 FIND v(dout0_102) AT=260.025n

.meas tran vdout0_103ck510 FIND v(dout0_103) AT=260.025n

.meas tran vdout0_104ck510 FIND v(dout0_104) AT=260.025n

.meas tran vdout0_105ck510 FIND v(dout0_105) AT=260.025n

.meas tran vdout0_106ck510 FIND v(dout0_106) AT=260.025n

.meas tran vdout0_107ck510 FIND v(dout0_107) AT=260.025n

.meas tran vdout0_108ck510 FIND v(dout0_108) AT=260.025n

.meas tran vdout0_109ck510 FIND v(dout0_109) AT=260.025n

.meas tran vdout0_110ck510 FIND v(dout0_110) AT=260.025n

.meas tran vdout0_111ck510 FIND v(dout0_111) AT=260.025n

.meas tran vdout0_112ck510 FIND v(dout0_112) AT=260.025n

.meas tran vdout0_113ck510 FIND v(dout0_113) AT=260.025n

.meas tran vdout0_114ck510 FIND v(dout0_114) AT=260.025n

.meas tran vdout0_115ck510 FIND v(dout0_115) AT=260.025n

.meas tran vdout0_116ck510 FIND v(dout0_116) AT=260.025n

.meas tran vdout0_117ck510 FIND v(dout0_117) AT=260.025n

.meas tran vdout0_118ck510 FIND v(dout0_118) AT=260.025n

.meas tran vdout0_119ck510 FIND v(dout0_119) AT=260.025n

.meas tran vdout0_120ck510 FIND v(dout0_120) AT=260.025n

.meas tran vdout0_121ck510 FIND v(dout0_121) AT=260.025n

.meas tran vdout0_122ck510 FIND v(dout0_122) AT=260.025n

.meas tran vdout0_123ck510 FIND v(dout0_123) AT=260.025n

.meas tran vdout0_124ck510 FIND v(dout0_124) AT=260.025n

.meas tran vdout0_125ck510 FIND v(dout0_125) AT=260.025n

.meas tran vdout0_126ck510 FIND v(dout0_126) AT=260.025n

.meas tran vdout0_127ck510 FIND v(dout0_127) AT=260.025n

.meas tran vdout0_0ck540 FIND v(dout0_0) AT=275.025n

.meas tran vdout0_1ck540 FIND v(dout0_1) AT=275.025n

.meas tran vdout0_2ck540 FIND v(dout0_2) AT=275.025n

.meas tran vdout0_3ck540 FIND v(dout0_3) AT=275.025n

.meas tran vdout0_4ck540 FIND v(dout0_4) AT=275.025n

.meas tran vdout0_5ck540 FIND v(dout0_5) AT=275.025n

.meas tran vdout0_6ck540 FIND v(dout0_6) AT=275.025n

.meas tran vdout0_7ck540 FIND v(dout0_7) AT=275.025n

.meas tran vdout0_8ck540 FIND v(dout0_8) AT=275.025n

.meas tran vdout0_9ck540 FIND v(dout0_9) AT=275.025n

.meas tran vdout0_10ck540 FIND v(dout0_10) AT=275.025n

.meas tran vdout0_11ck540 FIND v(dout0_11) AT=275.025n

.meas tran vdout0_12ck540 FIND v(dout0_12) AT=275.025n

.meas tran vdout0_13ck540 FIND v(dout0_13) AT=275.025n

.meas tran vdout0_14ck540 FIND v(dout0_14) AT=275.025n

.meas tran vdout0_15ck540 FIND v(dout0_15) AT=275.025n

.meas tran vdout0_16ck540 FIND v(dout0_16) AT=275.025n

.meas tran vdout0_17ck540 FIND v(dout0_17) AT=275.025n

.meas tran vdout0_18ck540 FIND v(dout0_18) AT=275.025n

.meas tran vdout0_19ck540 FIND v(dout0_19) AT=275.025n

.meas tran vdout0_20ck540 FIND v(dout0_20) AT=275.025n

.meas tran vdout0_21ck540 FIND v(dout0_21) AT=275.025n

.meas tran vdout0_22ck540 FIND v(dout0_22) AT=275.025n

.meas tran vdout0_23ck540 FIND v(dout0_23) AT=275.025n

.meas tran vdout0_24ck540 FIND v(dout0_24) AT=275.025n

.meas tran vdout0_25ck540 FIND v(dout0_25) AT=275.025n

.meas tran vdout0_26ck540 FIND v(dout0_26) AT=275.025n

.meas tran vdout0_27ck540 FIND v(dout0_27) AT=275.025n

.meas tran vdout0_28ck540 FIND v(dout0_28) AT=275.025n

.meas tran vdout0_29ck540 FIND v(dout0_29) AT=275.025n

.meas tran vdout0_30ck540 FIND v(dout0_30) AT=275.025n

.meas tran vdout0_31ck540 FIND v(dout0_31) AT=275.025n

.meas tran vdout0_32ck540 FIND v(dout0_32) AT=275.025n

.meas tran vdout0_33ck540 FIND v(dout0_33) AT=275.025n

.meas tran vdout0_34ck540 FIND v(dout0_34) AT=275.025n

.meas tran vdout0_35ck540 FIND v(dout0_35) AT=275.025n

.meas tran vdout0_36ck540 FIND v(dout0_36) AT=275.025n

.meas tran vdout0_37ck540 FIND v(dout0_37) AT=275.025n

.meas tran vdout0_38ck540 FIND v(dout0_38) AT=275.025n

.meas tran vdout0_39ck540 FIND v(dout0_39) AT=275.025n

.meas tran vdout0_40ck540 FIND v(dout0_40) AT=275.025n

.meas tran vdout0_41ck540 FIND v(dout0_41) AT=275.025n

.meas tran vdout0_42ck540 FIND v(dout0_42) AT=275.025n

.meas tran vdout0_43ck540 FIND v(dout0_43) AT=275.025n

.meas tran vdout0_44ck540 FIND v(dout0_44) AT=275.025n

.meas tran vdout0_45ck540 FIND v(dout0_45) AT=275.025n

.meas tran vdout0_46ck540 FIND v(dout0_46) AT=275.025n

.meas tran vdout0_47ck540 FIND v(dout0_47) AT=275.025n

.meas tran vdout0_48ck540 FIND v(dout0_48) AT=275.025n

.meas tran vdout0_49ck540 FIND v(dout0_49) AT=275.025n

.meas tran vdout0_50ck540 FIND v(dout0_50) AT=275.025n

.meas tran vdout0_51ck540 FIND v(dout0_51) AT=275.025n

.meas tran vdout0_52ck540 FIND v(dout0_52) AT=275.025n

.meas tran vdout0_53ck540 FIND v(dout0_53) AT=275.025n

.meas tran vdout0_54ck540 FIND v(dout0_54) AT=275.025n

.meas tran vdout0_55ck540 FIND v(dout0_55) AT=275.025n

.meas tran vdout0_56ck540 FIND v(dout0_56) AT=275.025n

.meas tran vdout0_57ck540 FIND v(dout0_57) AT=275.025n

.meas tran vdout0_58ck540 FIND v(dout0_58) AT=275.025n

.meas tran vdout0_59ck540 FIND v(dout0_59) AT=275.025n

.meas tran vdout0_60ck540 FIND v(dout0_60) AT=275.025n

.meas tran vdout0_61ck540 FIND v(dout0_61) AT=275.025n

.meas tran vdout0_62ck540 FIND v(dout0_62) AT=275.025n

.meas tran vdout0_63ck540 FIND v(dout0_63) AT=275.025n

.meas tran vdout0_64ck540 FIND v(dout0_64) AT=275.025n

.meas tran vdout0_65ck540 FIND v(dout0_65) AT=275.025n

.meas tran vdout0_66ck540 FIND v(dout0_66) AT=275.025n

.meas tran vdout0_67ck540 FIND v(dout0_67) AT=275.025n

.meas tran vdout0_68ck540 FIND v(dout0_68) AT=275.025n

.meas tran vdout0_69ck540 FIND v(dout0_69) AT=275.025n

.meas tran vdout0_70ck540 FIND v(dout0_70) AT=275.025n

.meas tran vdout0_71ck540 FIND v(dout0_71) AT=275.025n

.meas tran vdout0_72ck540 FIND v(dout0_72) AT=275.025n

.meas tran vdout0_73ck540 FIND v(dout0_73) AT=275.025n

.meas tran vdout0_74ck540 FIND v(dout0_74) AT=275.025n

.meas tran vdout0_75ck540 FIND v(dout0_75) AT=275.025n

.meas tran vdout0_76ck540 FIND v(dout0_76) AT=275.025n

.meas tran vdout0_77ck540 FIND v(dout0_77) AT=275.025n

.meas tran vdout0_78ck540 FIND v(dout0_78) AT=275.025n

.meas tran vdout0_79ck540 FIND v(dout0_79) AT=275.025n

.meas tran vdout0_80ck540 FIND v(dout0_80) AT=275.025n

.meas tran vdout0_81ck540 FIND v(dout0_81) AT=275.025n

.meas tran vdout0_82ck540 FIND v(dout0_82) AT=275.025n

.meas tran vdout0_83ck540 FIND v(dout0_83) AT=275.025n

.meas tran vdout0_84ck540 FIND v(dout0_84) AT=275.025n

.meas tran vdout0_85ck540 FIND v(dout0_85) AT=275.025n

.meas tran vdout0_86ck540 FIND v(dout0_86) AT=275.025n

.meas tran vdout0_87ck540 FIND v(dout0_87) AT=275.025n

.meas tran vdout0_88ck540 FIND v(dout0_88) AT=275.025n

.meas tran vdout0_89ck540 FIND v(dout0_89) AT=275.025n

.meas tran vdout0_90ck540 FIND v(dout0_90) AT=275.025n

.meas tran vdout0_91ck540 FIND v(dout0_91) AT=275.025n

.meas tran vdout0_92ck540 FIND v(dout0_92) AT=275.025n

.meas tran vdout0_93ck540 FIND v(dout0_93) AT=275.025n

.meas tran vdout0_94ck540 FIND v(dout0_94) AT=275.025n

.meas tran vdout0_95ck540 FIND v(dout0_95) AT=275.025n

.meas tran vdout0_96ck540 FIND v(dout0_96) AT=275.025n

.meas tran vdout0_97ck540 FIND v(dout0_97) AT=275.025n

.meas tran vdout0_98ck540 FIND v(dout0_98) AT=275.025n

.meas tran vdout0_99ck540 FIND v(dout0_99) AT=275.025n

.meas tran vdout0_100ck540 FIND v(dout0_100) AT=275.025n

.meas tran vdout0_101ck540 FIND v(dout0_101) AT=275.025n

.meas tran vdout0_102ck540 FIND v(dout0_102) AT=275.025n

.meas tran vdout0_103ck540 FIND v(dout0_103) AT=275.025n

.meas tran vdout0_104ck540 FIND v(dout0_104) AT=275.025n

.meas tran vdout0_105ck540 FIND v(dout0_105) AT=275.025n

.meas tran vdout0_106ck540 FIND v(dout0_106) AT=275.025n

.meas tran vdout0_107ck540 FIND v(dout0_107) AT=275.025n

.meas tran vdout0_108ck540 FIND v(dout0_108) AT=275.025n

.meas tran vdout0_109ck540 FIND v(dout0_109) AT=275.025n

.meas tran vdout0_110ck540 FIND v(dout0_110) AT=275.025n

.meas tran vdout0_111ck540 FIND v(dout0_111) AT=275.025n

.meas tran vdout0_112ck540 FIND v(dout0_112) AT=275.025n

.meas tran vdout0_113ck540 FIND v(dout0_113) AT=275.025n

.meas tran vdout0_114ck540 FIND v(dout0_114) AT=275.025n

.meas tran vdout0_115ck540 FIND v(dout0_115) AT=275.025n

.meas tran vdout0_116ck540 FIND v(dout0_116) AT=275.025n

.meas tran vdout0_117ck540 FIND v(dout0_117) AT=275.025n

.meas tran vdout0_118ck540 FIND v(dout0_118) AT=275.025n

.meas tran vdout0_119ck540 FIND v(dout0_119) AT=275.025n

.meas tran vdout0_120ck540 FIND v(dout0_120) AT=275.025n

.meas tran vdout0_121ck540 FIND v(dout0_121) AT=275.025n

.meas tran vdout0_122ck540 FIND v(dout0_122) AT=275.025n

.meas tran vdout0_123ck540 FIND v(dout0_123) AT=275.025n

.meas tran vdout0_124ck540 FIND v(dout0_124) AT=275.025n

.meas tran vdout0_125ck540 FIND v(dout0_125) AT=275.025n

.meas tran vdout0_126ck540 FIND v(dout0_126) AT=275.025n

.meas tran vdout0_127ck540 FIND v(dout0_127) AT=275.025n

.meas tran vdout0_0ck550 FIND v(dout0_0) AT=280.025n

.meas tran vdout0_1ck550 FIND v(dout0_1) AT=280.025n

.meas tran vdout0_2ck550 FIND v(dout0_2) AT=280.025n

.meas tran vdout0_3ck550 FIND v(dout0_3) AT=280.025n

.meas tran vdout0_4ck550 FIND v(dout0_4) AT=280.025n

.meas tran vdout0_5ck550 FIND v(dout0_5) AT=280.025n

.meas tran vdout0_6ck550 FIND v(dout0_6) AT=280.025n

.meas tran vdout0_7ck550 FIND v(dout0_7) AT=280.025n

.meas tran vdout0_8ck550 FIND v(dout0_8) AT=280.025n

.meas tran vdout0_9ck550 FIND v(dout0_9) AT=280.025n

.meas tran vdout0_10ck550 FIND v(dout0_10) AT=280.025n

.meas tran vdout0_11ck550 FIND v(dout0_11) AT=280.025n

.meas tran vdout0_12ck550 FIND v(dout0_12) AT=280.025n

.meas tran vdout0_13ck550 FIND v(dout0_13) AT=280.025n

.meas tran vdout0_14ck550 FIND v(dout0_14) AT=280.025n

.meas tran vdout0_15ck550 FIND v(dout0_15) AT=280.025n

.meas tran vdout0_16ck550 FIND v(dout0_16) AT=280.025n

.meas tran vdout0_17ck550 FIND v(dout0_17) AT=280.025n

.meas tran vdout0_18ck550 FIND v(dout0_18) AT=280.025n

.meas tran vdout0_19ck550 FIND v(dout0_19) AT=280.025n

.meas tran vdout0_20ck550 FIND v(dout0_20) AT=280.025n

.meas tran vdout0_21ck550 FIND v(dout0_21) AT=280.025n

.meas tran vdout0_22ck550 FIND v(dout0_22) AT=280.025n

.meas tran vdout0_23ck550 FIND v(dout0_23) AT=280.025n

.meas tran vdout0_24ck550 FIND v(dout0_24) AT=280.025n

.meas tran vdout0_25ck550 FIND v(dout0_25) AT=280.025n

.meas tran vdout0_26ck550 FIND v(dout0_26) AT=280.025n

.meas tran vdout0_27ck550 FIND v(dout0_27) AT=280.025n

.meas tran vdout0_28ck550 FIND v(dout0_28) AT=280.025n

.meas tran vdout0_29ck550 FIND v(dout0_29) AT=280.025n

.meas tran vdout0_30ck550 FIND v(dout0_30) AT=280.025n

.meas tran vdout0_31ck550 FIND v(dout0_31) AT=280.025n

.meas tran vdout0_32ck550 FIND v(dout0_32) AT=280.025n

.meas tran vdout0_33ck550 FIND v(dout0_33) AT=280.025n

.meas tran vdout0_34ck550 FIND v(dout0_34) AT=280.025n

.meas tran vdout0_35ck550 FIND v(dout0_35) AT=280.025n

.meas tran vdout0_36ck550 FIND v(dout0_36) AT=280.025n

.meas tran vdout0_37ck550 FIND v(dout0_37) AT=280.025n

.meas tran vdout0_38ck550 FIND v(dout0_38) AT=280.025n

.meas tran vdout0_39ck550 FIND v(dout0_39) AT=280.025n

.meas tran vdout0_40ck550 FIND v(dout0_40) AT=280.025n

.meas tran vdout0_41ck550 FIND v(dout0_41) AT=280.025n

.meas tran vdout0_42ck550 FIND v(dout0_42) AT=280.025n

.meas tran vdout0_43ck550 FIND v(dout0_43) AT=280.025n

.meas tran vdout0_44ck550 FIND v(dout0_44) AT=280.025n

.meas tran vdout0_45ck550 FIND v(dout0_45) AT=280.025n

.meas tran vdout0_46ck550 FIND v(dout0_46) AT=280.025n

.meas tran vdout0_47ck550 FIND v(dout0_47) AT=280.025n

.meas tran vdout0_48ck550 FIND v(dout0_48) AT=280.025n

.meas tran vdout0_49ck550 FIND v(dout0_49) AT=280.025n

.meas tran vdout0_50ck550 FIND v(dout0_50) AT=280.025n

.meas tran vdout0_51ck550 FIND v(dout0_51) AT=280.025n

.meas tran vdout0_52ck550 FIND v(dout0_52) AT=280.025n

.meas tran vdout0_53ck550 FIND v(dout0_53) AT=280.025n

.meas tran vdout0_54ck550 FIND v(dout0_54) AT=280.025n

.meas tran vdout0_55ck550 FIND v(dout0_55) AT=280.025n

.meas tran vdout0_56ck550 FIND v(dout0_56) AT=280.025n

.meas tran vdout0_57ck550 FIND v(dout0_57) AT=280.025n

.meas tran vdout0_58ck550 FIND v(dout0_58) AT=280.025n

.meas tran vdout0_59ck550 FIND v(dout0_59) AT=280.025n

.meas tran vdout0_60ck550 FIND v(dout0_60) AT=280.025n

.meas tran vdout0_61ck550 FIND v(dout0_61) AT=280.025n

.meas tran vdout0_62ck550 FIND v(dout0_62) AT=280.025n

.meas tran vdout0_63ck550 FIND v(dout0_63) AT=280.025n

.meas tran vdout0_64ck550 FIND v(dout0_64) AT=280.025n

.meas tran vdout0_65ck550 FIND v(dout0_65) AT=280.025n

.meas tran vdout0_66ck550 FIND v(dout0_66) AT=280.025n

.meas tran vdout0_67ck550 FIND v(dout0_67) AT=280.025n

.meas tran vdout0_68ck550 FIND v(dout0_68) AT=280.025n

.meas tran vdout0_69ck550 FIND v(dout0_69) AT=280.025n

.meas tran vdout0_70ck550 FIND v(dout0_70) AT=280.025n

.meas tran vdout0_71ck550 FIND v(dout0_71) AT=280.025n

.meas tran vdout0_72ck550 FIND v(dout0_72) AT=280.025n

.meas tran vdout0_73ck550 FIND v(dout0_73) AT=280.025n

.meas tran vdout0_74ck550 FIND v(dout0_74) AT=280.025n

.meas tran vdout0_75ck550 FIND v(dout0_75) AT=280.025n

.meas tran vdout0_76ck550 FIND v(dout0_76) AT=280.025n

.meas tran vdout0_77ck550 FIND v(dout0_77) AT=280.025n

.meas tran vdout0_78ck550 FIND v(dout0_78) AT=280.025n

.meas tran vdout0_79ck550 FIND v(dout0_79) AT=280.025n

.meas tran vdout0_80ck550 FIND v(dout0_80) AT=280.025n

.meas tran vdout0_81ck550 FIND v(dout0_81) AT=280.025n

.meas tran vdout0_82ck550 FIND v(dout0_82) AT=280.025n

.meas tran vdout0_83ck550 FIND v(dout0_83) AT=280.025n

.meas tran vdout0_84ck550 FIND v(dout0_84) AT=280.025n

.meas tran vdout0_85ck550 FIND v(dout0_85) AT=280.025n

.meas tran vdout0_86ck550 FIND v(dout0_86) AT=280.025n

.meas tran vdout0_87ck550 FIND v(dout0_87) AT=280.025n

.meas tran vdout0_88ck550 FIND v(dout0_88) AT=280.025n

.meas tran vdout0_89ck550 FIND v(dout0_89) AT=280.025n

.meas tran vdout0_90ck550 FIND v(dout0_90) AT=280.025n

.meas tran vdout0_91ck550 FIND v(dout0_91) AT=280.025n

.meas tran vdout0_92ck550 FIND v(dout0_92) AT=280.025n

.meas tran vdout0_93ck550 FIND v(dout0_93) AT=280.025n

.meas tran vdout0_94ck550 FIND v(dout0_94) AT=280.025n

.meas tran vdout0_95ck550 FIND v(dout0_95) AT=280.025n

.meas tran vdout0_96ck550 FIND v(dout0_96) AT=280.025n

.meas tran vdout0_97ck550 FIND v(dout0_97) AT=280.025n

.meas tran vdout0_98ck550 FIND v(dout0_98) AT=280.025n

.meas tran vdout0_99ck550 FIND v(dout0_99) AT=280.025n

.meas tran vdout0_100ck550 FIND v(dout0_100) AT=280.025n

.meas tran vdout0_101ck550 FIND v(dout0_101) AT=280.025n

.meas tran vdout0_102ck550 FIND v(dout0_102) AT=280.025n

.meas tran vdout0_103ck550 FIND v(dout0_103) AT=280.025n

.meas tran vdout0_104ck550 FIND v(dout0_104) AT=280.025n

.meas tran vdout0_105ck550 FIND v(dout0_105) AT=280.025n

.meas tran vdout0_106ck550 FIND v(dout0_106) AT=280.025n

.meas tran vdout0_107ck550 FIND v(dout0_107) AT=280.025n

.meas tran vdout0_108ck550 FIND v(dout0_108) AT=280.025n

.meas tran vdout0_109ck550 FIND v(dout0_109) AT=280.025n

.meas tran vdout0_110ck550 FIND v(dout0_110) AT=280.025n

.meas tran vdout0_111ck550 FIND v(dout0_111) AT=280.025n

.meas tran vdout0_112ck550 FIND v(dout0_112) AT=280.025n

.meas tran vdout0_113ck550 FIND v(dout0_113) AT=280.025n

.meas tran vdout0_114ck550 FIND v(dout0_114) AT=280.025n

.meas tran vdout0_115ck550 FIND v(dout0_115) AT=280.025n

.meas tran vdout0_116ck550 FIND v(dout0_116) AT=280.025n

.meas tran vdout0_117ck550 FIND v(dout0_117) AT=280.025n

.meas tran vdout0_118ck550 FIND v(dout0_118) AT=280.025n

.meas tran vdout0_119ck550 FIND v(dout0_119) AT=280.025n

.meas tran vdout0_120ck550 FIND v(dout0_120) AT=280.025n

.meas tran vdout0_121ck550 FIND v(dout0_121) AT=280.025n

.meas tran vdout0_122ck550 FIND v(dout0_122) AT=280.025n

.meas tran vdout0_123ck550 FIND v(dout0_123) AT=280.025n

.meas tran vdout0_124ck550 FIND v(dout0_124) AT=280.025n

.meas tran vdout0_125ck550 FIND v(dout0_125) AT=280.025n

.meas tran vdout0_126ck550 FIND v(dout0_126) AT=280.025n

.meas tran vdout0_127ck550 FIND v(dout0_127) AT=280.025n

.meas tran vdout0_0ck560 FIND v(dout0_0) AT=285.025n

.meas tran vdout0_1ck560 FIND v(dout0_1) AT=285.025n

.meas tran vdout0_2ck560 FIND v(dout0_2) AT=285.025n

.meas tran vdout0_3ck560 FIND v(dout0_3) AT=285.025n

.meas tran vdout0_4ck560 FIND v(dout0_4) AT=285.025n

.meas tran vdout0_5ck560 FIND v(dout0_5) AT=285.025n

.meas tran vdout0_6ck560 FIND v(dout0_6) AT=285.025n

.meas tran vdout0_7ck560 FIND v(dout0_7) AT=285.025n

.meas tran vdout0_8ck560 FIND v(dout0_8) AT=285.025n

.meas tran vdout0_9ck560 FIND v(dout0_9) AT=285.025n

.meas tran vdout0_10ck560 FIND v(dout0_10) AT=285.025n

.meas tran vdout0_11ck560 FIND v(dout0_11) AT=285.025n

.meas tran vdout0_12ck560 FIND v(dout0_12) AT=285.025n

.meas tran vdout0_13ck560 FIND v(dout0_13) AT=285.025n

.meas tran vdout0_14ck560 FIND v(dout0_14) AT=285.025n

.meas tran vdout0_15ck560 FIND v(dout0_15) AT=285.025n

.meas tran vdout0_16ck560 FIND v(dout0_16) AT=285.025n

.meas tran vdout0_17ck560 FIND v(dout0_17) AT=285.025n

.meas tran vdout0_18ck560 FIND v(dout0_18) AT=285.025n

.meas tran vdout0_19ck560 FIND v(dout0_19) AT=285.025n

.meas tran vdout0_20ck560 FIND v(dout0_20) AT=285.025n

.meas tran vdout0_21ck560 FIND v(dout0_21) AT=285.025n

.meas tran vdout0_22ck560 FIND v(dout0_22) AT=285.025n

.meas tran vdout0_23ck560 FIND v(dout0_23) AT=285.025n

.meas tran vdout0_24ck560 FIND v(dout0_24) AT=285.025n

.meas tran vdout0_25ck560 FIND v(dout0_25) AT=285.025n

.meas tran vdout0_26ck560 FIND v(dout0_26) AT=285.025n

.meas tran vdout0_27ck560 FIND v(dout0_27) AT=285.025n

.meas tran vdout0_28ck560 FIND v(dout0_28) AT=285.025n

.meas tran vdout0_29ck560 FIND v(dout0_29) AT=285.025n

.meas tran vdout0_30ck560 FIND v(dout0_30) AT=285.025n

.meas tran vdout0_31ck560 FIND v(dout0_31) AT=285.025n

.meas tran vdout0_32ck560 FIND v(dout0_32) AT=285.025n

.meas tran vdout0_33ck560 FIND v(dout0_33) AT=285.025n

.meas tran vdout0_34ck560 FIND v(dout0_34) AT=285.025n

.meas tran vdout0_35ck560 FIND v(dout0_35) AT=285.025n

.meas tran vdout0_36ck560 FIND v(dout0_36) AT=285.025n

.meas tran vdout0_37ck560 FIND v(dout0_37) AT=285.025n

.meas tran vdout0_38ck560 FIND v(dout0_38) AT=285.025n

.meas tran vdout0_39ck560 FIND v(dout0_39) AT=285.025n

.meas tran vdout0_40ck560 FIND v(dout0_40) AT=285.025n

.meas tran vdout0_41ck560 FIND v(dout0_41) AT=285.025n

.meas tran vdout0_42ck560 FIND v(dout0_42) AT=285.025n

.meas tran vdout0_43ck560 FIND v(dout0_43) AT=285.025n

.meas tran vdout0_44ck560 FIND v(dout0_44) AT=285.025n

.meas tran vdout0_45ck560 FIND v(dout0_45) AT=285.025n

.meas tran vdout0_46ck560 FIND v(dout0_46) AT=285.025n

.meas tran vdout0_47ck560 FIND v(dout0_47) AT=285.025n

.meas tran vdout0_48ck560 FIND v(dout0_48) AT=285.025n

.meas tran vdout0_49ck560 FIND v(dout0_49) AT=285.025n

.meas tran vdout0_50ck560 FIND v(dout0_50) AT=285.025n

.meas tran vdout0_51ck560 FIND v(dout0_51) AT=285.025n

.meas tran vdout0_52ck560 FIND v(dout0_52) AT=285.025n

.meas tran vdout0_53ck560 FIND v(dout0_53) AT=285.025n

.meas tran vdout0_54ck560 FIND v(dout0_54) AT=285.025n

.meas tran vdout0_55ck560 FIND v(dout0_55) AT=285.025n

.meas tran vdout0_56ck560 FIND v(dout0_56) AT=285.025n

.meas tran vdout0_57ck560 FIND v(dout0_57) AT=285.025n

.meas tran vdout0_58ck560 FIND v(dout0_58) AT=285.025n

.meas tran vdout0_59ck560 FIND v(dout0_59) AT=285.025n

.meas tran vdout0_60ck560 FIND v(dout0_60) AT=285.025n

.meas tran vdout0_61ck560 FIND v(dout0_61) AT=285.025n

.meas tran vdout0_62ck560 FIND v(dout0_62) AT=285.025n

.meas tran vdout0_63ck560 FIND v(dout0_63) AT=285.025n

.meas tran vdout0_64ck560 FIND v(dout0_64) AT=285.025n

.meas tran vdout0_65ck560 FIND v(dout0_65) AT=285.025n

.meas tran vdout0_66ck560 FIND v(dout0_66) AT=285.025n

.meas tran vdout0_67ck560 FIND v(dout0_67) AT=285.025n

.meas tran vdout0_68ck560 FIND v(dout0_68) AT=285.025n

.meas tran vdout0_69ck560 FIND v(dout0_69) AT=285.025n

.meas tran vdout0_70ck560 FIND v(dout0_70) AT=285.025n

.meas tran vdout0_71ck560 FIND v(dout0_71) AT=285.025n

.meas tran vdout0_72ck560 FIND v(dout0_72) AT=285.025n

.meas tran vdout0_73ck560 FIND v(dout0_73) AT=285.025n

.meas tran vdout0_74ck560 FIND v(dout0_74) AT=285.025n

.meas tran vdout0_75ck560 FIND v(dout0_75) AT=285.025n

.meas tran vdout0_76ck560 FIND v(dout0_76) AT=285.025n

.meas tran vdout0_77ck560 FIND v(dout0_77) AT=285.025n

.meas tran vdout0_78ck560 FIND v(dout0_78) AT=285.025n

.meas tran vdout0_79ck560 FIND v(dout0_79) AT=285.025n

.meas tran vdout0_80ck560 FIND v(dout0_80) AT=285.025n

.meas tran vdout0_81ck560 FIND v(dout0_81) AT=285.025n

.meas tran vdout0_82ck560 FIND v(dout0_82) AT=285.025n

.meas tran vdout0_83ck560 FIND v(dout0_83) AT=285.025n

.meas tran vdout0_84ck560 FIND v(dout0_84) AT=285.025n

.meas tran vdout0_85ck560 FIND v(dout0_85) AT=285.025n

.meas tran vdout0_86ck560 FIND v(dout0_86) AT=285.025n

.meas tran vdout0_87ck560 FIND v(dout0_87) AT=285.025n

.meas tran vdout0_88ck560 FIND v(dout0_88) AT=285.025n

.meas tran vdout0_89ck560 FIND v(dout0_89) AT=285.025n

.meas tran vdout0_90ck560 FIND v(dout0_90) AT=285.025n

.meas tran vdout0_91ck560 FIND v(dout0_91) AT=285.025n

.meas tran vdout0_92ck560 FIND v(dout0_92) AT=285.025n

.meas tran vdout0_93ck560 FIND v(dout0_93) AT=285.025n

.meas tran vdout0_94ck560 FIND v(dout0_94) AT=285.025n

.meas tran vdout0_95ck560 FIND v(dout0_95) AT=285.025n

.meas tran vdout0_96ck560 FIND v(dout0_96) AT=285.025n

.meas tran vdout0_97ck560 FIND v(dout0_97) AT=285.025n

.meas tran vdout0_98ck560 FIND v(dout0_98) AT=285.025n

.meas tran vdout0_99ck560 FIND v(dout0_99) AT=285.025n

.meas tran vdout0_100ck560 FIND v(dout0_100) AT=285.025n

.meas tran vdout0_101ck560 FIND v(dout0_101) AT=285.025n

.meas tran vdout0_102ck560 FIND v(dout0_102) AT=285.025n

.meas tran vdout0_103ck560 FIND v(dout0_103) AT=285.025n

.meas tran vdout0_104ck560 FIND v(dout0_104) AT=285.025n

.meas tran vdout0_105ck560 FIND v(dout0_105) AT=285.025n

.meas tran vdout0_106ck560 FIND v(dout0_106) AT=285.025n

.meas tran vdout0_107ck560 FIND v(dout0_107) AT=285.025n

.meas tran vdout0_108ck560 FIND v(dout0_108) AT=285.025n

.meas tran vdout0_109ck560 FIND v(dout0_109) AT=285.025n

.meas tran vdout0_110ck560 FIND v(dout0_110) AT=285.025n

.meas tran vdout0_111ck560 FIND v(dout0_111) AT=285.025n

.meas tran vdout0_112ck560 FIND v(dout0_112) AT=285.025n

.meas tran vdout0_113ck560 FIND v(dout0_113) AT=285.025n

.meas tran vdout0_114ck560 FIND v(dout0_114) AT=285.025n

.meas tran vdout0_115ck560 FIND v(dout0_115) AT=285.025n

.meas tran vdout0_116ck560 FIND v(dout0_116) AT=285.025n

.meas tran vdout0_117ck560 FIND v(dout0_117) AT=285.025n

.meas tran vdout0_118ck560 FIND v(dout0_118) AT=285.025n

.meas tran vdout0_119ck560 FIND v(dout0_119) AT=285.025n

.meas tran vdout0_120ck560 FIND v(dout0_120) AT=285.025n

.meas tran vdout0_121ck560 FIND v(dout0_121) AT=285.025n

.meas tran vdout0_122ck560 FIND v(dout0_122) AT=285.025n

.meas tran vdout0_123ck560 FIND v(dout0_123) AT=285.025n

.meas tran vdout0_124ck560 FIND v(dout0_124) AT=285.025n

.meas tran vdout0_125ck560 FIND v(dout0_125) AT=285.025n

.meas tran vdout0_126ck560 FIND v(dout0_126) AT=285.025n

.meas tran vdout0_127ck560 FIND v(dout0_127) AT=285.025n

.meas tran vdout0_0ck580 FIND v(dout0_0) AT=295.025n

.meas tran vdout0_1ck580 FIND v(dout0_1) AT=295.025n

.meas tran vdout0_2ck580 FIND v(dout0_2) AT=295.025n

.meas tran vdout0_3ck580 FIND v(dout0_3) AT=295.025n

.meas tran vdout0_4ck580 FIND v(dout0_4) AT=295.025n

.meas tran vdout0_5ck580 FIND v(dout0_5) AT=295.025n

.meas tran vdout0_6ck580 FIND v(dout0_6) AT=295.025n

.meas tran vdout0_7ck580 FIND v(dout0_7) AT=295.025n

.meas tran vdout0_8ck580 FIND v(dout0_8) AT=295.025n

.meas tran vdout0_9ck580 FIND v(dout0_9) AT=295.025n

.meas tran vdout0_10ck580 FIND v(dout0_10) AT=295.025n

.meas tran vdout0_11ck580 FIND v(dout0_11) AT=295.025n

.meas tran vdout0_12ck580 FIND v(dout0_12) AT=295.025n

.meas tran vdout0_13ck580 FIND v(dout0_13) AT=295.025n

.meas tran vdout0_14ck580 FIND v(dout0_14) AT=295.025n

.meas tran vdout0_15ck580 FIND v(dout0_15) AT=295.025n

.meas tran vdout0_16ck580 FIND v(dout0_16) AT=295.025n

.meas tran vdout0_17ck580 FIND v(dout0_17) AT=295.025n

.meas tran vdout0_18ck580 FIND v(dout0_18) AT=295.025n

.meas tran vdout0_19ck580 FIND v(dout0_19) AT=295.025n

.meas tran vdout0_20ck580 FIND v(dout0_20) AT=295.025n

.meas tran vdout0_21ck580 FIND v(dout0_21) AT=295.025n

.meas tran vdout0_22ck580 FIND v(dout0_22) AT=295.025n

.meas tran vdout0_23ck580 FIND v(dout0_23) AT=295.025n

.meas tran vdout0_24ck580 FIND v(dout0_24) AT=295.025n

.meas tran vdout0_25ck580 FIND v(dout0_25) AT=295.025n

.meas tran vdout0_26ck580 FIND v(dout0_26) AT=295.025n

.meas tran vdout0_27ck580 FIND v(dout0_27) AT=295.025n

.meas tran vdout0_28ck580 FIND v(dout0_28) AT=295.025n

.meas tran vdout0_29ck580 FIND v(dout0_29) AT=295.025n

.meas tran vdout0_30ck580 FIND v(dout0_30) AT=295.025n

.meas tran vdout0_31ck580 FIND v(dout0_31) AT=295.025n

.meas tran vdout0_32ck580 FIND v(dout0_32) AT=295.025n

.meas tran vdout0_33ck580 FIND v(dout0_33) AT=295.025n

.meas tran vdout0_34ck580 FIND v(dout0_34) AT=295.025n

.meas tran vdout0_35ck580 FIND v(dout0_35) AT=295.025n

.meas tran vdout0_36ck580 FIND v(dout0_36) AT=295.025n

.meas tran vdout0_37ck580 FIND v(dout0_37) AT=295.025n

.meas tran vdout0_38ck580 FIND v(dout0_38) AT=295.025n

.meas tran vdout0_39ck580 FIND v(dout0_39) AT=295.025n

.meas tran vdout0_40ck580 FIND v(dout0_40) AT=295.025n

.meas tran vdout0_41ck580 FIND v(dout0_41) AT=295.025n

.meas tran vdout0_42ck580 FIND v(dout0_42) AT=295.025n

.meas tran vdout0_43ck580 FIND v(dout0_43) AT=295.025n

.meas tran vdout0_44ck580 FIND v(dout0_44) AT=295.025n

.meas tran vdout0_45ck580 FIND v(dout0_45) AT=295.025n

.meas tran vdout0_46ck580 FIND v(dout0_46) AT=295.025n

.meas tran vdout0_47ck580 FIND v(dout0_47) AT=295.025n

.meas tran vdout0_48ck580 FIND v(dout0_48) AT=295.025n

.meas tran vdout0_49ck580 FIND v(dout0_49) AT=295.025n

.meas tran vdout0_50ck580 FIND v(dout0_50) AT=295.025n

.meas tran vdout0_51ck580 FIND v(dout0_51) AT=295.025n

.meas tran vdout0_52ck580 FIND v(dout0_52) AT=295.025n

.meas tran vdout0_53ck580 FIND v(dout0_53) AT=295.025n

.meas tran vdout0_54ck580 FIND v(dout0_54) AT=295.025n

.meas tran vdout0_55ck580 FIND v(dout0_55) AT=295.025n

.meas tran vdout0_56ck580 FIND v(dout0_56) AT=295.025n

.meas tran vdout0_57ck580 FIND v(dout0_57) AT=295.025n

.meas tran vdout0_58ck580 FIND v(dout0_58) AT=295.025n

.meas tran vdout0_59ck580 FIND v(dout0_59) AT=295.025n

.meas tran vdout0_60ck580 FIND v(dout0_60) AT=295.025n

.meas tran vdout0_61ck580 FIND v(dout0_61) AT=295.025n

.meas tran vdout0_62ck580 FIND v(dout0_62) AT=295.025n

.meas tran vdout0_63ck580 FIND v(dout0_63) AT=295.025n

.meas tran vdout0_64ck580 FIND v(dout0_64) AT=295.025n

.meas tran vdout0_65ck580 FIND v(dout0_65) AT=295.025n

.meas tran vdout0_66ck580 FIND v(dout0_66) AT=295.025n

.meas tran vdout0_67ck580 FIND v(dout0_67) AT=295.025n

.meas tran vdout0_68ck580 FIND v(dout0_68) AT=295.025n

.meas tran vdout0_69ck580 FIND v(dout0_69) AT=295.025n

.meas tran vdout0_70ck580 FIND v(dout0_70) AT=295.025n

.meas tran vdout0_71ck580 FIND v(dout0_71) AT=295.025n

.meas tran vdout0_72ck580 FIND v(dout0_72) AT=295.025n

.meas tran vdout0_73ck580 FIND v(dout0_73) AT=295.025n

.meas tran vdout0_74ck580 FIND v(dout0_74) AT=295.025n

.meas tran vdout0_75ck580 FIND v(dout0_75) AT=295.025n

.meas tran vdout0_76ck580 FIND v(dout0_76) AT=295.025n

.meas tran vdout0_77ck580 FIND v(dout0_77) AT=295.025n

.meas tran vdout0_78ck580 FIND v(dout0_78) AT=295.025n

.meas tran vdout0_79ck580 FIND v(dout0_79) AT=295.025n

.meas tran vdout0_80ck580 FIND v(dout0_80) AT=295.025n

.meas tran vdout0_81ck580 FIND v(dout0_81) AT=295.025n

.meas tran vdout0_82ck580 FIND v(dout0_82) AT=295.025n

.meas tran vdout0_83ck580 FIND v(dout0_83) AT=295.025n

.meas tran vdout0_84ck580 FIND v(dout0_84) AT=295.025n

.meas tran vdout0_85ck580 FIND v(dout0_85) AT=295.025n

.meas tran vdout0_86ck580 FIND v(dout0_86) AT=295.025n

.meas tran vdout0_87ck580 FIND v(dout0_87) AT=295.025n

.meas tran vdout0_88ck580 FIND v(dout0_88) AT=295.025n

.meas tran vdout0_89ck580 FIND v(dout0_89) AT=295.025n

.meas tran vdout0_90ck580 FIND v(dout0_90) AT=295.025n

.meas tran vdout0_91ck580 FIND v(dout0_91) AT=295.025n

.meas tran vdout0_92ck580 FIND v(dout0_92) AT=295.025n

.meas tran vdout0_93ck580 FIND v(dout0_93) AT=295.025n

.meas tran vdout0_94ck580 FIND v(dout0_94) AT=295.025n

.meas tran vdout0_95ck580 FIND v(dout0_95) AT=295.025n

.meas tran vdout0_96ck580 FIND v(dout0_96) AT=295.025n

.meas tran vdout0_97ck580 FIND v(dout0_97) AT=295.025n

.meas tran vdout0_98ck580 FIND v(dout0_98) AT=295.025n

.meas tran vdout0_99ck580 FIND v(dout0_99) AT=295.025n

.meas tran vdout0_100ck580 FIND v(dout0_100) AT=295.025n

.meas tran vdout0_101ck580 FIND v(dout0_101) AT=295.025n

.meas tran vdout0_102ck580 FIND v(dout0_102) AT=295.025n

.meas tran vdout0_103ck580 FIND v(dout0_103) AT=295.025n

.meas tran vdout0_104ck580 FIND v(dout0_104) AT=295.025n

.meas tran vdout0_105ck580 FIND v(dout0_105) AT=295.025n

.meas tran vdout0_106ck580 FIND v(dout0_106) AT=295.025n

.meas tran vdout0_107ck580 FIND v(dout0_107) AT=295.025n

.meas tran vdout0_108ck580 FIND v(dout0_108) AT=295.025n

.meas tran vdout0_109ck580 FIND v(dout0_109) AT=295.025n

.meas tran vdout0_110ck580 FIND v(dout0_110) AT=295.025n

.meas tran vdout0_111ck580 FIND v(dout0_111) AT=295.025n

.meas tran vdout0_112ck580 FIND v(dout0_112) AT=295.025n

.meas tran vdout0_113ck580 FIND v(dout0_113) AT=295.025n

.meas tran vdout0_114ck580 FIND v(dout0_114) AT=295.025n

.meas tran vdout0_115ck580 FIND v(dout0_115) AT=295.025n

.meas tran vdout0_116ck580 FIND v(dout0_116) AT=295.025n

.meas tran vdout0_117ck580 FIND v(dout0_117) AT=295.025n

.meas tran vdout0_118ck580 FIND v(dout0_118) AT=295.025n

.meas tran vdout0_119ck580 FIND v(dout0_119) AT=295.025n

.meas tran vdout0_120ck580 FIND v(dout0_120) AT=295.025n

.meas tran vdout0_121ck580 FIND v(dout0_121) AT=295.025n

.meas tran vdout0_122ck580 FIND v(dout0_122) AT=295.025n

.meas tran vdout0_123ck580 FIND v(dout0_123) AT=295.025n

.meas tran vdout0_124ck580 FIND v(dout0_124) AT=295.025n

.meas tran vdout0_125ck580 FIND v(dout0_125) AT=295.025n

.meas tran vdout0_126ck580 FIND v(dout0_126) AT=295.025n

.meas tran vdout0_127ck580 FIND v(dout0_127) AT=295.025n

.meas tran vdout0_0ck600 FIND v(dout0_0) AT=305.025n

.meas tran vdout0_1ck600 FIND v(dout0_1) AT=305.025n

.meas tran vdout0_2ck600 FIND v(dout0_2) AT=305.025n

.meas tran vdout0_3ck600 FIND v(dout0_3) AT=305.025n

.meas tran vdout0_4ck600 FIND v(dout0_4) AT=305.025n

.meas tran vdout0_5ck600 FIND v(dout0_5) AT=305.025n

.meas tran vdout0_6ck600 FIND v(dout0_6) AT=305.025n

.meas tran vdout0_7ck600 FIND v(dout0_7) AT=305.025n

.meas tran vdout0_8ck600 FIND v(dout0_8) AT=305.025n

.meas tran vdout0_9ck600 FIND v(dout0_9) AT=305.025n

.meas tran vdout0_10ck600 FIND v(dout0_10) AT=305.025n

.meas tran vdout0_11ck600 FIND v(dout0_11) AT=305.025n

.meas tran vdout0_12ck600 FIND v(dout0_12) AT=305.025n

.meas tran vdout0_13ck600 FIND v(dout0_13) AT=305.025n

.meas tran vdout0_14ck600 FIND v(dout0_14) AT=305.025n

.meas tran vdout0_15ck600 FIND v(dout0_15) AT=305.025n

.meas tran vdout0_16ck600 FIND v(dout0_16) AT=305.025n

.meas tran vdout0_17ck600 FIND v(dout0_17) AT=305.025n

.meas tran vdout0_18ck600 FIND v(dout0_18) AT=305.025n

.meas tran vdout0_19ck600 FIND v(dout0_19) AT=305.025n

.meas tran vdout0_20ck600 FIND v(dout0_20) AT=305.025n

.meas tran vdout0_21ck600 FIND v(dout0_21) AT=305.025n

.meas tran vdout0_22ck600 FIND v(dout0_22) AT=305.025n

.meas tran vdout0_23ck600 FIND v(dout0_23) AT=305.025n

.meas tran vdout0_24ck600 FIND v(dout0_24) AT=305.025n

.meas tran vdout0_25ck600 FIND v(dout0_25) AT=305.025n

.meas tran vdout0_26ck600 FIND v(dout0_26) AT=305.025n

.meas tran vdout0_27ck600 FIND v(dout0_27) AT=305.025n

.meas tran vdout0_28ck600 FIND v(dout0_28) AT=305.025n

.meas tran vdout0_29ck600 FIND v(dout0_29) AT=305.025n

.meas tran vdout0_30ck600 FIND v(dout0_30) AT=305.025n

.meas tran vdout0_31ck600 FIND v(dout0_31) AT=305.025n

.meas tran vdout0_32ck600 FIND v(dout0_32) AT=305.025n

.meas tran vdout0_33ck600 FIND v(dout0_33) AT=305.025n

.meas tran vdout0_34ck600 FIND v(dout0_34) AT=305.025n

.meas tran vdout0_35ck600 FIND v(dout0_35) AT=305.025n

.meas tran vdout0_36ck600 FIND v(dout0_36) AT=305.025n

.meas tran vdout0_37ck600 FIND v(dout0_37) AT=305.025n

.meas tran vdout0_38ck600 FIND v(dout0_38) AT=305.025n

.meas tran vdout0_39ck600 FIND v(dout0_39) AT=305.025n

.meas tran vdout0_40ck600 FIND v(dout0_40) AT=305.025n

.meas tran vdout0_41ck600 FIND v(dout0_41) AT=305.025n

.meas tran vdout0_42ck600 FIND v(dout0_42) AT=305.025n

.meas tran vdout0_43ck600 FIND v(dout0_43) AT=305.025n

.meas tran vdout0_44ck600 FIND v(dout0_44) AT=305.025n

.meas tran vdout0_45ck600 FIND v(dout0_45) AT=305.025n

.meas tran vdout0_46ck600 FIND v(dout0_46) AT=305.025n

.meas tran vdout0_47ck600 FIND v(dout0_47) AT=305.025n

.meas tran vdout0_48ck600 FIND v(dout0_48) AT=305.025n

.meas tran vdout0_49ck600 FIND v(dout0_49) AT=305.025n

.meas tran vdout0_50ck600 FIND v(dout0_50) AT=305.025n

.meas tran vdout0_51ck600 FIND v(dout0_51) AT=305.025n

.meas tran vdout0_52ck600 FIND v(dout0_52) AT=305.025n

.meas tran vdout0_53ck600 FIND v(dout0_53) AT=305.025n

.meas tran vdout0_54ck600 FIND v(dout0_54) AT=305.025n

.meas tran vdout0_55ck600 FIND v(dout0_55) AT=305.025n

.meas tran vdout0_56ck600 FIND v(dout0_56) AT=305.025n

.meas tran vdout0_57ck600 FIND v(dout0_57) AT=305.025n

.meas tran vdout0_58ck600 FIND v(dout0_58) AT=305.025n

.meas tran vdout0_59ck600 FIND v(dout0_59) AT=305.025n

.meas tran vdout0_60ck600 FIND v(dout0_60) AT=305.025n

.meas tran vdout0_61ck600 FIND v(dout0_61) AT=305.025n

.meas tran vdout0_62ck600 FIND v(dout0_62) AT=305.025n

.meas tran vdout0_63ck600 FIND v(dout0_63) AT=305.025n

.meas tran vdout0_64ck600 FIND v(dout0_64) AT=305.025n

.meas tran vdout0_65ck600 FIND v(dout0_65) AT=305.025n

.meas tran vdout0_66ck600 FIND v(dout0_66) AT=305.025n

.meas tran vdout0_67ck600 FIND v(dout0_67) AT=305.025n

.meas tran vdout0_68ck600 FIND v(dout0_68) AT=305.025n

.meas tran vdout0_69ck600 FIND v(dout0_69) AT=305.025n

.meas tran vdout0_70ck600 FIND v(dout0_70) AT=305.025n

.meas tran vdout0_71ck600 FIND v(dout0_71) AT=305.025n

.meas tran vdout0_72ck600 FIND v(dout0_72) AT=305.025n

.meas tran vdout0_73ck600 FIND v(dout0_73) AT=305.025n

.meas tran vdout0_74ck600 FIND v(dout0_74) AT=305.025n

.meas tran vdout0_75ck600 FIND v(dout0_75) AT=305.025n

.meas tran vdout0_76ck600 FIND v(dout0_76) AT=305.025n

.meas tran vdout0_77ck600 FIND v(dout0_77) AT=305.025n

.meas tran vdout0_78ck600 FIND v(dout0_78) AT=305.025n

.meas tran vdout0_79ck600 FIND v(dout0_79) AT=305.025n

.meas tran vdout0_80ck600 FIND v(dout0_80) AT=305.025n

.meas tran vdout0_81ck600 FIND v(dout0_81) AT=305.025n

.meas tran vdout0_82ck600 FIND v(dout0_82) AT=305.025n

.meas tran vdout0_83ck600 FIND v(dout0_83) AT=305.025n

.meas tran vdout0_84ck600 FIND v(dout0_84) AT=305.025n

.meas tran vdout0_85ck600 FIND v(dout0_85) AT=305.025n

.meas tran vdout0_86ck600 FIND v(dout0_86) AT=305.025n

.meas tran vdout0_87ck600 FIND v(dout0_87) AT=305.025n

.meas tran vdout0_88ck600 FIND v(dout0_88) AT=305.025n

.meas tran vdout0_89ck600 FIND v(dout0_89) AT=305.025n

.meas tran vdout0_90ck600 FIND v(dout0_90) AT=305.025n

.meas tran vdout0_91ck600 FIND v(dout0_91) AT=305.025n

.meas tran vdout0_92ck600 FIND v(dout0_92) AT=305.025n

.meas tran vdout0_93ck600 FIND v(dout0_93) AT=305.025n

.meas tran vdout0_94ck600 FIND v(dout0_94) AT=305.025n

.meas tran vdout0_95ck600 FIND v(dout0_95) AT=305.025n

.meas tran vdout0_96ck600 FIND v(dout0_96) AT=305.025n

.meas tran vdout0_97ck600 FIND v(dout0_97) AT=305.025n

.meas tran vdout0_98ck600 FIND v(dout0_98) AT=305.025n

.meas tran vdout0_99ck600 FIND v(dout0_99) AT=305.025n

.meas tran vdout0_100ck600 FIND v(dout0_100) AT=305.025n

.meas tran vdout0_101ck600 FIND v(dout0_101) AT=305.025n

.meas tran vdout0_102ck600 FIND v(dout0_102) AT=305.025n

.meas tran vdout0_103ck600 FIND v(dout0_103) AT=305.025n

.meas tran vdout0_104ck600 FIND v(dout0_104) AT=305.025n

.meas tran vdout0_105ck600 FIND v(dout0_105) AT=305.025n

.meas tran vdout0_106ck600 FIND v(dout0_106) AT=305.025n

.meas tran vdout0_107ck600 FIND v(dout0_107) AT=305.025n

.meas tran vdout0_108ck600 FIND v(dout0_108) AT=305.025n

.meas tran vdout0_109ck600 FIND v(dout0_109) AT=305.025n

.meas tran vdout0_110ck600 FIND v(dout0_110) AT=305.025n

.meas tran vdout0_111ck600 FIND v(dout0_111) AT=305.025n

.meas tran vdout0_112ck600 FIND v(dout0_112) AT=305.025n

.meas tran vdout0_113ck600 FIND v(dout0_113) AT=305.025n

.meas tran vdout0_114ck600 FIND v(dout0_114) AT=305.025n

.meas tran vdout0_115ck600 FIND v(dout0_115) AT=305.025n

.meas tran vdout0_116ck600 FIND v(dout0_116) AT=305.025n

.meas tran vdout0_117ck600 FIND v(dout0_117) AT=305.025n

.meas tran vdout0_118ck600 FIND v(dout0_118) AT=305.025n

.meas tran vdout0_119ck600 FIND v(dout0_119) AT=305.025n

.meas tran vdout0_120ck600 FIND v(dout0_120) AT=305.025n

.meas tran vdout0_121ck600 FIND v(dout0_121) AT=305.025n

.meas tran vdout0_122ck600 FIND v(dout0_122) AT=305.025n

.meas tran vdout0_123ck600 FIND v(dout0_123) AT=305.025n

.meas tran vdout0_124ck600 FIND v(dout0_124) AT=305.025n

.meas tran vdout0_125ck600 FIND v(dout0_125) AT=305.025n

.meas tran vdout0_126ck600 FIND v(dout0_126) AT=305.025n

.meas tran vdout0_127ck600 FIND v(dout0_127) AT=305.025n

.meas tran vdout0_0ck640 FIND v(dout0_0) AT=325.025n

.meas tran vdout0_1ck640 FIND v(dout0_1) AT=325.025n

.meas tran vdout0_2ck640 FIND v(dout0_2) AT=325.025n

.meas tran vdout0_3ck640 FIND v(dout0_3) AT=325.025n

.meas tran vdout0_4ck640 FIND v(dout0_4) AT=325.025n

.meas tran vdout0_5ck640 FIND v(dout0_5) AT=325.025n

.meas tran vdout0_6ck640 FIND v(dout0_6) AT=325.025n

.meas tran vdout0_7ck640 FIND v(dout0_7) AT=325.025n

.meas tran vdout0_8ck640 FIND v(dout0_8) AT=325.025n

.meas tran vdout0_9ck640 FIND v(dout0_9) AT=325.025n

.meas tran vdout0_10ck640 FIND v(dout0_10) AT=325.025n

.meas tran vdout0_11ck640 FIND v(dout0_11) AT=325.025n

.meas tran vdout0_12ck640 FIND v(dout0_12) AT=325.025n

.meas tran vdout0_13ck640 FIND v(dout0_13) AT=325.025n

.meas tran vdout0_14ck640 FIND v(dout0_14) AT=325.025n

.meas tran vdout0_15ck640 FIND v(dout0_15) AT=325.025n

.meas tran vdout0_16ck640 FIND v(dout0_16) AT=325.025n

.meas tran vdout0_17ck640 FIND v(dout0_17) AT=325.025n

.meas tran vdout0_18ck640 FIND v(dout0_18) AT=325.025n

.meas tran vdout0_19ck640 FIND v(dout0_19) AT=325.025n

.meas tran vdout0_20ck640 FIND v(dout0_20) AT=325.025n

.meas tran vdout0_21ck640 FIND v(dout0_21) AT=325.025n

.meas tran vdout0_22ck640 FIND v(dout0_22) AT=325.025n

.meas tran vdout0_23ck640 FIND v(dout0_23) AT=325.025n

.meas tran vdout0_24ck640 FIND v(dout0_24) AT=325.025n

.meas tran vdout0_25ck640 FIND v(dout0_25) AT=325.025n

.meas tran vdout0_26ck640 FIND v(dout0_26) AT=325.025n

.meas tran vdout0_27ck640 FIND v(dout0_27) AT=325.025n

.meas tran vdout0_28ck640 FIND v(dout0_28) AT=325.025n

.meas tran vdout0_29ck640 FIND v(dout0_29) AT=325.025n

.meas tran vdout0_30ck640 FIND v(dout0_30) AT=325.025n

.meas tran vdout0_31ck640 FIND v(dout0_31) AT=325.025n

.meas tran vdout0_32ck640 FIND v(dout0_32) AT=325.025n

.meas tran vdout0_33ck640 FIND v(dout0_33) AT=325.025n

.meas tran vdout0_34ck640 FIND v(dout0_34) AT=325.025n

.meas tran vdout0_35ck640 FIND v(dout0_35) AT=325.025n

.meas tran vdout0_36ck640 FIND v(dout0_36) AT=325.025n

.meas tran vdout0_37ck640 FIND v(dout0_37) AT=325.025n

.meas tran vdout0_38ck640 FIND v(dout0_38) AT=325.025n

.meas tran vdout0_39ck640 FIND v(dout0_39) AT=325.025n

.meas tran vdout0_40ck640 FIND v(dout0_40) AT=325.025n

.meas tran vdout0_41ck640 FIND v(dout0_41) AT=325.025n

.meas tran vdout0_42ck640 FIND v(dout0_42) AT=325.025n

.meas tran vdout0_43ck640 FIND v(dout0_43) AT=325.025n

.meas tran vdout0_44ck640 FIND v(dout0_44) AT=325.025n

.meas tran vdout0_45ck640 FIND v(dout0_45) AT=325.025n

.meas tran vdout0_46ck640 FIND v(dout0_46) AT=325.025n

.meas tran vdout0_47ck640 FIND v(dout0_47) AT=325.025n

.meas tran vdout0_48ck640 FIND v(dout0_48) AT=325.025n

.meas tran vdout0_49ck640 FIND v(dout0_49) AT=325.025n

.meas tran vdout0_50ck640 FIND v(dout0_50) AT=325.025n

.meas tran vdout0_51ck640 FIND v(dout0_51) AT=325.025n

.meas tran vdout0_52ck640 FIND v(dout0_52) AT=325.025n

.meas tran vdout0_53ck640 FIND v(dout0_53) AT=325.025n

.meas tran vdout0_54ck640 FIND v(dout0_54) AT=325.025n

.meas tran vdout0_55ck640 FIND v(dout0_55) AT=325.025n

.meas tran vdout0_56ck640 FIND v(dout0_56) AT=325.025n

.meas tran vdout0_57ck640 FIND v(dout0_57) AT=325.025n

.meas tran vdout0_58ck640 FIND v(dout0_58) AT=325.025n

.meas tran vdout0_59ck640 FIND v(dout0_59) AT=325.025n

.meas tran vdout0_60ck640 FIND v(dout0_60) AT=325.025n

.meas tran vdout0_61ck640 FIND v(dout0_61) AT=325.025n

.meas tran vdout0_62ck640 FIND v(dout0_62) AT=325.025n

.meas tran vdout0_63ck640 FIND v(dout0_63) AT=325.025n

.meas tran vdout0_64ck640 FIND v(dout0_64) AT=325.025n

.meas tran vdout0_65ck640 FIND v(dout0_65) AT=325.025n

.meas tran vdout0_66ck640 FIND v(dout0_66) AT=325.025n

.meas tran vdout0_67ck640 FIND v(dout0_67) AT=325.025n

.meas tran vdout0_68ck640 FIND v(dout0_68) AT=325.025n

.meas tran vdout0_69ck640 FIND v(dout0_69) AT=325.025n

.meas tran vdout0_70ck640 FIND v(dout0_70) AT=325.025n

.meas tran vdout0_71ck640 FIND v(dout0_71) AT=325.025n

.meas tran vdout0_72ck640 FIND v(dout0_72) AT=325.025n

.meas tran vdout0_73ck640 FIND v(dout0_73) AT=325.025n

.meas tran vdout0_74ck640 FIND v(dout0_74) AT=325.025n

.meas tran vdout0_75ck640 FIND v(dout0_75) AT=325.025n

.meas tran vdout0_76ck640 FIND v(dout0_76) AT=325.025n

.meas tran vdout0_77ck640 FIND v(dout0_77) AT=325.025n

.meas tran vdout0_78ck640 FIND v(dout0_78) AT=325.025n

.meas tran vdout0_79ck640 FIND v(dout0_79) AT=325.025n

.meas tran vdout0_80ck640 FIND v(dout0_80) AT=325.025n

.meas tran vdout0_81ck640 FIND v(dout0_81) AT=325.025n

.meas tran vdout0_82ck640 FIND v(dout0_82) AT=325.025n

.meas tran vdout0_83ck640 FIND v(dout0_83) AT=325.025n

.meas tran vdout0_84ck640 FIND v(dout0_84) AT=325.025n

.meas tran vdout0_85ck640 FIND v(dout0_85) AT=325.025n

.meas tran vdout0_86ck640 FIND v(dout0_86) AT=325.025n

.meas tran vdout0_87ck640 FIND v(dout0_87) AT=325.025n

.meas tran vdout0_88ck640 FIND v(dout0_88) AT=325.025n

.meas tran vdout0_89ck640 FIND v(dout0_89) AT=325.025n

.meas tran vdout0_90ck640 FIND v(dout0_90) AT=325.025n

.meas tran vdout0_91ck640 FIND v(dout0_91) AT=325.025n

.meas tran vdout0_92ck640 FIND v(dout0_92) AT=325.025n

.meas tran vdout0_93ck640 FIND v(dout0_93) AT=325.025n

.meas tran vdout0_94ck640 FIND v(dout0_94) AT=325.025n

.meas tran vdout0_95ck640 FIND v(dout0_95) AT=325.025n

.meas tran vdout0_96ck640 FIND v(dout0_96) AT=325.025n

.meas tran vdout0_97ck640 FIND v(dout0_97) AT=325.025n

.meas tran vdout0_98ck640 FIND v(dout0_98) AT=325.025n

.meas tran vdout0_99ck640 FIND v(dout0_99) AT=325.025n

.meas tran vdout0_100ck640 FIND v(dout0_100) AT=325.025n

.meas tran vdout0_101ck640 FIND v(dout0_101) AT=325.025n

.meas tran vdout0_102ck640 FIND v(dout0_102) AT=325.025n

.meas tran vdout0_103ck640 FIND v(dout0_103) AT=325.025n

.meas tran vdout0_104ck640 FIND v(dout0_104) AT=325.025n

.meas tran vdout0_105ck640 FIND v(dout0_105) AT=325.025n

.meas tran vdout0_106ck640 FIND v(dout0_106) AT=325.025n

.meas tran vdout0_107ck640 FIND v(dout0_107) AT=325.025n

.meas tran vdout0_108ck640 FIND v(dout0_108) AT=325.025n

.meas tran vdout0_109ck640 FIND v(dout0_109) AT=325.025n

.meas tran vdout0_110ck640 FIND v(dout0_110) AT=325.025n

.meas tran vdout0_111ck640 FIND v(dout0_111) AT=325.025n

.meas tran vdout0_112ck640 FIND v(dout0_112) AT=325.025n

.meas tran vdout0_113ck640 FIND v(dout0_113) AT=325.025n

.meas tran vdout0_114ck640 FIND v(dout0_114) AT=325.025n

.meas tran vdout0_115ck640 FIND v(dout0_115) AT=325.025n

.meas tran vdout0_116ck640 FIND v(dout0_116) AT=325.025n

.meas tran vdout0_117ck640 FIND v(dout0_117) AT=325.025n

.meas tran vdout0_118ck640 FIND v(dout0_118) AT=325.025n

.meas tran vdout0_119ck640 FIND v(dout0_119) AT=325.025n

.meas tran vdout0_120ck640 FIND v(dout0_120) AT=325.025n

.meas tran vdout0_121ck640 FIND v(dout0_121) AT=325.025n

.meas tran vdout0_122ck640 FIND v(dout0_122) AT=325.025n

.meas tran vdout0_123ck640 FIND v(dout0_123) AT=325.025n

.meas tran vdout0_124ck640 FIND v(dout0_124) AT=325.025n

.meas tran vdout0_125ck640 FIND v(dout0_125) AT=325.025n

.meas tran vdout0_126ck640 FIND v(dout0_126) AT=325.025n

.meas tran vdout0_127ck640 FIND v(dout0_127) AT=325.025n

.meas tran vdout0_0ck650 FIND v(dout0_0) AT=330.025n

.meas tran vdout0_1ck650 FIND v(dout0_1) AT=330.025n

.meas tran vdout0_2ck650 FIND v(dout0_2) AT=330.025n

.meas tran vdout0_3ck650 FIND v(dout0_3) AT=330.025n

.meas tran vdout0_4ck650 FIND v(dout0_4) AT=330.025n

.meas tran vdout0_5ck650 FIND v(dout0_5) AT=330.025n

.meas tran vdout0_6ck650 FIND v(dout0_6) AT=330.025n

.meas tran vdout0_7ck650 FIND v(dout0_7) AT=330.025n

.meas tran vdout0_8ck650 FIND v(dout0_8) AT=330.025n

.meas tran vdout0_9ck650 FIND v(dout0_9) AT=330.025n

.meas tran vdout0_10ck650 FIND v(dout0_10) AT=330.025n

.meas tran vdout0_11ck650 FIND v(dout0_11) AT=330.025n

.meas tran vdout0_12ck650 FIND v(dout0_12) AT=330.025n

.meas tran vdout0_13ck650 FIND v(dout0_13) AT=330.025n

.meas tran vdout0_14ck650 FIND v(dout0_14) AT=330.025n

.meas tran vdout0_15ck650 FIND v(dout0_15) AT=330.025n

.meas tran vdout0_16ck650 FIND v(dout0_16) AT=330.025n

.meas tran vdout0_17ck650 FIND v(dout0_17) AT=330.025n

.meas tran vdout0_18ck650 FIND v(dout0_18) AT=330.025n

.meas tran vdout0_19ck650 FIND v(dout0_19) AT=330.025n

.meas tran vdout0_20ck650 FIND v(dout0_20) AT=330.025n

.meas tran vdout0_21ck650 FIND v(dout0_21) AT=330.025n

.meas tran vdout0_22ck650 FIND v(dout0_22) AT=330.025n

.meas tran vdout0_23ck650 FIND v(dout0_23) AT=330.025n

.meas tran vdout0_24ck650 FIND v(dout0_24) AT=330.025n

.meas tran vdout0_25ck650 FIND v(dout0_25) AT=330.025n

.meas tran vdout0_26ck650 FIND v(dout0_26) AT=330.025n

.meas tran vdout0_27ck650 FIND v(dout0_27) AT=330.025n

.meas tran vdout0_28ck650 FIND v(dout0_28) AT=330.025n

.meas tran vdout0_29ck650 FIND v(dout0_29) AT=330.025n

.meas tran vdout0_30ck650 FIND v(dout0_30) AT=330.025n

.meas tran vdout0_31ck650 FIND v(dout0_31) AT=330.025n

.meas tran vdout0_32ck650 FIND v(dout0_32) AT=330.025n

.meas tran vdout0_33ck650 FIND v(dout0_33) AT=330.025n

.meas tran vdout0_34ck650 FIND v(dout0_34) AT=330.025n

.meas tran vdout0_35ck650 FIND v(dout0_35) AT=330.025n

.meas tran vdout0_36ck650 FIND v(dout0_36) AT=330.025n

.meas tran vdout0_37ck650 FIND v(dout0_37) AT=330.025n

.meas tran vdout0_38ck650 FIND v(dout0_38) AT=330.025n

.meas tran vdout0_39ck650 FIND v(dout0_39) AT=330.025n

.meas tran vdout0_40ck650 FIND v(dout0_40) AT=330.025n

.meas tran vdout0_41ck650 FIND v(dout0_41) AT=330.025n

.meas tran vdout0_42ck650 FIND v(dout0_42) AT=330.025n

.meas tran vdout0_43ck650 FIND v(dout0_43) AT=330.025n

.meas tran vdout0_44ck650 FIND v(dout0_44) AT=330.025n

.meas tran vdout0_45ck650 FIND v(dout0_45) AT=330.025n

.meas tran vdout0_46ck650 FIND v(dout0_46) AT=330.025n

.meas tran vdout0_47ck650 FIND v(dout0_47) AT=330.025n

.meas tran vdout0_48ck650 FIND v(dout0_48) AT=330.025n

.meas tran vdout0_49ck650 FIND v(dout0_49) AT=330.025n

.meas tran vdout0_50ck650 FIND v(dout0_50) AT=330.025n

.meas tran vdout0_51ck650 FIND v(dout0_51) AT=330.025n

.meas tran vdout0_52ck650 FIND v(dout0_52) AT=330.025n

.meas tran vdout0_53ck650 FIND v(dout0_53) AT=330.025n

.meas tran vdout0_54ck650 FIND v(dout0_54) AT=330.025n

.meas tran vdout0_55ck650 FIND v(dout0_55) AT=330.025n

.meas tran vdout0_56ck650 FIND v(dout0_56) AT=330.025n

.meas tran vdout0_57ck650 FIND v(dout0_57) AT=330.025n

.meas tran vdout0_58ck650 FIND v(dout0_58) AT=330.025n

.meas tran vdout0_59ck650 FIND v(dout0_59) AT=330.025n

.meas tran vdout0_60ck650 FIND v(dout0_60) AT=330.025n

.meas tran vdout0_61ck650 FIND v(dout0_61) AT=330.025n

.meas tran vdout0_62ck650 FIND v(dout0_62) AT=330.025n

.meas tran vdout0_63ck650 FIND v(dout0_63) AT=330.025n

.meas tran vdout0_64ck650 FIND v(dout0_64) AT=330.025n

.meas tran vdout0_65ck650 FIND v(dout0_65) AT=330.025n

.meas tran vdout0_66ck650 FIND v(dout0_66) AT=330.025n

.meas tran vdout0_67ck650 FIND v(dout0_67) AT=330.025n

.meas tran vdout0_68ck650 FIND v(dout0_68) AT=330.025n

.meas tran vdout0_69ck650 FIND v(dout0_69) AT=330.025n

.meas tran vdout0_70ck650 FIND v(dout0_70) AT=330.025n

.meas tran vdout0_71ck650 FIND v(dout0_71) AT=330.025n

.meas tran vdout0_72ck650 FIND v(dout0_72) AT=330.025n

.meas tran vdout0_73ck650 FIND v(dout0_73) AT=330.025n

.meas tran vdout0_74ck650 FIND v(dout0_74) AT=330.025n

.meas tran vdout0_75ck650 FIND v(dout0_75) AT=330.025n

.meas tran vdout0_76ck650 FIND v(dout0_76) AT=330.025n

.meas tran vdout0_77ck650 FIND v(dout0_77) AT=330.025n

.meas tran vdout0_78ck650 FIND v(dout0_78) AT=330.025n

.meas tran vdout0_79ck650 FIND v(dout0_79) AT=330.025n

.meas tran vdout0_80ck650 FIND v(dout0_80) AT=330.025n

.meas tran vdout0_81ck650 FIND v(dout0_81) AT=330.025n

.meas tran vdout0_82ck650 FIND v(dout0_82) AT=330.025n

.meas tran vdout0_83ck650 FIND v(dout0_83) AT=330.025n

.meas tran vdout0_84ck650 FIND v(dout0_84) AT=330.025n

.meas tran vdout0_85ck650 FIND v(dout0_85) AT=330.025n

.meas tran vdout0_86ck650 FIND v(dout0_86) AT=330.025n

.meas tran vdout0_87ck650 FIND v(dout0_87) AT=330.025n

.meas tran vdout0_88ck650 FIND v(dout0_88) AT=330.025n

.meas tran vdout0_89ck650 FIND v(dout0_89) AT=330.025n

.meas tran vdout0_90ck650 FIND v(dout0_90) AT=330.025n

.meas tran vdout0_91ck650 FIND v(dout0_91) AT=330.025n

.meas tran vdout0_92ck650 FIND v(dout0_92) AT=330.025n

.meas tran vdout0_93ck650 FIND v(dout0_93) AT=330.025n

.meas tran vdout0_94ck650 FIND v(dout0_94) AT=330.025n

.meas tran vdout0_95ck650 FIND v(dout0_95) AT=330.025n

.meas tran vdout0_96ck650 FIND v(dout0_96) AT=330.025n

.meas tran vdout0_97ck650 FIND v(dout0_97) AT=330.025n

.meas tran vdout0_98ck650 FIND v(dout0_98) AT=330.025n

.meas tran vdout0_99ck650 FIND v(dout0_99) AT=330.025n

.meas tran vdout0_100ck650 FIND v(dout0_100) AT=330.025n

.meas tran vdout0_101ck650 FIND v(dout0_101) AT=330.025n

.meas tran vdout0_102ck650 FIND v(dout0_102) AT=330.025n

.meas tran vdout0_103ck650 FIND v(dout0_103) AT=330.025n

.meas tran vdout0_104ck650 FIND v(dout0_104) AT=330.025n

.meas tran vdout0_105ck650 FIND v(dout0_105) AT=330.025n

.meas tran vdout0_106ck650 FIND v(dout0_106) AT=330.025n

.meas tran vdout0_107ck650 FIND v(dout0_107) AT=330.025n

.meas tran vdout0_108ck650 FIND v(dout0_108) AT=330.025n

.meas tran vdout0_109ck650 FIND v(dout0_109) AT=330.025n

.meas tran vdout0_110ck650 FIND v(dout0_110) AT=330.025n

.meas tran vdout0_111ck650 FIND v(dout0_111) AT=330.025n

.meas tran vdout0_112ck650 FIND v(dout0_112) AT=330.025n

.meas tran vdout0_113ck650 FIND v(dout0_113) AT=330.025n

.meas tran vdout0_114ck650 FIND v(dout0_114) AT=330.025n

.meas tran vdout0_115ck650 FIND v(dout0_115) AT=330.025n

.meas tran vdout0_116ck650 FIND v(dout0_116) AT=330.025n

.meas tran vdout0_117ck650 FIND v(dout0_117) AT=330.025n

.meas tran vdout0_118ck650 FIND v(dout0_118) AT=330.025n

.meas tran vdout0_119ck650 FIND v(dout0_119) AT=330.025n

.meas tran vdout0_120ck650 FIND v(dout0_120) AT=330.025n

.meas tran vdout0_121ck650 FIND v(dout0_121) AT=330.025n

.meas tran vdout0_122ck650 FIND v(dout0_122) AT=330.025n

.meas tran vdout0_123ck650 FIND v(dout0_123) AT=330.025n

.meas tran vdout0_124ck650 FIND v(dout0_124) AT=330.025n

.meas tran vdout0_125ck650 FIND v(dout0_125) AT=330.025n

.meas tran vdout0_126ck650 FIND v(dout0_126) AT=330.025n

.meas tran vdout0_127ck650 FIND v(dout0_127) AT=330.025n

.meas tran vdout0_0ck660 FIND v(dout0_0) AT=335.025n

.meas tran vdout0_1ck660 FIND v(dout0_1) AT=335.025n

.meas tran vdout0_2ck660 FIND v(dout0_2) AT=335.025n

.meas tran vdout0_3ck660 FIND v(dout0_3) AT=335.025n

.meas tran vdout0_4ck660 FIND v(dout0_4) AT=335.025n

.meas tran vdout0_5ck660 FIND v(dout0_5) AT=335.025n

.meas tran vdout0_6ck660 FIND v(dout0_6) AT=335.025n

.meas tran vdout0_7ck660 FIND v(dout0_7) AT=335.025n

.meas tran vdout0_8ck660 FIND v(dout0_8) AT=335.025n

.meas tran vdout0_9ck660 FIND v(dout0_9) AT=335.025n

.meas tran vdout0_10ck660 FIND v(dout0_10) AT=335.025n

.meas tran vdout0_11ck660 FIND v(dout0_11) AT=335.025n

.meas tran vdout0_12ck660 FIND v(dout0_12) AT=335.025n

.meas tran vdout0_13ck660 FIND v(dout0_13) AT=335.025n

.meas tran vdout0_14ck660 FIND v(dout0_14) AT=335.025n

.meas tran vdout0_15ck660 FIND v(dout0_15) AT=335.025n

.meas tran vdout0_16ck660 FIND v(dout0_16) AT=335.025n

.meas tran vdout0_17ck660 FIND v(dout0_17) AT=335.025n

.meas tran vdout0_18ck660 FIND v(dout0_18) AT=335.025n

.meas tran vdout0_19ck660 FIND v(dout0_19) AT=335.025n

.meas tran vdout0_20ck660 FIND v(dout0_20) AT=335.025n

.meas tran vdout0_21ck660 FIND v(dout0_21) AT=335.025n

.meas tran vdout0_22ck660 FIND v(dout0_22) AT=335.025n

.meas tran vdout0_23ck660 FIND v(dout0_23) AT=335.025n

.meas tran vdout0_24ck660 FIND v(dout0_24) AT=335.025n

.meas tran vdout0_25ck660 FIND v(dout0_25) AT=335.025n

.meas tran vdout0_26ck660 FIND v(dout0_26) AT=335.025n

.meas tran vdout0_27ck660 FIND v(dout0_27) AT=335.025n

.meas tran vdout0_28ck660 FIND v(dout0_28) AT=335.025n

.meas tran vdout0_29ck660 FIND v(dout0_29) AT=335.025n

.meas tran vdout0_30ck660 FIND v(dout0_30) AT=335.025n

.meas tran vdout0_31ck660 FIND v(dout0_31) AT=335.025n

.meas tran vdout0_32ck660 FIND v(dout0_32) AT=335.025n

.meas tran vdout0_33ck660 FIND v(dout0_33) AT=335.025n

.meas tran vdout0_34ck660 FIND v(dout0_34) AT=335.025n

.meas tran vdout0_35ck660 FIND v(dout0_35) AT=335.025n

.meas tran vdout0_36ck660 FIND v(dout0_36) AT=335.025n

.meas tran vdout0_37ck660 FIND v(dout0_37) AT=335.025n

.meas tran vdout0_38ck660 FIND v(dout0_38) AT=335.025n

.meas tran vdout0_39ck660 FIND v(dout0_39) AT=335.025n

.meas tran vdout0_40ck660 FIND v(dout0_40) AT=335.025n

.meas tran vdout0_41ck660 FIND v(dout0_41) AT=335.025n

.meas tran vdout0_42ck660 FIND v(dout0_42) AT=335.025n

.meas tran vdout0_43ck660 FIND v(dout0_43) AT=335.025n

.meas tran vdout0_44ck660 FIND v(dout0_44) AT=335.025n

.meas tran vdout0_45ck660 FIND v(dout0_45) AT=335.025n

.meas tran vdout0_46ck660 FIND v(dout0_46) AT=335.025n

.meas tran vdout0_47ck660 FIND v(dout0_47) AT=335.025n

.meas tran vdout0_48ck660 FIND v(dout0_48) AT=335.025n

.meas tran vdout0_49ck660 FIND v(dout0_49) AT=335.025n

.meas tran vdout0_50ck660 FIND v(dout0_50) AT=335.025n

.meas tran vdout0_51ck660 FIND v(dout0_51) AT=335.025n

.meas tran vdout0_52ck660 FIND v(dout0_52) AT=335.025n

.meas tran vdout0_53ck660 FIND v(dout0_53) AT=335.025n

.meas tran vdout0_54ck660 FIND v(dout0_54) AT=335.025n

.meas tran vdout0_55ck660 FIND v(dout0_55) AT=335.025n

.meas tran vdout0_56ck660 FIND v(dout0_56) AT=335.025n

.meas tran vdout0_57ck660 FIND v(dout0_57) AT=335.025n

.meas tran vdout0_58ck660 FIND v(dout0_58) AT=335.025n

.meas tran vdout0_59ck660 FIND v(dout0_59) AT=335.025n

.meas tran vdout0_60ck660 FIND v(dout0_60) AT=335.025n

.meas tran vdout0_61ck660 FIND v(dout0_61) AT=335.025n

.meas tran vdout0_62ck660 FIND v(dout0_62) AT=335.025n

.meas tran vdout0_63ck660 FIND v(dout0_63) AT=335.025n

.meas tran vdout0_64ck660 FIND v(dout0_64) AT=335.025n

.meas tran vdout0_65ck660 FIND v(dout0_65) AT=335.025n

.meas tran vdout0_66ck660 FIND v(dout0_66) AT=335.025n

.meas tran vdout0_67ck660 FIND v(dout0_67) AT=335.025n

.meas tran vdout0_68ck660 FIND v(dout0_68) AT=335.025n

.meas tran vdout0_69ck660 FIND v(dout0_69) AT=335.025n

.meas tran vdout0_70ck660 FIND v(dout0_70) AT=335.025n

.meas tran vdout0_71ck660 FIND v(dout0_71) AT=335.025n

.meas tran vdout0_72ck660 FIND v(dout0_72) AT=335.025n

.meas tran vdout0_73ck660 FIND v(dout0_73) AT=335.025n

.meas tran vdout0_74ck660 FIND v(dout0_74) AT=335.025n

.meas tran vdout0_75ck660 FIND v(dout0_75) AT=335.025n

.meas tran vdout0_76ck660 FIND v(dout0_76) AT=335.025n

.meas tran vdout0_77ck660 FIND v(dout0_77) AT=335.025n

.meas tran vdout0_78ck660 FIND v(dout0_78) AT=335.025n

.meas tran vdout0_79ck660 FIND v(dout0_79) AT=335.025n

.meas tran vdout0_80ck660 FIND v(dout0_80) AT=335.025n

.meas tran vdout0_81ck660 FIND v(dout0_81) AT=335.025n

.meas tran vdout0_82ck660 FIND v(dout0_82) AT=335.025n

.meas tran vdout0_83ck660 FIND v(dout0_83) AT=335.025n

.meas tran vdout0_84ck660 FIND v(dout0_84) AT=335.025n

.meas tran vdout0_85ck660 FIND v(dout0_85) AT=335.025n

.meas tran vdout0_86ck660 FIND v(dout0_86) AT=335.025n

.meas tran vdout0_87ck660 FIND v(dout0_87) AT=335.025n

.meas tran vdout0_88ck660 FIND v(dout0_88) AT=335.025n

.meas tran vdout0_89ck660 FIND v(dout0_89) AT=335.025n

.meas tran vdout0_90ck660 FIND v(dout0_90) AT=335.025n

.meas tran vdout0_91ck660 FIND v(dout0_91) AT=335.025n

.meas tran vdout0_92ck660 FIND v(dout0_92) AT=335.025n

.meas tran vdout0_93ck660 FIND v(dout0_93) AT=335.025n

.meas tran vdout0_94ck660 FIND v(dout0_94) AT=335.025n

.meas tran vdout0_95ck660 FIND v(dout0_95) AT=335.025n

.meas tran vdout0_96ck660 FIND v(dout0_96) AT=335.025n

.meas tran vdout0_97ck660 FIND v(dout0_97) AT=335.025n

.meas tran vdout0_98ck660 FIND v(dout0_98) AT=335.025n

.meas tran vdout0_99ck660 FIND v(dout0_99) AT=335.025n

.meas tran vdout0_100ck660 FIND v(dout0_100) AT=335.025n

.meas tran vdout0_101ck660 FIND v(dout0_101) AT=335.025n

.meas tran vdout0_102ck660 FIND v(dout0_102) AT=335.025n

.meas tran vdout0_103ck660 FIND v(dout0_103) AT=335.025n

.meas tran vdout0_104ck660 FIND v(dout0_104) AT=335.025n

.meas tran vdout0_105ck660 FIND v(dout0_105) AT=335.025n

.meas tran vdout0_106ck660 FIND v(dout0_106) AT=335.025n

.meas tran vdout0_107ck660 FIND v(dout0_107) AT=335.025n

.meas tran vdout0_108ck660 FIND v(dout0_108) AT=335.025n

.meas tran vdout0_109ck660 FIND v(dout0_109) AT=335.025n

.meas tran vdout0_110ck660 FIND v(dout0_110) AT=335.025n

.meas tran vdout0_111ck660 FIND v(dout0_111) AT=335.025n

.meas tran vdout0_112ck660 FIND v(dout0_112) AT=335.025n

.meas tran vdout0_113ck660 FIND v(dout0_113) AT=335.025n

.meas tran vdout0_114ck660 FIND v(dout0_114) AT=335.025n

.meas tran vdout0_115ck660 FIND v(dout0_115) AT=335.025n

.meas tran vdout0_116ck660 FIND v(dout0_116) AT=335.025n

.meas tran vdout0_117ck660 FIND v(dout0_117) AT=335.025n

.meas tran vdout0_118ck660 FIND v(dout0_118) AT=335.025n

.meas tran vdout0_119ck660 FIND v(dout0_119) AT=335.025n

.meas tran vdout0_120ck660 FIND v(dout0_120) AT=335.025n

.meas tran vdout0_121ck660 FIND v(dout0_121) AT=335.025n

.meas tran vdout0_122ck660 FIND v(dout0_122) AT=335.025n

.meas tran vdout0_123ck660 FIND v(dout0_123) AT=335.025n

.meas tran vdout0_124ck660 FIND v(dout0_124) AT=335.025n

.meas tran vdout0_125ck660 FIND v(dout0_125) AT=335.025n

.meas tran vdout0_126ck660 FIND v(dout0_126) AT=335.025n

.meas tran vdout0_127ck660 FIND v(dout0_127) AT=335.025n

.meas tran vdout0_0ck710 FIND v(dout0_0) AT=360.025n

.meas tran vdout0_1ck710 FIND v(dout0_1) AT=360.025n

.meas tran vdout0_2ck710 FIND v(dout0_2) AT=360.025n

.meas tran vdout0_3ck710 FIND v(dout0_3) AT=360.025n

.meas tran vdout0_4ck710 FIND v(dout0_4) AT=360.025n

.meas tran vdout0_5ck710 FIND v(dout0_5) AT=360.025n

.meas tran vdout0_6ck710 FIND v(dout0_6) AT=360.025n

.meas tran vdout0_7ck710 FIND v(dout0_7) AT=360.025n

.meas tran vdout0_8ck710 FIND v(dout0_8) AT=360.025n

.meas tran vdout0_9ck710 FIND v(dout0_9) AT=360.025n

.meas tran vdout0_10ck710 FIND v(dout0_10) AT=360.025n

.meas tran vdout0_11ck710 FIND v(dout0_11) AT=360.025n

.meas tran vdout0_12ck710 FIND v(dout0_12) AT=360.025n

.meas tran vdout0_13ck710 FIND v(dout0_13) AT=360.025n

.meas tran vdout0_14ck710 FIND v(dout0_14) AT=360.025n

.meas tran vdout0_15ck710 FIND v(dout0_15) AT=360.025n

.meas tran vdout0_16ck710 FIND v(dout0_16) AT=360.025n

.meas tran vdout0_17ck710 FIND v(dout0_17) AT=360.025n

.meas tran vdout0_18ck710 FIND v(dout0_18) AT=360.025n

.meas tran vdout0_19ck710 FIND v(dout0_19) AT=360.025n

.meas tran vdout0_20ck710 FIND v(dout0_20) AT=360.025n

.meas tran vdout0_21ck710 FIND v(dout0_21) AT=360.025n

.meas tran vdout0_22ck710 FIND v(dout0_22) AT=360.025n

.meas tran vdout0_23ck710 FIND v(dout0_23) AT=360.025n

.meas tran vdout0_24ck710 FIND v(dout0_24) AT=360.025n

.meas tran vdout0_25ck710 FIND v(dout0_25) AT=360.025n

.meas tran vdout0_26ck710 FIND v(dout0_26) AT=360.025n

.meas tran vdout0_27ck710 FIND v(dout0_27) AT=360.025n

.meas tran vdout0_28ck710 FIND v(dout0_28) AT=360.025n

.meas tran vdout0_29ck710 FIND v(dout0_29) AT=360.025n

.meas tran vdout0_30ck710 FIND v(dout0_30) AT=360.025n

.meas tran vdout0_31ck710 FIND v(dout0_31) AT=360.025n

.meas tran vdout0_32ck710 FIND v(dout0_32) AT=360.025n

.meas tran vdout0_33ck710 FIND v(dout0_33) AT=360.025n

.meas tran vdout0_34ck710 FIND v(dout0_34) AT=360.025n

.meas tran vdout0_35ck710 FIND v(dout0_35) AT=360.025n

.meas tran vdout0_36ck710 FIND v(dout0_36) AT=360.025n

.meas tran vdout0_37ck710 FIND v(dout0_37) AT=360.025n

.meas tran vdout0_38ck710 FIND v(dout0_38) AT=360.025n

.meas tran vdout0_39ck710 FIND v(dout0_39) AT=360.025n

.meas tran vdout0_40ck710 FIND v(dout0_40) AT=360.025n

.meas tran vdout0_41ck710 FIND v(dout0_41) AT=360.025n

.meas tran vdout0_42ck710 FIND v(dout0_42) AT=360.025n

.meas tran vdout0_43ck710 FIND v(dout0_43) AT=360.025n

.meas tran vdout0_44ck710 FIND v(dout0_44) AT=360.025n

.meas tran vdout0_45ck710 FIND v(dout0_45) AT=360.025n

.meas tran vdout0_46ck710 FIND v(dout0_46) AT=360.025n

.meas tran vdout0_47ck710 FIND v(dout0_47) AT=360.025n

.meas tran vdout0_48ck710 FIND v(dout0_48) AT=360.025n

.meas tran vdout0_49ck710 FIND v(dout0_49) AT=360.025n

.meas tran vdout0_50ck710 FIND v(dout0_50) AT=360.025n

.meas tran vdout0_51ck710 FIND v(dout0_51) AT=360.025n

.meas tran vdout0_52ck710 FIND v(dout0_52) AT=360.025n

.meas tran vdout0_53ck710 FIND v(dout0_53) AT=360.025n

.meas tran vdout0_54ck710 FIND v(dout0_54) AT=360.025n

.meas tran vdout0_55ck710 FIND v(dout0_55) AT=360.025n

.meas tran vdout0_56ck710 FIND v(dout0_56) AT=360.025n

.meas tran vdout0_57ck710 FIND v(dout0_57) AT=360.025n

.meas tran vdout0_58ck710 FIND v(dout0_58) AT=360.025n

.meas tran vdout0_59ck710 FIND v(dout0_59) AT=360.025n

.meas tran vdout0_60ck710 FIND v(dout0_60) AT=360.025n

.meas tran vdout0_61ck710 FIND v(dout0_61) AT=360.025n

.meas tran vdout0_62ck710 FIND v(dout0_62) AT=360.025n

.meas tran vdout0_63ck710 FIND v(dout0_63) AT=360.025n

.meas tran vdout0_64ck710 FIND v(dout0_64) AT=360.025n

.meas tran vdout0_65ck710 FIND v(dout0_65) AT=360.025n

.meas tran vdout0_66ck710 FIND v(dout0_66) AT=360.025n

.meas tran vdout0_67ck710 FIND v(dout0_67) AT=360.025n

.meas tran vdout0_68ck710 FIND v(dout0_68) AT=360.025n

.meas tran vdout0_69ck710 FIND v(dout0_69) AT=360.025n

.meas tran vdout0_70ck710 FIND v(dout0_70) AT=360.025n

.meas tran vdout0_71ck710 FIND v(dout0_71) AT=360.025n

.meas tran vdout0_72ck710 FIND v(dout0_72) AT=360.025n

.meas tran vdout0_73ck710 FIND v(dout0_73) AT=360.025n

.meas tran vdout0_74ck710 FIND v(dout0_74) AT=360.025n

.meas tran vdout0_75ck710 FIND v(dout0_75) AT=360.025n

.meas tran vdout0_76ck710 FIND v(dout0_76) AT=360.025n

.meas tran vdout0_77ck710 FIND v(dout0_77) AT=360.025n

.meas tran vdout0_78ck710 FIND v(dout0_78) AT=360.025n

.meas tran vdout0_79ck710 FIND v(dout0_79) AT=360.025n

.meas tran vdout0_80ck710 FIND v(dout0_80) AT=360.025n

.meas tran vdout0_81ck710 FIND v(dout0_81) AT=360.025n

.meas tran vdout0_82ck710 FIND v(dout0_82) AT=360.025n

.meas tran vdout0_83ck710 FIND v(dout0_83) AT=360.025n

.meas tran vdout0_84ck710 FIND v(dout0_84) AT=360.025n

.meas tran vdout0_85ck710 FIND v(dout0_85) AT=360.025n

.meas tran vdout0_86ck710 FIND v(dout0_86) AT=360.025n

.meas tran vdout0_87ck710 FIND v(dout0_87) AT=360.025n

.meas tran vdout0_88ck710 FIND v(dout0_88) AT=360.025n

.meas tran vdout0_89ck710 FIND v(dout0_89) AT=360.025n

.meas tran vdout0_90ck710 FIND v(dout0_90) AT=360.025n

.meas tran vdout0_91ck710 FIND v(dout0_91) AT=360.025n

.meas tran vdout0_92ck710 FIND v(dout0_92) AT=360.025n

.meas tran vdout0_93ck710 FIND v(dout0_93) AT=360.025n

.meas tran vdout0_94ck710 FIND v(dout0_94) AT=360.025n

.meas tran vdout0_95ck710 FIND v(dout0_95) AT=360.025n

.meas tran vdout0_96ck710 FIND v(dout0_96) AT=360.025n

.meas tran vdout0_97ck710 FIND v(dout0_97) AT=360.025n

.meas tran vdout0_98ck710 FIND v(dout0_98) AT=360.025n

.meas tran vdout0_99ck710 FIND v(dout0_99) AT=360.025n

.meas tran vdout0_100ck710 FIND v(dout0_100) AT=360.025n

.meas tran vdout0_101ck710 FIND v(dout0_101) AT=360.025n

.meas tran vdout0_102ck710 FIND v(dout0_102) AT=360.025n

.meas tran vdout0_103ck710 FIND v(dout0_103) AT=360.025n

.meas tran vdout0_104ck710 FIND v(dout0_104) AT=360.025n

.meas tran vdout0_105ck710 FIND v(dout0_105) AT=360.025n

.meas tran vdout0_106ck710 FIND v(dout0_106) AT=360.025n

.meas tran vdout0_107ck710 FIND v(dout0_107) AT=360.025n

.meas tran vdout0_108ck710 FIND v(dout0_108) AT=360.025n

.meas tran vdout0_109ck710 FIND v(dout0_109) AT=360.025n

.meas tran vdout0_110ck710 FIND v(dout0_110) AT=360.025n

.meas tran vdout0_111ck710 FIND v(dout0_111) AT=360.025n

.meas tran vdout0_112ck710 FIND v(dout0_112) AT=360.025n

.meas tran vdout0_113ck710 FIND v(dout0_113) AT=360.025n

.meas tran vdout0_114ck710 FIND v(dout0_114) AT=360.025n

.meas tran vdout0_115ck710 FIND v(dout0_115) AT=360.025n

.meas tran vdout0_116ck710 FIND v(dout0_116) AT=360.025n

.meas tran vdout0_117ck710 FIND v(dout0_117) AT=360.025n

.meas tran vdout0_118ck710 FIND v(dout0_118) AT=360.025n

.meas tran vdout0_119ck710 FIND v(dout0_119) AT=360.025n

.meas tran vdout0_120ck710 FIND v(dout0_120) AT=360.025n

.meas tran vdout0_121ck710 FIND v(dout0_121) AT=360.025n

.meas tran vdout0_122ck710 FIND v(dout0_122) AT=360.025n

.meas tran vdout0_123ck710 FIND v(dout0_123) AT=360.025n

.meas tran vdout0_124ck710 FIND v(dout0_124) AT=360.025n

.meas tran vdout0_125ck710 FIND v(dout0_125) AT=360.025n

.meas tran vdout0_126ck710 FIND v(dout0_126) AT=360.025n

.meas tran vdout0_127ck710 FIND v(dout0_127) AT=360.025n

.meas tran vdout0_0ck720 FIND v(dout0_0) AT=365.025n

.meas tran vdout0_1ck720 FIND v(dout0_1) AT=365.025n

.meas tran vdout0_2ck720 FIND v(dout0_2) AT=365.025n

.meas tran vdout0_3ck720 FIND v(dout0_3) AT=365.025n

.meas tran vdout0_4ck720 FIND v(dout0_4) AT=365.025n

.meas tran vdout0_5ck720 FIND v(dout0_5) AT=365.025n

.meas tran vdout0_6ck720 FIND v(dout0_6) AT=365.025n

.meas tran vdout0_7ck720 FIND v(dout0_7) AT=365.025n

.meas tran vdout0_8ck720 FIND v(dout0_8) AT=365.025n

.meas tran vdout0_9ck720 FIND v(dout0_9) AT=365.025n

.meas tran vdout0_10ck720 FIND v(dout0_10) AT=365.025n

.meas tran vdout0_11ck720 FIND v(dout0_11) AT=365.025n

.meas tran vdout0_12ck720 FIND v(dout0_12) AT=365.025n

.meas tran vdout0_13ck720 FIND v(dout0_13) AT=365.025n

.meas tran vdout0_14ck720 FIND v(dout0_14) AT=365.025n

.meas tran vdout0_15ck720 FIND v(dout0_15) AT=365.025n

.meas tran vdout0_16ck720 FIND v(dout0_16) AT=365.025n

.meas tran vdout0_17ck720 FIND v(dout0_17) AT=365.025n

.meas tran vdout0_18ck720 FIND v(dout0_18) AT=365.025n

.meas tran vdout0_19ck720 FIND v(dout0_19) AT=365.025n

.meas tran vdout0_20ck720 FIND v(dout0_20) AT=365.025n

.meas tran vdout0_21ck720 FIND v(dout0_21) AT=365.025n

.meas tran vdout0_22ck720 FIND v(dout0_22) AT=365.025n

.meas tran vdout0_23ck720 FIND v(dout0_23) AT=365.025n

.meas tran vdout0_24ck720 FIND v(dout0_24) AT=365.025n

.meas tran vdout0_25ck720 FIND v(dout0_25) AT=365.025n

.meas tran vdout0_26ck720 FIND v(dout0_26) AT=365.025n

.meas tran vdout0_27ck720 FIND v(dout0_27) AT=365.025n

.meas tran vdout0_28ck720 FIND v(dout0_28) AT=365.025n

.meas tran vdout0_29ck720 FIND v(dout0_29) AT=365.025n

.meas tran vdout0_30ck720 FIND v(dout0_30) AT=365.025n

.meas tran vdout0_31ck720 FIND v(dout0_31) AT=365.025n

.meas tran vdout0_32ck720 FIND v(dout0_32) AT=365.025n

.meas tran vdout0_33ck720 FIND v(dout0_33) AT=365.025n

.meas tran vdout0_34ck720 FIND v(dout0_34) AT=365.025n

.meas tran vdout0_35ck720 FIND v(dout0_35) AT=365.025n

.meas tran vdout0_36ck720 FIND v(dout0_36) AT=365.025n

.meas tran vdout0_37ck720 FIND v(dout0_37) AT=365.025n

.meas tran vdout0_38ck720 FIND v(dout0_38) AT=365.025n

.meas tran vdout0_39ck720 FIND v(dout0_39) AT=365.025n

.meas tran vdout0_40ck720 FIND v(dout0_40) AT=365.025n

.meas tran vdout0_41ck720 FIND v(dout0_41) AT=365.025n

.meas tran vdout0_42ck720 FIND v(dout0_42) AT=365.025n

.meas tran vdout0_43ck720 FIND v(dout0_43) AT=365.025n

.meas tran vdout0_44ck720 FIND v(dout0_44) AT=365.025n

.meas tran vdout0_45ck720 FIND v(dout0_45) AT=365.025n

.meas tran vdout0_46ck720 FIND v(dout0_46) AT=365.025n

.meas tran vdout0_47ck720 FIND v(dout0_47) AT=365.025n

.meas tran vdout0_48ck720 FIND v(dout0_48) AT=365.025n

.meas tran vdout0_49ck720 FIND v(dout0_49) AT=365.025n

.meas tran vdout0_50ck720 FIND v(dout0_50) AT=365.025n

.meas tran vdout0_51ck720 FIND v(dout0_51) AT=365.025n

.meas tran vdout0_52ck720 FIND v(dout0_52) AT=365.025n

.meas tran vdout0_53ck720 FIND v(dout0_53) AT=365.025n

.meas tran vdout0_54ck720 FIND v(dout0_54) AT=365.025n

.meas tran vdout0_55ck720 FIND v(dout0_55) AT=365.025n

.meas tran vdout0_56ck720 FIND v(dout0_56) AT=365.025n

.meas tran vdout0_57ck720 FIND v(dout0_57) AT=365.025n

.meas tran vdout0_58ck720 FIND v(dout0_58) AT=365.025n

.meas tran vdout0_59ck720 FIND v(dout0_59) AT=365.025n

.meas tran vdout0_60ck720 FIND v(dout0_60) AT=365.025n

.meas tran vdout0_61ck720 FIND v(dout0_61) AT=365.025n

.meas tran vdout0_62ck720 FIND v(dout0_62) AT=365.025n

.meas tran vdout0_63ck720 FIND v(dout0_63) AT=365.025n

.meas tran vdout0_64ck720 FIND v(dout0_64) AT=365.025n

.meas tran vdout0_65ck720 FIND v(dout0_65) AT=365.025n

.meas tran vdout0_66ck720 FIND v(dout0_66) AT=365.025n

.meas tran vdout0_67ck720 FIND v(dout0_67) AT=365.025n

.meas tran vdout0_68ck720 FIND v(dout0_68) AT=365.025n

.meas tran vdout0_69ck720 FIND v(dout0_69) AT=365.025n

.meas tran vdout0_70ck720 FIND v(dout0_70) AT=365.025n

.meas tran vdout0_71ck720 FIND v(dout0_71) AT=365.025n

.meas tran vdout0_72ck720 FIND v(dout0_72) AT=365.025n

.meas tran vdout0_73ck720 FIND v(dout0_73) AT=365.025n

.meas tran vdout0_74ck720 FIND v(dout0_74) AT=365.025n

.meas tran vdout0_75ck720 FIND v(dout0_75) AT=365.025n

.meas tran vdout0_76ck720 FIND v(dout0_76) AT=365.025n

.meas tran vdout0_77ck720 FIND v(dout0_77) AT=365.025n

.meas tran vdout0_78ck720 FIND v(dout0_78) AT=365.025n

.meas tran vdout0_79ck720 FIND v(dout0_79) AT=365.025n

.meas tran vdout0_80ck720 FIND v(dout0_80) AT=365.025n

.meas tran vdout0_81ck720 FIND v(dout0_81) AT=365.025n

.meas tran vdout0_82ck720 FIND v(dout0_82) AT=365.025n

.meas tran vdout0_83ck720 FIND v(dout0_83) AT=365.025n

.meas tran vdout0_84ck720 FIND v(dout0_84) AT=365.025n

.meas tran vdout0_85ck720 FIND v(dout0_85) AT=365.025n

.meas tran vdout0_86ck720 FIND v(dout0_86) AT=365.025n

.meas tran vdout0_87ck720 FIND v(dout0_87) AT=365.025n

.meas tran vdout0_88ck720 FIND v(dout0_88) AT=365.025n

.meas tran vdout0_89ck720 FIND v(dout0_89) AT=365.025n

.meas tran vdout0_90ck720 FIND v(dout0_90) AT=365.025n

.meas tran vdout0_91ck720 FIND v(dout0_91) AT=365.025n

.meas tran vdout0_92ck720 FIND v(dout0_92) AT=365.025n

.meas tran vdout0_93ck720 FIND v(dout0_93) AT=365.025n

.meas tran vdout0_94ck720 FIND v(dout0_94) AT=365.025n

.meas tran vdout0_95ck720 FIND v(dout0_95) AT=365.025n

.meas tran vdout0_96ck720 FIND v(dout0_96) AT=365.025n

.meas tran vdout0_97ck720 FIND v(dout0_97) AT=365.025n

.meas tran vdout0_98ck720 FIND v(dout0_98) AT=365.025n

.meas tran vdout0_99ck720 FIND v(dout0_99) AT=365.025n

.meas tran vdout0_100ck720 FIND v(dout0_100) AT=365.025n

.meas tran vdout0_101ck720 FIND v(dout0_101) AT=365.025n

.meas tran vdout0_102ck720 FIND v(dout0_102) AT=365.025n

.meas tran vdout0_103ck720 FIND v(dout0_103) AT=365.025n

.meas tran vdout0_104ck720 FIND v(dout0_104) AT=365.025n

.meas tran vdout0_105ck720 FIND v(dout0_105) AT=365.025n

.meas tran vdout0_106ck720 FIND v(dout0_106) AT=365.025n

.meas tran vdout0_107ck720 FIND v(dout0_107) AT=365.025n

.meas tran vdout0_108ck720 FIND v(dout0_108) AT=365.025n

.meas tran vdout0_109ck720 FIND v(dout0_109) AT=365.025n

.meas tran vdout0_110ck720 FIND v(dout0_110) AT=365.025n

.meas tran vdout0_111ck720 FIND v(dout0_111) AT=365.025n

.meas tran vdout0_112ck720 FIND v(dout0_112) AT=365.025n

.meas tran vdout0_113ck720 FIND v(dout0_113) AT=365.025n

.meas tran vdout0_114ck720 FIND v(dout0_114) AT=365.025n

.meas tran vdout0_115ck720 FIND v(dout0_115) AT=365.025n

.meas tran vdout0_116ck720 FIND v(dout0_116) AT=365.025n

.meas tran vdout0_117ck720 FIND v(dout0_117) AT=365.025n

.meas tran vdout0_118ck720 FIND v(dout0_118) AT=365.025n

.meas tran vdout0_119ck720 FIND v(dout0_119) AT=365.025n

.meas tran vdout0_120ck720 FIND v(dout0_120) AT=365.025n

.meas tran vdout0_121ck720 FIND v(dout0_121) AT=365.025n

.meas tran vdout0_122ck720 FIND v(dout0_122) AT=365.025n

.meas tran vdout0_123ck720 FIND v(dout0_123) AT=365.025n

.meas tran vdout0_124ck720 FIND v(dout0_124) AT=365.025n

.meas tran vdout0_125ck720 FIND v(dout0_125) AT=365.025n

.meas tran vdout0_126ck720 FIND v(dout0_126) AT=365.025n

.meas tran vdout0_127ck720 FIND v(dout0_127) AT=365.025n

.meas tran vdout0_0ck740 FIND v(dout0_0) AT=375.025n

.meas tran vdout0_1ck740 FIND v(dout0_1) AT=375.025n

.meas tran vdout0_2ck740 FIND v(dout0_2) AT=375.025n

.meas tran vdout0_3ck740 FIND v(dout0_3) AT=375.025n

.meas tran vdout0_4ck740 FIND v(dout0_4) AT=375.025n

.meas tran vdout0_5ck740 FIND v(dout0_5) AT=375.025n

.meas tran vdout0_6ck740 FIND v(dout0_6) AT=375.025n

.meas tran vdout0_7ck740 FIND v(dout0_7) AT=375.025n

.meas tran vdout0_8ck740 FIND v(dout0_8) AT=375.025n

.meas tran vdout0_9ck740 FIND v(dout0_9) AT=375.025n

.meas tran vdout0_10ck740 FIND v(dout0_10) AT=375.025n

.meas tran vdout0_11ck740 FIND v(dout0_11) AT=375.025n

.meas tran vdout0_12ck740 FIND v(dout0_12) AT=375.025n

.meas tran vdout0_13ck740 FIND v(dout0_13) AT=375.025n

.meas tran vdout0_14ck740 FIND v(dout0_14) AT=375.025n

.meas tran vdout0_15ck740 FIND v(dout0_15) AT=375.025n

.meas tran vdout0_16ck740 FIND v(dout0_16) AT=375.025n

.meas tran vdout0_17ck740 FIND v(dout0_17) AT=375.025n

.meas tran vdout0_18ck740 FIND v(dout0_18) AT=375.025n

.meas tran vdout0_19ck740 FIND v(dout0_19) AT=375.025n

.meas tran vdout0_20ck740 FIND v(dout0_20) AT=375.025n

.meas tran vdout0_21ck740 FIND v(dout0_21) AT=375.025n

.meas tran vdout0_22ck740 FIND v(dout0_22) AT=375.025n

.meas tran vdout0_23ck740 FIND v(dout0_23) AT=375.025n

.meas tran vdout0_24ck740 FIND v(dout0_24) AT=375.025n

.meas tran vdout0_25ck740 FIND v(dout0_25) AT=375.025n

.meas tran vdout0_26ck740 FIND v(dout0_26) AT=375.025n

.meas tran vdout0_27ck740 FIND v(dout0_27) AT=375.025n

.meas tran vdout0_28ck740 FIND v(dout0_28) AT=375.025n

.meas tran vdout0_29ck740 FIND v(dout0_29) AT=375.025n

.meas tran vdout0_30ck740 FIND v(dout0_30) AT=375.025n

.meas tran vdout0_31ck740 FIND v(dout0_31) AT=375.025n

.meas tran vdout0_32ck740 FIND v(dout0_32) AT=375.025n

.meas tran vdout0_33ck740 FIND v(dout0_33) AT=375.025n

.meas tran vdout0_34ck740 FIND v(dout0_34) AT=375.025n

.meas tran vdout0_35ck740 FIND v(dout0_35) AT=375.025n

.meas tran vdout0_36ck740 FIND v(dout0_36) AT=375.025n

.meas tran vdout0_37ck740 FIND v(dout0_37) AT=375.025n

.meas tran vdout0_38ck740 FIND v(dout0_38) AT=375.025n

.meas tran vdout0_39ck740 FIND v(dout0_39) AT=375.025n

.meas tran vdout0_40ck740 FIND v(dout0_40) AT=375.025n

.meas tran vdout0_41ck740 FIND v(dout0_41) AT=375.025n

.meas tran vdout0_42ck740 FIND v(dout0_42) AT=375.025n

.meas tran vdout0_43ck740 FIND v(dout0_43) AT=375.025n

.meas tran vdout0_44ck740 FIND v(dout0_44) AT=375.025n

.meas tran vdout0_45ck740 FIND v(dout0_45) AT=375.025n

.meas tran vdout0_46ck740 FIND v(dout0_46) AT=375.025n

.meas tran vdout0_47ck740 FIND v(dout0_47) AT=375.025n

.meas tran vdout0_48ck740 FIND v(dout0_48) AT=375.025n

.meas tran vdout0_49ck740 FIND v(dout0_49) AT=375.025n

.meas tran vdout0_50ck740 FIND v(dout0_50) AT=375.025n

.meas tran vdout0_51ck740 FIND v(dout0_51) AT=375.025n

.meas tran vdout0_52ck740 FIND v(dout0_52) AT=375.025n

.meas tran vdout0_53ck740 FIND v(dout0_53) AT=375.025n

.meas tran vdout0_54ck740 FIND v(dout0_54) AT=375.025n

.meas tran vdout0_55ck740 FIND v(dout0_55) AT=375.025n

.meas tran vdout0_56ck740 FIND v(dout0_56) AT=375.025n

.meas tran vdout0_57ck740 FIND v(dout0_57) AT=375.025n

.meas tran vdout0_58ck740 FIND v(dout0_58) AT=375.025n

.meas tran vdout0_59ck740 FIND v(dout0_59) AT=375.025n

.meas tran vdout0_60ck740 FIND v(dout0_60) AT=375.025n

.meas tran vdout0_61ck740 FIND v(dout0_61) AT=375.025n

.meas tran vdout0_62ck740 FIND v(dout0_62) AT=375.025n

.meas tran vdout0_63ck740 FIND v(dout0_63) AT=375.025n

.meas tran vdout0_64ck740 FIND v(dout0_64) AT=375.025n

.meas tran vdout0_65ck740 FIND v(dout0_65) AT=375.025n

.meas tran vdout0_66ck740 FIND v(dout0_66) AT=375.025n

.meas tran vdout0_67ck740 FIND v(dout0_67) AT=375.025n

.meas tran vdout0_68ck740 FIND v(dout0_68) AT=375.025n

.meas tran vdout0_69ck740 FIND v(dout0_69) AT=375.025n

.meas tran vdout0_70ck740 FIND v(dout0_70) AT=375.025n

.meas tran vdout0_71ck740 FIND v(dout0_71) AT=375.025n

.meas tran vdout0_72ck740 FIND v(dout0_72) AT=375.025n

.meas tran vdout0_73ck740 FIND v(dout0_73) AT=375.025n

.meas tran vdout0_74ck740 FIND v(dout0_74) AT=375.025n

.meas tran vdout0_75ck740 FIND v(dout0_75) AT=375.025n

.meas tran vdout0_76ck740 FIND v(dout0_76) AT=375.025n

.meas tran vdout0_77ck740 FIND v(dout0_77) AT=375.025n

.meas tran vdout0_78ck740 FIND v(dout0_78) AT=375.025n

.meas tran vdout0_79ck740 FIND v(dout0_79) AT=375.025n

.meas tran vdout0_80ck740 FIND v(dout0_80) AT=375.025n

.meas tran vdout0_81ck740 FIND v(dout0_81) AT=375.025n

.meas tran vdout0_82ck740 FIND v(dout0_82) AT=375.025n

.meas tran vdout0_83ck740 FIND v(dout0_83) AT=375.025n

.meas tran vdout0_84ck740 FIND v(dout0_84) AT=375.025n

.meas tran vdout0_85ck740 FIND v(dout0_85) AT=375.025n

.meas tran vdout0_86ck740 FIND v(dout0_86) AT=375.025n

.meas tran vdout0_87ck740 FIND v(dout0_87) AT=375.025n

.meas tran vdout0_88ck740 FIND v(dout0_88) AT=375.025n

.meas tran vdout0_89ck740 FIND v(dout0_89) AT=375.025n

.meas tran vdout0_90ck740 FIND v(dout0_90) AT=375.025n

.meas tran vdout0_91ck740 FIND v(dout0_91) AT=375.025n

.meas tran vdout0_92ck740 FIND v(dout0_92) AT=375.025n

.meas tran vdout0_93ck740 FIND v(dout0_93) AT=375.025n

.meas tran vdout0_94ck740 FIND v(dout0_94) AT=375.025n

.meas tran vdout0_95ck740 FIND v(dout0_95) AT=375.025n

.meas tran vdout0_96ck740 FIND v(dout0_96) AT=375.025n

.meas tran vdout0_97ck740 FIND v(dout0_97) AT=375.025n

.meas tran vdout0_98ck740 FIND v(dout0_98) AT=375.025n

.meas tran vdout0_99ck740 FIND v(dout0_99) AT=375.025n

.meas tran vdout0_100ck740 FIND v(dout0_100) AT=375.025n

.meas tran vdout0_101ck740 FIND v(dout0_101) AT=375.025n

.meas tran vdout0_102ck740 FIND v(dout0_102) AT=375.025n

.meas tran vdout0_103ck740 FIND v(dout0_103) AT=375.025n

.meas tran vdout0_104ck740 FIND v(dout0_104) AT=375.025n

.meas tran vdout0_105ck740 FIND v(dout0_105) AT=375.025n

.meas tran vdout0_106ck740 FIND v(dout0_106) AT=375.025n

.meas tran vdout0_107ck740 FIND v(dout0_107) AT=375.025n

.meas tran vdout0_108ck740 FIND v(dout0_108) AT=375.025n

.meas tran vdout0_109ck740 FIND v(dout0_109) AT=375.025n

.meas tran vdout0_110ck740 FIND v(dout0_110) AT=375.025n

.meas tran vdout0_111ck740 FIND v(dout0_111) AT=375.025n

.meas tran vdout0_112ck740 FIND v(dout0_112) AT=375.025n

.meas tran vdout0_113ck740 FIND v(dout0_113) AT=375.025n

.meas tran vdout0_114ck740 FIND v(dout0_114) AT=375.025n

.meas tran vdout0_115ck740 FIND v(dout0_115) AT=375.025n

.meas tran vdout0_116ck740 FIND v(dout0_116) AT=375.025n

.meas tran vdout0_117ck740 FIND v(dout0_117) AT=375.025n

.meas tran vdout0_118ck740 FIND v(dout0_118) AT=375.025n

.meas tran vdout0_119ck740 FIND v(dout0_119) AT=375.025n

.meas tran vdout0_120ck740 FIND v(dout0_120) AT=375.025n

.meas tran vdout0_121ck740 FIND v(dout0_121) AT=375.025n

.meas tran vdout0_122ck740 FIND v(dout0_122) AT=375.025n

.meas tran vdout0_123ck740 FIND v(dout0_123) AT=375.025n

.meas tran vdout0_124ck740 FIND v(dout0_124) AT=375.025n

.meas tran vdout0_125ck740 FIND v(dout0_125) AT=375.025n

.meas tran vdout0_126ck740 FIND v(dout0_126) AT=375.025n

.meas tran vdout0_127ck740 FIND v(dout0_127) AT=375.025n

.meas tran vdout0_0ck750 FIND v(dout0_0) AT=380.025n

.meas tran vdout0_1ck750 FIND v(dout0_1) AT=380.025n

.meas tran vdout0_2ck750 FIND v(dout0_2) AT=380.025n

.meas tran vdout0_3ck750 FIND v(dout0_3) AT=380.025n

.meas tran vdout0_4ck750 FIND v(dout0_4) AT=380.025n

.meas tran vdout0_5ck750 FIND v(dout0_5) AT=380.025n

.meas tran vdout0_6ck750 FIND v(dout0_6) AT=380.025n

.meas tran vdout0_7ck750 FIND v(dout0_7) AT=380.025n

.meas tran vdout0_8ck750 FIND v(dout0_8) AT=380.025n

.meas tran vdout0_9ck750 FIND v(dout0_9) AT=380.025n

.meas tran vdout0_10ck750 FIND v(dout0_10) AT=380.025n

.meas tran vdout0_11ck750 FIND v(dout0_11) AT=380.025n

.meas tran vdout0_12ck750 FIND v(dout0_12) AT=380.025n

.meas tran vdout0_13ck750 FIND v(dout0_13) AT=380.025n

.meas tran vdout0_14ck750 FIND v(dout0_14) AT=380.025n

.meas tran vdout0_15ck750 FIND v(dout0_15) AT=380.025n

.meas tran vdout0_16ck750 FIND v(dout0_16) AT=380.025n

.meas tran vdout0_17ck750 FIND v(dout0_17) AT=380.025n

.meas tran vdout0_18ck750 FIND v(dout0_18) AT=380.025n

.meas tran vdout0_19ck750 FIND v(dout0_19) AT=380.025n

.meas tran vdout0_20ck750 FIND v(dout0_20) AT=380.025n

.meas tran vdout0_21ck750 FIND v(dout0_21) AT=380.025n

.meas tran vdout0_22ck750 FIND v(dout0_22) AT=380.025n

.meas tran vdout0_23ck750 FIND v(dout0_23) AT=380.025n

.meas tran vdout0_24ck750 FIND v(dout0_24) AT=380.025n

.meas tran vdout0_25ck750 FIND v(dout0_25) AT=380.025n

.meas tran vdout0_26ck750 FIND v(dout0_26) AT=380.025n

.meas tran vdout0_27ck750 FIND v(dout0_27) AT=380.025n

.meas tran vdout0_28ck750 FIND v(dout0_28) AT=380.025n

.meas tran vdout0_29ck750 FIND v(dout0_29) AT=380.025n

.meas tran vdout0_30ck750 FIND v(dout0_30) AT=380.025n

.meas tran vdout0_31ck750 FIND v(dout0_31) AT=380.025n

.meas tran vdout0_32ck750 FIND v(dout0_32) AT=380.025n

.meas tran vdout0_33ck750 FIND v(dout0_33) AT=380.025n

.meas tran vdout0_34ck750 FIND v(dout0_34) AT=380.025n

.meas tran vdout0_35ck750 FIND v(dout0_35) AT=380.025n

.meas tran vdout0_36ck750 FIND v(dout0_36) AT=380.025n

.meas tran vdout0_37ck750 FIND v(dout0_37) AT=380.025n

.meas tran vdout0_38ck750 FIND v(dout0_38) AT=380.025n

.meas tran vdout0_39ck750 FIND v(dout0_39) AT=380.025n

.meas tran vdout0_40ck750 FIND v(dout0_40) AT=380.025n

.meas tran vdout0_41ck750 FIND v(dout0_41) AT=380.025n

.meas tran vdout0_42ck750 FIND v(dout0_42) AT=380.025n

.meas tran vdout0_43ck750 FIND v(dout0_43) AT=380.025n

.meas tran vdout0_44ck750 FIND v(dout0_44) AT=380.025n

.meas tran vdout0_45ck750 FIND v(dout0_45) AT=380.025n

.meas tran vdout0_46ck750 FIND v(dout0_46) AT=380.025n

.meas tran vdout0_47ck750 FIND v(dout0_47) AT=380.025n

.meas tran vdout0_48ck750 FIND v(dout0_48) AT=380.025n

.meas tran vdout0_49ck750 FIND v(dout0_49) AT=380.025n

.meas tran vdout0_50ck750 FIND v(dout0_50) AT=380.025n

.meas tran vdout0_51ck750 FIND v(dout0_51) AT=380.025n

.meas tran vdout0_52ck750 FIND v(dout0_52) AT=380.025n

.meas tran vdout0_53ck750 FIND v(dout0_53) AT=380.025n

.meas tran vdout0_54ck750 FIND v(dout0_54) AT=380.025n

.meas tran vdout0_55ck750 FIND v(dout0_55) AT=380.025n

.meas tran vdout0_56ck750 FIND v(dout0_56) AT=380.025n

.meas tran vdout0_57ck750 FIND v(dout0_57) AT=380.025n

.meas tran vdout0_58ck750 FIND v(dout0_58) AT=380.025n

.meas tran vdout0_59ck750 FIND v(dout0_59) AT=380.025n

.meas tran vdout0_60ck750 FIND v(dout0_60) AT=380.025n

.meas tran vdout0_61ck750 FIND v(dout0_61) AT=380.025n

.meas tran vdout0_62ck750 FIND v(dout0_62) AT=380.025n

.meas tran vdout0_63ck750 FIND v(dout0_63) AT=380.025n

.meas tran vdout0_64ck750 FIND v(dout0_64) AT=380.025n

.meas tran vdout0_65ck750 FIND v(dout0_65) AT=380.025n

.meas tran vdout0_66ck750 FIND v(dout0_66) AT=380.025n

.meas tran vdout0_67ck750 FIND v(dout0_67) AT=380.025n

.meas tran vdout0_68ck750 FIND v(dout0_68) AT=380.025n

.meas tran vdout0_69ck750 FIND v(dout0_69) AT=380.025n

.meas tran vdout0_70ck750 FIND v(dout0_70) AT=380.025n

.meas tran vdout0_71ck750 FIND v(dout0_71) AT=380.025n

.meas tran vdout0_72ck750 FIND v(dout0_72) AT=380.025n

.meas tran vdout0_73ck750 FIND v(dout0_73) AT=380.025n

.meas tran vdout0_74ck750 FIND v(dout0_74) AT=380.025n

.meas tran vdout0_75ck750 FIND v(dout0_75) AT=380.025n

.meas tran vdout0_76ck750 FIND v(dout0_76) AT=380.025n

.meas tran vdout0_77ck750 FIND v(dout0_77) AT=380.025n

.meas tran vdout0_78ck750 FIND v(dout0_78) AT=380.025n

.meas tran vdout0_79ck750 FIND v(dout0_79) AT=380.025n

.meas tran vdout0_80ck750 FIND v(dout0_80) AT=380.025n

.meas tran vdout0_81ck750 FIND v(dout0_81) AT=380.025n

.meas tran vdout0_82ck750 FIND v(dout0_82) AT=380.025n

.meas tran vdout0_83ck750 FIND v(dout0_83) AT=380.025n

.meas tran vdout0_84ck750 FIND v(dout0_84) AT=380.025n

.meas tran vdout0_85ck750 FIND v(dout0_85) AT=380.025n

.meas tran vdout0_86ck750 FIND v(dout0_86) AT=380.025n

.meas tran vdout0_87ck750 FIND v(dout0_87) AT=380.025n

.meas tran vdout0_88ck750 FIND v(dout0_88) AT=380.025n

.meas tran vdout0_89ck750 FIND v(dout0_89) AT=380.025n

.meas tran vdout0_90ck750 FIND v(dout0_90) AT=380.025n

.meas tran vdout0_91ck750 FIND v(dout0_91) AT=380.025n

.meas tran vdout0_92ck750 FIND v(dout0_92) AT=380.025n

.meas tran vdout0_93ck750 FIND v(dout0_93) AT=380.025n

.meas tran vdout0_94ck750 FIND v(dout0_94) AT=380.025n

.meas tran vdout0_95ck750 FIND v(dout0_95) AT=380.025n

.meas tran vdout0_96ck750 FIND v(dout0_96) AT=380.025n

.meas tran vdout0_97ck750 FIND v(dout0_97) AT=380.025n

.meas tran vdout0_98ck750 FIND v(dout0_98) AT=380.025n

.meas tran vdout0_99ck750 FIND v(dout0_99) AT=380.025n

.meas tran vdout0_100ck750 FIND v(dout0_100) AT=380.025n

.meas tran vdout0_101ck750 FIND v(dout0_101) AT=380.025n

.meas tran vdout0_102ck750 FIND v(dout0_102) AT=380.025n

.meas tran vdout0_103ck750 FIND v(dout0_103) AT=380.025n

.meas tran vdout0_104ck750 FIND v(dout0_104) AT=380.025n

.meas tran vdout0_105ck750 FIND v(dout0_105) AT=380.025n

.meas tran vdout0_106ck750 FIND v(dout0_106) AT=380.025n

.meas tran vdout0_107ck750 FIND v(dout0_107) AT=380.025n

.meas tran vdout0_108ck750 FIND v(dout0_108) AT=380.025n

.meas tran vdout0_109ck750 FIND v(dout0_109) AT=380.025n

.meas tran vdout0_110ck750 FIND v(dout0_110) AT=380.025n

.meas tran vdout0_111ck750 FIND v(dout0_111) AT=380.025n

.meas tran vdout0_112ck750 FIND v(dout0_112) AT=380.025n

.meas tran vdout0_113ck750 FIND v(dout0_113) AT=380.025n

.meas tran vdout0_114ck750 FIND v(dout0_114) AT=380.025n

.meas tran vdout0_115ck750 FIND v(dout0_115) AT=380.025n

.meas tran vdout0_116ck750 FIND v(dout0_116) AT=380.025n

.meas tran vdout0_117ck750 FIND v(dout0_117) AT=380.025n

.meas tran vdout0_118ck750 FIND v(dout0_118) AT=380.025n

.meas tran vdout0_119ck750 FIND v(dout0_119) AT=380.025n

.meas tran vdout0_120ck750 FIND v(dout0_120) AT=380.025n

.meas tran vdout0_121ck750 FIND v(dout0_121) AT=380.025n

.meas tran vdout0_122ck750 FIND v(dout0_122) AT=380.025n

.meas tran vdout0_123ck750 FIND v(dout0_123) AT=380.025n

.meas tran vdout0_124ck750 FIND v(dout0_124) AT=380.025n

.meas tran vdout0_125ck750 FIND v(dout0_125) AT=380.025n

.meas tran vdout0_126ck750 FIND v(dout0_126) AT=380.025n

.meas tran vdout0_127ck750 FIND v(dout0_127) AT=380.025n

.meas tran vdout0_0ck780 FIND v(dout0_0) AT=395.025n

.meas tran vdout0_1ck780 FIND v(dout0_1) AT=395.025n

.meas tran vdout0_2ck780 FIND v(dout0_2) AT=395.025n

.meas tran vdout0_3ck780 FIND v(dout0_3) AT=395.025n

.meas tran vdout0_4ck780 FIND v(dout0_4) AT=395.025n

.meas tran vdout0_5ck780 FIND v(dout0_5) AT=395.025n

.meas tran vdout0_6ck780 FIND v(dout0_6) AT=395.025n

.meas tran vdout0_7ck780 FIND v(dout0_7) AT=395.025n

.meas tran vdout0_8ck780 FIND v(dout0_8) AT=395.025n

.meas tran vdout0_9ck780 FIND v(dout0_9) AT=395.025n

.meas tran vdout0_10ck780 FIND v(dout0_10) AT=395.025n

.meas tran vdout0_11ck780 FIND v(dout0_11) AT=395.025n

.meas tran vdout0_12ck780 FIND v(dout0_12) AT=395.025n

.meas tran vdout0_13ck780 FIND v(dout0_13) AT=395.025n

.meas tran vdout0_14ck780 FIND v(dout0_14) AT=395.025n

.meas tran vdout0_15ck780 FIND v(dout0_15) AT=395.025n

.meas tran vdout0_16ck780 FIND v(dout0_16) AT=395.025n

.meas tran vdout0_17ck780 FIND v(dout0_17) AT=395.025n

.meas tran vdout0_18ck780 FIND v(dout0_18) AT=395.025n

.meas tran vdout0_19ck780 FIND v(dout0_19) AT=395.025n

.meas tran vdout0_20ck780 FIND v(dout0_20) AT=395.025n

.meas tran vdout0_21ck780 FIND v(dout0_21) AT=395.025n

.meas tran vdout0_22ck780 FIND v(dout0_22) AT=395.025n

.meas tran vdout0_23ck780 FIND v(dout0_23) AT=395.025n

.meas tran vdout0_24ck780 FIND v(dout0_24) AT=395.025n

.meas tran vdout0_25ck780 FIND v(dout0_25) AT=395.025n

.meas tran vdout0_26ck780 FIND v(dout0_26) AT=395.025n

.meas tran vdout0_27ck780 FIND v(dout0_27) AT=395.025n

.meas tran vdout0_28ck780 FIND v(dout0_28) AT=395.025n

.meas tran vdout0_29ck780 FIND v(dout0_29) AT=395.025n

.meas tran vdout0_30ck780 FIND v(dout0_30) AT=395.025n

.meas tran vdout0_31ck780 FIND v(dout0_31) AT=395.025n

.meas tran vdout0_32ck780 FIND v(dout0_32) AT=395.025n

.meas tran vdout0_33ck780 FIND v(dout0_33) AT=395.025n

.meas tran vdout0_34ck780 FIND v(dout0_34) AT=395.025n

.meas tran vdout0_35ck780 FIND v(dout0_35) AT=395.025n

.meas tran vdout0_36ck780 FIND v(dout0_36) AT=395.025n

.meas tran vdout0_37ck780 FIND v(dout0_37) AT=395.025n

.meas tran vdout0_38ck780 FIND v(dout0_38) AT=395.025n

.meas tran vdout0_39ck780 FIND v(dout0_39) AT=395.025n

.meas tran vdout0_40ck780 FIND v(dout0_40) AT=395.025n

.meas tran vdout0_41ck780 FIND v(dout0_41) AT=395.025n

.meas tran vdout0_42ck780 FIND v(dout0_42) AT=395.025n

.meas tran vdout0_43ck780 FIND v(dout0_43) AT=395.025n

.meas tran vdout0_44ck780 FIND v(dout0_44) AT=395.025n

.meas tran vdout0_45ck780 FIND v(dout0_45) AT=395.025n

.meas tran vdout0_46ck780 FIND v(dout0_46) AT=395.025n

.meas tran vdout0_47ck780 FIND v(dout0_47) AT=395.025n

.meas tran vdout0_48ck780 FIND v(dout0_48) AT=395.025n

.meas tran vdout0_49ck780 FIND v(dout0_49) AT=395.025n

.meas tran vdout0_50ck780 FIND v(dout0_50) AT=395.025n

.meas tran vdout0_51ck780 FIND v(dout0_51) AT=395.025n

.meas tran vdout0_52ck780 FIND v(dout0_52) AT=395.025n

.meas tran vdout0_53ck780 FIND v(dout0_53) AT=395.025n

.meas tran vdout0_54ck780 FIND v(dout0_54) AT=395.025n

.meas tran vdout0_55ck780 FIND v(dout0_55) AT=395.025n

.meas tran vdout0_56ck780 FIND v(dout0_56) AT=395.025n

.meas tran vdout0_57ck780 FIND v(dout0_57) AT=395.025n

.meas tran vdout0_58ck780 FIND v(dout0_58) AT=395.025n

.meas tran vdout0_59ck780 FIND v(dout0_59) AT=395.025n

.meas tran vdout0_60ck780 FIND v(dout0_60) AT=395.025n

.meas tran vdout0_61ck780 FIND v(dout0_61) AT=395.025n

.meas tran vdout0_62ck780 FIND v(dout0_62) AT=395.025n

.meas tran vdout0_63ck780 FIND v(dout0_63) AT=395.025n

.meas tran vdout0_64ck780 FIND v(dout0_64) AT=395.025n

.meas tran vdout0_65ck780 FIND v(dout0_65) AT=395.025n

.meas tran vdout0_66ck780 FIND v(dout0_66) AT=395.025n

.meas tran vdout0_67ck780 FIND v(dout0_67) AT=395.025n

.meas tran vdout0_68ck780 FIND v(dout0_68) AT=395.025n

.meas tran vdout0_69ck780 FIND v(dout0_69) AT=395.025n

.meas tran vdout0_70ck780 FIND v(dout0_70) AT=395.025n

.meas tran vdout0_71ck780 FIND v(dout0_71) AT=395.025n

.meas tran vdout0_72ck780 FIND v(dout0_72) AT=395.025n

.meas tran vdout0_73ck780 FIND v(dout0_73) AT=395.025n

.meas tran vdout0_74ck780 FIND v(dout0_74) AT=395.025n

.meas tran vdout0_75ck780 FIND v(dout0_75) AT=395.025n

.meas tran vdout0_76ck780 FIND v(dout0_76) AT=395.025n

.meas tran vdout0_77ck780 FIND v(dout0_77) AT=395.025n

.meas tran vdout0_78ck780 FIND v(dout0_78) AT=395.025n

.meas tran vdout0_79ck780 FIND v(dout0_79) AT=395.025n

.meas tran vdout0_80ck780 FIND v(dout0_80) AT=395.025n

.meas tran vdout0_81ck780 FIND v(dout0_81) AT=395.025n

.meas tran vdout0_82ck780 FIND v(dout0_82) AT=395.025n

.meas tran vdout0_83ck780 FIND v(dout0_83) AT=395.025n

.meas tran vdout0_84ck780 FIND v(dout0_84) AT=395.025n

.meas tran vdout0_85ck780 FIND v(dout0_85) AT=395.025n

.meas tran vdout0_86ck780 FIND v(dout0_86) AT=395.025n

.meas tran vdout0_87ck780 FIND v(dout0_87) AT=395.025n

.meas tran vdout0_88ck780 FIND v(dout0_88) AT=395.025n

.meas tran vdout0_89ck780 FIND v(dout0_89) AT=395.025n

.meas tran vdout0_90ck780 FIND v(dout0_90) AT=395.025n

.meas tran vdout0_91ck780 FIND v(dout0_91) AT=395.025n

.meas tran vdout0_92ck780 FIND v(dout0_92) AT=395.025n

.meas tran vdout0_93ck780 FIND v(dout0_93) AT=395.025n

.meas tran vdout0_94ck780 FIND v(dout0_94) AT=395.025n

.meas tran vdout0_95ck780 FIND v(dout0_95) AT=395.025n

.meas tran vdout0_96ck780 FIND v(dout0_96) AT=395.025n

.meas tran vdout0_97ck780 FIND v(dout0_97) AT=395.025n

.meas tran vdout0_98ck780 FIND v(dout0_98) AT=395.025n

.meas tran vdout0_99ck780 FIND v(dout0_99) AT=395.025n

.meas tran vdout0_100ck780 FIND v(dout0_100) AT=395.025n

.meas tran vdout0_101ck780 FIND v(dout0_101) AT=395.025n

.meas tran vdout0_102ck780 FIND v(dout0_102) AT=395.025n

.meas tran vdout0_103ck780 FIND v(dout0_103) AT=395.025n

.meas tran vdout0_104ck780 FIND v(dout0_104) AT=395.025n

.meas tran vdout0_105ck780 FIND v(dout0_105) AT=395.025n

.meas tran vdout0_106ck780 FIND v(dout0_106) AT=395.025n

.meas tran vdout0_107ck780 FIND v(dout0_107) AT=395.025n

.meas tran vdout0_108ck780 FIND v(dout0_108) AT=395.025n

.meas tran vdout0_109ck780 FIND v(dout0_109) AT=395.025n

.meas tran vdout0_110ck780 FIND v(dout0_110) AT=395.025n

.meas tran vdout0_111ck780 FIND v(dout0_111) AT=395.025n

.meas tran vdout0_112ck780 FIND v(dout0_112) AT=395.025n

.meas tran vdout0_113ck780 FIND v(dout0_113) AT=395.025n

.meas tran vdout0_114ck780 FIND v(dout0_114) AT=395.025n

.meas tran vdout0_115ck780 FIND v(dout0_115) AT=395.025n

.meas tran vdout0_116ck780 FIND v(dout0_116) AT=395.025n

.meas tran vdout0_117ck780 FIND v(dout0_117) AT=395.025n

.meas tran vdout0_118ck780 FIND v(dout0_118) AT=395.025n

.meas tran vdout0_119ck780 FIND v(dout0_119) AT=395.025n

.meas tran vdout0_120ck780 FIND v(dout0_120) AT=395.025n

.meas tran vdout0_121ck780 FIND v(dout0_121) AT=395.025n

.meas tran vdout0_122ck780 FIND v(dout0_122) AT=395.025n

.meas tran vdout0_123ck780 FIND v(dout0_123) AT=395.025n

.meas tran vdout0_124ck780 FIND v(dout0_124) AT=395.025n

.meas tran vdout0_125ck780 FIND v(dout0_125) AT=395.025n

.meas tran vdout0_126ck780 FIND v(dout0_126) AT=395.025n

.meas tran vdout0_127ck780 FIND v(dout0_127) AT=395.025n

.meas tran vdout0_0ck820 FIND v(dout0_0) AT=415.025n

.meas tran vdout0_1ck820 FIND v(dout0_1) AT=415.025n

.meas tran vdout0_2ck820 FIND v(dout0_2) AT=415.025n

.meas tran vdout0_3ck820 FIND v(dout0_3) AT=415.025n

.meas tran vdout0_4ck820 FIND v(dout0_4) AT=415.025n

.meas tran vdout0_5ck820 FIND v(dout0_5) AT=415.025n

.meas tran vdout0_6ck820 FIND v(dout0_6) AT=415.025n

.meas tran vdout0_7ck820 FIND v(dout0_7) AT=415.025n

.meas tran vdout0_8ck820 FIND v(dout0_8) AT=415.025n

.meas tran vdout0_9ck820 FIND v(dout0_9) AT=415.025n

.meas tran vdout0_10ck820 FIND v(dout0_10) AT=415.025n

.meas tran vdout0_11ck820 FIND v(dout0_11) AT=415.025n

.meas tran vdout0_12ck820 FIND v(dout0_12) AT=415.025n

.meas tran vdout0_13ck820 FIND v(dout0_13) AT=415.025n

.meas tran vdout0_14ck820 FIND v(dout0_14) AT=415.025n

.meas tran vdout0_15ck820 FIND v(dout0_15) AT=415.025n

.meas tran vdout0_16ck820 FIND v(dout0_16) AT=415.025n

.meas tran vdout0_17ck820 FIND v(dout0_17) AT=415.025n

.meas tran vdout0_18ck820 FIND v(dout0_18) AT=415.025n

.meas tran vdout0_19ck820 FIND v(dout0_19) AT=415.025n

.meas tran vdout0_20ck820 FIND v(dout0_20) AT=415.025n

.meas tran vdout0_21ck820 FIND v(dout0_21) AT=415.025n

.meas tran vdout0_22ck820 FIND v(dout0_22) AT=415.025n

.meas tran vdout0_23ck820 FIND v(dout0_23) AT=415.025n

.meas tran vdout0_24ck820 FIND v(dout0_24) AT=415.025n

.meas tran vdout0_25ck820 FIND v(dout0_25) AT=415.025n

.meas tran vdout0_26ck820 FIND v(dout0_26) AT=415.025n

.meas tran vdout0_27ck820 FIND v(dout0_27) AT=415.025n

.meas tran vdout0_28ck820 FIND v(dout0_28) AT=415.025n

.meas tran vdout0_29ck820 FIND v(dout0_29) AT=415.025n

.meas tran vdout0_30ck820 FIND v(dout0_30) AT=415.025n

.meas tran vdout0_31ck820 FIND v(dout0_31) AT=415.025n

.meas tran vdout0_32ck820 FIND v(dout0_32) AT=415.025n

.meas tran vdout0_33ck820 FIND v(dout0_33) AT=415.025n

.meas tran vdout0_34ck820 FIND v(dout0_34) AT=415.025n

.meas tran vdout0_35ck820 FIND v(dout0_35) AT=415.025n

.meas tran vdout0_36ck820 FIND v(dout0_36) AT=415.025n

.meas tran vdout0_37ck820 FIND v(dout0_37) AT=415.025n

.meas tran vdout0_38ck820 FIND v(dout0_38) AT=415.025n

.meas tran vdout0_39ck820 FIND v(dout0_39) AT=415.025n

.meas tran vdout0_40ck820 FIND v(dout0_40) AT=415.025n

.meas tran vdout0_41ck820 FIND v(dout0_41) AT=415.025n

.meas tran vdout0_42ck820 FIND v(dout0_42) AT=415.025n

.meas tran vdout0_43ck820 FIND v(dout0_43) AT=415.025n

.meas tran vdout0_44ck820 FIND v(dout0_44) AT=415.025n

.meas tran vdout0_45ck820 FIND v(dout0_45) AT=415.025n

.meas tran vdout0_46ck820 FIND v(dout0_46) AT=415.025n

.meas tran vdout0_47ck820 FIND v(dout0_47) AT=415.025n

.meas tran vdout0_48ck820 FIND v(dout0_48) AT=415.025n

.meas tran vdout0_49ck820 FIND v(dout0_49) AT=415.025n

.meas tran vdout0_50ck820 FIND v(dout0_50) AT=415.025n

.meas tran vdout0_51ck820 FIND v(dout0_51) AT=415.025n

.meas tran vdout0_52ck820 FIND v(dout0_52) AT=415.025n

.meas tran vdout0_53ck820 FIND v(dout0_53) AT=415.025n

.meas tran vdout0_54ck820 FIND v(dout0_54) AT=415.025n

.meas tran vdout0_55ck820 FIND v(dout0_55) AT=415.025n

.meas tran vdout0_56ck820 FIND v(dout0_56) AT=415.025n

.meas tran vdout0_57ck820 FIND v(dout0_57) AT=415.025n

.meas tran vdout0_58ck820 FIND v(dout0_58) AT=415.025n

.meas tran vdout0_59ck820 FIND v(dout0_59) AT=415.025n

.meas tran vdout0_60ck820 FIND v(dout0_60) AT=415.025n

.meas tran vdout0_61ck820 FIND v(dout0_61) AT=415.025n

.meas tran vdout0_62ck820 FIND v(dout0_62) AT=415.025n

.meas tran vdout0_63ck820 FIND v(dout0_63) AT=415.025n

.meas tran vdout0_64ck820 FIND v(dout0_64) AT=415.025n

.meas tran vdout0_65ck820 FIND v(dout0_65) AT=415.025n

.meas tran vdout0_66ck820 FIND v(dout0_66) AT=415.025n

.meas tran vdout0_67ck820 FIND v(dout0_67) AT=415.025n

.meas tran vdout0_68ck820 FIND v(dout0_68) AT=415.025n

.meas tran vdout0_69ck820 FIND v(dout0_69) AT=415.025n

.meas tran vdout0_70ck820 FIND v(dout0_70) AT=415.025n

.meas tran vdout0_71ck820 FIND v(dout0_71) AT=415.025n

.meas tran vdout0_72ck820 FIND v(dout0_72) AT=415.025n

.meas tran vdout0_73ck820 FIND v(dout0_73) AT=415.025n

.meas tran vdout0_74ck820 FIND v(dout0_74) AT=415.025n

.meas tran vdout0_75ck820 FIND v(dout0_75) AT=415.025n

.meas tran vdout0_76ck820 FIND v(dout0_76) AT=415.025n

.meas tran vdout0_77ck820 FIND v(dout0_77) AT=415.025n

.meas tran vdout0_78ck820 FIND v(dout0_78) AT=415.025n

.meas tran vdout0_79ck820 FIND v(dout0_79) AT=415.025n

.meas tran vdout0_80ck820 FIND v(dout0_80) AT=415.025n

.meas tran vdout0_81ck820 FIND v(dout0_81) AT=415.025n

.meas tran vdout0_82ck820 FIND v(dout0_82) AT=415.025n

.meas tran vdout0_83ck820 FIND v(dout0_83) AT=415.025n

.meas tran vdout0_84ck820 FIND v(dout0_84) AT=415.025n

.meas tran vdout0_85ck820 FIND v(dout0_85) AT=415.025n

.meas tran vdout0_86ck820 FIND v(dout0_86) AT=415.025n

.meas tran vdout0_87ck820 FIND v(dout0_87) AT=415.025n

.meas tran vdout0_88ck820 FIND v(dout0_88) AT=415.025n

.meas tran vdout0_89ck820 FIND v(dout0_89) AT=415.025n

.meas tran vdout0_90ck820 FIND v(dout0_90) AT=415.025n

.meas tran vdout0_91ck820 FIND v(dout0_91) AT=415.025n

.meas tran vdout0_92ck820 FIND v(dout0_92) AT=415.025n

.meas tran vdout0_93ck820 FIND v(dout0_93) AT=415.025n

.meas tran vdout0_94ck820 FIND v(dout0_94) AT=415.025n

.meas tran vdout0_95ck820 FIND v(dout0_95) AT=415.025n

.meas tran vdout0_96ck820 FIND v(dout0_96) AT=415.025n

.meas tran vdout0_97ck820 FIND v(dout0_97) AT=415.025n

.meas tran vdout0_98ck820 FIND v(dout0_98) AT=415.025n

.meas tran vdout0_99ck820 FIND v(dout0_99) AT=415.025n

.meas tran vdout0_100ck820 FIND v(dout0_100) AT=415.025n

.meas tran vdout0_101ck820 FIND v(dout0_101) AT=415.025n

.meas tran vdout0_102ck820 FIND v(dout0_102) AT=415.025n

.meas tran vdout0_103ck820 FIND v(dout0_103) AT=415.025n

.meas tran vdout0_104ck820 FIND v(dout0_104) AT=415.025n

.meas tran vdout0_105ck820 FIND v(dout0_105) AT=415.025n

.meas tran vdout0_106ck820 FIND v(dout0_106) AT=415.025n

.meas tran vdout0_107ck820 FIND v(dout0_107) AT=415.025n

.meas tran vdout0_108ck820 FIND v(dout0_108) AT=415.025n

.meas tran vdout0_109ck820 FIND v(dout0_109) AT=415.025n

.meas tran vdout0_110ck820 FIND v(dout0_110) AT=415.025n

.meas tran vdout0_111ck820 FIND v(dout0_111) AT=415.025n

.meas tran vdout0_112ck820 FIND v(dout0_112) AT=415.025n

.meas tran vdout0_113ck820 FIND v(dout0_113) AT=415.025n

.meas tran vdout0_114ck820 FIND v(dout0_114) AT=415.025n

.meas tran vdout0_115ck820 FIND v(dout0_115) AT=415.025n

.meas tran vdout0_116ck820 FIND v(dout0_116) AT=415.025n

.meas tran vdout0_117ck820 FIND v(dout0_117) AT=415.025n

.meas tran vdout0_118ck820 FIND v(dout0_118) AT=415.025n

.meas tran vdout0_119ck820 FIND v(dout0_119) AT=415.025n

.meas tran vdout0_120ck820 FIND v(dout0_120) AT=415.025n

.meas tran vdout0_121ck820 FIND v(dout0_121) AT=415.025n

.meas tran vdout0_122ck820 FIND v(dout0_122) AT=415.025n

.meas tran vdout0_123ck820 FIND v(dout0_123) AT=415.025n

.meas tran vdout0_124ck820 FIND v(dout0_124) AT=415.025n

.meas tran vdout0_125ck820 FIND v(dout0_125) AT=415.025n

.meas tran vdout0_126ck820 FIND v(dout0_126) AT=415.025n

.meas tran vdout0_127ck820 FIND v(dout0_127) AT=415.025n

.meas tran vdout0_0ck870 FIND v(dout0_0) AT=440.025n

.meas tran vdout0_1ck870 FIND v(dout0_1) AT=440.025n

.meas tran vdout0_2ck870 FIND v(dout0_2) AT=440.025n

.meas tran vdout0_3ck870 FIND v(dout0_3) AT=440.025n

.meas tran vdout0_4ck870 FIND v(dout0_4) AT=440.025n

.meas tran vdout0_5ck870 FIND v(dout0_5) AT=440.025n

.meas tran vdout0_6ck870 FIND v(dout0_6) AT=440.025n

.meas tran vdout0_7ck870 FIND v(dout0_7) AT=440.025n

.meas tran vdout0_8ck870 FIND v(dout0_8) AT=440.025n

.meas tran vdout0_9ck870 FIND v(dout0_9) AT=440.025n

.meas tran vdout0_10ck870 FIND v(dout0_10) AT=440.025n

.meas tran vdout0_11ck870 FIND v(dout0_11) AT=440.025n

.meas tran vdout0_12ck870 FIND v(dout0_12) AT=440.025n

.meas tran vdout0_13ck870 FIND v(dout0_13) AT=440.025n

.meas tran vdout0_14ck870 FIND v(dout0_14) AT=440.025n

.meas tran vdout0_15ck870 FIND v(dout0_15) AT=440.025n

.meas tran vdout0_16ck870 FIND v(dout0_16) AT=440.025n

.meas tran vdout0_17ck870 FIND v(dout0_17) AT=440.025n

.meas tran vdout0_18ck870 FIND v(dout0_18) AT=440.025n

.meas tran vdout0_19ck870 FIND v(dout0_19) AT=440.025n

.meas tran vdout0_20ck870 FIND v(dout0_20) AT=440.025n

.meas tran vdout0_21ck870 FIND v(dout0_21) AT=440.025n

.meas tran vdout0_22ck870 FIND v(dout0_22) AT=440.025n

.meas tran vdout0_23ck870 FIND v(dout0_23) AT=440.025n

.meas tran vdout0_24ck870 FIND v(dout0_24) AT=440.025n

.meas tran vdout0_25ck870 FIND v(dout0_25) AT=440.025n

.meas tran vdout0_26ck870 FIND v(dout0_26) AT=440.025n

.meas tran vdout0_27ck870 FIND v(dout0_27) AT=440.025n

.meas tran vdout0_28ck870 FIND v(dout0_28) AT=440.025n

.meas tran vdout0_29ck870 FIND v(dout0_29) AT=440.025n

.meas tran vdout0_30ck870 FIND v(dout0_30) AT=440.025n

.meas tran vdout0_31ck870 FIND v(dout0_31) AT=440.025n

.meas tran vdout0_32ck870 FIND v(dout0_32) AT=440.025n

.meas tran vdout0_33ck870 FIND v(dout0_33) AT=440.025n

.meas tran vdout0_34ck870 FIND v(dout0_34) AT=440.025n

.meas tran vdout0_35ck870 FIND v(dout0_35) AT=440.025n

.meas tran vdout0_36ck870 FIND v(dout0_36) AT=440.025n

.meas tran vdout0_37ck870 FIND v(dout0_37) AT=440.025n

.meas tran vdout0_38ck870 FIND v(dout0_38) AT=440.025n

.meas tran vdout0_39ck870 FIND v(dout0_39) AT=440.025n

.meas tran vdout0_40ck870 FIND v(dout0_40) AT=440.025n

.meas tran vdout0_41ck870 FIND v(dout0_41) AT=440.025n

.meas tran vdout0_42ck870 FIND v(dout0_42) AT=440.025n

.meas tran vdout0_43ck870 FIND v(dout0_43) AT=440.025n

.meas tran vdout0_44ck870 FIND v(dout0_44) AT=440.025n

.meas tran vdout0_45ck870 FIND v(dout0_45) AT=440.025n

.meas tran vdout0_46ck870 FIND v(dout0_46) AT=440.025n

.meas tran vdout0_47ck870 FIND v(dout0_47) AT=440.025n

.meas tran vdout0_48ck870 FIND v(dout0_48) AT=440.025n

.meas tran vdout0_49ck870 FIND v(dout0_49) AT=440.025n

.meas tran vdout0_50ck870 FIND v(dout0_50) AT=440.025n

.meas tran vdout0_51ck870 FIND v(dout0_51) AT=440.025n

.meas tran vdout0_52ck870 FIND v(dout0_52) AT=440.025n

.meas tran vdout0_53ck870 FIND v(dout0_53) AT=440.025n

.meas tran vdout0_54ck870 FIND v(dout0_54) AT=440.025n

.meas tran vdout0_55ck870 FIND v(dout0_55) AT=440.025n

.meas tran vdout0_56ck870 FIND v(dout0_56) AT=440.025n

.meas tran vdout0_57ck870 FIND v(dout0_57) AT=440.025n

.meas tran vdout0_58ck870 FIND v(dout0_58) AT=440.025n

.meas tran vdout0_59ck870 FIND v(dout0_59) AT=440.025n

.meas tran vdout0_60ck870 FIND v(dout0_60) AT=440.025n

.meas tran vdout0_61ck870 FIND v(dout0_61) AT=440.025n

.meas tran vdout0_62ck870 FIND v(dout0_62) AT=440.025n

.meas tran vdout0_63ck870 FIND v(dout0_63) AT=440.025n

.meas tran vdout0_64ck870 FIND v(dout0_64) AT=440.025n

.meas tran vdout0_65ck870 FIND v(dout0_65) AT=440.025n

.meas tran vdout0_66ck870 FIND v(dout0_66) AT=440.025n

.meas tran vdout0_67ck870 FIND v(dout0_67) AT=440.025n

.meas tran vdout0_68ck870 FIND v(dout0_68) AT=440.025n

.meas tran vdout0_69ck870 FIND v(dout0_69) AT=440.025n

.meas tran vdout0_70ck870 FIND v(dout0_70) AT=440.025n

.meas tran vdout0_71ck870 FIND v(dout0_71) AT=440.025n

.meas tran vdout0_72ck870 FIND v(dout0_72) AT=440.025n

.meas tran vdout0_73ck870 FIND v(dout0_73) AT=440.025n

.meas tran vdout0_74ck870 FIND v(dout0_74) AT=440.025n

.meas tran vdout0_75ck870 FIND v(dout0_75) AT=440.025n

.meas tran vdout0_76ck870 FIND v(dout0_76) AT=440.025n

.meas tran vdout0_77ck870 FIND v(dout0_77) AT=440.025n

.meas tran vdout0_78ck870 FIND v(dout0_78) AT=440.025n

.meas tran vdout0_79ck870 FIND v(dout0_79) AT=440.025n

.meas tran vdout0_80ck870 FIND v(dout0_80) AT=440.025n

.meas tran vdout0_81ck870 FIND v(dout0_81) AT=440.025n

.meas tran vdout0_82ck870 FIND v(dout0_82) AT=440.025n

.meas tran vdout0_83ck870 FIND v(dout0_83) AT=440.025n

.meas tran vdout0_84ck870 FIND v(dout0_84) AT=440.025n

.meas tran vdout0_85ck870 FIND v(dout0_85) AT=440.025n

.meas tran vdout0_86ck870 FIND v(dout0_86) AT=440.025n

.meas tran vdout0_87ck870 FIND v(dout0_87) AT=440.025n

.meas tran vdout0_88ck870 FIND v(dout0_88) AT=440.025n

.meas tran vdout0_89ck870 FIND v(dout0_89) AT=440.025n

.meas tran vdout0_90ck870 FIND v(dout0_90) AT=440.025n

.meas tran vdout0_91ck870 FIND v(dout0_91) AT=440.025n

.meas tran vdout0_92ck870 FIND v(dout0_92) AT=440.025n

.meas tran vdout0_93ck870 FIND v(dout0_93) AT=440.025n

.meas tran vdout0_94ck870 FIND v(dout0_94) AT=440.025n

.meas tran vdout0_95ck870 FIND v(dout0_95) AT=440.025n

.meas tran vdout0_96ck870 FIND v(dout0_96) AT=440.025n

.meas tran vdout0_97ck870 FIND v(dout0_97) AT=440.025n

.meas tran vdout0_98ck870 FIND v(dout0_98) AT=440.025n

.meas tran vdout0_99ck870 FIND v(dout0_99) AT=440.025n

.meas tran vdout0_100ck870 FIND v(dout0_100) AT=440.025n

.meas tran vdout0_101ck870 FIND v(dout0_101) AT=440.025n

.meas tran vdout0_102ck870 FIND v(dout0_102) AT=440.025n

.meas tran vdout0_103ck870 FIND v(dout0_103) AT=440.025n

.meas tran vdout0_104ck870 FIND v(dout0_104) AT=440.025n

.meas tran vdout0_105ck870 FIND v(dout0_105) AT=440.025n

.meas tran vdout0_106ck870 FIND v(dout0_106) AT=440.025n

.meas tran vdout0_107ck870 FIND v(dout0_107) AT=440.025n

.meas tran vdout0_108ck870 FIND v(dout0_108) AT=440.025n

.meas tran vdout0_109ck870 FIND v(dout0_109) AT=440.025n

.meas tran vdout0_110ck870 FIND v(dout0_110) AT=440.025n

.meas tran vdout0_111ck870 FIND v(dout0_111) AT=440.025n

.meas tran vdout0_112ck870 FIND v(dout0_112) AT=440.025n

.meas tran vdout0_113ck870 FIND v(dout0_113) AT=440.025n

.meas tran vdout0_114ck870 FIND v(dout0_114) AT=440.025n

.meas tran vdout0_115ck870 FIND v(dout0_115) AT=440.025n

.meas tran vdout0_116ck870 FIND v(dout0_116) AT=440.025n

.meas tran vdout0_117ck870 FIND v(dout0_117) AT=440.025n

.meas tran vdout0_118ck870 FIND v(dout0_118) AT=440.025n

.meas tran vdout0_119ck870 FIND v(dout0_119) AT=440.025n

.meas tran vdout0_120ck870 FIND v(dout0_120) AT=440.025n

.meas tran vdout0_121ck870 FIND v(dout0_121) AT=440.025n

.meas tran vdout0_122ck870 FIND v(dout0_122) AT=440.025n

.meas tran vdout0_123ck870 FIND v(dout0_123) AT=440.025n

.meas tran vdout0_124ck870 FIND v(dout0_124) AT=440.025n

.meas tran vdout0_125ck870 FIND v(dout0_125) AT=440.025n

.meas tran vdout0_126ck870 FIND v(dout0_126) AT=440.025n

.meas tran vdout0_127ck870 FIND v(dout0_127) AT=440.025n

.meas tran vdout0_0ck880 FIND v(dout0_0) AT=445.025n

.meas tran vdout0_1ck880 FIND v(dout0_1) AT=445.025n

.meas tran vdout0_2ck880 FIND v(dout0_2) AT=445.025n

.meas tran vdout0_3ck880 FIND v(dout0_3) AT=445.025n

.meas tran vdout0_4ck880 FIND v(dout0_4) AT=445.025n

.meas tran vdout0_5ck880 FIND v(dout0_5) AT=445.025n

.meas tran vdout0_6ck880 FIND v(dout0_6) AT=445.025n

.meas tran vdout0_7ck880 FIND v(dout0_7) AT=445.025n

.meas tran vdout0_8ck880 FIND v(dout0_8) AT=445.025n

.meas tran vdout0_9ck880 FIND v(dout0_9) AT=445.025n

.meas tran vdout0_10ck880 FIND v(dout0_10) AT=445.025n

.meas tran vdout0_11ck880 FIND v(dout0_11) AT=445.025n

.meas tran vdout0_12ck880 FIND v(dout0_12) AT=445.025n

.meas tran vdout0_13ck880 FIND v(dout0_13) AT=445.025n

.meas tran vdout0_14ck880 FIND v(dout0_14) AT=445.025n

.meas tran vdout0_15ck880 FIND v(dout0_15) AT=445.025n

.meas tran vdout0_16ck880 FIND v(dout0_16) AT=445.025n

.meas tran vdout0_17ck880 FIND v(dout0_17) AT=445.025n

.meas tran vdout0_18ck880 FIND v(dout0_18) AT=445.025n

.meas tran vdout0_19ck880 FIND v(dout0_19) AT=445.025n

.meas tran vdout0_20ck880 FIND v(dout0_20) AT=445.025n

.meas tran vdout0_21ck880 FIND v(dout0_21) AT=445.025n

.meas tran vdout0_22ck880 FIND v(dout0_22) AT=445.025n

.meas tran vdout0_23ck880 FIND v(dout0_23) AT=445.025n

.meas tran vdout0_24ck880 FIND v(dout0_24) AT=445.025n

.meas tran vdout0_25ck880 FIND v(dout0_25) AT=445.025n

.meas tran vdout0_26ck880 FIND v(dout0_26) AT=445.025n

.meas tran vdout0_27ck880 FIND v(dout0_27) AT=445.025n

.meas tran vdout0_28ck880 FIND v(dout0_28) AT=445.025n

.meas tran vdout0_29ck880 FIND v(dout0_29) AT=445.025n

.meas tran vdout0_30ck880 FIND v(dout0_30) AT=445.025n

.meas tran vdout0_31ck880 FIND v(dout0_31) AT=445.025n

.meas tran vdout0_32ck880 FIND v(dout0_32) AT=445.025n

.meas tran vdout0_33ck880 FIND v(dout0_33) AT=445.025n

.meas tran vdout0_34ck880 FIND v(dout0_34) AT=445.025n

.meas tran vdout0_35ck880 FIND v(dout0_35) AT=445.025n

.meas tran vdout0_36ck880 FIND v(dout0_36) AT=445.025n

.meas tran vdout0_37ck880 FIND v(dout0_37) AT=445.025n

.meas tran vdout0_38ck880 FIND v(dout0_38) AT=445.025n

.meas tran vdout0_39ck880 FIND v(dout0_39) AT=445.025n

.meas tran vdout0_40ck880 FIND v(dout0_40) AT=445.025n

.meas tran vdout0_41ck880 FIND v(dout0_41) AT=445.025n

.meas tran vdout0_42ck880 FIND v(dout0_42) AT=445.025n

.meas tran vdout0_43ck880 FIND v(dout0_43) AT=445.025n

.meas tran vdout0_44ck880 FIND v(dout0_44) AT=445.025n

.meas tran vdout0_45ck880 FIND v(dout0_45) AT=445.025n

.meas tran vdout0_46ck880 FIND v(dout0_46) AT=445.025n

.meas tran vdout0_47ck880 FIND v(dout0_47) AT=445.025n

.meas tran vdout0_48ck880 FIND v(dout0_48) AT=445.025n

.meas tran vdout0_49ck880 FIND v(dout0_49) AT=445.025n

.meas tran vdout0_50ck880 FIND v(dout0_50) AT=445.025n

.meas tran vdout0_51ck880 FIND v(dout0_51) AT=445.025n

.meas tran vdout0_52ck880 FIND v(dout0_52) AT=445.025n

.meas tran vdout0_53ck880 FIND v(dout0_53) AT=445.025n

.meas tran vdout0_54ck880 FIND v(dout0_54) AT=445.025n

.meas tran vdout0_55ck880 FIND v(dout0_55) AT=445.025n

.meas tran vdout0_56ck880 FIND v(dout0_56) AT=445.025n

.meas tran vdout0_57ck880 FIND v(dout0_57) AT=445.025n

.meas tran vdout0_58ck880 FIND v(dout0_58) AT=445.025n

.meas tran vdout0_59ck880 FIND v(dout0_59) AT=445.025n

.meas tran vdout0_60ck880 FIND v(dout0_60) AT=445.025n

.meas tran vdout0_61ck880 FIND v(dout0_61) AT=445.025n

.meas tran vdout0_62ck880 FIND v(dout0_62) AT=445.025n

.meas tran vdout0_63ck880 FIND v(dout0_63) AT=445.025n

.meas tran vdout0_64ck880 FIND v(dout0_64) AT=445.025n

.meas tran vdout0_65ck880 FIND v(dout0_65) AT=445.025n

.meas tran vdout0_66ck880 FIND v(dout0_66) AT=445.025n

.meas tran vdout0_67ck880 FIND v(dout0_67) AT=445.025n

.meas tran vdout0_68ck880 FIND v(dout0_68) AT=445.025n

.meas tran vdout0_69ck880 FIND v(dout0_69) AT=445.025n

.meas tran vdout0_70ck880 FIND v(dout0_70) AT=445.025n

.meas tran vdout0_71ck880 FIND v(dout0_71) AT=445.025n

.meas tran vdout0_72ck880 FIND v(dout0_72) AT=445.025n

.meas tran vdout0_73ck880 FIND v(dout0_73) AT=445.025n

.meas tran vdout0_74ck880 FIND v(dout0_74) AT=445.025n

.meas tran vdout0_75ck880 FIND v(dout0_75) AT=445.025n

.meas tran vdout0_76ck880 FIND v(dout0_76) AT=445.025n

.meas tran vdout0_77ck880 FIND v(dout0_77) AT=445.025n

.meas tran vdout0_78ck880 FIND v(dout0_78) AT=445.025n

.meas tran vdout0_79ck880 FIND v(dout0_79) AT=445.025n

.meas tran vdout0_80ck880 FIND v(dout0_80) AT=445.025n

.meas tran vdout0_81ck880 FIND v(dout0_81) AT=445.025n

.meas tran vdout0_82ck880 FIND v(dout0_82) AT=445.025n

.meas tran vdout0_83ck880 FIND v(dout0_83) AT=445.025n

.meas tran vdout0_84ck880 FIND v(dout0_84) AT=445.025n

.meas tran vdout0_85ck880 FIND v(dout0_85) AT=445.025n

.meas tran vdout0_86ck880 FIND v(dout0_86) AT=445.025n

.meas tran vdout0_87ck880 FIND v(dout0_87) AT=445.025n

.meas tran vdout0_88ck880 FIND v(dout0_88) AT=445.025n

.meas tran vdout0_89ck880 FIND v(dout0_89) AT=445.025n

.meas tran vdout0_90ck880 FIND v(dout0_90) AT=445.025n

.meas tran vdout0_91ck880 FIND v(dout0_91) AT=445.025n

.meas tran vdout0_92ck880 FIND v(dout0_92) AT=445.025n

.meas tran vdout0_93ck880 FIND v(dout0_93) AT=445.025n

.meas tran vdout0_94ck880 FIND v(dout0_94) AT=445.025n

.meas tran vdout0_95ck880 FIND v(dout0_95) AT=445.025n

.meas tran vdout0_96ck880 FIND v(dout0_96) AT=445.025n

.meas tran vdout0_97ck880 FIND v(dout0_97) AT=445.025n

.meas tran vdout0_98ck880 FIND v(dout0_98) AT=445.025n

.meas tran vdout0_99ck880 FIND v(dout0_99) AT=445.025n

.meas tran vdout0_100ck880 FIND v(dout0_100) AT=445.025n

.meas tran vdout0_101ck880 FIND v(dout0_101) AT=445.025n

.meas tran vdout0_102ck880 FIND v(dout0_102) AT=445.025n

.meas tran vdout0_103ck880 FIND v(dout0_103) AT=445.025n

.meas tran vdout0_104ck880 FIND v(dout0_104) AT=445.025n

.meas tran vdout0_105ck880 FIND v(dout0_105) AT=445.025n

.meas tran vdout0_106ck880 FIND v(dout0_106) AT=445.025n

.meas tran vdout0_107ck880 FIND v(dout0_107) AT=445.025n

.meas tran vdout0_108ck880 FIND v(dout0_108) AT=445.025n

.meas tran vdout0_109ck880 FIND v(dout0_109) AT=445.025n

.meas tran vdout0_110ck880 FIND v(dout0_110) AT=445.025n

.meas tran vdout0_111ck880 FIND v(dout0_111) AT=445.025n

.meas tran vdout0_112ck880 FIND v(dout0_112) AT=445.025n

.meas tran vdout0_113ck880 FIND v(dout0_113) AT=445.025n

.meas tran vdout0_114ck880 FIND v(dout0_114) AT=445.025n

.meas tran vdout0_115ck880 FIND v(dout0_115) AT=445.025n

.meas tran vdout0_116ck880 FIND v(dout0_116) AT=445.025n

.meas tran vdout0_117ck880 FIND v(dout0_117) AT=445.025n

.meas tran vdout0_118ck880 FIND v(dout0_118) AT=445.025n

.meas tran vdout0_119ck880 FIND v(dout0_119) AT=445.025n

.meas tran vdout0_120ck880 FIND v(dout0_120) AT=445.025n

.meas tran vdout0_121ck880 FIND v(dout0_121) AT=445.025n

.meas tran vdout0_122ck880 FIND v(dout0_122) AT=445.025n

.meas tran vdout0_123ck880 FIND v(dout0_123) AT=445.025n

.meas tran vdout0_124ck880 FIND v(dout0_124) AT=445.025n

.meas tran vdout0_125ck880 FIND v(dout0_125) AT=445.025n

.meas tran vdout0_126ck880 FIND v(dout0_126) AT=445.025n

.meas tran vdout0_127ck880 FIND v(dout0_127) AT=445.025n

.meas tran vdout0_0ck900 FIND v(dout0_0) AT=455.025n

.meas tran vdout0_1ck900 FIND v(dout0_1) AT=455.025n

.meas tran vdout0_2ck900 FIND v(dout0_2) AT=455.025n

.meas tran vdout0_3ck900 FIND v(dout0_3) AT=455.025n

.meas tran vdout0_4ck900 FIND v(dout0_4) AT=455.025n

.meas tran vdout0_5ck900 FIND v(dout0_5) AT=455.025n

.meas tran vdout0_6ck900 FIND v(dout0_6) AT=455.025n

.meas tran vdout0_7ck900 FIND v(dout0_7) AT=455.025n

.meas tran vdout0_8ck900 FIND v(dout0_8) AT=455.025n

.meas tran vdout0_9ck900 FIND v(dout0_9) AT=455.025n

.meas tran vdout0_10ck900 FIND v(dout0_10) AT=455.025n

.meas tran vdout0_11ck900 FIND v(dout0_11) AT=455.025n

.meas tran vdout0_12ck900 FIND v(dout0_12) AT=455.025n

.meas tran vdout0_13ck900 FIND v(dout0_13) AT=455.025n

.meas tran vdout0_14ck900 FIND v(dout0_14) AT=455.025n

.meas tran vdout0_15ck900 FIND v(dout0_15) AT=455.025n

.meas tran vdout0_16ck900 FIND v(dout0_16) AT=455.025n

.meas tran vdout0_17ck900 FIND v(dout0_17) AT=455.025n

.meas tran vdout0_18ck900 FIND v(dout0_18) AT=455.025n

.meas tran vdout0_19ck900 FIND v(dout0_19) AT=455.025n

.meas tran vdout0_20ck900 FIND v(dout0_20) AT=455.025n

.meas tran vdout0_21ck900 FIND v(dout0_21) AT=455.025n

.meas tran vdout0_22ck900 FIND v(dout0_22) AT=455.025n

.meas tran vdout0_23ck900 FIND v(dout0_23) AT=455.025n

.meas tran vdout0_24ck900 FIND v(dout0_24) AT=455.025n

.meas tran vdout0_25ck900 FIND v(dout0_25) AT=455.025n

.meas tran vdout0_26ck900 FIND v(dout0_26) AT=455.025n

.meas tran vdout0_27ck900 FIND v(dout0_27) AT=455.025n

.meas tran vdout0_28ck900 FIND v(dout0_28) AT=455.025n

.meas tran vdout0_29ck900 FIND v(dout0_29) AT=455.025n

.meas tran vdout0_30ck900 FIND v(dout0_30) AT=455.025n

.meas tran vdout0_31ck900 FIND v(dout0_31) AT=455.025n

.meas tran vdout0_32ck900 FIND v(dout0_32) AT=455.025n

.meas tran vdout0_33ck900 FIND v(dout0_33) AT=455.025n

.meas tran vdout0_34ck900 FIND v(dout0_34) AT=455.025n

.meas tran vdout0_35ck900 FIND v(dout0_35) AT=455.025n

.meas tran vdout0_36ck900 FIND v(dout0_36) AT=455.025n

.meas tran vdout0_37ck900 FIND v(dout0_37) AT=455.025n

.meas tran vdout0_38ck900 FIND v(dout0_38) AT=455.025n

.meas tran vdout0_39ck900 FIND v(dout0_39) AT=455.025n

.meas tran vdout0_40ck900 FIND v(dout0_40) AT=455.025n

.meas tran vdout0_41ck900 FIND v(dout0_41) AT=455.025n

.meas tran vdout0_42ck900 FIND v(dout0_42) AT=455.025n

.meas tran vdout0_43ck900 FIND v(dout0_43) AT=455.025n

.meas tran vdout0_44ck900 FIND v(dout0_44) AT=455.025n

.meas tran vdout0_45ck900 FIND v(dout0_45) AT=455.025n

.meas tran vdout0_46ck900 FIND v(dout0_46) AT=455.025n

.meas tran vdout0_47ck900 FIND v(dout0_47) AT=455.025n

.meas tran vdout0_48ck900 FIND v(dout0_48) AT=455.025n

.meas tran vdout0_49ck900 FIND v(dout0_49) AT=455.025n

.meas tran vdout0_50ck900 FIND v(dout0_50) AT=455.025n

.meas tran vdout0_51ck900 FIND v(dout0_51) AT=455.025n

.meas tran vdout0_52ck900 FIND v(dout0_52) AT=455.025n

.meas tran vdout0_53ck900 FIND v(dout0_53) AT=455.025n

.meas tran vdout0_54ck900 FIND v(dout0_54) AT=455.025n

.meas tran vdout0_55ck900 FIND v(dout0_55) AT=455.025n

.meas tran vdout0_56ck900 FIND v(dout0_56) AT=455.025n

.meas tran vdout0_57ck900 FIND v(dout0_57) AT=455.025n

.meas tran vdout0_58ck900 FIND v(dout0_58) AT=455.025n

.meas tran vdout0_59ck900 FIND v(dout0_59) AT=455.025n

.meas tran vdout0_60ck900 FIND v(dout0_60) AT=455.025n

.meas tran vdout0_61ck900 FIND v(dout0_61) AT=455.025n

.meas tran vdout0_62ck900 FIND v(dout0_62) AT=455.025n

.meas tran vdout0_63ck900 FIND v(dout0_63) AT=455.025n

.meas tran vdout0_64ck900 FIND v(dout0_64) AT=455.025n

.meas tran vdout0_65ck900 FIND v(dout0_65) AT=455.025n

.meas tran vdout0_66ck900 FIND v(dout0_66) AT=455.025n

.meas tran vdout0_67ck900 FIND v(dout0_67) AT=455.025n

.meas tran vdout0_68ck900 FIND v(dout0_68) AT=455.025n

.meas tran vdout0_69ck900 FIND v(dout0_69) AT=455.025n

.meas tran vdout0_70ck900 FIND v(dout0_70) AT=455.025n

.meas tran vdout0_71ck900 FIND v(dout0_71) AT=455.025n

.meas tran vdout0_72ck900 FIND v(dout0_72) AT=455.025n

.meas tran vdout0_73ck900 FIND v(dout0_73) AT=455.025n

.meas tran vdout0_74ck900 FIND v(dout0_74) AT=455.025n

.meas tran vdout0_75ck900 FIND v(dout0_75) AT=455.025n

.meas tran vdout0_76ck900 FIND v(dout0_76) AT=455.025n

.meas tran vdout0_77ck900 FIND v(dout0_77) AT=455.025n

.meas tran vdout0_78ck900 FIND v(dout0_78) AT=455.025n

.meas tran vdout0_79ck900 FIND v(dout0_79) AT=455.025n

.meas tran vdout0_80ck900 FIND v(dout0_80) AT=455.025n

.meas tran vdout0_81ck900 FIND v(dout0_81) AT=455.025n

.meas tran vdout0_82ck900 FIND v(dout0_82) AT=455.025n

.meas tran vdout0_83ck900 FIND v(dout0_83) AT=455.025n

.meas tran vdout0_84ck900 FIND v(dout0_84) AT=455.025n

.meas tran vdout0_85ck900 FIND v(dout0_85) AT=455.025n

.meas tran vdout0_86ck900 FIND v(dout0_86) AT=455.025n

.meas tran vdout0_87ck900 FIND v(dout0_87) AT=455.025n

.meas tran vdout0_88ck900 FIND v(dout0_88) AT=455.025n

.meas tran vdout0_89ck900 FIND v(dout0_89) AT=455.025n

.meas tran vdout0_90ck900 FIND v(dout0_90) AT=455.025n

.meas tran vdout0_91ck900 FIND v(dout0_91) AT=455.025n

.meas tran vdout0_92ck900 FIND v(dout0_92) AT=455.025n

.meas tran vdout0_93ck900 FIND v(dout0_93) AT=455.025n

.meas tran vdout0_94ck900 FIND v(dout0_94) AT=455.025n

.meas tran vdout0_95ck900 FIND v(dout0_95) AT=455.025n

.meas tran vdout0_96ck900 FIND v(dout0_96) AT=455.025n

.meas tran vdout0_97ck900 FIND v(dout0_97) AT=455.025n

.meas tran vdout0_98ck900 FIND v(dout0_98) AT=455.025n

.meas tran vdout0_99ck900 FIND v(dout0_99) AT=455.025n

.meas tran vdout0_100ck900 FIND v(dout0_100) AT=455.025n

.meas tran vdout0_101ck900 FIND v(dout0_101) AT=455.025n

.meas tran vdout0_102ck900 FIND v(dout0_102) AT=455.025n

.meas tran vdout0_103ck900 FIND v(dout0_103) AT=455.025n

.meas tran vdout0_104ck900 FIND v(dout0_104) AT=455.025n

.meas tran vdout0_105ck900 FIND v(dout0_105) AT=455.025n

.meas tran vdout0_106ck900 FIND v(dout0_106) AT=455.025n

.meas tran vdout0_107ck900 FIND v(dout0_107) AT=455.025n

.meas tran vdout0_108ck900 FIND v(dout0_108) AT=455.025n

.meas tran vdout0_109ck900 FIND v(dout0_109) AT=455.025n

.meas tran vdout0_110ck900 FIND v(dout0_110) AT=455.025n

.meas tran vdout0_111ck900 FIND v(dout0_111) AT=455.025n

.meas tran vdout0_112ck900 FIND v(dout0_112) AT=455.025n

.meas tran vdout0_113ck900 FIND v(dout0_113) AT=455.025n

.meas tran vdout0_114ck900 FIND v(dout0_114) AT=455.025n

.meas tran vdout0_115ck900 FIND v(dout0_115) AT=455.025n

.meas tran vdout0_116ck900 FIND v(dout0_116) AT=455.025n

.meas tran vdout0_117ck900 FIND v(dout0_117) AT=455.025n

.meas tran vdout0_118ck900 FIND v(dout0_118) AT=455.025n

.meas tran vdout0_119ck900 FIND v(dout0_119) AT=455.025n

.meas tran vdout0_120ck900 FIND v(dout0_120) AT=455.025n

.meas tran vdout0_121ck900 FIND v(dout0_121) AT=455.025n

.meas tran vdout0_122ck900 FIND v(dout0_122) AT=455.025n

.meas tran vdout0_123ck900 FIND v(dout0_123) AT=455.025n

.meas tran vdout0_124ck900 FIND v(dout0_124) AT=455.025n

.meas tran vdout0_125ck900 FIND v(dout0_125) AT=455.025n

.meas tran vdout0_126ck900 FIND v(dout0_126) AT=455.025n

.meas tran vdout0_127ck900 FIND v(dout0_127) AT=455.025n

.meas tran vdout0_0ck920 FIND v(dout0_0) AT=465.025n

.meas tran vdout0_1ck920 FIND v(dout0_1) AT=465.025n

.meas tran vdout0_2ck920 FIND v(dout0_2) AT=465.025n

.meas tran vdout0_3ck920 FIND v(dout0_3) AT=465.025n

.meas tran vdout0_4ck920 FIND v(dout0_4) AT=465.025n

.meas tran vdout0_5ck920 FIND v(dout0_5) AT=465.025n

.meas tran vdout0_6ck920 FIND v(dout0_6) AT=465.025n

.meas tran vdout0_7ck920 FIND v(dout0_7) AT=465.025n

.meas tran vdout0_8ck920 FIND v(dout0_8) AT=465.025n

.meas tran vdout0_9ck920 FIND v(dout0_9) AT=465.025n

.meas tran vdout0_10ck920 FIND v(dout0_10) AT=465.025n

.meas tran vdout0_11ck920 FIND v(dout0_11) AT=465.025n

.meas tran vdout0_12ck920 FIND v(dout0_12) AT=465.025n

.meas tran vdout0_13ck920 FIND v(dout0_13) AT=465.025n

.meas tran vdout0_14ck920 FIND v(dout0_14) AT=465.025n

.meas tran vdout0_15ck920 FIND v(dout0_15) AT=465.025n

.meas tran vdout0_16ck920 FIND v(dout0_16) AT=465.025n

.meas tran vdout0_17ck920 FIND v(dout0_17) AT=465.025n

.meas tran vdout0_18ck920 FIND v(dout0_18) AT=465.025n

.meas tran vdout0_19ck920 FIND v(dout0_19) AT=465.025n

.meas tran vdout0_20ck920 FIND v(dout0_20) AT=465.025n

.meas tran vdout0_21ck920 FIND v(dout0_21) AT=465.025n

.meas tran vdout0_22ck920 FIND v(dout0_22) AT=465.025n

.meas tran vdout0_23ck920 FIND v(dout0_23) AT=465.025n

.meas tran vdout0_24ck920 FIND v(dout0_24) AT=465.025n

.meas tran vdout0_25ck920 FIND v(dout0_25) AT=465.025n

.meas tran vdout0_26ck920 FIND v(dout0_26) AT=465.025n

.meas tran vdout0_27ck920 FIND v(dout0_27) AT=465.025n

.meas tran vdout0_28ck920 FIND v(dout0_28) AT=465.025n

.meas tran vdout0_29ck920 FIND v(dout0_29) AT=465.025n

.meas tran vdout0_30ck920 FIND v(dout0_30) AT=465.025n

.meas tran vdout0_31ck920 FIND v(dout0_31) AT=465.025n

.meas tran vdout0_32ck920 FIND v(dout0_32) AT=465.025n

.meas tran vdout0_33ck920 FIND v(dout0_33) AT=465.025n

.meas tran vdout0_34ck920 FIND v(dout0_34) AT=465.025n

.meas tran vdout0_35ck920 FIND v(dout0_35) AT=465.025n

.meas tran vdout0_36ck920 FIND v(dout0_36) AT=465.025n

.meas tran vdout0_37ck920 FIND v(dout0_37) AT=465.025n

.meas tran vdout0_38ck920 FIND v(dout0_38) AT=465.025n

.meas tran vdout0_39ck920 FIND v(dout0_39) AT=465.025n

.meas tran vdout0_40ck920 FIND v(dout0_40) AT=465.025n

.meas tran vdout0_41ck920 FIND v(dout0_41) AT=465.025n

.meas tran vdout0_42ck920 FIND v(dout0_42) AT=465.025n

.meas tran vdout0_43ck920 FIND v(dout0_43) AT=465.025n

.meas tran vdout0_44ck920 FIND v(dout0_44) AT=465.025n

.meas tran vdout0_45ck920 FIND v(dout0_45) AT=465.025n

.meas tran vdout0_46ck920 FIND v(dout0_46) AT=465.025n

.meas tran vdout0_47ck920 FIND v(dout0_47) AT=465.025n

.meas tran vdout0_48ck920 FIND v(dout0_48) AT=465.025n

.meas tran vdout0_49ck920 FIND v(dout0_49) AT=465.025n

.meas tran vdout0_50ck920 FIND v(dout0_50) AT=465.025n

.meas tran vdout0_51ck920 FIND v(dout0_51) AT=465.025n

.meas tran vdout0_52ck920 FIND v(dout0_52) AT=465.025n

.meas tran vdout0_53ck920 FIND v(dout0_53) AT=465.025n

.meas tran vdout0_54ck920 FIND v(dout0_54) AT=465.025n

.meas tran vdout0_55ck920 FIND v(dout0_55) AT=465.025n

.meas tran vdout0_56ck920 FIND v(dout0_56) AT=465.025n

.meas tran vdout0_57ck920 FIND v(dout0_57) AT=465.025n

.meas tran vdout0_58ck920 FIND v(dout0_58) AT=465.025n

.meas tran vdout0_59ck920 FIND v(dout0_59) AT=465.025n

.meas tran vdout0_60ck920 FIND v(dout0_60) AT=465.025n

.meas tran vdout0_61ck920 FIND v(dout0_61) AT=465.025n

.meas tran vdout0_62ck920 FIND v(dout0_62) AT=465.025n

.meas tran vdout0_63ck920 FIND v(dout0_63) AT=465.025n

.meas tran vdout0_64ck920 FIND v(dout0_64) AT=465.025n

.meas tran vdout0_65ck920 FIND v(dout0_65) AT=465.025n

.meas tran vdout0_66ck920 FIND v(dout0_66) AT=465.025n

.meas tran vdout0_67ck920 FIND v(dout0_67) AT=465.025n

.meas tran vdout0_68ck920 FIND v(dout0_68) AT=465.025n

.meas tran vdout0_69ck920 FIND v(dout0_69) AT=465.025n

.meas tran vdout0_70ck920 FIND v(dout0_70) AT=465.025n

.meas tran vdout0_71ck920 FIND v(dout0_71) AT=465.025n

.meas tran vdout0_72ck920 FIND v(dout0_72) AT=465.025n

.meas tran vdout0_73ck920 FIND v(dout0_73) AT=465.025n

.meas tran vdout0_74ck920 FIND v(dout0_74) AT=465.025n

.meas tran vdout0_75ck920 FIND v(dout0_75) AT=465.025n

.meas tran vdout0_76ck920 FIND v(dout0_76) AT=465.025n

.meas tran vdout0_77ck920 FIND v(dout0_77) AT=465.025n

.meas tran vdout0_78ck920 FIND v(dout0_78) AT=465.025n

.meas tran vdout0_79ck920 FIND v(dout0_79) AT=465.025n

.meas tran vdout0_80ck920 FIND v(dout0_80) AT=465.025n

.meas tran vdout0_81ck920 FIND v(dout0_81) AT=465.025n

.meas tran vdout0_82ck920 FIND v(dout0_82) AT=465.025n

.meas tran vdout0_83ck920 FIND v(dout0_83) AT=465.025n

.meas tran vdout0_84ck920 FIND v(dout0_84) AT=465.025n

.meas tran vdout0_85ck920 FIND v(dout0_85) AT=465.025n

.meas tran vdout0_86ck920 FIND v(dout0_86) AT=465.025n

.meas tran vdout0_87ck920 FIND v(dout0_87) AT=465.025n

.meas tran vdout0_88ck920 FIND v(dout0_88) AT=465.025n

.meas tran vdout0_89ck920 FIND v(dout0_89) AT=465.025n

.meas tran vdout0_90ck920 FIND v(dout0_90) AT=465.025n

.meas tran vdout0_91ck920 FIND v(dout0_91) AT=465.025n

.meas tran vdout0_92ck920 FIND v(dout0_92) AT=465.025n

.meas tran vdout0_93ck920 FIND v(dout0_93) AT=465.025n

.meas tran vdout0_94ck920 FIND v(dout0_94) AT=465.025n

.meas tran vdout0_95ck920 FIND v(dout0_95) AT=465.025n

.meas tran vdout0_96ck920 FIND v(dout0_96) AT=465.025n

.meas tran vdout0_97ck920 FIND v(dout0_97) AT=465.025n

.meas tran vdout0_98ck920 FIND v(dout0_98) AT=465.025n

.meas tran vdout0_99ck920 FIND v(dout0_99) AT=465.025n

.meas tran vdout0_100ck920 FIND v(dout0_100) AT=465.025n

.meas tran vdout0_101ck920 FIND v(dout0_101) AT=465.025n

.meas tran vdout0_102ck920 FIND v(dout0_102) AT=465.025n

.meas tran vdout0_103ck920 FIND v(dout0_103) AT=465.025n

.meas tran vdout0_104ck920 FIND v(dout0_104) AT=465.025n

.meas tran vdout0_105ck920 FIND v(dout0_105) AT=465.025n

.meas tran vdout0_106ck920 FIND v(dout0_106) AT=465.025n

.meas tran vdout0_107ck920 FIND v(dout0_107) AT=465.025n

.meas tran vdout0_108ck920 FIND v(dout0_108) AT=465.025n

.meas tran vdout0_109ck920 FIND v(dout0_109) AT=465.025n

.meas tran vdout0_110ck920 FIND v(dout0_110) AT=465.025n

.meas tran vdout0_111ck920 FIND v(dout0_111) AT=465.025n

.meas tran vdout0_112ck920 FIND v(dout0_112) AT=465.025n

.meas tran vdout0_113ck920 FIND v(dout0_113) AT=465.025n

.meas tran vdout0_114ck920 FIND v(dout0_114) AT=465.025n

.meas tran vdout0_115ck920 FIND v(dout0_115) AT=465.025n

.meas tran vdout0_116ck920 FIND v(dout0_116) AT=465.025n

.meas tran vdout0_117ck920 FIND v(dout0_117) AT=465.025n

.meas tran vdout0_118ck920 FIND v(dout0_118) AT=465.025n

.meas tran vdout0_119ck920 FIND v(dout0_119) AT=465.025n

.meas tran vdout0_120ck920 FIND v(dout0_120) AT=465.025n

.meas tran vdout0_121ck920 FIND v(dout0_121) AT=465.025n

.meas tran vdout0_122ck920 FIND v(dout0_122) AT=465.025n

.meas tran vdout0_123ck920 FIND v(dout0_123) AT=465.025n

.meas tran vdout0_124ck920 FIND v(dout0_124) AT=465.025n

.meas tran vdout0_125ck920 FIND v(dout0_125) AT=465.025n

.meas tran vdout0_126ck920 FIND v(dout0_126) AT=465.025n

.meas tran vdout0_127ck920 FIND v(dout0_127) AT=465.025n

.meas tran vdout0_0ck930 FIND v(dout0_0) AT=470.025n

.meas tran vdout0_1ck930 FIND v(dout0_1) AT=470.025n

.meas tran vdout0_2ck930 FIND v(dout0_2) AT=470.025n

.meas tran vdout0_3ck930 FIND v(dout0_3) AT=470.025n

.meas tran vdout0_4ck930 FIND v(dout0_4) AT=470.025n

.meas tran vdout0_5ck930 FIND v(dout0_5) AT=470.025n

.meas tran vdout0_6ck930 FIND v(dout0_6) AT=470.025n

.meas tran vdout0_7ck930 FIND v(dout0_7) AT=470.025n

.meas tran vdout0_8ck930 FIND v(dout0_8) AT=470.025n

.meas tran vdout0_9ck930 FIND v(dout0_9) AT=470.025n

.meas tran vdout0_10ck930 FIND v(dout0_10) AT=470.025n

.meas tran vdout0_11ck930 FIND v(dout0_11) AT=470.025n

.meas tran vdout0_12ck930 FIND v(dout0_12) AT=470.025n

.meas tran vdout0_13ck930 FIND v(dout0_13) AT=470.025n

.meas tran vdout0_14ck930 FIND v(dout0_14) AT=470.025n

.meas tran vdout0_15ck930 FIND v(dout0_15) AT=470.025n

.meas tran vdout0_16ck930 FIND v(dout0_16) AT=470.025n

.meas tran vdout0_17ck930 FIND v(dout0_17) AT=470.025n

.meas tran vdout0_18ck930 FIND v(dout0_18) AT=470.025n

.meas tran vdout0_19ck930 FIND v(dout0_19) AT=470.025n

.meas tran vdout0_20ck930 FIND v(dout0_20) AT=470.025n

.meas tran vdout0_21ck930 FIND v(dout0_21) AT=470.025n

.meas tran vdout0_22ck930 FIND v(dout0_22) AT=470.025n

.meas tran vdout0_23ck930 FIND v(dout0_23) AT=470.025n

.meas tran vdout0_24ck930 FIND v(dout0_24) AT=470.025n

.meas tran vdout0_25ck930 FIND v(dout0_25) AT=470.025n

.meas tran vdout0_26ck930 FIND v(dout0_26) AT=470.025n

.meas tran vdout0_27ck930 FIND v(dout0_27) AT=470.025n

.meas tran vdout0_28ck930 FIND v(dout0_28) AT=470.025n

.meas tran vdout0_29ck930 FIND v(dout0_29) AT=470.025n

.meas tran vdout0_30ck930 FIND v(dout0_30) AT=470.025n

.meas tran vdout0_31ck930 FIND v(dout0_31) AT=470.025n

.meas tran vdout0_32ck930 FIND v(dout0_32) AT=470.025n

.meas tran vdout0_33ck930 FIND v(dout0_33) AT=470.025n

.meas tran vdout0_34ck930 FIND v(dout0_34) AT=470.025n

.meas tran vdout0_35ck930 FIND v(dout0_35) AT=470.025n

.meas tran vdout0_36ck930 FIND v(dout0_36) AT=470.025n

.meas tran vdout0_37ck930 FIND v(dout0_37) AT=470.025n

.meas tran vdout0_38ck930 FIND v(dout0_38) AT=470.025n

.meas tran vdout0_39ck930 FIND v(dout0_39) AT=470.025n

.meas tran vdout0_40ck930 FIND v(dout0_40) AT=470.025n

.meas tran vdout0_41ck930 FIND v(dout0_41) AT=470.025n

.meas tran vdout0_42ck930 FIND v(dout0_42) AT=470.025n

.meas tran vdout0_43ck930 FIND v(dout0_43) AT=470.025n

.meas tran vdout0_44ck930 FIND v(dout0_44) AT=470.025n

.meas tran vdout0_45ck930 FIND v(dout0_45) AT=470.025n

.meas tran vdout0_46ck930 FIND v(dout0_46) AT=470.025n

.meas tran vdout0_47ck930 FIND v(dout0_47) AT=470.025n

.meas tran vdout0_48ck930 FIND v(dout0_48) AT=470.025n

.meas tran vdout0_49ck930 FIND v(dout0_49) AT=470.025n

.meas tran vdout0_50ck930 FIND v(dout0_50) AT=470.025n

.meas tran vdout0_51ck930 FIND v(dout0_51) AT=470.025n

.meas tran vdout0_52ck930 FIND v(dout0_52) AT=470.025n

.meas tran vdout0_53ck930 FIND v(dout0_53) AT=470.025n

.meas tran vdout0_54ck930 FIND v(dout0_54) AT=470.025n

.meas tran vdout0_55ck930 FIND v(dout0_55) AT=470.025n

.meas tran vdout0_56ck930 FIND v(dout0_56) AT=470.025n

.meas tran vdout0_57ck930 FIND v(dout0_57) AT=470.025n

.meas tran vdout0_58ck930 FIND v(dout0_58) AT=470.025n

.meas tran vdout0_59ck930 FIND v(dout0_59) AT=470.025n

.meas tran vdout0_60ck930 FIND v(dout0_60) AT=470.025n

.meas tran vdout0_61ck930 FIND v(dout0_61) AT=470.025n

.meas tran vdout0_62ck930 FIND v(dout0_62) AT=470.025n

.meas tran vdout0_63ck930 FIND v(dout0_63) AT=470.025n

.meas tran vdout0_64ck930 FIND v(dout0_64) AT=470.025n

.meas tran vdout0_65ck930 FIND v(dout0_65) AT=470.025n

.meas tran vdout0_66ck930 FIND v(dout0_66) AT=470.025n

.meas tran vdout0_67ck930 FIND v(dout0_67) AT=470.025n

.meas tran vdout0_68ck930 FIND v(dout0_68) AT=470.025n

.meas tran vdout0_69ck930 FIND v(dout0_69) AT=470.025n

.meas tran vdout0_70ck930 FIND v(dout0_70) AT=470.025n

.meas tran vdout0_71ck930 FIND v(dout0_71) AT=470.025n

.meas tran vdout0_72ck930 FIND v(dout0_72) AT=470.025n

.meas tran vdout0_73ck930 FIND v(dout0_73) AT=470.025n

.meas tran vdout0_74ck930 FIND v(dout0_74) AT=470.025n

.meas tran vdout0_75ck930 FIND v(dout0_75) AT=470.025n

.meas tran vdout0_76ck930 FIND v(dout0_76) AT=470.025n

.meas tran vdout0_77ck930 FIND v(dout0_77) AT=470.025n

.meas tran vdout0_78ck930 FIND v(dout0_78) AT=470.025n

.meas tran vdout0_79ck930 FIND v(dout0_79) AT=470.025n

.meas tran vdout0_80ck930 FIND v(dout0_80) AT=470.025n

.meas tran vdout0_81ck930 FIND v(dout0_81) AT=470.025n

.meas tran vdout0_82ck930 FIND v(dout0_82) AT=470.025n

.meas tran vdout0_83ck930 FIND v(dout0_83) AT=470.025n

.meas tran vdout0_84ck930 FIND v(dout0_84) AT=470.025n

.meas tran vdout0_85ck930 FIND v(dout0_85) AT=470.025n

.meas tran vdout0_86ck930 FIND v(dout0_86) AT=470.025n

.meas tran vdout0_87ck930 FIND v(dout0_87) AT=470.025n

.meas tran vdout0_88ck930 FIND v(dout0_88) AT=470.025n

.meas tran vdout0_89ck930 FIND v(dout0_89) AT=470.025n

.meas tran vdout0_90ck930 FIND v(dout0_90) AT=470.025n

.meas tran vdout0_91ck930 FIND v(dout0_91) AT=470.025n

.meas tran vdout0_92ck930 FIND v(dout0_92) AT=470.025n

.meas tran vdout0_93ck930 FIND v(dout0_93) AT=470.025n

.meas tran vdout0_94ck930 FIND v(dout0_94) AT=470.025n

.meas tran vdout0_95ck930 FIND v(dout0_95) AT=470.025n

.meas tran vdout0_96ck930 FIND v(dout0_96) AT=470.025n

.meas tran vdout0_97ck930 FIND v(dout0_97) AT=470.025n

.meas tran vdout0_98ck930 FIND v(dout0_98) AT=470.025n

.meas tran vdout0_99ck930 FIND v(dout0_99) AT=470.025n

.meas tran vdout0_100ck930 FIND v(dout0_100) AT=470.025n

.meas tran vdout0_101ck930 FIND v(dout0_101) AT=470.025n

.meas tran vdout0_102ck930 FIND v(dout0_102) AT=470.025n

.meas tran vdout0_103ck930 FIND v(dout0_103) AT=470.025n

.meas tran vdout0_104ck930 FIND v(dout0_104) AT=470.025n

.meas tran vdout0_105ck930 FIND v(dout0_105) AT=470.025n

.meas tran vdout0_106ck930 FIND v(dout0_106) AT=470.025n

.meas tran vdout0_107ck930 FIND v(dout0_107) AT=470.025n

.meas tran vdout0_108ck930 FIND v(dout0_108) AT=470.025n

.meas tran vdout0_109ck930 FIND v(dout0_109) AT=470.025n

.meas tran vdout0_110ck930 FIND v(dout0_110) AT=470.025n

.meas tran vdout0_111ck930 FIND v(dout0_111) AT=470.025n

.meas tran vdout0_112ck930 FIND v(dout0_112) AT=470.025n

.meas tran vdout0_113ck930 FIND v(dout0_113) AT=470.025n

.meas tran vdout0_114ck930 FIND v(dout0_114) AT=470.025n

.meas tran vdout0_115ck930 FIND v(dout0_115) AT=470.025n

.meas tran vdout0_116ck930 FIND v(dout0_116) AT=470.025n

.meas tran vdout0_117ck930 FIND v(dout0_117) AT=470.025n

.meas tran vdout0_118ck930 FIND v(dout0_118) AT=470.025n

.meas tran vdout0_119ck930 FIND v(dout0_119) AT=470.025n

.meas tran vdout0_120ck930 FIND v(dout0_120) AT=470.025n

.meas tran vdout0_121ck930 FIND v(dout0_121) AT=470.025n

.meas tran vdout0_122ck930 FIND v(dout0_122) AT=470.025n

.meas tran vdout0_123ck930 FIND v(dout0_123) AT=470.025n

.meas tran vdout0_124ck930 FIND v(dout0_124) AT=470.025n

.meas tran vdout0_125ck930 FIND v(dout0_125) AT=470.025n

.meas tran vdout0_126ck930 FIND v(dout0_126) AT=470.025n

.meas tran vdout0_127ck930 FIND v(dout0_127) AT=470.025n

.meas tran vdout0_0ck960 FIND v(dout0_0) AT=485.025n

.meas tran vdout0_1ck960 FIND v(dout0_1) AT=485.025n

.meas tran vdout0_2ck960 FIND v(dout0_2) AT=485.025n

.meas tran vdout0_3ck960 FIND v(dout0_3) AT=485.025n

.meas tran vdout0_4ck960 FIND v(dout0_4) AT=485.025n

.meas tran vdout0_5ck960 FIND v(dout0_5) AT=485.025n

.meas tran vdout0_6ck960 FIND v(dout0_6) AT=485.025n

.meas tran vdout0_7ck960 FIND v(dout0_7) AT=485.025n

.meas tran vdout0_8ck960 FIND v(dout0_8) AT=485.025n

.meas tran vdout0_9ck960 FIND v(dout0_9) AT=485.025n

.meas tran vdout0_10ck960 FIND v(dout0_10) AT=485.025n

.meas tran vdout0_11ck960 FIND v(dout0_11) AT=485.025n

.meas tran vdout0_12ck960 FIND v(dout0_12) AT=485.025n

.meas tran vdout0_13ck960 FIND v(dout0_13) AT=485.025n

.meas tran vdout0_14ck960 FIND v(dout0_14) AT=485.025n

.meas tran vdout0_15ck960 FIND v(dout0_15) AT=485.025n

.meas tran vdout0_16ck960 FIND v(dout0_16) AT=485.025n

.meas tran vdout0_17ck960 FIND v(dout0_17) AT=485.025n

.meas tran vdout0_18ck960 FIND v(dout0_18) AT=485.025n

.meas tran vdout0_19ck960 FIND v(dout0_19) AT=485.025n

.meas tran vdout0_20ck960 FIND v(dout0_20) AT=485.025n

.meas tran vdout0_21ck960 FIND v(dout0_21) AT=485.025n

.meas tran vdout0_22ck960 FIND v(dout0_22) AT=485.025n

.meas tran vdout0_23ck960 FIND v(dout0_23) AT=485.025n

.meas tran vdout0_24ck960 FIND v(dout0_24) AT=485.025n

.meas tran vdout0_25ck960 FIND v(dout0_25) AT=485.025n

.meas tran vdout0_26ck960 FIND v(dout0_26) AT=485.025n

.meas tran vdout0_27ck960 FIND v(dout0_27) AT=485.025n

.meas tran vdout0_28ck960 FIND v(dout0_28) AT=485.025n

.meas tran vdout0_29ck960 FIND v(dout0_29) AT=485.025n

.meas tran vdout0_30ck960 FIND v(dout0_30) AT=485.025n

.meas tran vdout0_31ck960 FIND v(dout0_31) AT=485.025n

.meas tran vdout0_32ck960 FIND v(dout0_32) AT=485.025n

.meas tran vdout0_33ck960 FIND v(dout0_33) AT=485.025n

.meas tran vdout0_34ck960 FIND v(dout0_34) AT=485.025n

.meas tran vdout0_35ck960 FIND v(dout0_35) AT=485.025n

.meas tran vdout0_36ck960 FIND v(dout0_36) AT=485.025n

.meas tran vdout0_37ck960 FIND v(dout0_37) AT=485.025n

.meas tran vdout0_38ck960 FIND v(dout0_38) AT=485.025n

.meas tran vdout0_39ck960 FIND v(dout0_39) AT=485.025n

.meas tran vdout0_40ck960 FIND v(dout0_40) AT=485.025n

.meas tran vdout0_41ck960 FIND v(dout0_41) AT=485.025n

.meas tran vdout0_42ck960 FIND v(dout0_42) AT=485.025n

.meas tran vdout0_43ck960 FIND v(dout0_43) AT=485.025n

.meas tran vdout0_44ck960 FIND v(dout0_44) AT=485.025n

.meas tran vdout0_45ck960 FIND v(dout0_45) AT=485.025n

.meas tran vdout0_46ck960 FIND v(dout0_46) AT=485.025n

.meas tran vdout0_47ck960 FIND v(dout0_47) AT=485.025n

.meas tran vdout0_48ck960 FIND v(dout0_48) AT=485.025n

.meas tran vdout0_49ck960 FIND v(dout0_49) AT=485.025n

.meas tran vdout0_50ck960 FIND v(dout0_50) AT=485.025n

.meas tran vdout0_51ck960 FIND v(dout0_51) AT=485.025n

.meas tran vdout0_52ck960 FIND v(dout0_52) AT=485.025n

.meas tran vdout0_53ck960 FIND v(dout0_53) AT=485.025n

.meas tran vdout0_54ck960 FIND v(dout0_54) AT=485.025n

.meas tran vdout0_55ck960 FIND v(dout0_55) AT=485.025n

.meas tran vdout0_56ck960 FIND v(dout0_56) AT=485.025n

.meas tran vdout0_57ck960 FIND v(dout0_57) AT=485.025n

.meas tran vdout0_58ck960 FIND v(dout0_58) AT=485.025n

.meas tran vdout0_59ck960 FIND v(dout0_59) AT=485.025n

.meas tran vdout0_60ck960 FIND v(dout0_60) AT=485.025n

.meas tran vdout0_61ck960 FIND v(dout0_61) AT=485.025n

.meas tran vdout0_62ck960 FIND v(dout0_62) AT=485.025n

.meas tran vdout0_63ck960 FIND v(dout0_63) AT=485.025n

.meas tran vdout0_64ck960 FIND v(dout0_64) AT=485.025n

.meas tran vdout0_65ck960 FIND v(dout0_65) AT=485.025n

.meas tran vdout0_66ck960 FIND v(dout0_66) AT=485.025n

.meas tran vdout0_67ck960 FIND v(dout0_67) AT=485.025n

.meas tran vdout0_68ck960 FIND v(dout0_68) AT=485.025n

.meas tran vdout0_69ck960 FIND v(dout0_69) AT=485.025n

.meas tran vdout0_70ck960 FIND v(dout0_70) AT=485.025n

.meas tran vdout0_71ck960 FIND v(dout0_71) AT=485.025n

.meas tran vdout0_72ck960 FIND v(dout0_72) AT=485.025n

.meas tran vdout0_73ck960 FIND v(dout0_73) AT=485.025n

.meas tran vdout0_74ck960 FIND v(dout0_74) AT=485.025n

.meas tran vdout0_75ck960 FIND v(dout0_75) AT=485.025n

.meas tran vdout0_76ck960 FIND v(dout0_76) AT=485.025n

.meas tran vdout0_77ck960 FIND v(dout0_77) AT=485.025n

.meas tran vdout0_78ck960 FIND v(dout0_78) AT=485.025n

.meas tran vdout0_79ck960 FIND v(dout0_79) AT=485.025n

.meas tran vdout0_80ck960 FIND v(dout0_80) AT=485.025n

.meas tran vdout0_81ck960 FIND v(dout0_81) AT=485.025n

.meas tran vdout0_82ck960 FIND v(dout0_82) AT=485.025n

.meas tran vdout0_83ck960 FIND v(dout0_83) AT=485.025n

.meas tran vdout0_84ck960 FIND v(dout0_84) AT=485.025n

.meas tran vdout0_85ck960 FIND v(dout0_85) AT=485.025n

.meas tran vdout0_86ck960 FIND v(dout0_86) AT=485.025n

.meas tran vdout0_87ck960 FIND v(dout0_87) AT=485.025n

.meas tran vdout0_88ck960 FIND v(dout0_88) AT=485.025n

.meas tran vdout0_89ck960 FIND v(dout0_89) AT=485.025n

.meas tran vdout0_90ck960 FIND v(dout0_90) AT=485.025n

.meas tran vdout0_91ck960 FIND v(dout0_91) AT=485.025n

.meas tran vdout0_92ck960 FIND v(dout0_92) AT=485.025n

.meas tran vdout0_93ck960 FIND v(dout0_93) AT=485.025n

.meas tran vdout0_94ck960 FIND v(dout0_94) AT=485.025n

.meas tran vdout0_95ck960 FIND v(dout0_95) AT=485.025n

.meas tran vdout0_96ck960 FIND v(dout0_96) AT=485.025n

.meas tran vdout0_97ck960 FIND v(dout0_97) AT=485.025n

.meas tran vdout0_98ck960 FIND v(dout0_98) AT=485.025n

.meas tran vdout0_99ck960 FIND v(dout0_99) AT=485.025n

.meas tran vdout0_100ck960 FIND v(dout0_100) AT=485.025n

.meas tran vdout0_101ck960 FIND v(dout0_101) AT=485.025n

.meas tran vdout0_102ck960 FIND v(dout0_102) AT=485.025n

.meas tran vdout0_103ck960 FIND v(dout0_103) AT=485.025n

.meas tran vdout0_104ck960 FIND v(dout0_104) AT=485.025n

.meas tran vdout0_105ck960 FIND v(dout0_105) AT=485.025n

.meas tran vdout0_106ck960 FIND v(dout0_106) AT=485.025n

.meas tran vdout0_107ck960 FIND v(dout0_107) AT=485.025n

.meas tran vdout0_108ck960 FIND v(dout0_108) AT=485.025n

.meas tran vdout0_109ck960 FIND v(dout0_109) AT=485.025n

.meas tran vdout0_110ck960 FIND v(dout0_110) AT=485.025n

.meas tran vdout0_111ck960 FIND v(dout0_111) AT=485.025n

.meas tran vdout0_112ck960 FIND v(dout0_112) AT=485.025n

.meas tran vdout0_113ck960 FIND v(dout0_113) AT=485.025n

.meas tran vdout0_114ck960 FIND v(dout0_114) AT=485.025n

.meas tran vdout0_115ck960 FIND v(dout0_115) AT=485.025n

.meas tran vdout0_116ck960 FIND v(dout0_116) AT=485.025n

.meas tran vdout0_117ck960 FIND v(dout0_117) AT=485.025n

.meas tran vdout0_118ck960 FIND v(dout0_118) AT=485.025n

.meas tran vdout0_119ck960 FIND v(dout0_119) AT=485.025n

.meas tran vdout0_120ck960 FIND v(dout0_120) AT=485.025n

.meas tran vdout0_121ck960 FIND v(dout0_121) AT=485.025n

.meas tran vdout0_122ck960 FIND v(dout0_122) AT=485.025n

.meas tran vdout0_123ck960 FIND v(dout0_123) AT=485.025n

.meas tran vdout0_124ck960 FIND v(dout0_124) AT=485.025n

.meas tran vdout0_125ck960 FIND v(dout0_125) AT=485.025n

.meas tran vdout0_126ck960 FIND v(dout0_126) AT=485.025n

.meas tran vdout0_127ck960 FIND v(dout0_127) AT=485.025n

.meas tran vdout0_0ck980 FIND v(dout0_0) AT=495.025n

.meas tran vdout0_1ck980 FIND v(dout0_1) AT=495.025n

.meas tran vdout0_2ck980 FIND v(dout0_2) AT=495.025n

.meas tran vdout0_3ck980 FIND v(dout0_3) AT=495.025n

.meas tran vdout0_4ck980 FIND v(dout0_4) AT=495.025n

.meas tran vdout0_5ck980 FIND v(dout0_5) AT=495.025n

.meas tran vdout0_6ck980 FIND v(dout0_6) AT=495.025n

.meas tran vdout0_7ck980 FIND v(dout0_7) AT=495.025n

.meas tran vdout0_8ck980 FIND v(dout0_8) AT=495.025n

.meas tran vdout0_9ck980 FIND v(dout0_9) AT=495.025n

.meas tran vdout0_10ck980 FIND v(dout0_10) AT=495.025n

.meas tran vdout0_11ck980 FIND v(dout0_11) AT=495.025n

.meas tran vdout0_12ck980 FIND v(dout0_12) AT=495.025n

.meas tran vdout0_13ck980 FIND v(dout0_13) AT=495.025n

.meas tran vdout0_14ck980 FIND v(dout0_14) AT=495.025n

.meas tran vdout0_15ck980 FIND v(dout0_15) AT=495.025n

.meas tran vdout0_16ck980 FIND v(dout0_16) AT=495.025n

.meas tran vdout0_17ck980 FIND v(dout0_17) AT=495.025n

.meas tran vdout0_18ck980 FIND v(dout0_18) AT=495.025n

.meas tran vdout0_19ck980 FIND v(dout0_19) AT=495.025n

.meas tran vdout0_20ck980 FIND v(dout0_20) AT=495.025n

.meas tran vdout0_21ck980 FIND v(dout0_21) AT=495.025n

.meas tran vdout0_22ck980 FIND v(dout0_22) AT=495.025n

.meas tran vdout0_23ck980 FIND v(dout0_23) AT=495.025n

.meas tran vdout0_24ck980 FIND v(dout0_24) AT=495.025n

.meas tran vdout0_25ck980 FIND v(dout0_25) AT=495.025n

.meas tran vdout0_26ck980 FIND v(dout0_26) AT=495.025n

.meas tran vdout0_27ck980 FIND v(dout0_27) AT=495.025n

.meas tran vdout0_28ck980 FIND v(dout0_28) AT=495.025n

.meas tran vdout0_29ck980 FIND v(dout0_29) AT=495.025n

.meas tran vdout0_30ck980 FIND v(dout0_30) AT=495.025n

.meas tran vdout0_31ck980 FIND v(dout0_31) AT=495.025n

.meas tran vdout0_32ck980 FIND v(dout0_32) AT=495.025n

.meas tran vdout0_33ck980 FIND v(dout0_33) AT=495.025n

.meas tran vdout0_34ck980 FIND v(dout0_34) AT=495.025n

.meas tran vdout0_35ck980 FIND v(dout0_35) AT=495.025n

.meas tran vdout0_36ck980 FIND v(dout0_36) AT=495.025n

.meas tran vdout0_37ck980 FIND v(dout0_37) AT=495.025n

.meas tran vdout0_38ck980 FIND v(dout0_38) AT=495.025n

.meas tran vdout0_39ck980 FIND v(dout0_39) AT=495.025n

.meas tran vdout0_40ck980 FIND v(dout0_40) AT=495.025n

.meas tran vdout0_41ck980 FIND v(dout0_41) AT=495.025n

.meas tran vdout0_42ck980 FIND v(dout0_42) AT=495.025n

.meas tran vdout0_43ck980 FIND v(dout0_43) AT=495.025n

.meas tran vdout0_44ck980 FIND v(dout0_44) AT=495.025n

.meas tran vdout0_45ck980 FIND v(dout0_45) AT=495.025n

.meas tran vdout0_46ck980 FIND v(dout0_46) AT=495.025n

.meas tran vdout0_47ck980 FIND v(dout0_47) AT=495.025n

.meas tran vdout0_48ck980 FIND v(dout0_48) AT=495.025n

.meas tran vdout0_49ck980 FIND v(dout0_49) AT=495.025n

.meas tran vdout0_50ck980 FIND v(dout0_50) AT=495.025n

.meas tran vdout0_51ck980 FIND v(dout0_51) AT=495.025n

.meas tran vdout0_52ck980 FIND v(dout0_52) AT=495.025n

.meas tran vdout0_53ck980 FIND v(dout0_53) AT=495.025n

.meas tran vdout0_54ck980 FIND v(dout0_54) AT=495.025n

.meas tran vdout0_55ck980 FIND v(dout0_55) AT=495.025n

.meas tran vdout0_56ck980 FIND v(dout0_56) AT=495.025n

.meas tran vdout0_57ck980 FIND v(dout0_57) AT=495.025n

.meas tran vdout0_58ck980 FIND v(dout0_58) AT=495.025n

.meas tran vdout0_59ck980 FIND v(dout0_59) AT=495.025n

.meas tran vdout0_60ck980 FIND v(dout0_60) AT=495.025n

.meas tran vdout0_61ck980 FIND v(dout0_61) AT=495.025n

.meas tran vdout0_62ck980 FIND v(dout0_62) AT=495.025n

.meas tran vdout0_63ck980 FIND v(dout0_63) AT=495.025n

.meas tran vdout0_64ck980 FIND v(dout0_64) AT=495.025n

.meas tran vdout0_65ck980 FIND v(dout0_65) AT=495.025n

.meas tran vdout0_66ck980 FIND v(dout0_66) AT=495.025n

.meas tran vdout0_67ck980 FIND v(dout0_67) AT=495.025n

.meas tran vdout0_68ck980 FIND v(dout0_68) AT=495.025n

.meas tran vdout0_69ck980 FIND v(dout0_69) AT=495.025n

.meas tran vdout0_70ck980 FIND v(dout0_70) AT=495.025n

.meas tran vdout0_71ck980 FIND v(dout0_71) AT=495.025n

.meas tran vdout0_72ck980 FIND v(dout0_72) AT=495.025n

.meas tran vdout0_73ck980 FIND v(dout0_73) AT=495.025n

.meas tran vdout0_74ck980 FIND v(dout0_74) AT=495.025n

.meas tran vdout0_75ck980 FIND v(dout0_75) AT=495.025n

.meas tran vdout0_76ck980 FIND v(dout0_76) AT=495.025n

.meas tran vdout0_77ck980 FIND v(dout0_77) AT=495.025n

.meas tran vdout0_78ck980 FIND v(dout0_78) AT=495.025n

.meas tran vdout0_79ck980 FIND v(dout0_79) AT=495.025n

.meas tran vdout0_80ck980 FIND v(dout0_80) AT=495.025n

.meas tran vdout0_81ck980 FIND v(dout0_81) AT=495.025n

.meas tran vdout0_82ck980 FIND v(dout0_82) AT=495.025n

.meas tran vdout0_83ck980 FIND v(dout0_83) AT=495.025n

.meas tran vdout0_84ck980 FIND v(dout0_84) AT=495.025n

.meas tran vdout0_85ck980 FIND v(dout0_85) AT=495.025n

.meas tran vdout0_86ck980 FIND v(dout0_86) AT=495.025n

.meas tran vdout0_87ck980 FIND v(dout0_87) AT=495.025n

.meas tran vdout0_88ck980 FIND v(dout0_88) AT=495.025n

.meas tran vdout0_89ck980 FIND v(dout0_89) AT=495.025n

.meas tran vdout0_90ck980 FIND v(dout0_90) AT=495.025n

.meas tran vdout0_91ck980 FIND v(dout0_91) AT=495.025n

.meas tran vdout0_92ck980 FIND v(dout0_92) AT=495.025n

.meas tran vdout0_93ck980 FIND v(dout0_93) AT=495.025n

.meas tran vdout0_94ck980 FIND v(dout0_94) AT=495.025n

.meas tran vdout0_95ck980 FIND v(dout0_95) AT=495.025n

.meas tran vdout0_96ck980 FIND v(dout0_96) AT=495.025n

.meas tran vdout0_97ck980 FIND v(dout0_97) AT=495.025n

.meas tran vdout0_98ck980 FIND v(dout0_98) AT=495.025n

.meas tran vdout0_99ck980 FIND v(dout0_99) AT=495.025n

.meas tran vdout0_100ck980 FIND v(dout0_100) AT=495.025n

.meas tran vdout0_101ck980 FIND v(dout0_101) AT=495.025n

.meas tran vdout0_102ck980 FIND v(dout0_102) AT=495.025n

.meas tran vdout0_103ck980 FIND v(dout0_103) AT=495.025n

.meas tran vdout0_104ck980 FIND v(dout0_104) AT=495.025n

.meas tran vdout0_105ck980 FIND v(dout0_105) AT=495.025n

.meas tran vdout0_106ck980 FIND v(dout0_106) AT=495.025n

.meas tran vdout0_107ck980 FIND v(dout0_107) AT=495.025n

.meas tran vdout0_108ck980 FIND v(dout0_108) AT=495.025n

.meas tran vdout0_109ck980 FIND v(dout0_109) AT=495.025n

.meas tran vdout0_110ck980 FIND v(dout0_110) AT=495.025n

.meas tran vdout0_111ck980 FIND v(dout0_111) AT=495.025n

.meas tran vdout0_112ck980 FIND v(dout0_112) AT=495.025n

.meas tran vdout0_113ck980 FIND v(dout0_113) AT=495.025n

.meas tran vdout0_114ck980 FIND v(dout0_114) AT=495.025n

.meas tran vdout0_115ck980 FIND v(dout0_115) AT=495.025n

.meas tran vdout0_116ck980 FIND v(dout0_116) AT=495.025n

.meas tran vdout0_117ck980 FIND v(dout0_117) AT=495.025n

.meas tran vdout0_118ck980 FIND v(dout0_118) AT=495.025n

.meas tran vdout0_119ck980 FIND v(dout0_119) AT=495.025n

.meas tran vdout0_120ck980 FIND v(dout0_120) AT=495.025n

.meas tran vdout0_121ck980 FIND v(dout0_121) AT=495.025n

.meas tran vdout0_122ck980 FIND v(dout0_122) AT=495.025n

.meas tran vdout0_123ck980 FIND v(dout0_123) AT=495.025n

.meas tran vdout0_124ck980 FIND v(dout0_124) AT=495.025n

.meas tran vdout0_125ck980 FIND v(dout0_125) AT=495.025n

.meas tran vdout0_126ck980 FIND v(dout0_126) AT=495.025n

.meas tran vdout0_127ck980 FIND v(dout0_127) AT=495.025n

.meas tran vdout0_0ck1030 FIND v(dout0_0) AT=520.025n

.meas tran vdout0_1ck1030 FIND v(dout0_1) AT=520.025n

.meas tran vdout0_2ck1030 FIND v(dout0_2) AT=520.025n

.meas tran vdout0_3ck1030 FIND v(dout0_3) AT=520.025n

.meas tran vdout0_4ck1030 FIND v(dout0_4) AT=520.025n

.meas tran vdout0_5ck1030 FIND v(dout0_5) AT=520.025n

.meas tran vdout0_6ck1030 FIND v(dout0_6) AT=520.025n

.meas tran vdout0_7ck1030 FIND v(dout0_7) AT=520.025n

.meas tran vdout0_8ck1030 FIND v(dout0_8) AT=520.025n

.meas tran vdout0_9ck1030 FIND v(dout0_9) AT=520.025n

.meas tran vdout0_10ck1030 FIND v(dout0_10) AT=520.025n

.meas tran vdout0_11ck1030 FIND v(dout0_11) AT=520.025n

.meas tran vdout0_12ck1030 FIND v(dout0_12) AT=520.025n

.meas tran vdout0_13ck1030 FIND v(dout0_13) AT=520.025n

.meas tran vdout0_14ck1030 FIND v(dout0_14) AT=520.025n

.meas tran vdout0_15ck1030 FIND v(dout0_15) AT=520.025n

.meas tran vdout0_16ck1030 FIND v(dout0_16) AT=520.025n

.meas tran vdout0_17ck1030 FIND v(dout0_17) AT=520.025n

.meas tran vdout0_18ck1030 FIND v(dout0_18) AT=520.025n

.meas tran vdout0_19ck1030 FIND v(dout0_19) AT=520.025n

.meas tran vdout0_20ck1030 FIND v(dout0_20) AT=520.025n

.meas tran vdout0_21ck1030 FIND v(dout0_21) AT=520.025n

.meas tran vdout0_22ck1030 FIND v(dout0_22) AT=520.025n

.meas tran vdout0_23ck1030 FIND v(dout0_23) AT=520.025n

.meas tran vdout0_24ck1030 FIND v(dout0_24) AT=520.025n

.meas tran vdout0_25ck1030 FIND v(dout0_25) AT=520.025n

.meas tran vdout0_26ck1030 FIND v(dout0_26) AT=520.025n

.meas tran vdout0_27ck1030 FIND v(dout0_27) AT=520.025n

.meas tran vdout0_28ck1030 FIND v(dout0_28) AT=520.025n

.meas tran vdout0_29ck1030 FIND v(dout0_29) AT=520.025n

.meas tran vdout0_30ck1030 FIND v(dout0_30) AT=520.025n

.meas tran vdout0_31ck1030 FIND v(dout0_31) AT=520.025n

.meas tran vdout0_32ck1030 FIND v(dout0_32) AT=520.025n

.meas tran vdout0_33ck1030 FIND v(dout0_33) AT=520.025n

.meas tran vdout0_34ck1030 FIND v(dout0_34) AT=520.025n

.meas tran vdout0_35ck1030 FIND v(dout0_35) AT=520.025n

.meas tran vdout0_36ck1030 FIND v(dout0_36) AT=520.025n

.meas tran vdout0_37ck1030 FIND v(dout0_37) AT=520.025n

.meas tran vdout0_38ck1030 FIND v(dout0_38) AT=520.025n

.meas tran vdout0_39ck1030 FIND v(dout0_39) AT=520.025n

.meas tran vdout0_40ck1030 FIND v(dout0_40) AT=520.025n

.meas tran vdout0_41ck1030 FIND v(dout0_41) AT=520.025n

.meas tran vdout0_42ck1030 FIND v(dout0_42) AT=520.025n

.meas tran vdout0_43ck1030 FIND v(dout0_43) AT=520.025n

.meas tran vdout0_44ck1030 FIND v(dout0_44) AT=520.025n

.meas tran vdout0_45ck1030 FIND v(dout0_45) AT=520.025n

.meas tran vdout0_46ck1030 FIND v(dout0_46) AT=520.025n

.meas tran vdout0_47ck1030 FIND v(dout0_47) AT=520.025n

.meas tran vdout0_48ck1030 FIND v(dout0_48) AT=520.025n

.meas tran vdout0_49ck1030 FIND v(dout0_49) AT=520.025n

.meas tran vdout0_50ck1030 FIND v(dout0_50) AT=520.025n

.meas tran vdout0_51ck1030 FIND v(dout0_51) AT=520.025n

.meas tran vdout0_52ck1030 FIND v(dout0_52) AT=520.025n

.meas tran vdout0_53ck1030 FIND v(dout0_53) AT=520.025n

.meas tran vdout0_54ck1030 FIND v(dout0_54) AT=520.025n

.meas tran vdout0_55ck1030 FIND v(dout0_55) AT=520.025n

.meas tran vdout0_56ck1030 FIND v(dout0_56) AT=520.025n

.meas tran vdout0_57ck1030 FIND v(dout0_57) AT=520.025n

.meas tran vdout0_58ck1030 FIND v(dout0_58) AT=520.025n

.meas tran vdout0_59ck1030 FIND v(dout0_59) AT=520.025n

.meas tran vdout0_60ck1030 FIND v(dout0_60) AT=520.025n

.meas tran vdout0_61ck1030 FIND v(dout0_61) AT=520.025n

.meas tran vdout0_62ck1030 FIND v(dout0_62) AT=520.025n

.meas tran vdout0_63ck1030 FIND v(dout0_63) AT=520.025n

.meas tran vdout0_64ck1030 FIND v(dout0_64) AT=520.025n

.meas tran vdout0_65ck1030 FIND v(dout0_65) AT=520.025n

.meas tran vdout0_66ck1030 FIND v(dout0_66) AT=520.025n

.meas tran vdout0_67ck1030 FIND v(dout0_67) AT=520.025n

.meas tran vdout0_68ck1030 FIND v(dout0_68) AT=520.025n

.meas tran vdout0_69ck1030 FIND v(dout0_69) AT=520.025n

.meas tran vdout0_70ck1030 FIND v(dout0_70) AT=520.025n

.meas tran vdout0_71ck1030 FIND v(dout0_71) AT=520.025n

.meas tran vdout0_72ck1030 FIND v(dout0_72) AT=520.025n

.meas tran vdout0_73ck1030 FIND v(dout0_73) AT=520.025n

.meas tran vdout0_74ck1030 FIND v(dout0_74) AT=520.025n

.meas tran vdout0_75ck1030 FIND v(dout0_75) AT=520.025n

.meas tran vdout0_76ck1030 FIND v(dout0_76) AT=520.025n

.meas tran vdout0_77ck1030 FIND v(dout0_77) AT=520.025n

.meas tran vdout0_78ck1030 FIND v(dout0_78) AT=520.025n

.meas tran vdout0_79ck1030 FIND v(dout0_79) AT=520.025n

.meas tran vdout0_80ck1030 FIND v(dout0_80) AT=520.025n

.meas tran vdout0_81ck1030 FIND v(dout0_81) AT=520.025n

.meas tran vdout0_82ck1030 FIND v(dout0_82) AT=520.025n

.meas tran vdout0_83ck1030 FIND v(dout0_83) AT=520.025n

.meas tran vdout0_84ck1030 FIND v(dout0_84) AT=520.025n

.meas tran vdout0_85ck1030 FIND v(dout0_85) AT=520.025n

.meas tran vdout0_86ck1030 FIND v(dout0_86) AT=520.025n

.meas tran vdout0_87ck1030 FIND v(dout0_87) AT=520.025n

.meas tran vdout0_88ck1030 FIND v(dout0_88) AT=520.025n

.meas tran vdout0_89ck1030 FIND v(dout0_89) AT=520.025n

.meas tran vdout0_90ck1030 FIND v(dout0_90) AT=520.025n

.meas tran vdout0_91ck1030 FIND v(dout0_91) AT=520.025n

.meas tran vdout0_92ck1030 FIND v(dout0_92) AT=520.025n

.meas tran vdout0_93ck1030 FIND v(dout0_93) AT=520.025n

.meas tran vdout0_94ck1030 FIND v(dout0_94) AT=520.025n

.meas tran vdout0_95ck1030 FIND v(dout0_95) AT=520.025n

.meas tran vdout0_96ck1030 FIND v(dout0_96) AT=520.025n

.meas tran vdout0_97ck1030 FIND v(dout0_97) AT=520.025n

.meas tran vdout0_98ck1030 FIND v(dout0_98) AT=520.025n

.meas tran vdout0_99ck1030 FIND v(dout0_99) AT=520.025n

.meas tran vdout0_100ck1030 FIND v(dout0_100) AT=520.025n

.meas tran vdout0_101ck1030 FIND v(dout0_101) AT=520.025n

.meas tran vdout0_102ck1030 FIND v(dout0_102) AT=520.025n

.meas tran vdout0_103ck1030 FIND v(dout0_103) AT=520.025n

.meas tran vdout0_104ck1030 FIND v(dout0_104) AT=520.025n

.meas tran vdout0_105ck1030 FIND v(dout0_105) AT=520.025n

.meas tran vdout0_106ck1030 FIND v(dout0_106) AT=520.025n

.meas tran vdout0_107ck1030 FIND v(dout0_107) AT=520.025n

.meas tran vdout0_108ck1030 FIND v(dout0_108) AT=520.025n

.meas tran vdout0_109ck1030 FIND v(dout0_109) AT=520.025n

.meas tran vdout0_110ck1030 FIND v(dout0_110) AT=520.025n

.meas tran vdout0_111ck1030 FIND v(dout0_111) AT=520.025n

.meas tran vdout0_112ck1030 FIND v(dout0_112) AT=520.025n

.meas tran vdout0_113ck1030 FIND v(dout0_113) AT=520.025n

.meas tran vdout0_114ck1030 FIND v(dout0_114) AT=520.025n

.meas tran vdout0_115ck1030 FIND v(dout0_115) AT=520.025n

.meas tran vdout0_116ck1030 FIND v(dout0_116) AT=520.025n

.meas tran vdout0_117ck1030 FIND v(dout0_117) AT=520.025n

.meas tran vdout0_118ck1030 FIND v(dout0_118) AT=520.025n

.meas tran vdout0_119ck1030 FIND v(dout0_119) AT=520.025n

.meas tran vdout0_120ck1030 FIND v(dout0_120) AT=520.025n

.meas tran vdout0_121ck1030 FIND v(dout0_121) AT=520.025n

.meas tran vdout0_122ck1030 FIND v(dout0_122) AT=520.025n

.meas tran vdout0_123ck1030 FIND v(dout0_123) AT=520.025n

.meas tran vdout0_124ck1030 FIND v(dout0_124) AT=520.025n

.meas tran vdout0_125ck1030 FIND v(dout0_125) AT=520.025n

.meas tran vdout0_126ck1030 FIND v(dout0_126) AT=520.025n

.meas tran vdout0_127ck1030 FIND v(dout0_127) AT=520.025n

.meas tran vdout0_0ck1060 FIND v(dout0_0) AT=535.025n

.meas tran vdout0_1ck1060 FIND v(dout0_1) AT=535.025n

.meas tran vdout0_2ck1060 FIND v(dout0_2) AT=535.025n

.meas tran vdout0_3ck1060 FIND v(dout0_3) AT=535.025n

.meas tran vdout0_4ck1060 FIND v(dout0_4) AT=535.025n

.meas tran vdout0_5ck1060 FIND v(dout0_5) AT=535.025n

.meas tran vdout0_6ck1060 FIND v(dout0_6) AT=535.025n

.meas tran vdout0_7ck1060 FIND v(dout0_7) AT=535.025n

.meas tran vdout0_8ck1060 FIND v(dout0_8) AT=535.025n

.meas tran vdout0_9ck1060 FIND v(dout0_9) AT=535.025n

.meas tran vdout0_10ck1060 FIND v(dout0_10) AT=535.025n

.meas tran vdout0_11ck1060 FIND v(dout0_11) AT=535.025n

.meas tran vdout0_12ck1060 FIND v(dout0_12) AT=535.025n

.meas tran vdout0_13ck1060 FIND v(dout0_13) AT=535.025n

.meas tran vdout0_14ck1060 FIND v(dout0_14) AT=535.025n

.meas tran vdout0_15ck1060 FIND v(dout0_15) AT=535.025n

.meas tran vdout0_16ck1060 FIND v(dout0_16) AT=535.025n

.meas tran vdout0_17ck1060 FIND v(dout0_17) AT=535.025n

.meas tran vdout0_18ck1060 FIND v(dout0_18) AT=535.025n

.meas tran vdout0_19ck1060 FIND v(dout0_19) AT=535.025n

.meas tran vdout0_20ck1060 FIND v(dout0_20) AT=535.025n

.meas tran vdout0_21ck1060 FIND v(dout0_21) AT=535.025n

.meas tran vdout0_22ck1060 FIND v(dout0_22) AT=535.025n

.meas tran vdout0_23ck1060 FIND v(dout0_23) AT=535.025n

.meas tran vdout0_24ck1060 FIND v(dout0_24) AT=535.025n

.meas tran vdout0_25ck1060 FIND v(dout0_25) AT=535.025n

.meas tran vdout0_26ck1060 FIND v(dout0_26) AT=535.025n

.meas tran vdout0_27ck1060 FIND v(dout0_27) AT=535.025n

.meas tran vdout0_28ck1060 FIND v(dout0_28) AT=535.025n

.meas tran vdout0_29ck1060 FIND v(dout0_29) AT=535.025n

.meas tran vdout0_30ck1060 FIND v(dout0_30) AT=535.025n

.meas tran vdout0_31ck1060 FIND v(dout0_31) AT=535.025n

.meas tran vdout0_32ck1060 FIND v(dout0_32) AT=535.025n

.meas tran vdout0_33ck1060 FIND v(dout0_33) AT=535.025n

.meas tran vdout0_34ck1060 FIND v(dout0_34) AT=535.025n

.meas tran vdout0_35ck1060 FIND v(dout0_35) AT=535.025n

.meas tran vdout0_36ck1060 FIND v(dout0_36) AT=535.025n

.meas tran vdout0_37ck1060 FIND v(dout0_37) AT=535.025n

.meas tran vdout0_38ck1060 FIND v(dout0_38) AT=535.025n

.meas tran vdout0_39ck1060 FIND v(dout0_39) AT=535.025n

.meas tran vdout0_40ck1060 FIND v(dout0_40) AT=535.025n

.meas tran vdout0_41ck1060 FIND v(dout0_41) AT=535.025n

.meas tran vdout0_42ck1060 FIND v(dout0_42) AT=535.025n

.meas tran vdout0_43ck1060 FIND v(dout0_43) AT=535.025n

.meas tran vdout0_44ck1060 FIND v(dout0_44) AT=535.025n

.meas tran vdout0_45ck1060 FIND v(dout0_45) AT=535.025n

.meas tran vdout0_46ck1060 FIND v(dout0_46) AT=535.025n

.meas tran vdout0_47ck1060 FIND v(dout0_47) AT=535.025n

.meas tran vdout0_48ck1060 FIND v(dout0_48) AT=535.025n

.meas tran vdout0_49ck1060 FIND v(dout0_49) AT=535.025n

.meas tran vdout0_50ck1060 FIND v(dout0_50) AT=535.025n

.meas tran vdout0_51ck1060 FIND v(dout0_51) AT=535.025n

.meas tran vdout0_52ck1060 FIND v(dout0_52) AT=535.025n

.meas tran vdout0_53ck1060 FIND v(dout0_53) AT=535.025n

.meas tran vdout0_54ck1060 FIND v(dout0_54) AT=535.025n

.meas tran vdout0_55ck1060 FIND v(dout0_55) AT=535.025n

.meas tran vdout0_56ck1060 FIND v(dout0_56) AT=535.025n

.meas tran vdout0_57ck1060 FIND v(dout0_57) AT=535.025n

.meas tran vdout0_58ck1060 FIND v(dout0_58) AT=535.025n

.meas tran vdout0_59ck1060 FIND v(dout0_59) AT=535.025n

.meas tran vdout0_60ck1060 FIND v(dout0_60) AT=535.025n

.meas tran vdout0_61ck1060 FIND v(dout0_61) AT=535.025n

.meas tran vdout0_62ck1060 FIND v(dout0_62) AT=535.025n

.meas tran vdout0_63ck1060 FIND v(dout0_63) AT=535.025n

.meas tran vdout0_64ck1060 FIND v(dout0_64) AT=535.025n

.meas tran vdout0_65ck1060 FIND v(dout0_65) AT=535.025n

.meas tran vdout0_66ck1060 FIND v(dout0_66) AT=535.025n

.meas tran vdout0_67ck1060 FIND v(dout0_67) AT=535.025n

.meas tran vdout0_68ck1060 FIND v(dout0_68) AT=535.025n

.meas tran vdout0_69ck1060 FIND v(dout0_69) AT=535.025n

.meas tran vdout0_70ck1060 FIND v(dout0_70) AT=535.025n

.meas tran vdout0_71ck1060 FIND v(dout0_71) AT=535.025n

.meas tran vdout0_72ck1060 FIND v(dout0_72) AT=535.025n

.meas tran vdout0_73ck1060 FIND v(dout0_73) AT=535.025n

.meas tran vdout0_74ck1060 FIND v(dout0_74) AT=535.025n

.meas tran vdout0_75ck1060 FIND v(dout0_75) AT=535.025n

.meas tran vdout0_76ck1060 FIND v(dout0_76) AT=535.025n

.meas tran vdout0_77ck1060 FIND v(dout0_77) AT=535.025n

.meas tran vdout0_78ck1060 FIND v(dout0_78) AT=535.025n

.meas tran vdout0_79ck1060 FIND v(dout0_79) AT=535.025n

.meas tran vdout0_80ck1060 FIND v(dout0_80) AT=535.025n

.meas tran vdout0_81ck1060 FIND v(dout0_81) AT=535.025n

.meas tran vdout0_82ck1060 FIND v(dout0_82) AT=535.025n

.meas tran vdout0_83ck1060 FIND v(dout0_83) AT=535.025n

.meas tran vdout0_84ck1060 FIND v(dout0_84) AT=535.025n

.meas tran vdout0_85ck1060 FIND v(dout0_85) AT=535.025n

.meas tran vdout0_86ck1060 FIND v(dout0_86) AT=535.025n

.meas tran vdout0_87ck1060 FIND v(dout0_87) AT=535.025n

.meas tran vdout0_88ck1060 FIND v(dout0_88) AT=535.025n

.meas tran vdout0_89ck1060 FIND v(dout0_89) AT=535.025n

.meas tran vdout0_90ck1060 FIND v(dout0_90) AT=535.025n

.meas tran vdout0_91ck1060 FIND v(dout0_91) AT=535.025n

.meas tran vdout0_92ck1060 FIND v(dout0_92) AT=535.025n

.meas tran vdout0_93ck1060 FIND v(dout0_93) AT=535.025n

.meas tran vdout0_94ck1060 FIND v(dout0_94) AT=535.025n

.meas tran vdout0_95ck1060 FIND v(dout0_95) AT=535.025n

.meas tran vdout0_96ck1060 FIND v(dout0_96) AT=535.025n

.meas tran vdout0_97ck1060 FIND v(dout0_97) AT=535.025n

.meas tran vdout0_98ck1060 FIND v(dout0_98) AT=535.025n

.meas tran vdout0_99ck1060 FIND v(dout0_99) AT=535.025n

.meas tran vdout0_100ck1060 FIND v(dout0_100) AT=535.025n

.meas tran vdout0_101ck1060 FIND v(dout0_101) AT=535.025n

.meas tran vdout0_102ck1060 FIND v(dout0_102) AT=535.025n

.meas tran vdout0_103ck1060 FIND v(dout0_103) AT=535.025n

.meas tran vdout0_104ck1060 FIND v(dout0_104) AT=535.025n

.meas tran vdout0_105ck1060 FIND v(dout0_105) AT=535.025n

.meas tran vdout0_106ck1060 FIND v(dout0_106) AT=535.025n

.meas tran vdout0_107ck1060 FIND v(dout0_107) AT=535.025n

.meas tran vdout0_108ck1060 FIND v(dout0_108) AT=535.025n

.meas tran vdout0_109ck1060 FIND v(dout0_109) AT=535.025n

.meas tran vdout0_110ck1060 FIND v(dout0_110) AT=535.025n

.meas tran vdout0_111ck1060 FIND v(dout0_111) AT=535.025n

.meas tran vdout0_112ck1060 FIND v(dout0_112) AT=535.025n

.meas tran vdout0_113ck1060 FIND v(dout0_113) AT=535.025n

.meas tran vdout0_114ck1060 FIND v(dout0_114) AT=535.025n

.meas tran vdout0_115ck1060 FIND v(dout0_115) AT=535.025n

.meas tran vdout0_116ck1060 FIND v(dout0_116) AT=535.025n

.meas tran vdout0_117ck1060 FIND v(dout0_117) AT=535.025n

.meas tran vdout0_118ck1060 FIND v(dout0_118) AT=535.025n

.meas tran vdout0_119ck1060 FIND v(dout0_119) AT=535.025n

.meas tran vdout0_120ck1060 FIND v(dout0_120) AT=535.025n

.meas tran vdout0_121ck1060 FIND v(dout0_121) AT=535.025n

.meas tran vdout0_122ck1060 FIND v(dout0_122) AT=535.025n

.meas tran vdout0_123ck1060 FIND v(dout0_123) AT=535.025n

.meas tran vdout0_124ck1060 FIND v(dout0_124) AT=535.025n

.meas tran vdout0_125ck1060 FIND v(dout0_125) AT=535.025n

.meas tran vdout0_126ck1060 FIND v(dout0_126) AT=535.025n

.meas tran vdout0_127ck1060 FIND v(dout0_127) AT=535.025n

.meas tran vdout0_0ck1080 FIND v(dout0_0) AT=545.025n

.meas tran vdout0_1ck1080 FIND v(dout0_1) AT=545.025n

.meas tran vdout0_2ck1080 FIND v(dout0_2) AT=545.025n

.meas tran vdout0_3ck1080 FIND v(dout0_3) AT=545.025n

.meas tran vdout0_4ck1080 FIND v(dout0_4) AT=545.025n

.meas tran vdout0_5ck1080 FIND v(dout0_5) AT=545.025n

.meas tran vdout0_6ck1080 FIND v(dout0_6) AT=545.025n

.meas tran vdout0_7ck1080 FIND v(dout0_7) AT=545.025n

.meas tran vdout0_8ck1080 FIND v(dout0_8) AT=545.025n

.meas tran vdout0_9ck1080 FIND v(dout0_9) AT=545.025n

.meas tran vdout0_10ck1080 FIND v(dout0_10) AT=545.025n

.meas tran vdout0_11ck1080 FIND v(dout0_11) AT=545.025n

.meas tran vdout0_12ck1080 FIND v(dout0_12) AT=545.025n

.meas tran vdout0_13ck1080 FIND v(dout0_13) AT=545.025n

.meas tran vdout0_14ck1080 FIND v(dout0_14) AT=545.025n

.meas tran vdout0_15ck1080 FIND v(dout0_15) AT=545.025n

.meas tran vdout0_16ck1080 FIND v(dout0_16) AT=545.025n

.meas tran vdout0_17ck1080 FIND v(dout0_17) AT=545.025n

.meas tran vdout0_18ck1080 FIND v(dout0_18) AT=545.025n

.meas tran vdout0_19ck1080 FIND v(dout0_19) AT=545.025n

.meas tran vdout0_20ck1080 FIND v(dout0_20) AT=545.025n

.meas tran vdout0_21ck1080 FIND v(dout0_21) AT=545.025n

.meas tran vdout0_22ck1080 FIND v(dout0_22) AT=545.025n

.meas tran vdout0_23ck1080 FIND v(dout0_23) AT=545.025n

.meas tran vdout0_24ck1080 FIND v(dout0_24) AT=545.025n

.meas tran vdout0_25ck1080 FIND v(dout0_25) AT=545.025n

.meas tran vdout0_26ck1080 FIND v(dout0_26) AT=545.025n

.meas tran vdout0_27ck1080 FIND v(dout0_27) AT=545.025n

.meas tran vdout0_28ck1080 FIND v(dout0_28) AT=545.025n

.meas tran vdout0_29ck1080 FIND v(dout0_29) AT=545.025n

.meas tran vdout0_30ck1080 FIND v(dout0_30) AT=545.025n

.meas tran vdout0_31ck1080 FIND v(dout0_31) AT=545.025n

.meas tran vdout0_32ck1080 FIND v(dout0_32) AT=545.025n

.meas tran vdout0_33ck1080 FIND v(dout0_33) AT=545.025n

.meas tran vdout0_34ck1080 FIND v(dout0_34) AT=545.025n

.meas tran vdout0_35ck1080 FIND v(dout0_35) AT=545.025n

.meas tran vdout0_36ck1080 FIND v(dout0_36) AT=545.025n

.meas tran vdout0_37ck1080 FIND v(dout0_37) AT=545.025n

.meas tran vdout0_38ck1080 FIND v(dout0_38) AT=545.025n

.meas tran vdout0_39ck1080 FIND v(dout0_39) AT=545.025n

.meas tran vdout0_40ck1080 FIND v(dout0_40) AT=545.025n

.meas tran vdout0_41ck1080 FIND v(dout0_41) AT=545.025n

.meas tran vdout0_42ck1080 FIND v(dout0_42) AT=545.025n

.meas tran vdout0_43ck1080 FIND v(dout0_43) AT=545.025n

.meas tran vdout0_44ck1080 FIND v(dout0_44) AT=545.025n

.meas tran vdout0_45ck1080 FIND v(dout0_45) AT=545.025n

.meas tran vdout0_46ck1080 FIND v(dout0_46) AT=545.025n

.meas tran vdout0_47ck1080 FIND v(dout0_47) AT=545.025n

.meas tran vdout0_48ck1080 FIND v(dout0_48) AT=545.025n

.meas tran vdout0_49ck1080 FIND v(dout0_49) AT=545.025n

.meas tran vdout0_50ck1080 FIND v(dout0_50) AT=545.025n

.meas tran vdout0_51ck1080 FIND v(dout0_51) AT=545.025n

.meas tran vdout0_52ck1080 FIND v(dout0_52) AT=545.025n

.meas tran vdout0_53ck1080 FIND v(dout0_53) AT=545.025n

.meas tran vdout0_54ck1080 FIND v(dout0_54) AT=545.025n

.meas tran vdout0_55ck1080 FIND v(dout0_55) AT=545.025n

.meas tran vdout0_56ck1080 FIND v(dout0_56) AT=545.025n

.meas tran vdout0_57ck1080 FIND v(dout0_57) AT=545.025n

.meas tran vdout0_58ck1080 FIND v(dout0_58) AT=545.025n

.meas tran vdout0_59ck1080 FIND v(dout0_59) AT=545.025n

.meas tran vdout0_60ck1080 FIND v(dout0_60) AT=545.025n

.meas tran vdout0_61ck1080 FIND v(dout0_61) AT=545.025n

.meas tran vdout0_62ck1080 FIND v(dout0_62) AT=545.025n

.meas tran vdout0_63ck1080 FIND v(dout0_63) AT=545.025n

.meas tran vdout0_64ck1080 FIND v(dout0_64) AT=545.025n

.meas tran vdout0_65ck1080 FIND v(dout0_65) AT=545.025n

.meas tran vdout0_66ck1080 FIND v(dout0_66) AT=545.025n

.meas tran vdout0_67ck1080 FIND v(dout0_67) AT=545.025n

.meas tran vdout0_68ck1080 FIND v(dout0_68) AT=545.025n

.meas tran vdout0_69ck1080 FIND v(dout0_69) AT=545.025n

.meas tran vdout0_70ck1080 FIND v(dout0_70) AT=545.025n

.meas tran vdout0_71ck1080 FIND v(dout0_71) AT=545.025n

.meas tran vdout0_72ck1080 FIND v(dout0_72) AT=545.025n

.meas tran vdout0_73ck1080 FIND v(dout0_73) AT=545.025n

.meas tran vdout0_74ck1080 FIND v(dout0_74) AT=545.025n

.meas tran vdout0_75ck1080 FIND v(dout0_75) AT=545.025n

.meas tran vdout0_76ck1080 FIND v(dout0_76) AT=545.025n

.meas tran vdout0_77ck1080 FIND v(dout0_77) AT=545.025n

.meas tran vdout0_78ck1080 FIND v(dout0_78) AT=545.025n

.meas tran vdout0_79ck1080 FIND v(dout0_79) AT=545.025n

.meas tran vdout0_80ck1080 FIND v(dout0_80) AT=545.025n

.meas tran vdout0_81ck1080 FIND v(dout0_81) AT=545.025n

.meas tran vdout0_82ck1080 FIND v(dout0_82) AT=545.025n

.meas tran vdout0_83ck1080 FIND v(dout0_83) AT=545.025n

.meas tran vdout0_84ck1080 FIND v(dout0_84) AT=545.025n

.meas tran vdout0_85ck1080 FIND v(dout0_85) AT=545.025n

.meas tran vdout0_86ck1080 FIND v(dout0_86) AT=545.025n

.meas tran vdout0_87ck1080 FIND v(dout0_87) AT=545.025n

.meas tran vdout0_88ck1080 FIND v(dout0_88) AT=545.025n

.meas tran vdout0_89ck1080 FIND v(dout0_89) AT=545.025n

.meas tran vdout0_90ck1080 FIND v(dout0_90) AT=545.025n

.meas tran vdout0_91ck1080 FIND v(dout0_91) AT=545.025n

.meas tran vdout0_92ck1080 FIND v(dout0_92) AT=545.025n

.meas tran vdout0_93ck1080 FIND v(dout0_93) AT=545.025n

.meas tran vdout0_94ck1080 FIND v(dout0_94) AT=545.025n

.meas tran vdout0_95ck1080 FIND v(dout0_95) AT=545.025n

.meas tran vdout0_96ck1080 FIND v(dout0_96) AT=545.025n

.meas tran vdout0_97ck1080 FIND v(dout0_97) AT=545.025n

.meas tran vdout0_98ck1080 FIND v(dout0_98) AT=545.025n

.meas tran vdout0_99ck1080 FIND v(dout0_99) AT=545.025n

.meas tran vdout0_100ck1080 FIND v(dout0_100) AT=545.025n

.meas tran vdout0_101ck1080 FIND v(dout0_101) AT=545.025n

.meas tran vdout0_102ck1080 FIND v(dout0_102) AT=545.025n

.meas tran vdout0_103ck1080 FIND v(dout0_103) AT=545.025n

.meas tran vdout0_104ck1080 FIND v(dout0_104) AT=545.025n

.meas tran vdout0_105ck1080 FIND v(dout0_105) AT=545.025n

.meas tran vdout0_106ck1080 FIND v(dout0_106) AT=545.025n

.meas tran vdout0_107ck1080 FIND v(dout0_107) AT=545.025n

.meas tran vdout0_108ck1080 FIND v(dout0_108) AT=545.025n

.meas tran vdout0_109ck1080 FIND v(dout0_109) AT=545.025n

.meas tran vdout0_110ck1080 FIND v(dout0_110) AT=545.025n

.meas tran vdout0_111ck1080 FIND v(dout0_111) AT=545.025n

.meas tran vdout0_112ck1080 FIND v(dout0_112) AT=545.025n

.meas tran vdout0_113ck1080 FIND v(dout0_113) AT=545.025n

.meas tran vdout0_114ck1080 FIND v(dout0_114) AT=545.025n

.meas tran vdout0_115ck1080 FIND v(dout0_115) AT=545.025n

.meas tran vdout0_116ck1080 FIND v(dout0_116) AT=545.025n

.meas tran vdout0_117ck1080 FIND v(dout0_117) AT=545.025n

.meas tran vdout0_118ck1080 FIND v(dout0_118) AT=545.025n

.meas tran vdout0_119ck1080 FIND v(dout0_119) AT=545.025n

.meas tran vdout0_120ck1080 FIND v(dout0_120) AT=545.025n

.meas tran vdout0_121ck1080 FIND v(dout0_121) AT=545.025n

.meas tran vdout0_122ck1080 FIND v(dout0_122) AT=545.025n

.meas tran vdout0_123ck1080 FIND v(dout0_123) AT=545.025n

.meas tran vdout0_124ck1080 FIND v(dout0_124) AT=545.025n

.meas tran vdout0_125ck1080 FIND v(dout0_125) AT=545.025n

.meas tran vdout0_126ck1080 FIND v(dout0_126) AT=545.025n

.meas tran vdout0_127ck1080 FIND v(dout0_127) AT=545.025n

.meas tran vdout0_0ck1090 FIND v(dout0_0) AT=550.025n

.meas tran vdout0_1ck1090 FIND v(dout0_1) AT=550.025n

.meas tran vdout0_2ck1090 FIND v(dout0_2) AT=550.025n

.meas tran vdout0_3ck1090 FIND v(dout0_3) AT=550.025n

.meas tran vdout0_4ck1090 FIND v(dout0_4) AT=550.025n

.meas tran vdout0_5ck1090 FIND v(dout0_5) AT=550.025n

.meas tran vdout0_6ck1090 FIND v(dout0_6) AT=550.025n

.meas tran vdout0_7ck1090 FIND v(dout0_7) AT=550.025n

.meas tran vdout0_8ck1090 FIND v(dout0_8) AT=550.025n

.meas tran vdout0_9ck1090 FIND v(dout0_9) AT=550.025n

.meas tran vdout0_10ck1090 FIND v(dout0_10) AT=550.025n

.meas tran vdout0_11ck1090 FIND v(dout0_11) AT=550.025n

.meas tran vdout0_12ck1090 FIND v(dout0_12) AT=550.025n

.meas tran vdout0_13ck1090 FIND v(dout0_13) AT=550.025n

.meas tran vdout0_14ck1090 FIND v(dout0_14) AT=550.025n

.meas tran vdout0_15ck1090 FIND v(dout0_15) AT=550.025n

.meas tran vdout0_16ck1090 FIND v(dout0_16) AT=550.025n

.meas tran vdout0_17ck1090 FIND v(dout0_17) AT=550.025n

.meas tran vdout0_18ck1090 FIND v(dout0_18) AT=550.025n

.meas tran vdout0_19ck1090 FIND v(dout0_19) AT=550.025n

.meas tran vdout0_20ck1090 FIND v(dout0_20) AT=550.025n

.meas tran vdout0_21ck1090 FIND v(dout0_21) AT=550.025n

.meas tran vdout0_22ck1090 FIND v(dout0_22) AT=550.025n

.meas tran vdout0_23ck1090 FIND v(dout0_23) AT=550.025n

.meas tran vdout0_24ck1090 FIND v(dout0_24) AT=550.025n

.meas tran vdout0_25ck1090 FIND v(dout0_25) AT=550.025n

.meas tran vdout0_26ck1090 FIND v(dout0_26) AT=550.025n

.meas tran vdout0_27ck1090 FIND v(dout0_27) AT=550.025n

.meas tran vdout0_28ck1090 FIND v(dout0_28) AT=550.025n

.meas tran vdout0_29ck1090 FIND v(dout0_29) AT=550.025n

.meas tran vdout0_30ck1090 FIND v(dout0_30) AT=550.025n

.meas tran vdout0_31ck1090 FIND v(dout0_31) AT=550.025n

.meas tran vdout0_32ck1090 FIND v(dout0_32) AT=550.025n

.meas tran vdout0_33ck1090 FIND v(dout0_33) AT=550.025n

.meas tran vdout0_34ck1090 FIND v(dout0_34) AT=550.025n

.meas tran vdout0_35ck1090 FIND v(dout0_35) AT=550.025n

.meas tran vdout0_36ck1090 FIND v(dout0_36) AT=550.025n

.meas tran vdout0_37ck1090 FIND v(dout0_37) AT=550.025n

.meas tran vdout0_38ck1090 FIND v(dout0_38) AT=550.025n

.meas tran vdout0_39ck1090 FIND v(dout0_39) AT=550.025n

.meas tran vdout0_40ck1090 FIND v(dout0_40) AT=550.025n

.meas tran vdout0_41ck1090 FIND v(dout0_41) AT=550.025n

.meas tran vdout0_42ck1090 FIND v(dout0_42) AT=550.025n

.meas tran vdout0_43ck1090 FIND v(dout0_43) AT=550.025n

.meas tran vdout0_44ck1090 FIND v(dout0_44) AT=550.025n

.meas tran vdout0_45ck1090 FIND v(dout0_45) AT=550.025n

.meas tran vdout0_46ck1090 FIND v(dout0_46) AT=550.025n

.meas tran vdout0_47ck1090 FIND v(dout0_47) AT=550.025n

.meas tran vdout0_48ck1090 FIND v(dout0_48) AT=550.025n

.meas tran vdout0_49ck1090 FIND v(dout0_49) AT=550.025n

.meas tran vdout0_50ck1090 FIND v(dout0_50) AT=550.025n

.meas tran vdout0_51ck1090 FIND v(dout0_51) AT=550.025n

.meas tran vdout0_52ck1090 FIND v(dout0_52) AT=550.025n

.meas tran vdout0_53ck1090 FIND v(dout0_53) AT=550.025n

.meas tran vdout0_54ck1090 FIND v(dout0_54) AT=550.025n

.meas tran vdout0_55ck1090 FIND v(dout0_55) AT=550.025n

.meas tran vdout0_56ck1090 FIND v(dout0_56) AT=550.025n

.meas tran vdout0_57ck1090 FIND v(dout0_57) AT=550.025n

.meas tran vdout0_58ck1090 FIND v(dout0_58) AT=550.025n

.meas tran vdout0_59ck1090 FIND v(dout0_59) AT=550.025n

.meas tran vdout0_60ck1090 FIND v(dout0_60) AT=550.025n

.meas tran vdout0_61ck1090 FIND v(dout0_61) AT=550.025n

.meas tran vdout0_62ck1090 FIND v(dout0_62) AT=550.025n

.meas tran vdout0_63ck1090 FIND v(dout0_63) AT=550.025n

.meas tran vdout0_64ck1090 FIND v(dout0_64) AT=550.025n

.meas tran vdout0_65ck1090 FIND v(dout0_65) AT=550.025n

.meas tran vdout0_66ck1090 FIND v(dout0_66) AT=550.025n

.meas tran vdout0_67ck1090 FIND v(dout0_67) AT=550.025n

.meas tran vdout0_68ck1090 FIND v(dout0_68) AT=550.025n

.meas tran vdout0_69ck1090 FIND v(dout0_69) AT=550.025n

.meas tran vdout0_70ck1090 FIND v(dout0_70) AT=550.025n

.meas tran vdout0_71ck1090 FIND v(dout0_71) AT=550.025n

.meas tran vdout0_72ck1090 FIND v(dout0_72) AT=550.025n

.meas tran vdout0_73ck1090 FIND v(dout0_73) AT=550.025n

.meas tran vdout0_74ck1090 FIND v(dout0_74) AT=550.025n

.meas tran vdout0_75ck1090 FIND v(dout0_75) AT=550.025n

.meas tran vdout0_76ck1090 FIND v(dout0_76) AT=550.025n

.meas tran vdout0_77ck1090 FIND v(dout0_77) AT=550.025n

.meas tran vdout0_78ck1090 FIND v(dout0_78) AT=550.025n

.meas tran vdout0_79ck1090 FIND v(dout0_79) AT=550.025n

.meas tran vdout0_80ck1090 FIND v(dout0_80) AT=550.025n

.meas tran vdout0_81ck1090 FIND v(dout0_81) AT=550.025n

.meas tran vdout0_82ck1090 FIND v(dout0_82) AT=550.025n

.meas tran vdout0_83ck1090 FIND v(dout0_83) AT=550.025n

.meas tran vdout0_84ck1090 FIND v(dout0_84) AT=550.025n

.meas tran vdout0_85ck1090 FIND v(dout0_85) AT=550.025n

.meas tran vdout0_86ck1090 FIND v(dout0_86) AT=550.025n

.meas tran vdout0_87ck1090 FIND v(dout0_87) AT=550.025n

.meas tran vdout0_88ck1090 FIND v(dout0_88) AT=550.025n

.meas tran vdout0_89ck1090 FIND v(dout0_89) AT=550.025n

.meas tran vdout0_90ck1090 FIND v(dout0_90) AT=550.025n

.meas tran vdout0_91ck1090 FIND v(dout0_91) AT=550.025n

.meas tran vdout0_92ck1090 FIND v(dout0_92) AT=550.025n

.meas tran vdout0_93ck1090 FIND v(dout0_93) AT=550.025n

.meas tran vdout0_94ck1090 FIND v(dout0_94) AT=550.025n

.meas tran vdout0_95ck1090 FIND v(dout0_95) AT=550.025n

.meas tran vdout0_96ck1090 FIND v(dout0_96) AT=550.025n

.meas tran vdout0_97ck1090 FIND v(dout0_97) AT=550.025n

.meas tran vdout0_98ck1090 FIND v(dout0_98) AT=550.025n

.meas tran vdout0_99ck1090 FIND v(dout0_99) AT=550.025n

.meas tran vdout0_100ck1090 FIND v(dout0_100) AT=550.025n

.meas tran vdout0_101ck1090 FIND v(dout0_101) AT=550.025n

.meas tran vdout0_102ck1090 FIND v(dout0_102) AT=550.025n

.meas tran vdout0_103ck1090 FIND v(dout0_103) AT=550.025n

.meas tran vdout0_104ck1090 FIND v(dout0_104) AT=550.025n

.meas tran vdout0_105ck1090 FIND v(dout0_105) AT=550.025n

.meas tran vdout0_106ck1090 FIND v(dout0_106) AT=550.025n

.meas tran vdout0_107ck1090 FIND v(dout0_107) AT=550.025n

.meas tran vdout0_108ck1090 FIND v(dout0_108) AT=550.025n

.meas tran vdout0_109ck1090 FIND v(dout0_109) AT=550.025n

.meas tran vdout0_110ck1090 FIND v(dout0_110) AT=550.025n

.meas tran vdout0_111ck1090 FIND v(dout0_111) AT=550.025n

.meas tran vdout0_112ck1090 FIND v(dout0_112) AT=550.025n

.meas tran vdout0_113ck1090 FIND v(dout0_113) AT=550.025n

.meas tran vdout0_114ck1090 FIND v(dout0_114) AT=550.025n

.meas tran vdout0_115ck1090 FIND v(dout0_115) AT=550.025n

.meas tran vdout0_116ck1090 FIND v(dout0_116) AT=550.025n

.meas tran vdout0_117ck1090 FIND v(dout0_117) AT=550.025n

.meas tran vdout0_118ck1090 FIND v(dout0_118) AT=550.025n

.meas tran vdout0_119ck1090 FIND v(dout0_119) AT=550.025n

.meas tran vdout0_120ck1090 FIND v(dout0_120) AT=550.025n

.meas tran vdout0_121ck1090 FIND v(dout0_121) AT=550.025n

.meas tran vdout0_122ck1090 FIND v(dout0_122) AT=550.025n

.meas tran vdout0_123ck1090 FIND v(dout0_123) AT=550.025n

.meas tran vdout0_124ck1090 FIND v(dout0_124) AT=550.025n

.meas tran vdout0_125ck1090 FIND v(dout0_125) AT=550.025n

.meas tran vdout0_126ck1090 FIND v(dout0_126) AT=550.025n

.meas tran vdout0_127ck1090 FIND v(dout0_127) AT=550.025n

.meas tran vdout0_0ck1140 FIND v(dout0_0) AT=575.025n

.meas tran vdout0_1ck1140 FIND v(dout0_1) AT=575.025n

.meas tran vdout0_2ck1140 FIND v(dout0_2) AT=575.025n

.meas tran vdout0_3ck1140 FIND v(dout0_3) AT=575.025n

.meas tran vdout0_4ck1140 FIND v(dout0_4) AT=575.025n

.meas tran vdout0_5ck1140 FIND v(dout0_5) AT=575.025n

.meas tran vdout0_6ck1140 FIND v(dout0_6) AT=575.025n

.meas tran vdout0_7ck1140 FIND v(dout0_7) AT=575.025n

.meas tran vdout0_8ck1140 FIND v(dout0_8) AT=575.025n

.meas tran vdout0_9ck1140 FIND v(dout0_9) AT=575.025n

.meas tran vdout0_10ck1140 FIND v(dout0_10) AT=575.025n

.meas tran vdout0_11ck1140 FIND v(dout0_11) AT=575.025n

.meas tran vdout0_12ck1140 FIND v(dout0_12) AT=575.025n

.meas tran vdout0_13ck1140 FIND v(dout0_13) AT=575.025n

.meas tran vdout0_14ck1140 FIND v(dout0_14) AT=575.025n

.meas tran vdout0_15ck1140 FIND v(dout0_15) AT=575.025n

.meas tran vdout0_16ck1140 FIND v(dout0_16) AT=575.025n

.meas tran vdout0_17ck1140 FIND v(dout0_17) AT=575.025n

.meas tran vdout0_18ck1140 FIND v(dout0_18) AT=575.025n

.meas tran vdout0_19ck1140 FIND v(dout0_19) AT=575.025n

.meas tran vdout0_20ck1140 FIND v(dout0_20) AT=575.025n

.meas tran vdout0_21ck1140 FIND v(dout0_21) AT=575.025n

.meas tran vdout0_22ck1140 FIND v(dout0_22) AT=575.025n

.meas tran vdout0_23ck1140 FIND v(dout0_23) AT=575.025n

.meas tran vdout0_24ck1140 FIND v(dout0_24) AT=575.025n

.meas tran vdout0_25ck1140 FIND v(dout0_25) AT=575.025n

.meas tran vdout0_26ck1140 FIND v(dout0_26) AT=575.025n

.meas tran vdout0_27ck1140 FIND v(dout0_27) AT=575.025n

.meas tran vdout0_28ck1140 FIND v(dout0_28) AT=575.025n

.meas tran vdout0_29ck1140 FIND v(dout0_29) AT=575.025n

.meas tran vdout0_30ck1140 FIND v(dout0_30) AT=575.025n

.meas tran vdout0_31ck1140 FIND v(dout0_31) AT=575.025n

.meas tran vdout0_32ck1140 FIND v(dout0_32) AT=575.025n

.meas tran vdout0_33ck1140 FIND v(dout0_33) AT=575.025n

.meas tran vdout0_34ck1140 FIND v(dout0_34) AT=575.025n

.meas tran vdout0_35ck1140 FIND v(dout0_35) AT=575.025n

.meas tran vdout0_36ck1140 FIND v(dout0_36) AT=575.025n

.meas tran vdout0_37ck1140 FIND v(dout0_37) AT=575.025n

.meas tran vdout0_38ck1140 FIND v(dout0_38) AT=575.025n

.meas tran vdout0_39ck1140 FIND v(dout0_39) AT=575.025n

.meas tran vdout0_40ck1140 FIND v(dout0_40) AT=575.025n

.meas tran vdout0_41ck1140 FIND v(dout0_41) AT=575.025n

.meas tran vdout0_42ck1140 FIND v(dout0_42) AT=575.025n

.meas tran vdout0_43ck1140 FIND v(dout0_43) AT=575.025n

.meas tran vdout0_44ck1140 FIND v(dout0_44) AT=575.025n

.meas tran vdout0_45ck1140 FIND v(dout0_45) AT=575.025n

.meas tran vdout0_46ck1140 FIND v(dout0_46) AT=575.025n

.meas tran vdout0_47ck1140 FIND v(dout0_47) AT=575.025n

.meas tran vdout0_48ck1140 FIND v(dout0_48) AT=575.025n

.meas tran vdout0_49ck1140 FIND v(dout0_49) AT=575.025n

.meas tran vdout0_50ck1140 FIND v(dout0_50) AT=575.025n

.meas tran vdout0_51ck1140 FIND v(dout0_51) AT=575.025n

.meas tran vdout0_52ck1140 FIND v(dout0_52) AT=575.025n

.meas tran vdout0_53ck1140 FIND v(dout0_53) AT=575.025n

.meas tran vdout0_54ck1140 FIND v(dout0_54) AT=575.025n

.meas tran vdout0_55ck1140 FIND v(dout0_55) AT=575.025n

.meas tran vdout0_56ck1140 FIND v(dout0_56) AT=575.025n

.meas tran vdout0_57ck1140 FIND v(dout0_57) AT=575.025n

.meas tran vdout0_58ck1140 FIND v(dout0_58) AT=575.025n

.meas tran vdout0_59ck1140 FIND v(dout0_59) AT=575.025n

.meas tran vdout0_60ck1140 FIND v(dout0_60) AT=575.025n

.meas tran vdout0_61ck1140 FIND v(dout0_61) AT=575.025n

.meas tran vdout0_62ck1140 FIND v(dout0_62) AT=575.025n

.meas tran vdout0_63ck1140 FIND v(dout0_63) AT=575.025n

.meas tran vdout0_64ck1140 FIND v(dout0_64) AT=575.025n

.meas tran vdout0_65ck1140 FIND v(dout0_65) AT=575.025n

.meas tran vdout0_66ck1140 FIND v(dout0_66) AT=575.025n

.meas tran vdout0_67ck1140 FIND v(dout0_67) AT=575.025n

.meas tran vdout0_68ck1140 FIND v(dout0_68) AT=575.025n

.meas tran vdout0_69ck1140 FIND v(dout0_69) AT=575.025n

.meas tran vdout0_70ck1140 FIND v(dout0_70) AT=575.025n

.meas tran vdout0_71ck1140 FIND v(dout0_71) AT=575.025n

.meas tran vdout0_72ck1140 FIND v(dout0_72) AT=575.025n

.meas tran vdout0_73ck1140 FIND v(dout0_73) AT=575.025n

.meas tran vdout0_74ck1140 FIND v(dout0_74) AT=575.025n

.meas tran vdout0_75ck1140 FIND v(dout0_75) AT=575.025n

.meas tran vdout0_76ck1140 FIND v(dout0_76) AT=575.025n

.meas tran vdout0_77ck1140 FIND v(dout0_77) AT=575.025n

.meas tran vdout0_78ck1140 FIND v(dout0_78) AT=575.025n

.meas tran vdout0_79ck1140 FIND v(dout0_79) AT=575.025n

.meas tran vdout0_80ck1140 FIND v(dout0_80) AT=575.025n

.meas tran vdout0_81ck1140 FIND v(dout0_81) AT=575.025n

.meas tran vdout0_82ck1140 FIND v(dout0_82) AT=575.025n

.meas tran vdout0_83ck1140 FIND v(dout0_83) AT=575.025n

.meas tran vdout0_84ck1140 FIND v(dout0_84) AT=575.025n

.meas tran vdout0_85ck1140 FIND v(dout0_85) AT=575.025n

.meas tran vdout0_86ck1140 FIND v(dout0_86) AT=575.025n

.meas tran vdout0_87ck1140 FIND v(dout0_87) AT=575.025n

.meas tran vdout0_88ck1140 FIND v(dout0_88) AT=575.025n

.meas tran vdout0_89ck1140 FIND v(dout0_89) AT=575.025n

.meas tran vdout0_90ck1140 FIND v(dout0_90) AT=575.025n

.meas tran vdout0_91ck1140 FIND v(dout0_91) AT=575.025n

.meas tran vdout0_92ck1140 FIND v(dout0_92) AT=575.025n

.meas tran vdout0_93ck1140 FIND v(dout0_93) AT=575.025n

.meas tran vdout0_94ck1140 FIND v(dout0_94) AT=575.025n

.meas tran vdout0_95ck1140 FIND v(dout0_95) AT=575.025n

.meas tran vdout0_96ck1140 FIND v(dout0_96) AT=575.025n

.meas tran vdout0_97ck1140 FIND v(dout0_97) AT=575.025n

.meas tran vdout0_98ck1140 FIND v(dout0_98) AT=575.025n

.meas tran vdout0_99ck1140 FIND v(dout0_99) AT=575.025n

.meas tran vdout0_100ck1140 FIND v(dout0_100) AT=575.025n

.meas tran vdout0_101ck1140 FIND v(dout0_101) AT=575.025n

.meas tran vdout0_102ck1140 FIND v(dout0_102) AT=575.025n

.meas tran vdout0_103ck1140 FIND v(dout0_103) AT=575.025n

.meas tran vdout0_104ck1140 FIND v(dout0_104) AT=575.025n

.meas tran vdout0_105ck1140 FIND v(dout0_105) AT=575.025n

.meas tran vdout0_106ck1140 FIND v(dout0_106) AT=575.025n

.meas tran vdout0_107ck1140 FIND v(dout0_107) AT=575.025n

.meas tran vdout0_108ck1140 FIND v(dout0_108) AT=575.025n

.meas tran vdout0_109ck1140 FIND v(dout0_109) AT=575.025n

.meas tran vdout0_110ck1140 FIND v(dout0_110) AT=575.025n

.meas tran vdout0_111ck1140 FIND v(dout0_111) AT=575.025n

.meas tran vdout0_112ck1140 FIND v(dout0_112) AT=575.025n

.meas tran vdout0_113ck1140 FIND v(dout0_113) AT=575.025n

.meas tran vdout0_114ck1140 FIND v(dout0_114) AT=575.025n

.meas tran vdout0_115ck1140 FIND v(dout0_115) AT=575.025n

.meas tran vdout0_116ck1140 FIND v(dout0_116) AT=575.025n

.meas tran vdout0_117ck1140 FIND v(dout0_117) AT=575.025n

.meas tran vdout0_118ck1140 FIND v(dout0_118) AT=575.025n

.meas tran vdout0_119ck1140 FIND v(dout0_119) AT=575.025n

.meas tran vdout0_120ck1140 FIND v(dout0_120) AT=575.025n

.meas tran vdout0_121ck1140 FIND v(dout0_121) AT=575.025n

.meas tran vdout0_122ck1140 FIND v(dout0_122) AT=575.025n

.meas tran vdout0_123ck1140 FIND v(dout0_123) AT=575.025n

.meas tran vdout0_124ck1140 FIND v(dout0_124) AT=575.025n

.meas tran vdout0_125ck1140 FIND v(dout0_125) AT=575.025n

.meas tran vdout0_126ck1140 FIND v(dout0_126) AT=575.025n

.meas tran vdout0_127ck1140 FIND v(dout0_127) AT=575.025n

.meas tran vdout0_0ck1150 FIND v(dout0_0) AT=580.025n

.meas tran vdout0_1ck1150 FIND v(dout0_1) AT=580.025n

.meas tran vdout0_2ck1150 FIND v(dout0_2) AT=580.025n

.meas tran vdout0_3ck1150 FIND v(dout0_3) AT=580.025n

.meas tran vdout0_4ck1150 FIND v(dout0_4) AT=580.025n

.meas tran vdout0_5ck1150 FIND v(dout0_5) AT=580.025n

.meas tran vdout0_6ck1150 FIND v(dout0_6) AT=580.025n

.meas tran vdout0_7ck1150 FIND v(dout0_7) AT=580.025n

.meas tran vdout0_8ck1150 FIND v(dout0_8) AT=580.025n

.meas tran vdout0_9ck1150 FIND v(dout0_9) AT=580.025n

.meas tran vdout0_10ck1150 FIND v(dout0_10) AT=580.025n

.meas tran vdout0_11ck1150 FIND v(dout0_11) AT=580.025n

.meas tran vdout0_12ck1150 FIND v(dout0_12) AT=580.025n

.meas tran vdout0_13ck1150 FIND v(dout0_13) AT=580.025n

.meas tran vdout0_14ck1150 FIND v(dout0_14) AT=580.025n

.meas tran vdout0_15ck1150 FIND v(dout0_15) AT=580.025n

.meas tran vdout0_16ck1150 FIND v(dout0_16) AT=580.025n

.meas tran vdout0_17ck1150 FIND v(dout0_17) AT=580.025n

.meas tran vdout0_18ck1150 FIND v(dout0_18) AT=580.025n

.meas tran vdout0_19ck1150 FIND v(dout0_19) AT=580.025n

.meas tran vdout0_20ck1150 FIND v(dout0_20) AT=580.025n

.meas tran vdout0_21ck1150 FIND v(dout0_21) AT=580.025n

.meas tran vdout0_22ck1150 FIND v(dout0_22) AT=580.025n

.meas tran vdout0_23ck1150 FIND v(dout0_23) AT=580.025n

.meas tran vdout0_24ck1150 FIND v(dout0_24) AT=580.025n

.meas tran vdout0_25ck1150 FIND v(dout0_25) AT=580.025n

.meas tran vdout0_26ck1150 FIND v(dout0_26) AT=580.025n

.meas tran vdout0_27ck1150 FIND v(dout0_27) AT=580.025n

.meas tran vdout0_28ck1150 FIND v(dout0_28) AT=580.025n

.meas tran vdout0_29ck1150 FIND v(dout0_29) AT=580.025n

.meas tran vdout0_30ck1150 FIND v(dout0_30) AT=580.025n

.meas tran vdout0_31ck1150 FIND v(dout0_31) AT=580.025n

.meas tran vdout0_32ck1150 FIND v(dout0_32) AT=580.025n

.meas tran vdout0_33ck1150 FIND v(dout0_33) AT=580.025n

.meas tran vdout0_34ck1150 FIND v(dout0_34) AT=580.025n

.meas tran vdout0_35ck1150 FIND v(dout0_35) AT=580.025n

.meas tran vdout0_36ck1150 FIND v(dout0_36) AT=580.025n

.meas tran vdout0_37ck1150 FIND v(dout0_37) AT=580.025n

.meas tran vdout0_38ck1150 FIND v(dout0_38) AT=580.025n

.meas tran vdout0_39ck1150 FIND v(dout0_39) AT=580.025n

.meas tran vdout0_40ck1150 FIND v(dout0_40) AT=580.025n

.meas tran vdout0_41ck1150 FIND v(dout0_41) AT=580.025n

.meas tran vdout0_42ck1150 FIND v(dout0_42) AT=580.025n

.meas tran vdout0_43ck1150 FIND v(dout0_43) AT=580.025n

.meas tran vdout0_44ck1150 FIND v(dout0_44) AT=580.025n

.meas tran vdout0_45ck1150 FIND v(dout0_45) AT=580.025n

.meas tran vdout0_46ck1150 FIND v(dout0_46) AT=580.025n

.meas tran vdout0_47ck1150 FIND v(dout0_47) AT=580.025n

.meas tran vdout0_48ck1150 FIND v(dout0_48) AT=580.025n

.meas tran vdout0_49ck1150 FIND v(dout0_49) AT=580.025n

.meas tran vdout0_50ck1150 FIND v(dout0_50) AT=580.025n

.meas tran vdout0_51ck1150 FIND v(dout0_51) AT=580.025n

.meas tran vdout0_52ck1150 FIND v(dout0_52) AT=580.025n

.meas tran vdout0_53ck1150 FIND v(dout0_53) AT=580.025n

.meas tran vdout0_54ck1150 FIND v(dout0_54) AT=580.025n

.meas tran vdout0_55ck1150 FIND v(dout0_55) AT=580.025n

.meas tran vdout0_56ck1150 FIND v(dout0_56) AT=580.025n

.meas tran vdout0_57ck1150 FIND v(dout0_57) AT=580.025n

.meas tran vdout0_58ck1150 FIND v(dout0_58) AT=580.025n

.meas tran vdout0_59ck1150 FIND v(dout0_59) AT=580.025n

.meas tran vdout0_60ck1150 FIND v(dout0_60) AT=580.025n

.meas tran vdout0_61ck1150 FIND v(dout0_61) AT=580.025n

.meas tran vdout0_62ck1150 FIND v(dout0_62) AT=580.025n

.meas tran vdout0_63ck1150 FIND v(dout0_63) AT=580.025n

.meas tran vdout0_64ck1150 FIND v(dout0_64) AT=580.025n

.meas tran vdout0_65ck1150 FIND v(dout0_65) AT=580.025n

.meas tran vdout0_66ck1150 FIND v(dout0_66) AT=580.025n

.meas tran vdout0_67ck1150 FIND v(dout0_67) AT=580.025n

.meas tran vdout0_68ck1150 FIND v(dout0_68) AT=580.025n

.meas tran vdout0_69ck1150 FIND v(dout0_69) AT=580.025n

.meas tran vdout0_70ck1150 FIND v(dout0_70) AT=580.025n

.meas tran vdout0_71ck1150 FIND v(dout0_71) AT=580.025n

.meas tran vdout0_72ck1150 FIND v(dout0_72) AT=580.025n

.meas tran vdout0_73ck1150 FIND v(dout0_73) AT=580.025n

.meas tran vdout0_74ck1150 FIND v(dout0_74) AT=580.025n

.meas tran vdout0_75ck1150 FIND v(dout0_75) AT=580.025n

.meas tran vdout0_76ck1150 FIND v(dout0_76) AT=580.025n

.meas tran vdout0_77ck1150 FIND v(dout0_77) AT=580.025n

.meas tran vdout0_78ck1150 FIND v(dout0_78) AT=580.025n

.meas tran vdout0_79ck1150 FIND v(dout0_79) AT=580.025n

.meas tran vdout0_80ck1150 FIND v(dout0_80) AT=580.025n

.meas tran vdout0_81ck1150 FIND v(dout0_81) AT=580.025n

.meas tran vdout0_82ck1150 FIND v(dout0_82) AT=580.025n

.meas tran vdout0_83ck1150 FIND v(dout0_83) AT=580.025n

.meas tran vdout0_84ck1150 FIND v(dout0_84) AT=580.025n

.meas tran vdout0_85ck1150 FIND v(dout0_85) AT=580.025n

.meas tran vdout0_86ck1150 FIND v(dout0_86) AT=580.025n

.meas tran vdout0_87ck1150 FIND v(dout0_87) AT=580.025n

.meas tran vdout0_88ck1150 FIND v(dout0_88) AT=580.025n

.meas tran vdout0_89ck1150 FIND v(dout0_89) AT=580.025n

.meas tran vdout0_90ck1150 FIND v(dout0_90) AT=580.025n

.meas tran vdout0_91ck1150 FIND v(dout0_91) AT=580.025n

.meas tran vdout0_92ck1150 FIND v(dout0_92) AT=580.025n

.meas tran vdout0_93ck1150 FIND v(dout0_93) AT=580.025n

.meas tran vdout0_94ck1150 FIND v(dout0_94) AT=580.025n

.meas tran vdout0_95ck1150 FIND v(dout0_95) AT=580.025n

.meas tran vdout0_96ck1150 FIND v(dout0_96) AT=580.025n

.meas tran vdout0_97ck1150 FIND v(dout0_97) AT=580.025n

.meas tran vdout0_98ck1150 FIND v(dout0_98) AT=580.025n

.meas tran vdout0_99ck1150 FIND v(dout0_99) AT=580.025n

.meas tran vdout0_100ck1150 FIND v(dout0_100) AT=580.025n

.meas tran vdout0_101ck1150 FIND v(dout0_101) AT=580.025n

.meas tran vdout0_102ck1150 FIND v(dout0_102) AT=580.025n

.meas tran vdout0_103ck1150 FIND v(dout0_103) AT=580.025n

.meas tran vdout0_104ck1150 FIND v(dout0_104) AT=580.025n

.meas tran vdout0_105ck1150 FIND v(dout0_105) AT=580.025n

.meas tran vdout0_106ck1150 FIND v(dout0_106) AT=580.025n

.meas tran vdout0_107ck1150 FIND v(dout0_107) AT=580.025n

.meas tran vdout0_108ck1150 FIND v(dout0_108) AT=580.025n

.meas tran vdout0_109ck1150 FIND v(dout0_109) AT=580.025n

.meas tran vdout0_110ck1150 FIND v(dout0_110) AT=580.025n

.meas tran vdout0_111ck1150 FIND v(dout0_111) AT=580.025n

.meas tran vdout0_112ck1150 FIND v(dout0_112) AT=580.025n

.meas tran vdout0_113ck1150 FIND v(dout0_113) AT=580.025n

.meas tran vdout0_114ck1150 FIND v(dout0_114) AT=580.025n

.meas tran vdout0_115ck1150 FIND v(dout0_115) AT=580.025n

.meas tran vdout0_116ck1150 FIND v(dout0_116) AT=580.025n

.meas tran vdout0_117ck1150 FIND v(dout0_117) AT=580.025n

.meas tran vdout0_118ck1150 FIND v(dout0_118) AT=580.025n

.meas tran vdout0_119ck1150 FIND v(dout0_119) AT=580.025n

.meas tran vdout0_120ck1150 FIND v(dout0_120) AT=580.025n

.meas tran vdout0_121ck1150 FIND v(dout0_121) AT=580.025n

.meas tran vdout0_122ck1150 FIND v(dout0_122) AT=580.025n

.meas tran vdout0_123ck1150 FIND v(dout0_123) AT=580.025n

.meas tran vdout0_124ck1150 FIND v(dout0_124) AT=580.025n

.meas tran vdout0_125ck1150 FIND v(dout0_125) AT=580.025n

.meas tran vdout0_126ck1150 FIND v(dout0_126) AT=580.025n

.meas tran vdout0_127ck1150 FIND v(dout0_127) AT=580.025n

.meas tran vdout0_0ck1180 FIND v(dout0_0) AT=595.025n

.meas tran vdout0_1ck1180 FIND v(dout0_1) AT=595.025n

.meas tran vdout0_2ck1180 FIND v(dout0_2) AT=595.025n

.meas tran vdout0_3ck1180 FIND v(dout0_3) AT=595.025n

.meas tran vdout0_4ck1180 FIND v(dout0_4) AT=595.025n

.meas tran vdout0_5ck1180 FIND v(dout0_5) AT=595.025n

.meas tran vdout0_6ck1180 FIND v(dout0_6) AT=595.025n

.meas tran vdout0_7ck1180 FIND v(dout0_7) AT=595.025n

.meas tran vdout0_8ck1180 FIND v(dout0_8) AT=595.025n

.meas tran vdout0_9ck1180 FIND v(dout0_9) AT=595.025n

.meas tran vdout0_10ck1180 FIND v(dout0_10) AT=595.025n

.meas tran vdout0_11ck1180 FIND v(dout0_11) AT=595.025n

.meas tran vdout0_12ck1180 FIND v(dout0_12) AT=595.025n

.meas tran vdout0_13ck1180 FIND v(dout0_13) AT=595.025n

.meas tran vdout0_14ck1180 FIND v(dout0_14) AT=595.025n

.meas tran vdout0_15ck1180 FIND v(dout0_15) AT=595.025n

.meas tran vdout0_16ck1180 FIND v(dout0_16) AT=595.025n

.meas tran vdout0_17ck1180 FIND v(dout0_17) AT=595.025n

.meas tran vdout0_18ck1180 FIND v(dout0_18) AT=595.025n

.meas tran vdout0_19ck1180 FIND v(dout0_19) AT=595.025n

.meas tran vdout0_20ck1180 FIND v(dout0_20) AT=595.025n

.meas tran vdout0_21ck1180 FIND v(dout0_21) AT=595.025n

.meas tran vdout0_22ck1180 FIND v(dout0_22) AT=595.025n

.meas tran vdout0_23ck1180 FIND v(dout0_23) AT=595.025n

.meas tran vdout0_24ck1180 FIND v(dout0_24) AT=595.025n

.meas tran vdout0_25ck1180 FIND v(dout0_25) AT=595.025n

.meas tran vdout0_26ck1180 FIND v(dout0_26) AT=595.025n

.meas tran vdout0_27ck1180 FIND v(dout0_27) AT=595.025n

.meas tran vdout0_28ck1180 FIND v(dout0_28) AT=595.025n

.meas tran vdout0_29ck1180 FIND v(dout0_29) AT=595.025n

.meas tran vdout0_30ck1180 FIND v(dout0_30) AT=595.025n

.meas tran vdout0_31ck1180 FIND v(dout0_31) AT=595.025n

.meas tran vdout0_32ck1180 FIND v(dout0_32) AT=595.025n

.meas tran vdout0_33ck1180 FIND v(dout0_33) AT=595.025n

.meas tran vdout0_34ck1180 FIND v(dout0_34) AT=595.025n

.meas tran vdout0_35ck1180 FIND v(dout0_35) AT=595.025n

.meas tran vdout0_36ck1180 FIND v(dout0_36) AT=595.025n

.meas tran vdout0_37ck1180 FIND v(dout0_37) AT=595.025n

.meas tran vdout0_38ck1180 FIND v(dout0_38) AT=595.025n

.meas tran vdout0_39ck1180 FIND v(dout0_39) AT=595.025n

.meas tran vdout0_40ck1180 FIND v(dout0_40) AT=595.025n

.meas tran vdout0_41ck1180 FIND v(dout0_41) AT=595.025n

.meas tran vdout0_42ck1180 FIND v(dout0_42) AT=595.025n

.meas tran vdout0_43ck1180 FIND v(dout0_43) AT=595.025n

.meas tran vdout0_44ck1180 FIND v(dout0_44) AT=595.025n

.meas tran vdout0_45ck1180 FIND v(dout0_45) AT=595.025n

.meas tran vdout0_46ck1180 FIND v(dout0_46) AT=595.025n

.meas tran vdout0_47ck1180 FIND v(dout0_47) AT=595.025n

.meas tran vdout0_48ck1180 FIND v(dout0_48) AT=595.025n

.meas tran vdout0_49ck1180 FIND v(dout0_49) AT=595.025n

.meas tran vdout0_50ck1180 FIND v(dout0_50) AT=595.025n

.meas tran vdout0_51ck1180 FIND v(dout0_51) AT=595.025n

.meas tran vdout0_52ck1180 FIND v(dout0_52) AT=595.025n

.meas tran vdout0_53ck1180 FIND v(dout0_53) AT=595.025n

.meas tran vdout0_54ck1180 FIND v(dout0_54) AT=595.025n

.meas tran vdout0_55ck1180 FIND v(dout0_55) AT=595.025n

.meas tran vdout0_56ck1180 FIND v(dout0_56) AT=595.025n

.meas tran vdout0_57ck1180 FIND v(dout0_57) AT=595.025n

.meas tran vdout0_58ck1180 FIND v(dout0_58) AT=595.025n

.meas tran vdout0_59ck1180 FIND v(dout0_59) AT=595.025n

.meas tran vdout0_60ck1180 FIND v(dout0_60) AT=595.025n

.meas tran vdout0_61ck1180 FIND v(dout0_61) AT=595.025n

.meas tran vdout0_62ck1180 FIND v(dout0_62) AT=595.025n

.meas tran vdout0_63ck1180 FIND v(dout0_63) AT=595.025n

.meas tran vdout0_64ck1180 FIND v(dout0_64) AT=595.025n

.meas tran vdout0_65ck1180 FIND v(dout0_65) AT=595.025n

.meas tran vdout0_66ck1180 FIND v(dout0_66) AT=595.025n

.meas tran vdout0_67ck1180 FIND v(dout0_67) AT=595.025n

.meas tran vdout0_68ck1180 FIND v(dout0_68) AT=595.025n

.meas tran vdout0_69ck1180 FIND v(dout0_69) AT=595.025n

.meas tran vdout0_70ck1180 FIND v(dout0_70) AT=595.025n

.meas tran vdout0_71ck1180 FIND v(dout0_71) AT=595.025n

.meas tran vdout0_72ck1180 FIND v(dout0_72) AT=595.025n

.meas tran vdout0_73ck1180 FIND v(dout0_73) AT=595.025n

.meas tran vdout0_74ck1180 FIND v(dout0_74) AT=595.025n

.meas tran vdout0_75ck1180 FIND v(dout0_75) AT=595.025n

.meas tran vdout0_76ck1180 FIND v(dout0_76) AT=595.025n

.meas tran vdout0_77ck1180 FIND v(dout0_77) AT=595.025n

.meas tran vdout0_78ck1180 FIND v(dout0_78) AT=595.025n

.meas tran vdout0_79ck1180 FIND v(dout0_79) AT=595.025n

.meas tran vdout0_80ck1180 FIND v(dout0_80) AT=595.025n

.meas tran vdout0_81ck1180 FIND v(dout0_81) AT=595.025n

.meas tran vdout0_82ck1180 FIND v(dout0_82) AT=595.025n

.meas tran vdout0_83ck1180 FIND v(dout0_83) AT=595.025n

.meas tran vdout0_84ck1180 FIND v(dout0_84) AT=595.025n

.meas tran vdout0_85ck1180 FIND v(dout0_85) AT=595.025n

.meas tran vdout0_86ck1180 FIND v(dout0_86) AT=595.025n

.meas tran vdout0_87ck1180 FIND v(dout0_87) AT=595.025n

.meas tran vdout0_88ck1180 FIND v(dout0_88) AT=595.025n

.meas tran vdout0_89ck1180 FIND v(dout0_89) AT=595.025n

.meas tran vdout0_90ck1180 FIND v(dout0_90) AT=595.025n

.meas tran vdout0_91ck1180 FIND v(dout0_91) AT=595.025n

.meas tran vdout0_92ck1180 FIND v(dout0_92) AT=595.025n

.meas tran vdout0_93ck1180 FIND v(dout0_93) AT=595.025n

.meas tran vdout0_94ck1180 FIND v(dout0_94) AT=595.025n

.meas tran vdout0_95ck1180 FIND v(dout0_95) AT=595.025n

.meas tran vdout0_96ck1180 FIND v(dout0_96) AT=595.025n

.meas tran vdout0_97ck1180 FIND v(dout0_97) AT=595.025n

.meas tran vdout0_98ck1180 FIND v(dout0_98) AT=595.025n

.meas tran vdout0_99ck1180 FIND v(dout0_99) AT=595.025n

.meas tran vdout0_100ck1180 FIND v(dout0_100) AT=595.025n

.meas tran vdout0_101ck1180 FIND v(dout0_101) AT=595.025n

.meas tran vdout0_102ck1180 FIND v(dout0_102) AT=595.025n

.meas tran vdout0_103ck1180 FIND v(dout0_103) AT=595.025n

.meas tran vdout0_104ck1180 FIND v(dout0_104) AT=595.025n

.meas tran vdout0_105ck1180 FIND v(dout0_105) AT=595.025n

.meas tran vdout0_106ck1180 FIND v(dout0_106) AT=595.025n

.meas tran vdout0_107ck1180 FIND v(dout0_107) AT=595.025n

.meas tran vdout0_108ck1180 FIND v(dout0_108) AT=595.025n

.meas tran vdout0_109ck1180 FIND v(dout0_109) AT=595.025n

.meas tran vdout0_110ck1180 FIND v(dout0_110) AT=595.025n

.meas tran vdout0_111ck1180 FIND v(dout0_111) AT=595.025n

.meas tran vdout0_112ck1180 FIND v(dout0_112) AT=595.025n

.meas tran vdout0_113ck1180 FIND v(dout0_113) AT=595.025n

.meas tran vdout0_114ck1180 FIND v(dout0_114) AT=595.025n

.meas tran vdout0_115ck1180 FIND v(dout0_115) AT=595.025n

.meas tran vdout0_116ck1180 FIND v(dout0_116) AT=595.025n

.meas tran vdout0_117ck1180 FIND v(dout0_117) AT=595.025n

.meas tran vdout0_118ck1180 FIND v(dout0_118) AT=595.025n

.meas tran vdout0_119ck1180 FIND v(dout0_119) AT=595.025n

.meas tran vdout0_120ck1180 FIND v(dout0_120) AT=595.025n

.meas tran vdout0_121ck1180 FIND v(dout0_121) AT=595.025n

.meas tran vdout0_122ck1180 FIND v(dout0_122) AT=595.025n

.meas tran vdout0_123ck1180 FIND v(dout0_123) AT=595.025n

.meas tran vdout0_124ck1180 FIND v(dout0_124) AT=595.025n

.meas tran vdout0_125ck1180 FIND v(dout0_125) AT=595.025n

.meas tran vdout0_126ck1180 FIND v(dout0_126) AT=595.025n

.meas tran vdout0_127ck1180 FIND v(dout0_127) AT=595.025n

.meas tran vdout0_0ck1190 FIND v(dout0_0) AT=600.025n

.meas tran vdout0_1ck1190 FIND v(dout0_1) AT=600.025n

.meas tran vdout0_2ck1190 FIND v(dout0_2) AT=600.025n

.meas tran vdout0_3ck1190 FIND v(dout0_3) AT=600.025n

.meas tran vdout0_4ck1190 FIND v(dout0_4) AT=600.025n

.meas tran vdout0_5ck1190 FIND v(dout0_5) AT=600.025n

.meas tran vdout0_6ck1190 FIND v(dout0_6) AT=600.025n

.meas tran vdout0_7ck1190 FIND v(dout0_7) AT=600.025n

.meas tran vdout0_8ck1190 FIND v(dout0_8) AT=600.025n

.meas tran vdout0_9ck1190 FIND v(dout0_9) AT=600.025n

.meas tran vdout0_10ck1190 FIND v(dout0_10) AT=600.025n

.meas tran vdout0_11ck1190 FIND v(dout0_11) AT=600.025n

.meas tran vdout0_12ck1190 FIND v(dout0_12) AT=600.025n

.meas tran vdout0_13ck1190 FIND v(dout0_13) AT=600.025n

.meas tran vdout0_14ck1190 FIND v(dout0_14) AT=600.025n

.meas tran vdout0_15ck1190 FIND v(dout0_15) AT=600.025n

.meas tran vdout0_16ck1190 FIND v(dout0_16) AT=600.025n

.meas tran vdout0_17ck1190 FIND v(dout0_17) AT=600.025n

.meas tran vdout0_18ck1190 FIND v(dout0_18) AT=600.025n

.meas tran vdout0_19ck1190 FIND v(dout0_19) AT=600.025n

.meas tran vdout0_20ck1190 FIND v(dout0_20) AT=600.025n

.meas tran vdout0_21ck1190 FIND v(dout0_21) AT=600.025n

.meas tran vdout0_22ck1190 FIND v(dout0_22) AT=600.025n

.meas tran vdout0_23ck1190 FIND v(dout0_23) AT=600.025n

.meas tran vdout0_24ck1190 FIND v(dout0_24) AT=600.025n

.meas tran vdout0_25ck1190 FIND v(dout0_25) AT=600.025n

.meas tran vdout0_26ck1190 FIND v(dout0_26) AT=600.025n

.meas tran vdout0_27ck1190 FIND v(dout0_27) AT=600.025n

.meas tran vdout0_28ck1190 FIND v(dout0_28) AT=600.025n

.meas tran vdout0_29ck1190 FIND v(dout0_29) AT=600.025n

.meas tran vdout0_30ck1190 FIND v(dout0_30) AT=600.025n

.meas tran vdout0_31ck1190 FIND v(dout0_31) AT=600.025n

.meas tran vdout0_32ck1190 FIND v(dout0_32) AT=600.025n

.meas tran vdout0_33ck1190 FIND v(dout0_33) AT=600.025n

.meas tran vdout0_34ck1190 FIND v(dout0_34) AT=600.025n

.meas tran vdout0_35ck1190 FIND v(dout0_35) AT=600.025n

.meas tran vdout0_36ck1190 FIND v(dout0_36) AT=600.025n

.meas tran vdout0_37ck1190 FIND v(dout0_37) AT=600.025n

.meas tran vdout0_38ck1190 FIND v(dout0_38) AT=600.025n

.meas tran vdout0_39ck1190 FIND v(dout0_39) AT=600.025n

.meas tran vdout0_40ck1190 FIND v(dout0_40) AT=600.025n

.meas tran vdout0_41ck1190 FIND v(dout0_41) AT=600.025n

.meas tran vdout0_42ck1190 FIND v(dout0_42) AT=600.025n

.meas tran vdout0_43ck1190 FIND v(dout0_43) AT=600.025n

.meas tran vdout0_44ck1190 FIND v(dout0_44) AT=600.025n

.meas tran vdout0_45ck1190 FIND v(dout0_45) AT=600.025n

.meas tran vdout0_46ck1190 FIND v(dout0_46) AT=600.025n

.meas tran vdout0_47ck1190 FIND v(dout0_47) AT=600.025n

.meas tran vdout0_48ck1190 FIND v(dout0_48) AT=600.025n

.meas tran vdout0_49ck1190 FIND v(dout0_49) AT=600.025n

.meas tran vdout0_50ck1190 FIND v(dout0_50) AT=600.025n

.meas tran vdout0_51ck1190 FIND v(dout0_51) AT=600.025n

.meas tran vdout0_52ck1190 FIND v(dout0_52) AT=600.025n

.meas tran vdout0_53ck1190 FIND v(dout0_53) AT=600.025n

.meas tran vdout0_54ck1190 FIND v(dout0_54) AT=600.025n

.meas tran vdout0_55ck1190 FIND v(dout0_55) AT=600.025n

.meas tran vdout0_56ck1190 FIND v(dout0_56) AT=600.025n

.meas tran vdout0_57ck1190 FIND v(dout0_57) AT=600.025n

.meas tran vdout0_58ck1190 FIND v(dout0_58) AT=600.025n

.meas tran vdout0_59ck1190 FIND v(dout0_59) AT=600.025n

.meas tran vdout0_60ck1190 FIND v(dout0_60) AT=600.025n

.meas tran vdout0_61ck1190 FIND v(dout0_61) AT=600.025n

.meas tran vdout0_62ck1190 FIND v(dout0_62) AT=600.025n

.meas tran vdout0_63ck1190 FIND v(dout0_63) AT=600.025n

.meas tran vdout0_64ck1190 FIND v(dout0_64) AT=600.025n

.meas tran vdout0_65ck1190 FIND v(dout0_65) AT=600.025n

.meas tran vdout0_66ck1190 FIND v(dout0_66) AT=600.025n

.meas tran vdout0_67ck1190 FIND v(dout0_67) AT=600.025n

.meas tran vdout0_68ck1190 FIND v(dout0_68) AT=600.025n

.meas tran vdout0_69ck1190 FIND v(dout0_69) AT=600.025n

.meas tran vdout0_70ck1190 FIND v(dout0_70) AT=600.025n

.meas tran vdout0_71ck1190 FIND v(dout0_71) AT=600.025n

.meas tran vdout0_72ck1190 FIND v(dout0_72) AT=600.025n

.meas tran vdout0_73ck1190 FIND v(dout0_73) AT=600.025n

.meas tran vdout0_74ck1190 FIND v(dout0_74) AT=600.025n

.meas tran vdout0_75ck1190 FIND v(dout0_75) AT=600.025n

.meas tran vdout0_76ck1190 FIND v(dout0_76) AT=600.025n

.meas tran vdout0_77ck1190 FIND v(dout0_77) AT=600.025n

.meas tran vdout0_78ck1190 FIND v(dout0_78) AT=600.025n

.meas tran vdout0_79ck1190 FIND v(dout0_79) AT=600.025n

.meas tran vdout0_80ck1190 FIND v(dout0_80) AT=600.025n

.meas tran vdout0_81ck1190 FIND v(dout0_81) AT=600.025n

.meas tran vdout0_82ck1190 FIND v(dout0_82) AT=600.025n

.meas tran vdout0_83ck1190 FIND v(dout0_83) AT=600.025n

.meas tran vdout0_84ck1190 FIND v(dout0_84) AT=600.025n

.meas tran vdout0_85ck1190 FIND v(dout0_85) AT=600.025n

.meas tran vdout0_86ck1190 FIND v(dout0_86) AT=600.025n

.meas tran vdout0_87ck1190 FIND v(dout0_87) AT=600.025n

.meas tran vdout0_88ck1190 FIND v(dout0_88) AT=600.025n

.meas tran vdout0_89ck1190 FIND v(dout0_89) AT=600.025n

.meas tran vdout0_90ck1190 FIND v(dout0_90) AT=600.025n

.meas tran vdout0_91ck1190 FIND v(dout0_91) AT=600.025n

.meas tran vdout0_92ck1190 FIND v(dout0_92) AT=600.025n

.meas tran vdout0_93ck1190 FIND v(dout0_93) AT=600.025n

.meas tran vdout0_94ck1190 FIND v(dout0_94) AT=600.025n

.meas tran vdout0_95ck1190 FIND v(dout0_95) AT=600.025n

.meas tran vdout0_96ck1190 FIND v(dout0_96) AT=600.025n

.meas tran vdout0_97ck1190 FIND v(dout0_97) AT=600.025n

.meas tran vdout0_98ck1190 FIND v(dout0_98) AT=600.025n

.meas tran vdout0_99ck1190 FIND v(dout0_99) AT=600.025n

.meas tran vdout0_100ck1190 FIND v(dout0_100) AT=600.025n

.meas tran vdout0_101ck1190 FIND v(dout0_101) AT=600.025n

.meas tran vdout0_102ck1190 FIND v(dout0_102) AT=600.025n

.meas tran vdout0_103ck1190 FIND v(dout0_103) AT=600.025n

.meas tran vdout0_104ck1190 FIND v(dout0_104) AT=600.025n

.meas tran vdout0_105ck1190 FIND v(dout0_105) AT=600.025n

.meas tran vdout0_106ck1190 FIND v(dout0_106) AT=600.025n

.meas tran vdout0_107ck1190 FIND v(dout0_107) AT=600.025n

.meas tran vdout0_108ck1190 FIND v(dout0_108) AT=600.025n

.meas tran vdout0_109ck1190 FIND v(dout0_109) AT=600.025n

.meas tran vdout0_110ck1190 FIND v(dout0_110) AT=600.025n

.meas tran vdout0_111ck1190 FIND v(dout0_111) AT=600.025n

.meas tran vdout0_112ck1190 FIND v(dout0_112) AT=600.025n

.meas tran vdout0_113ck1190 FIND v(dout0_113) AT=600.025n

.meas tran vdout0_114ck1190 FIND v(dout0_114) AT=600.025n

.meas tran vdout0_115ck1190 FIND v(dout0_115) AT=600.025n

.meas tran vdout0_116ck1190 FIND v(dout0_116) AT=600.025n

.meas tran vdout0_117ck1190 FIND v(dout0_117) AT=600.025n

.meas tran vdout0_118ck1190 FIND v(dout0_118) AT=600.025n

.meas tran vdout0_119ck1190 FIND v(dout0_119) AT=600.025n

.meas tran vdout0_120ck1190 FIND v(dout0_120) AT=600.025n

.meas tran vdout0_121ck1190 FIND v(dout0_121) AT=600.025n

.meas tran vdout0_122ck1190 FIND v(dout0_122) AT=600.025n

.meas tran vdout0_123ck1190 FIND v(dout0_123) AT=600.025n

.meas tran vdout0_124ck1190 FIND v(dout0_124) AT=600.025n

.meas tran vdout0_125ck1190 FIND v(dout0_125) AT=600.025n

.meas tran vdout0_126ck1190 FIND v(dout0_126) AT=600.025n

.meas tran vdout0_127ck1190 FIND v(dout0_127) AT=600.025n

.meas tran vdout0_0ck1200 FIND v(dout0_0) AT=605.025n

.meas tran vdout0_1ck1200 FIND v(dout0_1) AT=605.025n

.meas tran vdout0_2ck1200 FIND v(dout0_2) AT=605.025n

.meas tran vdout0_3ck1200 FIND v(dout0_3) AT=605.025n

.meas tran vdout0_4ck1200 FIND v(dout0_4) AT=605.025n

.meas tran vdout0_5ck1200 FIND v(dout0_5) AT=605.025n

.meas tran vdout0_6ck1200 FIND v(dout0_6) AT=605.025n

.meas tran vdout0_7ck1200 FIND v(dout0_7) AT=605.025n

.meas tran vdout0_8ck1200 FIND v(dout0_8) AT=605.025n

.meas tran vdout0_9ck1200 FIND v(dout0_9) AT=605.025n

.meas tran vdout0_10ck1200 FIND v(dout0_10) AT=605.025n

.meas tran vdout0_11ck1200 FIND v(dout0_11) AT=605.025n

.meas tran vdout0_12ck1200 FIND v(dout0_12) AT=605.025n

.meas tran vdout0_13ck1200 FIND v(dout0_13) AT=605.025n

.meas tran vdout0_14ck1200 FIND v(dout0_14) AT=605.025n

.meas tran vdout0_15ck1200 FIND v(dout0_15) AT=605.025n

.meas tran vdout0_16ck1200 FIND v(dout0_16) AT=605.025n

.meas tran vdout0_17ck1200 FIND v(dout0_17) AT=605.025n

.meas tran vdout0_18ck1200 FIND v(dout0_18) AT=605.025n

.meas tran vdout0_19ck1200 FIND v(dout0_19) AT=605.025n

.meas tran vdout0_20ck1200 FIND v(dout0_20) AT=605.025n

.meas tran vdout0_21ck1200 FIND v(dout0_21) AT=605.025n

.meas tran vdout0_22ck1200 FIND v(dout0_22) AT=605.025n

.meas tran vdout0_23ck1200 FIND v(dout0_23) AT=605.025n

.meas tran vdout0_24ck1200 FIND v(dout0_24) AT=605.025n

.meas tran vdout0_25ck1200 FIND v(dout0_25) AT=605.025n

.meas tran vdout0_26ck1200 FIND v(dout0_26) AT=605.025n

.meas tran vdout0_27ck1200 FIND v(dout0_27) AT=605.025n

.meas tran vdout0_28ck1200 FIND v(dout0_28) AT=605.025n

.meas tran vdout0_29ck1200 FIND v(dout0_29) AT=605.025n

.meas tran vdout0_30ck1200 FIND v(dout0_30) AT=605.025n

.meas tran vdout0_31ck1200 FIND v(dout0_31) AT=605.025n

.meas tran vdout0_32ck1200 FIND v(dout0_32) AT=605.025n

.meas tran vdout0_33ck1200 FIND v(dout0_33) AT=605.025n

.meas tran vdout0_34ck1200 FIND v(dout0_34) AT=605.025n

.meas tran vdout0_35ck1200 FIND v(dout0_35) AT=605.025n

.meas tran vdout0_36ck1200 FIND v(dout0_36) AT=605.025n

.meas tran vdout0_37ck1200 FIND v(dout0_37) AT=605.025n

.meas tran vdout0_38ck1200 FIND v(dout0_38) AT=605.025n

.meas tran vdout0_39ck1200 FIND v(dout0_39) AT=605.025n

.meas tran vdout0_40ck1200 FIND v(dout0_40) AT=605.025n

.meas tran vdout0_41ck1200 FIND v(dout0_41) AT=605.025n

.meas tran vdout0_42ck1200 FIND v(dout0_42) AT=605.025n

.meas tran vdout0_43ck1200 FIND v(dout0_43) AT=605.025n

.meas tran vdout0_44ck1200 FIND v(dout0_44) AT=605.025n

.meas tran vdout0_45ck1200 FIND v(dout0_45) AT=605.025n

.meas tran vdout0_46ck1200 FIND v(dout0_46) AT=605.025n

.meas tran vdout0_47ck1200 FIND v(dout0_47) AT=605.025n

.meas tran vdout0_48ck1200 FIND v(dout0_48) AT=605.025n

.meas tran vdout0_49ck1200 FIND v(dout0_49) AT=605.025n

.meas tran vdout0_50ck1200 FIND v(dout0_50) AT=605.025n

.meas tran vdout0_51ck1200 FIND v(dout0_51) AT=605.025n

.meas tran vdout0_52ck1200 FIND v(dout0_52) AT=605.025n

.meas tran vdout0_53ck1200 FIND v(dout0_53) AT=605.025n

.meas tran vdout0_54ck1200 FIND v(dout0_54) AT=605.025n

.meas tran vdout0_55ck1200 FIND v(dout0_55) AT=605.025n

.meas tran vdout0_56ck1200 FIND v(dout0_56) AT=605.025n

.meas tran vdout0_57ck1200 FIND v(dout0_57) AT=605.025n

.meas tran vdout0_58ck1200 FIND v(dout0_58) AT=605.025n

.meas tran vdout0_59ck1200 FIND v(dout0_59) AT=605.025n

.meas tran vdout0_60ck1200 FIND v(dout0_60) AT=605.025n

.meas tran vdout0_61ck1200 FIND v(dout0_61) AT=605.025n

.meas tran vdout0_62ck1200 FIND v(dout0_62) AT=605.025n

.meas tran vdout0_63ck1200 FIND v(dout0_63) AT=605.025n

.meas tran vdout0_64ck1200 FIND v(dout0_64) AT=605.025n

.meas tran vdout0_65ck1200 FIND v(dout0_65) AT=605.025n

.meas tran vdout0_66ck1200 FIND v(dout0_66) AT=605.025n

.meas tran vdout0_67ck1200 FIND v(dout0_67) AT=605.025n

.meas tran vdout0_68ck1200 FIND v(dout0_68) AT=605.025n

.meas tran vdout0_69ck1200 FIND v(dout0_69) AT=605.025n

.meas tran vdout0_70ck1200 FIND v(dout0_70) AT=605.025n

.meas tran vdout0_71ck1200 FIND v(dout0_71) AT=605.025n

.meas tran vdout0_72ck1200 FIND v(dout0_72) AT=605.025n

.meas tran vdout0_73ck1200 FIND v(dout0_73) AT=605.025n

.meas tran vdout0_74ck1200 FIND v(dout0_74) AT=605.025n

.meas tran vdout0_75ck1200 FIND v(dout0_75) AT=605.025n

.meas tran vdout0_76ck1200 FIND v(dout0_76) AT=605.025n

.meas tran vdout0_77ck1200 FIND v(dout0_77) AT=605.025n

.meas tran vdout0_78ck1200 FIND v(dout0_78) AT=605.025n

.meas tran vdout0_79ck1200 FIND v(dout0_79) AT=605.025n

.meas tran vdout0_80ck1200 FIND v(dout0_80) AT=605.025n

.meas tran vdout0_81ck1200 FIND v(dout0_81) AT=605.025n

.meas tran vdout0_82ck1200 FIND v(dout0_82) AT=605.025n

.meas tran vdout0_83ck1200 FIND v(dout0_83) AT=605.025n

.meas tran vdout0_84ck1200 FIND v(dout0_84) AT=605.025n

.meas tran vdout0_85ck1200 FIND v(dout0_85) AT=605.025n

.meas tran vdout0_86ck1200 FIND v(dout0_86) AT=605.025n

.meas tran vdout0_87ck1200 FIND v(dout0_87) AT=605.025n

.meas tran vdout0_88ck1200 FIND v(dout0_88) AT=605.025n

.meas tran vdout0_89ck1200 FIND v(dout0_89) AT=605.025n

.meas tran vdout0_90ck1200 FIND v(dout0_90) AT=605.025n

.meas tran vdout0_91ck1200 FIND v(dout0_91) AT=605.025n

.meas tran vdout0_92ck1200 FIND v(dout0_92) AT=605.025n

.meas tran vdout0_93ck1200 FIND v(dout0_93) AT=605.025n

.meas tran vdout0_94ck1200 FIND v(dout0_94) AT=605.025n

.meas tran vdout0_95ck1200 FIND v(dout0_95) AT=605.025n

.meas tran vdout0_96ck1200 FIND v(dout0_96) AT=605.025n

.meas tran vdout0_97ck1200 FIND v(dout0_97) AT=605.025n

.meas tran vdout0_98ck1200 FIND v(dout0_98) AT=605.025n

.meas tran vdout0_99ck1200 FIND v(dout0_99) AT=605.025n

.meas tran vdout0_100ck1200 FIND v(dout0_100) AT=605.025n

.meas tran vdout0_101ck1200 FIND v(dout0_101) AT=605.025n

.meas tran vdout0_102ck1200 FIND v(dout0_102) AT=605.025n

.meas tran vdout0_103ck1200 FIND v(dout0_103) AT=605.025n

.meas tran vdout0_104ck1200 FIND v(dout0_104) AT=605.025n

.meas tran vdout0_105ck1200 FIND v(dout0_105) AT=605.025n

.meas tran vdout0_106ck1200 FIND v(dout0_106) AT=605.025n

.meas tran vdout0_107ck1200 FIND v(dout0_107) AT=605.025n

.meas tran vdout0_108ck1200 FIND v(dout0_108) AT=605.025n

.meas tran vdout0_109ck1200 FIND v(dout0_109) AT=605.025n

.meas tran vdout0_110ck1200 FIND v(dout0_110) AT=605.025n

.meas tran vdout0_111ck1200 FIND v(dout0_111) AT=605.025n

.meas tran vdout0_112ck1200 FIND v(dout0_112) AT=605.025n

.meas tran vdout0_113ck1200 FIND v(dout0_113) AT=605.025n

.meas tran vdout0_114ck1200 FIND v(dout0_114) AT=605.025n

.meas tran vdout0_115ck1200 FIND v(dout0_115) AT=605.025n

.meas tran vdout0_116ck1200 FIND v(dout0_116) AT=605.025n

.meas tran vdout0_117ck1200 FIND v(dout0_117) AT=605.025n

.meas tran vdout0_118ck1200 FIND v(dout0_118) AT=605.025n

.meas tran vdout0_119ck1200 FIND v(dout0_119) AT=605.025n

.meas tran vdout0_120ck1200 FIND v(dout0_120) AT=605.025n

.meas tran vdout0_121ck1200 FIND v(dout0_121) AT=605.025n

.meas tran vdout0_122ck1200 FIND v(dout0_122) AT=605.025n

.meas tran vdout0_123ck1200 FIND v(dout0_123) AT=605.025n

.meas tran vdout0_124ck1200 FIND v(dout0_124) AT=605.025n

.meas tran vdout0_125ck1200 FIND v(dout0_125) AT=605.025n

.meas tran vdout0_126ck1200 FIND v(dout0_126) AT=605.025n

.meas tran vdout0_127ck1200 FIND v(dout0_127) AT=605.025n

.meas tran vdout0_0ck1230 FIND v(dout0_0) AT=620.025n

.meas tran vdout0_1ck1230 FIND v(dout0_1) AT=620.025n

.meas tran vdout0_2ck1230 FIND v(dout0_2) AT=620.025n

.meas tran vdout0_3ck1230 FIND v(dout0_3) AT=620.025n

.meas tran vdout0_4ck1230 FIND v(dout0_4) AT=620.025n

.meas tran vdout0_5ck1230 FIND v(dout0_5) AT=620.025n

.meas tran vdout0_6ck1230 FIND v(dout0_6) AT=620.025n

.meas tran vdout0_7ck1230 FIND v(dout0_7) AT=620.025n

.meas tran vdout0_8ck1230 FIND v(dout0_8) AT=620.025n

.meas tran vdout0_9ck1230 FIND v(dout0_9) AT=620.025n

.meas tran vdout0_10ck1230 FIND v(dout0_10) AT=620.025n

.meas tran vdout0_11ck1230 FIND v(dout0_11) AT=620.025n

.meas tran vdout0_12ck1230 FIND v(dout0_12) AT=620.025n

.meas tran vdout0_13ck1230 FIND v(dout0_13) AT=620.025n

.meas tran vdout0_14ck1230 FIND v(dout0_14) AT=620.025n

.meas tran vdout0_15ck1230 FIND v(dout0_15) AT=620.025n

.meas tran vdout0_16ck1230 FIND v(dout0_16) AT=620.025n

.meas tran vdout0_17ck1230 FIND v(dout0_17) AT=620.025n

.meas tran vdout0_18ck1230 FIND v(dout0_18) AT=620.025n

.meas tran vdout0_19ck1230 FIND v(dout0_19) AT=620.025n

.meas tran vdout0_20ck1230 FIND v(dout0_20) AT=620.025n

.meas tran vdout0_21ck1230 FIND v(dout0_21) AT=620.025n

.meas tran vdout0_22ck1230 FIND v(dout0_22) AT=620.025n

.meas tran vdout0_23ck1230 FIND v(dout0_23) AT=620.025n

.meas tran vdout0_24ck1230 FIND v(dout0_24) AT=620.025n

.meas tran vdout0_25ck1230 FIND v(dout0_25) AT=620.025n

.meas tran vdout0_26ck1230 FIND v(dout0_26) AT=620.025n

.meas tran vdout0_27ck1230 FIND v(dout0_27) AT=620.025n

.meas tran vdout0_28ck1230 FIND v(dout0_28) AT=620.025n

.meas tran vdout0_29ck1230 FIND v(dout0_29) AT=620.025n

.meas tran vdout0_30ck1230 FIND v(dout0_30) AT=620.025n

.meas tran vdout0_31ck1230 FIND v(dout0_31) AT=620.025n

.meas tran vdout0_32ck1230 FIND v(dout0_32) AT=620.025n

.meas tran vdout0_33ck1230 FIND v(dout0_33) AT=620.025n

.meas tran vdout0_34ck1230 FIND v(dout0_34) AT=620.025n

.meas tran vdout0_35ck1230 FIND v(dout0_35) AT=620.025n

.meas tran vdout0_36ck1230 FIND v(dout0_36) AT=620.025n

.meas tran vdout0_37ck1230 FIND v(dout0_37) AT=620.025n

.meas tran vdout0_38ck1230 FIND v(dout0_38) AT=620.025n

.meas tran vdout0_39ck1230 FIND v(dout0_39) AT=620.025n

.meas tran vdout0_40ck1230 FIND v(dout0_40) AT=620.025n

.meas tran vdout0_41ck1230 FIND v(dout0_41) AT=620.025n

.meas tran vdout0_42ck1230 FIND v(dout0_42) AT=620.025n

.meas tran vdout0_43ck1230 FIND v(dout0_43) AT=620.025n

.meas tran vdout0_44ck1230 FIND v(dout0_44) AT=620.025n

.meas tran vdout0_45ck1230 FIND v(dout0_45) AT=620.025n

.meas tran vdout0_46ck1230 FIND v(dout0_46) AT=620.025n

.meas tran vdout0_47ck1230 FIND v(dout0_47) AT=620.025n

.meas tran vdout0_48ck1230 FIND v(dout0_48) AT=620.025n

.meas tran vdout0_49ck1230 FIND v(dout0_49) AT=620.025n

.meas tran vdout0_50ck1230 FIND v(dout0_50) AT=620.025n

.meas tran vdout0_51ck1230 FIND v(dout0_51) AT=620.025n

.meas tran vdout0_52ck1230 FIND v(dout0_52) AT=620.025n

.meas tran vdout0_53ck1230 FIND v(dout0_53) AT=620.025n

.meas tran vdout0_54ck1230 FIND v(dout0_54) AT=620.025n

.meas tran vdout0_55ck1230 FIND v(dout0_55) AT=620.025n

.meas tran vdout0_56ck1230 FIND v(dout0_56) AT=620.025n

.meas tran vdout0_57ck1230 FIND v(dout0_57) AT=620.025n

.meas tran vdout0_58ck1230 FIND v(dout0_58) AT=620.025n

.meas tran vdout0_59ck1230 FIND v(dout0_59) AT=620.025n

.meas tran vdout0_60ck1230 FIND v(dout0_60) AT=620.025n

.meas tran vdout0_61ck1230 FIND v(dout0_61) AT=620.025n

.meas tran vdout0_62ck1230 FIND v(dout0_62) AT=620.025n

.meas tran vdout0_63ck1230 FIND v(dout0_63) AT=620.025n

.meas tran vdout0_64ck1230 FIND v(dout0_64) AT=620.025n

.meas tran vdout0_65ck1230 FIND v(dout0_65) AT=620.025n

.meas tran vdout0_66ck1230 FIND v(dout0_66) AT=620.025n

.meas tran vdout0_67ck1230 FIND v(dout0_67) AT=620.025n

.meas tran vdout0_68ck1230 FIND v(dout0_68) AT=620.025n

.meas tran vdout0_69ck1230 FIND v(dout0_69) AT=620.025n

.meas tran vdout0_70ck1230 FIND v(dout0_70) AT=620.025n

.meas tran vdout0_71ck1230 FIND v(dout0_71) AT=620.025n

.meas tran vdout0_72ck1230 FIND v(dout0_72) AT=620.025n

.meas tran vdout0_73ck1230 FIND v(dout0_73) AT=620.025n

.meas tran vdout0_74ck1230 FIND v(dout0_74) AT=620.025n

.meas tran vdout0_75ck1230 FIND v(dout0_75) AT=620.025n

.meas tran vdout0_76ck1230 FIND v(dout0_76) AT=620.025n

.meas tran vdout0_77ck1230 FIND v(dout0_77) AT=620.025n

.meas tran vdout0_78ck1230 FIND v(dout0_78) AT=620.025n

.meas tran vdout0_79ck1230 FIND v(dout0_79) AT=620.025n

.meas tran vdout0_80ck1230 FIND v(dout0_80) AT=620.025n

.meas tran vdout0_81ck1230 FIND v(dout0_81) AT=620.025n

.meas tran vdout0_82ck1230 FIND v(dout0_82) AT=620.025n

.meas tran vdout0_83ck1230 FIND v(dout0_83) AT=620.025n

.meas tran vdout0_84ck1230 FIND v(dout0_84) AT=620.025n

.meas tran vdout0_85ck1230 FIND v(dout0_85) AT=620.025n

.meas tran vdout0_86ck1230 FIND v(dout0_86) AT=620.025n

.meas tran vdout0_87ck1230 FIND v(dout0_87) AT=620.025n

.meas tran vdout0_88ck1230 FIND v(dout0_88) AT=620.025n

.meas tran vdout0_89ck1230 FIND v(dout0_89) AT=620.025n

.meas tran vdout0_90ck1230 FIND v(dout0_90) AT=620.025n

.meas tran vdout0_91ck1230 FIND v(dout0_91) AT=620.025n

.meas tran vdout0_92ck1230 FIND v(dout0_92) AT=620.025n

.meas tran vdout0_93ck1230 FIND v(dout0_93) AT=620.025n

.meas tran vdout0_94ck1230 FIND v(dout0_94) AT=620.025n

.meas tran vdout0_95ck1230 FIND v(dout0_95) AT=620.025n

.meas tran vdout0_96ck1230 FIND v(dout0_96) AT=620.025n

.meas tran vdout0_97ck1230 FIND v(dout0_97) AT=620.025n

.meas tran vdout0_98ck1230 FIND v(dout0_98) AT=620.025n

.meas tran vdout0_99ck1230 FIND v(dout0_99) AT=620.025n

.meas tran vdout0_100ck1230 FIND v(dout0_100) AT=620.025n

.meas tran vdout0_101ck1230 FIND v(dout0_101) AT=620.025n

.meas tran vdout0_102ck1230 FIND v(dout0_102) AT=620.025n

.meas tran vdout0_103ck1230 FIND v(dout0_103) AT=620.025n

.meas tran vdout0_104ck1230 FIND v(dout0_104) AT=620.025n

.meas tran vdout0_105ck1230 FIND v(dout0_105) AT=620.025n

.meas tran vdout0_106ck1230 FIND v(dout0_106) AT=620.025n

.meas tran vdout0_107ck1230 FIND v(dout0_107) AT=620.025n

.meas tran vdout0_108ck1230 FIND v(dout0_108) AT=620.025n

.meas tran vdout0_109ck1230 FIND v(dout0_109) AT=620.025n

.meas tran vdout0_110ck1230 FIND v(dout0_110) AT=620.025n

.meas tran vdout0_111ck1230 FIND v(dout0_111) AT=620.025n

.meas tran vdout0_112ck1230 FIND v(dout0_112) AT=620.025n

.meas tran vdout0_113ck1230 FIND v(dout0_113) AT=620.025n

.meas tran vdout0_114ck1230 FIND v(dout0_114) AT=620.025n

.meas tran vdout0_115ck1230 FIND v(dout0_115) AT=620.025n

.meas tran vdout0_116ck1230 FIND v(dout0_116) AT=620.025n

.meas tran vdout0_117ck1230 FIND v(dout0_117) AT=620.025n

.meas tran vdout0_118ck1230 FIND v(dout0_118) AT=620.025n

.meas tran vdout0_119ck1230 FIND v(dout0_119) AT=620.025n

.meas tran vdout0_120ck1230 FIND v(dout0_120) AT=620.025n

.meas tran vdout0_121ck1230 FIND v(dout0_121) AT=620.025n

.meas tran vdout0_122ck1230 FIND v(dout0_122) AT=620.025n

.meas tran vdout0_123ck1230 FIND v(dout0_123) AT=620.025n

.meas tran vdout0_124ck1230 FIND v(dout0_124) AT=620.025n

.meas tran vdout0_125ck1230 FIND v(dout0_125) AT=620.025n

.meas tran vdout0_126ck1230 FIND v(dout0_126) AT=620.025n

.meas tran vdout0_127ck1230 FIND v(dout0_127) AT=620.025n

.meas tran vdout0_0ck1250 FIND v(dout0_0) AT=630.025n

.meas tran vdout0_1ck1250 FIND v(dout0_1) AT=630.025n

.meas tran vdout0_2ck1250 FIND v(dout0_2) AT=630.025n

.meas tran vdout0_3ck1250 FIND v(dout0_3) AT=630.025n

.meas tran vdout0_4ck1250 FIND v(dout0_4) AT=630.025n

.meas tran vdout0_5ck1250 FIND v(dout0_5) AT=630.025n

.meas tran vdout0_6ck1250 FIND v(dout0_6) AT=630.025n

.meas tran vdout0_7ck1250 FIND v(dout0_7) AT=630.025n

.meas tran vdout0_8ck1250 FIND v(dout0_8) AT=630.025n

.meas tran vdout0_9ck1250 FIND v(dout0_9) AT=630.025n

.meas tran vdout0_10ck1250 FIND v(dout0_10) AT=630.025n

.meas tran vdout0_11ck1250 FIND v(dout0_11) AT=630.025n

.meas tran vdout0_12ck1250 FIND v(dout0_12) AT=630.025n

.meas tran vdout0_13ck1250 FIND v(dout0_13) AT=630.025n

.meas tran vdout0_14ck1250 FIND v(dout0_14) AT=630.025n

.meas tran vdout0_15ck1250 FIND v(dout0_15) AT=630.025n

.meas tran vdout0_16ck1250 FIND v(dout0_16) AT=630.025n

.meas tran vdout0_17ck1250 FIND v(dout0_17) AT=630.025n

.meas tran vdout0_18ck1250 FIND v(dout0_18) AT=630.025n

.meas tran vdout0_19ck1250 FIND v(dout0_19) AT=630.025n

.meas tran vdout0_20ck1250 FIND v(dout0_20) AT=630.025n

.meas tran vdout0_21ck1250 FIND v(dout0_21) AT=630.025n

.meas tran vdout0_22ck1250 FIND v(dout0_22) AT=630.025n

.meas tran vdout0_23ck1250 FIND v(dout0_23) AT=630.025n

.meas tran vdout0_24ck1250 FIND v(dout0_24) AT=630.025n

.meas tran vdout0_25ck1250 FIND v(dout0_25) AT=630.025n

.meas tran vdout0_26ck1250 FIND v(dout0_26) AT=630.025n

.meas tran vdout0_27ck1250 FIND v(dout0_27) AT=630.025n

.meas tran vdout0_28ck1250 FIND v(dout0_28) AT=630.025n

.meas tran vdout0_29ck1250 FIND v(dout0_29) AT=630.025n

.meas tran vdout0_30ck1250 FIND v(dout0_30) AT=630.025n

.meas tran vdout0_31ck1250 FIND v(dout0_31) AT=630.025n

.meas tran vdout0_32ck1250 FIND v(dout0_32) AT=630.025n

.meas tran vdout0_33ck1250 FIND v(dout0_33) AT=630.025n

.meas tran vdout0_34ck1250 FIND v(dout0_34) AT=630.025n

.meas tran vdout0_35ck1250 FIND v(dout0_35) AT=630.025n

.meas tran vdout0_36ck1250 FIND v(dout0_36) AT=630.025n

.meas tran vdout0_37ck1250 FIND v(dout0_37) AT=630.025n

.meas tran vdout0_38ck1250 FIND v(dout0_38) AT=630.025n

.meas tran vdout0_39ck1250 FIND v(dout0_39) AT=630.025n

.meas tran vdout0_40ck1250 FIND v(dout0_40) AT=630.025n

.meas tran vdout0_41ck1250 FIND v(dout0_41) AT=630.025n

.meas tran vdout0_42ck1250 FIND v(dout0_42) AT=630.025n

.meas tran vdout0_43ck1250 FIND v(dout0_43) AT=630.025n

.meas tran vdout0_44ck1250 FIND v(dout0_44) AT=630.025n

.meas tran vdout0_45ck1250 FIND v(dout0_45) AT=630.025n

.meas tran vdout0_46ck1250 FIND v(dout0_46) AT=630.025n

.meas tran vdout0_47ck1250 FIND v(dout0_47) AT=630.025n

.meas tran vdout0_48ck1250 FIND v(dout0_48) AT=630.025n

.meas tran vdout0_49ck1250 FIND v(dout0_49) AT=630.025n

.meas tran vdout0_50ck1250 FIND v(dout0_50) AT=630.025n

.meas tran vdout0_51ck1250 FIND v(dout0_51) AT=630.025n

.meas tran vdout0_52ck1250 FIND v(dout0_52) AT=630.025n

.meas tran vdout0_53ck1250 FIND v(dout0_53) AT=630.025n

.meas tran vdout0_54ck1250 FIND v(dout0_54) AT=630.025n

.meas tran vdout0_55ck1250 FIND v(dout0_55) AT=630.025n

.meas tran vdout0_56ck1250 FIND v(dout0_56) AT=630.025n

.meas tran vdout0_57ck1250 FIND v(dout0_57) AT=630.025n

.meas tran vdout0_58ck1250 FIND v(dout0_58) AT=630.025n

.meas tran vdout0_59ck1250 FIND v(dout0_59) AT=630.025n

.meas tran vdout0_60ck1250 FIND v(dout0_60) AT=630.025n

.meas tran vdout0_61ck1250 FIND v(dout0_61) AT=630.025n

.meas tran vdout0_62ck1250 FIND v(dout0_62) AT=630.025n

.meas tran vdout0_63ck1250 FIND v(dout0_63) AT=630.025n

.meas tran vdout0_64ck1250 FIND v(dout0_64) AT=630.025n

.meas tran vdout0_65ck1250 FIND v(dout0_65) AT=630.025n

.meas tran vdout0_66ck1250 FIND v(dout0_66) AT=630.025n

.meas tran vdout0_67ck1250 FIND v(dout0_67) AT=630.025n

.meas tran vdout0_68ck1250 FIND v(dout0_68) AT=630.025n

.meas tran vdout0_69ck1250 FIND v(dout0_69) AT=630.025n

.meas tran vdout0_70ck1250 FIND v(dout0_70) AT=630.025n

.meas tran vdout0_71ck1250 FIND v(dout0_71) AT=630.025n

.meas tran vdout0_72ck1250 FIND v(dout0_72) AT=630.025n

.meas tran vdout0_73ck1250 FIND v(dout0_73) AT=630.025n

.meas tran vdout0_74ck1250 FIND v(dout0_74) AT=630.025n

.meas tran vdout0_75ck1250 FIND v(dout0_75) AT=630.025n

.meas tran vdout0_76ck1250 FIND v(dout0_76) AT=630.025n

.meas tran vdout0_77ck1250 FIND v(dout0_77) AT=630.025n

.meas tran vdout0_78ck1250 FIND v(dout0_78) AT=630.025n

.meas tran vdout0_79ck1250 FIND v(dout0_79) AT=630.025n

.meas tran vdout0_80ck1250 FIND v(dout0_80) AT=630.025n

.meas tran vdout0_81ck1250 FIND v(dout0_81) AT=630.025n

.meas tran vdout0_82ck1250 FIND v(dout0_82) AT=630.025n

.meas tran vdout0_83ck1250 FIND v(dout0_83) AT=630.025n

.meas tran vdout0_84ck1250 FIND v(dout0_84) AT=630.025n

.meas tran vdout0_85ck1250 FIND v(dout0_85) AT=630.025n

.meas tran vdout0_86ck1250 FIND v(dout0_86) AT=630.025n

.meas tran vdout0_87ck1250 FIND v(dout0_87) AT=630.025n

.meas tran vdout0_88ck1250 FIND v(dout0_88) AT=630.025n

.meas tran vdout0_89ck1250 FIND v(dout0_89) AT=630.025n

.meas tran vdout0_90ck1250 FIND v(dout0_90) AT=630.025n

.meas tran vdout0_91ck1250 FIND v(dout0_91) AT=630.025n

.meas tran vdout0_92ck1250 FIND v(dout0_92) AT=630.025n

.meas tran vdout0_93ck1250 FIND v(dout0_93) AT=630.025n

.meas tran vdout0_94ck1250 FIND v(dout0_94) AT=630.025n

.meas tran vdout0_95ck1250 FIND v(dout0_95) AT=630.025n

.meas tran vdout0_96ck1250 FIND v(dout0_96) AT=630.025n

.meas tran vdout0_97ck1250 FIND v(dout0_97) AT=630.025n

.meas tran vdout0_98ck1250 FIND v(dout0_98) AT=630.025n

.meas tran vdout0_99ck1250 FIND v(dout0_99) AT=630.025n

.meas tran vdout0_100ck1250 FIND v(dout0_100) AT=630.025n

.meas tran vdout0_101ck1250 FIND v(dout0_101) AT=630.025n

.meas tran vdout0_102ck1250 FIND v(dout0_102) AT=630.025n

.meas tran vdout0_103ck1250 FIND v(dout0_103) AT=630.025n

.meas tran vdout0_104ck1250 FIND v(dout0_104) AT=630.025n

.meas tran vdout0_105ck1250 FIND v(dout0_105) AT=630.025n

.meas tran vdout0_106ck1250 FIND v(dout0_106) AT=630.025n

.meas tran vdout0_107ck1250 FIND v(dout0_107) AT=630.025n

.meas tran vdout0_108ck1250 FIND v(dout0_108) AT=630.025n

.meas tran vdout0_109ck1250 FIND v(dout0_109) AT=630.025n

.meas tran vdout0_110ck1250 FIND v(dout0_110) AT=630.025n

.meas tran vdout0_111ck1250 FIND v(dout0_111) AT=630.025n

.meas tran vdout0_112ck1250 FIND v(dout0_112) AT=630.025n

.meas tran vdout0_113ck1250 FIND v(dout0_113) AT=630.025n

.meas tran vdout0_114ck1250 FIND v(dout0_114) AT=630.025n

.meas tran vdout0_115ck1250 FIND v(dout0_115) AT=630.025n

.meas tran vdout0_116ck1250 FIND v(dout0_116) AT=630.025n

.meas tran vdout0_117ck1250 FIND v(dout0_117) AT=630.025n

.meas tran vdout0_118ck1250 FIND v(dout0_118) AT=630.025n

.meas tran vdout0_119ck1250 FIND v(dout0_119) AT=630.025n

.meas tran vdout0_120ck1250 FIND v(dout0_120) AT=630.025n

.meas tran vdout0_121ck1250 FIND v(dout0_121) AT=630.025n

.meas tran vdout0_122ck1250 FIND v(dout0_122) AT=630.025n

.meas tran vdout0_123ck1250 FIND v(dout0_123) AT=630.025n

.meas tran vdout0_124ck1250 FIND v(dout0_124) AT=630.025n

.meas tran vdout0_125ck1250 FIND v(dout0_125) AT=630.025n

.meas tran vdout0_126ck1250 FIND v(dout0_126) AT=630.025n

.meas tran vdout0_127ck1250 FIND v(dout0_127) AT=630.025n

.meas tran vdout0_0ck1280 FIND v(dout0_0) AT=645.025n

.meas tran vdout0_1ck1280 FIND v(dout0_1) AT=645.025n

.meas tran vdout0_2ck1280 FIND v(dout0_2) AT=645.025n

.meas tran vdout0_3ck1280 FIND v(dout0_3) AT=645.025n

.meas tran vdout0_4ck1280 FIND v(dout0_4) AT=645.025n

.meas tran vdout0_5ck1280 FIND v(dout0_5) AT=645.025n

.meas tran vdout0_6ck1280 FIND v(dout0_6) AT=645.025n

.meas tran vdout0_7ck1280 FIND v(dout0_7) AT=645.025n

.meas tran vdout0_8ck1280 FIND v(dout0_8) AT=645.025n

.meas tran vdout0_9ck1280 FIND v(dout0_9) AT=645.025n

.meas tran vdout0_10ck1280 FIND v(dout0_10) AT=645.025n

.meas tran vdout0_11ck1280 FIND v(dout0_11) AT=645.025n

.meas tran vdout0_12ck1280 FIND v(dout0_12) AT=645.025n

.meas tran vdout0_13ck1280 FIND v(dout0_13) AT=645.025n

.meas tran vdout0_14ck1280 FIND v(dout0_14) AT=645.025n

.meas tran vdout0_15ck1280 FIND v(dout0_15) AT=645.025n

.meas tran vdout0_16ck1280 FIND v(dout0_16) AT=645.025n

.meas tran vdout0_17ck1280 FIND v(dout0_17) AT=645.025n

.meas tran vdout0_18ck1280 FIND v(dout0_18) AT=645.025n

.meas tran vdout0_19ck1280 FIND v(dout0_19) AT=645.025n

.meas tran vdout0_20ck1280 FIND v(dout0_20) AT=645.025n

.meas tran vdout0_21ck1280 FIND v(dout0_21) AT=645.025n

.meas tran vdout0_22ck1280 FIND v(dout0_22) AT=645.025n

.meas tran vdout0_23ck1280 FIND v(dout0_23) AT=645.025n

.meas tran vdout0_24ck1280 FIND v(dout0_24) AT=645.025n

.meas tran vdout0_25ck1280 FIND v(dout0_25) AT=645.025n

.meas tran vdout0_26ck1280 FIND v(dout0_26) AT=645.025n

.meas tran vdout0_27ck1280 FIND v(dout0_27) AT=645.025n

.meas tran vdout0_28ck1280 FIND v(dout0_28) AT=645.025n

.meas tran vdout0_29ck1280 FIND v(dout0_29) AT=645.025n

.meas tran vdout0_30ck1280 FIND v(dout0_30) AT=645.025n

.meas tran vdout0_31ck1280 FIND v(dout0_31) AT=645.025n

.meas tran vdout0_32ck1280 FIND v(dout0_32) AT=645.025n

.meas tran vdout0_33ck1280 FIND v(dout0_33) AT=645.025n

.meas tran vdout0_34ck1280 FIND v(dout0_34) AT=645.025n

.meas tran vdout0_35ck1280 FIND v(dout0_35) AT=645.025n

.meas tran vdout0_36ck1280 FIND v(dout0_36) AT=645.025n

.meas tran vdout0_37ck1280 FIND v(dout0_37) AT=645.025n

.meas tran vdout0_38ck1280 FIND v(dout0_38) AT=645.025n

.meas tran vdout0_39ck1280 FIND v(dout0_39) AT=645.025n

.meas tran vdout0_40ck1280 FIND v(dout0_40) AT=645.025n

.meas tran vdout0_41ck1280 FIND v(dout0_41) AT=645.025n

.meas tran vdout0_42ck1280 FIND v(dout0_42) AT=645.025n

.meas tran vdout0_43ck1280 FIND v(dout0_43) AT=645.025n

.meas tran vdout0_44ck1280 FIND v(dout0_44) AT=645.025n

.meas tran vdout0_45ck1280 FIND v(dout0_45) AT=645.025n

.meas tran vdout0_46ck1280 FIND v(dout0_46) AT=645.025n

.meas tran vdout0_47ck1280 FIND v(dout0_47) AT=645.025n

.meas tran vdout0_48ck1280 FIND v(dout0_48) AT=645.025n

.meas tran vdout0_49ck1280 FIND v(dout0_49) AT=645.025n

.meas tran vdout0_50ck1280 FIND v(dout0_50) AT=645.025n

.meas tran vdout0_51ck1280 FIND v(dout0_51) AT=645.025n

.meas tran vdout0_52ck1280 FIND v(dout0_52) AT=645.025n

.meas tran vdout0_53ck1280 FIND v(dout0_53) AT=645.025n

.meas tran vdout0_54ck1280 FIND v(dout0_54) AT=645.025n

.meas tran vdout0_55ck1280 FIND v(dout0_55) AT=645.025n

.meas tran vdout0_56ck1280 FIND v(dout0_56) AT=645.025n

.meas tran vdout0_57ck1280 FIND v(dout0_57) AT=645.025n

.meas tran vdout0_58ck1280 FIND v(dout0_58) AT=645.025n

.meas tran vdout0_59ck1280 FIND v(dout0_59) AT=645.025n

.meas tran vdout0_60ck1280 FIND v(dout0_60) AT=645.025n

.meas tran vdout0_61ck1280 FIND v(dout0_61) AT=645.025n

.meas tran vdout0_62ck1280 FIND v(dout0_62) AT=645.025n

.meas tran vdout0_63ck1280 FIND v(dout0_63) AT=645.025n

.meas tran vdout0_64ck1280 FIND v(dout0_64) AT=645.025n

.meas tran vdout0_65ck1280 FIND v(dout0_65) AT=645.025n

.meas tran vdout0_66ck1280 FIND v(dout0_66) AT=645.025n

.meas tran vdout0_67ck1280 FIND v(dout0_67) AT=645.025n

.meas tran vdout0_68ck1280 FIND v(dout0_68) AT=645.025n

.meas tran vdout0_69ck1280 FIND v(dout0_69) AT=645.025n

.meas tran vdout0_70ck1280 FIND v(dout0_70) AT=645.025n

.meas tran vdout0_71ck1280 FIND v(dout0_71) AT=645.025n

.meas tran vdout0_72ck1280 FIND v(dout0_72) AT=645.025n

.meas tran vdout0_73ck1280 FIND v(dout0_73) AT=645.025n

.meas tran vdout0_74ck1280 FIND v(dout0_74) AT=645.025n

.meas tran vdout0_75ck1280 FIND v(dout0_75) AT=645.025n

.meas tran vdout0_76ck1280 FIND v(dout0_76) AT=645.025n

.meas tran vdout0_77ck1280 FIND v(dout0_77) AT=645.025n

.meas tran vdout0_78ck1280 FIND v(dout0_78) AT=645.025n

.meas tran vdout0_79ck1280 FIND v(dout0_79) AT=645.025n

.meas tran vdout0_80ck1280 FIND v(dout0_80) AT=645.025n

.meas tran vdout0_81ck1280 FIND v(dout0_81) AT=645.025n

.meas tran vdout0_82ck1280 FIND v(dout0_82) AT=645.025n

.meas tran vdout0_83ck1280 FIND v(dout0_83) AT=645.025n

.meas tran vdout0_84ck1280 FIND v(dout0_84) AT=645.025n

.meas tran vdout0_85ck1280 FIND v(dout0_85) AT=645.025n

.meas tran vdout0_86ck1280 FIND v(dout0_86) AT=645.025n

.meas tran vdout0_87ck1280 FIND v(dout0_87) AT=645.025n

.meas tran vdout0_88ck1280 FIND v(dout0_88) AT=645.025n

.meas tran vdout0_89ck1280 FIND v(dout0_89) AT=645.025n

.meas tran vdout0_90ck1280 FIND v(dout0_90) AT=645.025n

.meas tran vdout0_91ck1280 FIND v(dout0_91) AT=645.025n

.meas tran vdout0_92ck1280 FIND v(dout0_92) AT=645.025n

.meas tran vdout0_93ck1280 FIND v(dout0_93) AT=645.025n

.meas tran vdout0_94ck1280 FIND v(dout0_94) AT=645.025n

.meas tran vdout0_95ck1280 FIND v(dout0_95) AT=645.025n

.meas tran vdout0_96ck1280 FIND v(dout0_96) AT=645.025n

.meas tran vdout0_97ck1280 FIND v(dout0_97) AT=645.025n

.meas tran vdout0_98ck1280 FIND v(dout0_98) AT=645.025n

.meas tran vdout0_99ck1280 FIND v(dout0_99) AT=645.025n

.meas tran vdout0_100ck1280 FIND v(dout0_100) AT=645.025n

.meas tran vdout0_101ck1280 FIND v(dout0_101) AT=645.025n

.meas tran vdout0_102ck1280 FIND v(dout0_102) AT=645.025n

.meas tran vdout0_103ck1280 FIND v(dout0_103) AT=645.025n

.meas tran vdout0_104ck1280 FIND v(dout0_104) AT=645.025n

.meas tran vdout0_105ck1280 FIND v(dout0_105) AT=645.025n

.meas tran vdout0_106ck1280 FIND v(dout0_106) AT=645.025n

.meas tran vdout0_107ck1280 FIND v(dout0_107) AT=645.025n

.meas tran vdout0_108ck1280 FIND v(dout0_108) AT=645.025n

.meas tran vdout0_109ck1280 FIND v(dout0_109) AT=645.025n

.meas tran vdout0_110ck1280 FIND v(dout0_110) AT=645.025n

.meas tran vdout0_111ck1280 FIND v(dout0_111) AT=645.025n

.meas tran vdout0_112ck1280 FIND v(dout0_112) AT=645.025n

.meas tran vdout0_113ck1280 FIND v(dout0_113) AT=645.025n

.meas tran vdout0_114ck1280 FIND v(dout0_114) AT=645.025n

.meas tran vdout0_115ck1280 FIND v(dout0_115) AT=645.025n

.meas tran vdout0_116ck1280 FIND v(dout0_116) AT=645.025n

.meas tran vdout0_117ck1280 FIND v(dout0_117) AT=645.025n

.meas tran vdout0_118ck1280 FIND v(dout0_118) AT=645.025n

.meas tran vdout0_119ck1280 FIND v(dout0_119) AT=645.025n

.meas tran vdout0_120ck1280 FIND v(dout0_120) AT=645.025n

.meas tran vdout0_121ck1280 FIND v(dout0_121) AT=645.025n

.meas tran vdout0_122ck1280 FIND v(dout0_122) AT=645.025n

.meas tran vdout0_123ck1280 FIND v(dout0_123) AT=645.025n

.meas tran vdout0_124ck1280 FIND v(dout0_124) AT=645.025n

.meas tran vdout0_125ck1280 FIND v(dout0_125) AT=645.025n

.meas tran vdout0_126ck1280 FIND v(dout0_126) AT=645.025n

.meas tran vdout0_127ck1280 FIND v(dout0_127) AT=645.025n

.meas tran vdout0_0ck1320 FIND v(dout0_0) AT=665.025n

.meas tran vdout0_1ck1320 FIND v(dout0_1) AT=665.025n

.meas tran vdout0_2ck1320 FIND v(dout0_2) AT=665.025n

.meas tran vdout0_3ck1320 FIND v(dout0_3) AT=665.025n

.meas tran vdout0_4ck1320 FIND v(dout0_4) AT=665.025n

.meas tran vdout0_5ck1320 FIND v(dout0_5) AT=665.025n

.meas tran vdout0_6ck1320 FIND v(dout0_6) AT=665.025n

.meas tran vdout0_7ck1320 FIND v(dout0_7) AT=665.025n

.meas tran vdout0_8ck1320 FIND v(dout0_8) AT=665.025n

.meas tran vdout0_9ck1320 FIND v(dout0_9) AT=665.025n

.meas tran vdout0_10ck1320 FIND v(dout0_10) AT=665.025n

.meas tran vdout0_11ck1320 FIND v(dout0_11) AT=665.025n

.meas tran vdout0_12ck1320 FIND v(dout0_12) AT=665.025n

.meas tran vdout0_13ck1320 FIND v(dout0_13) AT=665.025n

.meas tran vdout0_14ck1320 FIND v(dout0_14) AT=665.025n

.meas tran vdout0_15ck1320 FIND v(dout0_15) AT=665.025n

.meas tran vdout0_16ck1320 FIND v(dout0_16) AT=665.025n

.meas tran vdout0_17ck1320 FIND v(dout0_17) AT=665.025n

.meas tran vdout0_18ck1320 FIND v(dout0_18) AT=665.025n

.meas tran vdout0_19ck1320 FIND v(dout0_19) AT=665.025n

.meas tran vdout0_20ck1320 FIND v(dout0_20) AT=665.025n

.meas tran vdout0_21ck1320 FIND v(dout0_21) AT=665.025n

.meas tran vdout0_22ck1320 FIND v(dout0_22) AT=665.025n

.meas tran vdout0_23ck1320 FIND v(dout0_23) AT=665.025n

.meas tran vdout0_24ck1320 FIND v(dout0_24) AT=665.025n

.meas tran vdout0_25ck1320 FIND v(dout0_25) AT=665.025n

.meas tran vdout0_26ck1320 FIND v(dout0_26) AT=665.025n

.meas tran vdout0_27ck1320 FIND v(dout0_27) AT=665.025n

.meas tran vdout0_28ck1320 FIND v(dout0_28) AT=665.025n

.meas tran vdout0_29ck1320 FIND v(dout0_29) AT=665.025n

.meas tran vdout0_30ck1320 FIND v(dout0_30) AT=665.025n

.meas tran vdout0_31ck1320 FIND v(dout0_31) AT=665.025n

.meas tran vdout0_32ck1320 FIND v(dout0_32) AT=665.025n

.meas tran vdout0_33ck1320 FIND v(dout0_33) AT=665.025n

.meas tran vdout0_34ck1320 FIND v(dout0_34) AT=665.025n

.meas tran vdout0_35ck1320 FIND v(dout0_35) AT=665.025n

.meas tran vdout0_36ck1320 FIND v(dout0_36) AT=665.025n

.meas tran vdout0_37ck1320 FIND v(dout0_37) AT=665.025n

.meas tran vdout0_38ck1320 FIND v(dout0_38) AT=665.025n

.meas tran vdout0_39ck1320 FIND v(dout0_39) AT=665.025n

.meas tran vdout0_40ck1320 FIND v(dout0_40) AT=665.025n

.meas tran vdout0_41ck1320 FIND v(dout0_41) AT=665.025n

.meas tran vdout0_42ck1320 FIND v(dout0_42) AT=665.025n

.meas tran vdout0_43ck1320 FIND v(dout0_43) AT=665.025n

.meas tran vdout0_44ck1320 FIND v(dout0_44) AT=665.025n

.meas tran vdout0_45ck1320 FIND v(dout0_45) AT=665.025n

.meas tran vdout0_46ck1320 FIND v(dout0_46) AT=665.025n

.meas tran vdout0_47ck1320 FIND v(dout0_47) AT=665.025n

.meas tran vdout0_48ck1320 FIND v(dout0_48) AT=665.025n

.meas tran vdout0_49ck1320 FIND v(dout0_49) AT=665.025n

.meas tran vdout0_50ck1320 FIND v(dout0_50) AT=665.025n

.meas tran vdout0_51ck1320 FIND v(dout0_51) AT=665.025n

.meas tran vdout0_52ck1320 FIND v(dout0_52) AT=665.025n

.meas tran vdout0_53ck1320 FIND v(dout0_53) AT=665.025n

.meas tran vdout0_54ck1320 FIND v(dout0_54) AT=665.025n

.meas tran vdout0_55ck1320 FIND v(dout0_55) AT=665.025n

.meas tran vdout0_56ck1320 FIND v(dout0_56) AT=665.025n

.meas tran vdout0_57ck1320 FIND v(dout0_57) AT=665.025n

.meas tran vdout0_58ck1320 FIND v(dout0_58) AT=665.025n

.meas tran vdout0_59ck1320 FIND v(dout0_59) AT=665.025n

.meas tran vdout0_60ck1320 FIND v(dout0_60) AT=665.025n

.meas tran vdout0_61ck1320 FIND v(dout0_61) AT=665.025n

.meas tran vdout0_62ck1320 FIND v(dout0_62) AT=665.025n

.meas tran vdout0_63ck1320 FIND v(dout0_63) AT=665.025n

.meas tran vdout0_64ck1320 FIND v(dout0_64) AT=665.025n

.meas tran vdout0_65ck1320 FIND v(dout0_65) AT=665.025n

.meas tran vdout0_66ck1320 FIND v(dout0_66) AT=665.025n

.meas tran vdout0_67ck1320 FIND v(dout0_67) AT=665.025n

.meas tran vdout0_68ck1320 FIND v(dout0_68) AT=665.025n

.meas tran vdout0_69ck1320 FIND v(dout0_69) AT=665.025n

.meas tran vdout0_70ck1320 FIND v(dout0_70) AT=665.025n

.meas tran vdout0_71ck1320 FIND v(dout0_71) AT=665.025n

.meas tran vdout0_72ck1320 FIND v(dout0_72) AT=665.025n

.meas tran vdout0_73ck1320 FIND v(dout0_73) AT=665.025n

.meas tran vdout0_74ck1320 FIND v(dout0_74) AT=665.025n

.meas tran vdout0_75ck1320 FIND v(dout0_75) AT=665.025n

.meas tran vdout0_76ck1320 FIND v(dout0_76) AT=665.025n

.meas tran vdout0_77ck1320 FIND v(dout0_77) AT=665.025n

.meas tran vdout0_78ck1320 FIND v(dout0_78) AT=665.025n

.meas tran vdout0_79ck1320 FIND v(dout0_79) AT=665.025n

.meas tran vdout0_80ck1320 FIND v(dout0_80) AT=665.025n

.meas tran vdout0_81ck1320 FIND v(dout0_81) AT=665.025n

.meas tran vdout0_82ck1320 FIND v(dout0_82) AT=665.025n

.meas tran vdout0_83ck1320 FIND v(dout0_83) AT=665.025n

.meas tran vdout0_84ck1320 FIND v(dout0_84) AT=665.025n

.meas tran vdout0_85ck1320 FIND v(dout0_85) AT=665.025n

.meas tran vdout0_86ck1320 FIND v(dout0_86) AT=665.025n

.meas tran vdout0_87ck1320 FIND v(dout0_87) AT=665.025n

.meas tran vdout0_88ck1320 FIND v(dout0_88) AT=665.025n

.meas tran vdout0_89ck1320 FIND v(dout0_89) AT=665.025n

.meas tran vdout0_90ck1320 FIND v(dout0_90) AT=665.025n

.meas tran vdout0_91ck1320 FIND v(dout0_91) AT=665.025n

.meas tran vdout0_92ck1320 FIND v(dout0_92) AT=665.025n

.meas tran vdout0_93ck1320 FIND v(dout0_93) AT=665.025n

.meas tran vdout0_94ck1320 FIND v(dout0_94) AT=665.025n

.meas tran vdout0_95ck1320 FIND v(dout0_95) AT=665.025n

.meas tran vdout0_96ck1320 FIND v(dout0_96) AT=665.025n

.meas tran vdout0_97ck1320 FIND v(dout0_97) AT=665.025n

.meas tran vdout0_98ck1320 FIND v(dout0_98) AT=665.025n

.meas tran vdout0_99ck1320 FIND v(dout0_99) AT=665.025n

.meas tran vdout0_100ck1320 FIND v(dout0_100) AT=665.025n

.meas tran vdout0_101ck1320 FIND v(dout0_101) AT=665.025n

.meas tran vdout0_102ck1320 FIND v(dout0_102) AT=665.025n

.meas tran vdout0_103ck1320 FIND v(dout0_103) AT=665.025n

.meas tran vdout0_104ck1320 FIND v(dout0_104) AT=665.025n

.meas tran vdout0_105ck1320 FIND v(dout0_105) AT=665.025n

.meas tran vdout0_106ck1320 FIND v(dout0_106) AT=665.025n

.meas tran vdout0_107ck1320 FIND v(dout0_107) AT=665.025n

.meas tran vdout0_108ck1320 FIND v(dout0_108) AT=665.025n

.meas tran vdout0_109ck1320 FIND v(dout0_109) AT=665.025n

.meas tran vdout0_110ck1320 FIND v(dout0_110) AT=665.025n

.meas tran vdout0_111ck1320 FIND v(dout0_111) AT=665.025n

.meas tran vdout0_112ck1320 FIND v(dout0_112) AT=665.025n

.meas tran vdout0_113ck1320 FIND v(dout0_113) AT=665.025n

.meas tran vdout0_114ck1320 FIND v(dout0_114) AT=665.025n

.meas tran vdout0_115ck1320 FIND v(dout0_115) AT=665.025n

.meas tran vdout0_116ck1320 FIND v(dout0_116) AT=665.025n

.meas tran vdout0_117ck1320 FIND v(dout0_117) AT=665.025n

.meas tran vdout0_118ck1320 FIND v(dout0_118) AT=665.025n

.meas tran vdout0_119ck1320 FIND v(dout0_119) AT=665.025n

.meas tran vdout0_120ck1320 FIND v(dout0_120) AT=665.025n

.meas tran vdout0_121ck1320 FIND v(dout0_121) AT=665.025n

.meas tran vdout0_122ck1320 FIND v(dout0_122) AT=665.025n

.meas tran vdout0_123ck1320 FIND v(dout0_123) AT=665.025n

.meas tran vdout0_124ck1320 FIND v(dout0_124) AT=665.025n

.meas tran vdout0_125ck1320 FIND v(dout0_125) AT=665.025n

.meas tran vdout0_126ck1320 FIND v(dout0_126) AT=665.025n

.meas tran vdout0_127ck1320 FIND v(dout0_127) AT=665.025n

.meas tran vdout0_0ck1340 FIND v(dout0_0) AT=675.025n

.meas tran vdout0_1ck1340 FIND v(dout0_1) AT=675.025n

.meas tran vdout0_2ck1340 FIND v(dout0_2) AT=675.025n

.meas tran vdout0_3ck1340 FIND v(dout0_3) AT=675.025n

.meas tran vdout0_4ck1340 FIND v(dout0_4) AT=675.025n

.meas tran vdout0_5ck1340 FIND v(dout0_5) AT=675.025n

.meas tran vdout0_6ck1340 FIND v(dout0_6) AT=675.025n

.meas tran vdout0_7ck1340 FIND v(dout0_7) AT=675.025n

.meas tran vdout0_8ck1340 FIND v(dout0_8) AT=675.025n

.meas tran vdout0_9ck1340 FIND v(dout0_9) AT=675.025n

.meas tran vdout0_10ck1340 FIND v(dout0_10) AT=675.025n

.meas tran vdout0_11ck1340 FIND v(dout0_11) AT=675.025n

.meas tran vdout0_12ck1340 FIND v(dout0_12) AT=675.025n

.meas tran vdout0_13ck1340 FIND v(dout0_13) AT=675.025n

.meas tran vdout0_14ck1340 FIND v(dout0_14) AT=675.025n

.meas tran vdout0_15ck1340 FIND v(dout0_15) AT=675.025n

.meas tran vdout0_16ck1340 FIND v(dout0_16) AT=675.025n

.meas tran vdout0_17ck1340 FIND v(dout0_17) AT=675.025n

.meas tran vdout0_18ck1340 FIND v(dout0_18) AT=675.025n

.meas tran vdout0_19ck1340 FIND v(dout0_19) AT=675.025n

.meas tran vdout0_20ck1340 FIND v(dout0_20) AT=675.025n

.meas tran vdout0_21ck1340 FIND v(dout0_21) AT=675.025n

.meas tran vdout0_22ck1340 FIND v(dout0_22) AT=675.025n

.meas tran vdout0_23ck1340 FIND v(dout0_23) AT=675.025n

.meas tran vdout0_24ck1340 FIND v(dout0_24) AT=675.025n

.meas tran vdout0_25ck1340 FIND v(dout0_25) AT=675.025n

.meas tran vdout0_26ck1340 FIND v(dout0_26) AT=675.025n

.meas tran vdout0_27ck1340 FIND v(dout0_27) AT=675.025n

.meas tran vdout0_28ck1340 FIND v(dout0_28) AT=675.025n

.meas tran vdout0_29ck1340 FIND v(dout0_29) AT=675.025n

.meas tran vdout0_30ck1340 FIND v(dout0_30) AT=675.025n

.meas tran vdout0_31ck1340 FIND v(dout0_31) AT=675.025n

.meas tran vdout0_32ck1340 FIND v(dout0_32) AT=675.025n

.meas tran vdout0_33ck1340 FIND v(dout0_33) AT=675.025n

.meas tran vdout0_34ck1340 FIND v(dout0_34) AT=675.025n

.meas tran vdout0_35ck1340 FIND v(dout0_35) AT=675.025n

.meas tran vdout0_36ck1340 FIND v(dout0_36) AT=675.025n

.meas tran vdout0_37ck1340 FIND v(dout0_37) AT=675.025n

.meas tran vdout0_38ck1340 FIND v(dout0_38) AT=675.025n

.meas tran vdout0_39ck1340 FIND v(dout0_39) AT=675.025n

.meas tran vdout0_40ck1340 FIND v(dout0_40) AT=675.025n

.meas tran vdout0_41ck1340 FIND v(dout0_41) AT=675.025n

.meas tran vdout0_42ck1340 FIND v(dout0_42) AT=675.025n

.meas tran vdout0_43ck1340 FIND v(dout0_43) AT=675.025n

.meas tran vdout0_44ck1340 FIND v(dout0_44) AT=675.025n

.meas tran vdout0_45ck1340 FIND v(dout0_45) AT=675.025n

.meas tran vdout0_46ck1340 FIND v(dout0_46) AT=675.025n

.meas tran vdout0_47ck1340 FIND v(dout0_47) AT=675.025n

.meas tran vdout0_48ck1340 FIND v(dout0_48) AT=675.025n

.meas tran vdout0_49ck1340 FIND v(dout0_49) AT=675.025n

.meas tran vdout0_50ck1340 FIND v(dout0_50) AT=675.025n

.meas tran vdout0_51ck1340 FIND v(dout0_51) AT=675.025n

.meas tran vdout0_52ck1340 FIND v(dout0_52) AT=675.025n

.meas tran vdout0_53ck1340 FIND v(dout0_53) AT=675.025n

.meas tran vdout0_54ck1340 FIND v(dout0_54) AT=675.025n

.meas tran vdout0_55ck1340 FIND v(dout0_55) AT=675.025n

.meas tran vdout0_56ck1340 FIND v(dout0_56) AT=675.025n

.meas tran vdout0_57ck1340 FIND v(dout0_57) AT=675.025n

.meas tran vdout0_58ck1340 FIND v(dout0_58) AT=675.025n

.meas tran vdout0_59ck1340 FIND v(dout0_59) AT=675.025n

.meas tran vdout0_60ck1340 FIND v(dout0_60) AT=675.025n

.meas tran vdout0_61ck1340 FIND v(dout0_61) AT=675.025n

.meas tran vdout0_62ck1340 FIND v(dout0_62) AT=675.025n

.meas tran vdout0_63ck1340 FIND v(dout0_63) AT=675.025n

.meas tran vdout0_64ck1340 FIND v(dout0_64) AT=675.025n

.meas tran vdout0_65ck1340 FIND v(dout0_65) AT=675.025n

.meas tran vdout0_66ck1340 FIND v(dout0_66) AT=675.025n

.meas tran vdout0_67ck1340 FIND v(dout0_67) AT=675.025n

.meas tran vdout0_68ck1340 FIND v(dout0_68) AT=675.025n

.meas tran vdout0_69ck1340 FIND v(dout0_69) AT=675.025n

.meas tran vdout0_70ck1340 FIND v(dout0_70) AT=675.025n

.meas tran vdout0_71ck1340 FIND v(dout0_71) AT=675.025n

.meas tran vdout0_72ck1340 FIND v(dout0_72) AT=675.025n

.meas tran vdout0_73ck1340 FIND v(dout0_73) AT=675.025n

.meas tran vdout0_74ck1340 FIND v(dout0_74) AT=675.025n

.meas tran vdout0_75ck1340 FIND v(dout0_75) AT=675.025n

.meas tran vdout0_76ck1340 FIND v(dout0_76) AT=675.025n

.meas tran vdout0_77ck1340 FIND v(dout0_77) AT=675.025n

.meas tran vdout0_78ck1340 FIND v(dout0_78) AT=675.025n

.meas tran vdout0_79ck1340 FIND v(dout0_79) AT=675.025n

.meas tran vdout0_80ck1340 FIND v(dout0_80) AT=675.025n

.meas tran vdout0_81ck1340 FIND v(dout0_81) AT=675.025n

.meas tran vdout0_82ck1340 FIND v(dout0_82) AT=675.025n

.meas tran vdout0_83ck1340 FIND v(dout0_83) AT=675.025n

.meas tran vdout0_84ck1340 FIND v(dout0_84) AT=675.025n

.meas tran vdout0_85ck1340 FIND v(dout0_85) AT=675.025n

.meas tran vdout0_86ck1340 FIND v(dout0_86) AT=675.025n

.meas tran vdout0_87ck1340 FIND v(dout0_87) AT=675.025n

.meas tran vdout0_88ck1340 FIND v(dout0_88) AT=675.025n

.meas tran vdout0_89ck1340 FIND v(dout0_89) AT=675.025n

.meas tran vdout0_90ck1340 FIND v(dout0_90) AT=675.025n

.meas tran vdout0_91ck1340 FIND v(dout0_91) AT=675.025n

.meas tran vdout0_92ck1340 FIND v(dout0_92) AT=675.025n

.meas tran vdout0_93ck1340 FIND v(dout0_93) AT=675.025n

.meas tran vdout0_94ck1340 FIND v(dout0_94) AT=675.025n

.meas tran vdout0_95ck1340 FIND v(dout0_95) AT=675.025n

.meas tran vdout0_96ck1340 FIND v(dout0_96) AT=675.025n

.meas tran vdout0_97ck1340 FIND v(dout0_97) AT=675.025n

.meas tran vdout0_98ck1340 FIND v(dout0_98) AT=675.025n

.meas tran vdout0_99ck1340 FIND v(dout0_99) AT=675.025n

.meas tran vdout0_100ck1340 FIND v(dout0_100) AT=675.025n

.meas tran vdout0_101ck1340 FIND v(dout0_101) AT=675.025n

.meas tran vdout0_102ck1340 FIND v(dout0_102) AT=675.025n

.meas tran vdout0_103ck1340 FIND v(dout0_103) AT=675.025n

.meas tran vdout0_104ck1340 FIND v(dout0_104) AT=675.025n

.meas tran vdout0_105ck1340 FIND v(dout0_105) AT=675.025n

.meas tran vdout0_106ck1340 FIND v(dout0_106) AT=675.025n

.meas tran vdout0_107ck1340 FIND v(dout0_107) AT=675.025n

.meas tran vdout0_108ck1340 FIND v(dout0_108) AT=675.025n

.meas tran vdout0_109ck1340 FIND v(dout0_109) AT=675.025n

.meas tran vdout0_110ck1340 FIND v(dout0_110) AT=675.025n

.meas tran vdout0_111ck1340 FIND v(dout0_111) AT=675.025n

.meas tran vdout0_112ck1340 FIND v(dout0_112) AT=675.025n

.meas tran vdout0_113ck1340 FIND v(dout0_113) AT=675.025n

.meas tran vdout0_114ck1340 FIND v(dout0_114) AT=675.025n

.meas tran vdout0_115ck1340 FIND v(dout0_115) AT=675.025n

.meas tran vdout0_116ck1340 FIND v(dout0_116) AT=675.025n

.meas tran vdout0_117ck1340 FIND v(dout0_117) AT=675.025n

.meas tran vdout0_118ck1340 FIND v(dout0_118) AT=675.025n

.meas tran vdout0_119ck1340 FIND v(dout0_119) AT=675.025n

.meas tran vdout0_120ck1340 FIND v(dout0_120) AT=675.025n

.meas tran vdout0_121ck1340 FIND v(dout0_121) AT=675.025n

.meas tran vdout0_122ck1340 FIND v(dout0_122) AT=675.025n

.meas tran vdout0_123ck1340 FIND v(dout0_123) AT=675.025n

.meas tran vdout0_124ck1340 FIND v(dout0_124) AT=675.025n

.meas tran vdout0_125ck1340 FIND v(dout0_125) AT=675.025n

.meas tran vdout0_126ck1340 FIND v(dout0_126) AT=675.025n

.meas tran vdout0_127ck1340 FIND v(dout0_127) AT=675.025n

.meas tran vdout0_0ck1400 FIND v(dout0_0) AT=705.025n

.meas tran vdout0_1ck1400 FIND v(dout0_1) AT=705.025n

.meas tran vdout0_2ck1400 FIND v(dout0_2) AT=705.025n

.meas tran vdout0_3ck1400 FIND v(dout0_3) AT=705.025n

.meas tran vdout0_4ck1400 FIND v(dout0_4) AT=705.025n

.meas tran vdout0_5ck1400 FIND v(dout0_5) AT=705.025n

.meas tran vdout0_6ck1400 FIND v(dout0_6) AT=705.025n

.meas tran vdout0_7ck1400 FIND v(dout0_7) AT=705.025n

.meas tran vdout0_8ck1400 FIND v(dout0_8) AT=705.025n

.meas tran vdout0_9ck1400 FIND v(dout0_9) AT=705.025n

.meas tran vdout0_10ck1400 FIND v(dout0_10) AT=705.025n

.meas tran vdout0_11ck1400 FIND v(dout0_11) AT=705.025n

.meas tran vdout0_12ck1400 FIND v(dout0_12) AT=705.025n

.meas tran vdout0_13ck1400 FIND v(dout0_13) AT=705.025n

.meas tran vdout0_14ck1400 FIND v(dout0_14) AT=705.025n

.meas tran vdout0_15ck1400 FIND v(dout0_15) AT=705.025n

.meas tran vdout0_16ck1400 FIND v(dout0_16) AT=705.025n

.meas tran vdout0_17ck1400 FIND v(dout0_17) AT=705.025n

.meas tran vdout0_18ck1400 FIND v(dout0_18) AT=705.025n

.meas tran vdout0_19ck1400 FIND v(dout0_19) AT=705.025n

.meas tran vdout0_20ck1400 FIND v(dout0_20) AT=705.025n

.meas tran vdout0_21ck1400 FIND v(dout0_21) AT=705.025n

.meas tran vdout0_22ck1400 FIND v(dout0_22) AT=705.025n

.meas tran vdout0_23ck1400 FIND v(dout0_23) AT=705.025n

.meas tran vdout0_24ck1400 FIND v(dout0_24) AT=705.025n

.meas tran vdout0_25ck1400 FIND v(dout0_25) AT=705.025n

.meas tran vdout0_26ck1400 FIND v(dout0_26) AT=705.025n

.meas tran vdout0_27ck1400 FIND v(dout0_27) AT=705.025n

.meas tran vdout0_28ck1400 FIND v(dout0_28) AT=705.025n

.meas tran vdout0_29ck1400 FIND v(dout0_29) AT=705.025n

.meas tran vdout0_30ck1400 FIND v(dout0_30) AT=705.025n

.meas tran vdout0_31ck1400 FIND v(dout0_31) AT=705.025n

.meas tran vdout0_32ck1400 FIND v(dout0_32) AT=705.025n

.meas tran vdout0_33ck1400 FIND v(dout0_33) AT=705.025n

.meas tran vdout0_34ck1400 FIND v(dout0_34) AT=705.025n

.meas tran vdout0_35ck1400 FIND v(dout0_35) AT=705.025n

.meas tran vdout0_36ck1400 FIND v(dout0_36) AT=705.025n

.meas tran vdout0_37ck1400 FIND v(dout0_37) AT=705.025n

.meas tran vdout0_38ck1400 FIND v(dout0_38) AT=705.025n

.meas tran vdout0_39ck1400 FIND v(dout0_39) AT=705.025n

.meas tran vdout0_40ck1400 FIND v(dout0_40) AT=705.025n

.meas tran vdout0_41ck1400 FIND v(dout0_41) AT=705.025n

.meas tran vdout0_42ck1400 FIND v(dout0_42) AT=705.025n

.meas tran vdout0_43ck1400 FIND v(dout0_43) AT=705.025n

.meas tran vdout0_44ck1400 FIND v(dout0_44) AT=705.025n

.meas tran vdout0_45ck1400 FIND v(dout0_45) AT=705.025n

.meas tran vdout0_46ck1400 FIND v(dout0_46) AT=705.025n

.meas tran vdout0_47ck1400 FIND v(dout0_47) AT=705.025n

.meas tran vdout0_48ck1400 FIND v(dout0_48) AT=705.025n

.meas tran vdout0_49ck1400 FIND v(dout0_49) AT=705.025n

.meas tran vdout0_50ck1400 FIND v(dout0_50) AT=705.025n

.meas tran vdout0_51ck1400 FIND v(dout0_51) AT=705.025n

.meas tran vdout0_52ck1400 FIND v(dout0_52) AT=705.025n

.meas tran vdout0_53ck1400 FIND v(dout0_53) AT=705.025n

.meas tran vdout0_54ck1400 FIND v(dout0_54) AT=705.025n

.meas tran vdout0_55ck1400 FIND v(dout0_55) AT=705.025n

.meas tran vdout0_56ck1400 FIND v(dout0_56) AT=705.025n

.meas tran vdout0_57ck1400 FIND v(dout0_57) AT=705.025n

.meas tran vdout0_58ck1400 FIND v(dout0_58) AT=705.025n

.meas tran vdout0_59ck1400 FIND v(dout0_59) AT=705.025n

.meas tran vdout0_60ck1400 FIND v(dout0_60) AT=705.025n

.meas tran vdout0_61ck1400 FIND v(dout0_61) AT=705.025n

.meas tran vdout0_62ck1400 FIND v(dout0_62) AT=705.025n

.meas tran vdout0_63ck1400 FIND v(dout0_63) AT=705.025n

.meas tran vdout0_64ck1400 FIND v(dout0_64) AT=705.025n

.meas tran vdout0_65ck1400 FIND v(dout0_65) AT=705.025n

.meas tran vdout0_66ck1400 FIND v(dout0_66) AT=705.025n

.meas tran vdout0_67ck1400 FIND v(dout0_67) AT=705.025n

.meas tran vdout0_68ck1400 FIND v(dout0_68) AT=705.025n

.meas tran vdout0_69ck1400 FIND v(dout0_69) AT=705.025n

.meas tran vdout0_70ck1400 FIND v(dout0_70) AT=705.025n

.meas tran vdout0_71ck1400 FIND v(dout0_71) AT=705.025n

.meas tran vdout0_72ck1400 FIND v(dout0_72) AT=705.025n

.meas tran vdout0_73ck1400 FIND v(dout0_73) AT=705.025n

.meas tran vdout0_74ck1400 FIND v(dout0_74) AT=705.025n

.meas tran vdout0_75ck1400 FIND v(dout0_75) AT=705.025n

.meas tran vdout0_76ck1400 FIND v(dout0_76) AT=705.025n

.meas tran vdout0_77ck1400 FIND v(dout0_77) AT=705.025n

.meas tran vdout0_78ck1400 FIND v(dout0_78) AT=705.025n

.meas tran vdout0_79ck1400 FIND v(dout0_79) AT=705.025n

.meas tran vdout0_80ck1400 FIND v(dout0_80) AT=705.025n

.meas tran vdout0_81ck1400 FIND v(dout0_81) AT=705.025n

.meas tran vdout0_82ck1400 FIND v(dout0_82) AT=705.025n

.meas tran vdout0_83ck1400 FIND v(dout0_83) AT=705.025n

.meas tran vdout0_84ck1400 FIND v(dout0_84) AT=705.025n

.meas tran vdout0_85ck1400 FIND v(dout0_85) AT=705.025n

.meas tran vdout0_86ck1400 FIND v(dout0_86) AT=705.025n

.meas tran vdout0_87ck1400 FIND v(dout0_87) AT=705.025n

.meas tran vdout0_88ck1400 FIND v(dout0_88) AT=705.025n

.meas tran vdout0_89ck1400 FIND v(dout0_89) AT=705.025n

.meas tran vdout0_90ck1400 FIND v(dout0_90) AT=705.025n

.meas tran vdout0_91ck1400 FIND v(dout0_91) AT=705.025n

.meas tran vdout0_92ck1400 FIND v(dout0_92) AT=705.025n

.meas tran vdout0_93ck1400 FIND v(dout0_93) AT=705.025n

.meas tran vdout0_94ck1400 FIND v(dout0_94) AT=705.025n

.meas tran vdout0_95ck1400 FIND v(dout0_95) AT=705.025n

.meas tran vdout0_96ck1400 FIND v(dout0_96) AT=705.025n

.meas tran vdout0_97ck1400 FIND v(dout0_97) AT=705.025n

.meas tran vdout0_98ck1400 FIND v(dout0_98) AT=705.025n

.meas tran vdout0_99ck1400 FIND v(dout0_99) AT=705.025n

.meas tran vdout0_100ck1400 FIND v(dout0_100) AT=705.025n

.meas tran vdout0_101ck1400 FIND v(dout0_101) AT=705.025n

.meas tran vdout0_102ck1400 FIND v(dout0_102) AT=705.025n

.meas tran vdout0_103ck1400 FIND v(dout0_103) AT=705.025n

.meas tran vdout0_104ck1400 FIND v(dout0_104) AT=705.025n

.meas tran vdout0_105ck1400 FIND v(dout0_105) AT=705.025n

.meas tran vdout0_106ck1400 FIND v(dout0_106) AT=705.025n

.meas tran vdout0_107ck1400 FIND v(dout0_107) AT=705.025n

.meas tran vdout0_108ck1400 FIND v(dout0_108) AT=705.025n

.meas tran vdout0_109ck1400 FIND v(dout0_109) AT=705.025n

.meas tran vdout0_110ck1400 FIND v(dout0_110) AT=705.025n

.meas tran vdout0_111ck1400 FIND v(dout0_111) AT=705.025n

.meas tran vdout0_112ck1400 FIND v(dout0_112) AT=705.025n

.meas tran vdout0_113ck1400 FIND v(dout0_113) AT=705.025n

.meas tran vdout0_114ck1400 FIND v(dout0_114) AT=705.025n

.meas tran vdout0_115ck1400 FIND v(dout0_115) AT=705.025n

.meas tran vdout0_116ck1400 FIND v(dout0_116) AT=705.025n

.meas tran vdout0_117ck1400 FIND v(dout0_117) AT=705.025n

.meas tran vdout0_118ck1400 FIND v(dout0_118) AT=705.025n

.meas tran vdout0_119ck1400 FIND v(dout0_119) AT=705.025n

.meas tran vdout0_120ck1400 FIND v(dout0_120) AT=705.025n

.meas tran vdout0_121ck1400 FIND v(dout0_121) AT=705.025n

.meas tran vdout0_122ck1400 FIND v(dout0_122) AT=705.025n

.meas tran vdout0_123ck1400 FIND v(dout0_123) AT=705.025n

.meas tran vdout0_124ck1400 FIND v(dout0_124) AT=705.025n

.meas tran vdout0_125ck1400 FIND v(dout0_125) AT=705.025n

.meas tran vdout0_126ck1400 FIND v(dout0_126) AT=705.025n

.meas tran vdout0_127ck1400 FIND v(dout0_127) AT=705.025n

.meas tran vdout0_0ck1410 FIND v(dout0_0) AT=710.025n

.meas tran vdout0_1ck1410 FIND v(dout0_1) AT=710.025n

.meas tran vdout0_2ck1410 FIND v(dout0_2) AT=710.025n

.meas tran vdout0_3ck1410 FIND v(dout0_3) AT=710.025n

.meas tran vdout0_4ck1410 FIND v(dout0_4) AT=710.025n

.meas tran vdout0_5ck1410 FIND v(dout0_5) AT=710.025n

.meas tran vdout0_6ck1410 FIND v(dout0_6) AT=710.025n

.meas tran vdout0_7ck1410 FIND v(dout0_7) AT=710.025n

.meas tran vdout0_8ck1410 FIND v(dout0_8) AT=710.025n

.meas tran vdout0_9ck1410 FIND v(dout0_9) AT=710.025n

.meas tran vdout0_10ck1410 FIND v(dout0_10) AT=710.025n

.meas tran vdout0_11ck1410 FIND v(dout0_11) AT=710.025n

.meas tran vdout0_12ck1410 FIND v(dout0_12) AT=710.025n

.meas tran vdout0_13ck1410 FIND v(dout0_13) AT=710.025n

.meas tran vdout0_14ck1410 FIND v(dout0_14) AT=710.025n

.meas tran vdout0_15ck1410 FIND v(dout0_15) AT=710.025n

.meas tran vdout0_16ck1410 FIND v(dout0_16) AT=710.025n

.meas tran vdout0_17ck1410 FIND v(dout0_17) AT=710.025n

.meas tran vdout0_18ck1410 FIND v(dout0_18) AT=710.025n

.meas tran vdout0_19ck1410 FIND v(dout0_19) AT=710.025n

.meas tran vdout0_20ck1410 FIND v(dout0_20) AT=710.025n

.meas tran vdout0_21ck1410 FIND v(dout0_21) AT=710.025n

.meas tran vdout0_22ck1410 FIND v(dout0_22) AT=710.025n

.meas tran vdout0_23ck1410 FIND v(dout0_23) AT=710.025n

.meas tran vdout0_24ck1410 FIND v(dout0_24) AT=710.025n

.meas tran vdout0_25ck1410 FIND v(dout0_25) AT=710.025n

.meas tran vdout0_26ck1410 FIND v(dout0_26) AT=710.025n

.meas tran vdout0_27ck1410 FIND v(dout0_27) AT=710.025n

.meas tran vdout0_28ck1410 FIND v(dout0_28) AT=710.025n

.meas tran vdout0_29ck1410 FIND v(dout0_29) AT=710.025n

.meas tran vdout0_30ck1410 FIND v(dout0_30) AT=710.025n

.meas tran vdout0_31ck1410 FIND v(dout0_31) AT=710.025n

.meas tran vdout0_32ck1410 FIND v(dout0_32) AT=710.025n

.meas tran vdout0_33ck1410 FIND v(dout0_33) AT=710.025n

.meas tran vdout0_34ck1410 FIND v(dout0_34) AT=710.025n

.meas tran vdout0_35ck1410 FIND v(dout0_35) AT=710.025n

.meas tran vdout0_36ck1410 FIND v(dout0_36) AT=710.025n

.meas tran vdout0_37ck1410 FIND v(dout0_37) AT=710.025n

.meas tran vdout0_38ck1410 FIND v(dout0_38) AT=710.025n

.meas tran vdout0_39ck1410 FIND v(dout0_39) AT=710.025n

.meas tran vdout0_40ck1410 FIND v(dout0_40) AT=710.025n

.meas tran vdout0_41ck1410 FIND v(dout0_41) AT=710.025n

.meas tran vdout0_42ck1410 FIND v(dout0_42) AT=710.025n

.meas tran vdout0_43ck1410 FIND v(dout0_43) AT=710.025n

.meas tran vdout0_44ck1410 FIND v(dout0_44) AT=710.025n

.meas tran vdout0_45ck1410 FIND v(dout0_45) AT=710.025n

.meas tran vdout0_46ck1410 FIND v(dout0_46) AT=710.025n

.meas tran vdout0_47ck1410 FIND v(dout0_47) AT=710.025n

.meas tran vdout0_48ck1410 FIND v(dout0_48) AT=710.025n

.meas tran vdout0_49ck1410 FIND v(dout0_49) AT=710.025n

.meas tran vdout0_50ck1410 FIND v(dout0_50) AT=710.025n

.meas tran vdout0_51ck1410 FIND v(dout0_51) AT=710.025n

.meas tran vdout0_52ck1410 FIND v(dout0_52) AT=710.025n

.meas tran vdout0_53ck1410 FIND v(dout0_53) AT=710.025n

.meas tran vdout0_54ck1410 FIND v(dout0_54) AT=710.025n

.meas tran vdout0_55ck1410 FIND v(dout0_55) AT=710.025n

.meas tran vdout0_56ck1410 FIND v(dout0_56) AT=710.025n

.meas tran vdout0_57ck1410 FIND v(dout0_57) AT=710.025n

.meas tran vdout0_58ck1410 FIND v(dout0_58) AT=710.025n

.meas tran vdout0_59ck1410 FIND v(dout0_59) AT=710.025n

.meas tran vdout0_60ck1410 FIND v(dout0_60) AT=710.025n

.meas tran vdout0_61ck1410 FIND v(dout0_61) AT=710.025n

.meas tran vdout0_62ck1410 FIND v(dout0_62) AT=710.025n

.meas tran vdout0_63ck1410 FIND v(dout0_63) AT=710.025n

.meas tran vdout0_64ck1410 FIND v(dout0_64) AT=710.025n

.meas tran vdout0_65ck1410 FIND v(dout0_65) AT=710.025n

.meas tran vdout0_66ck1410 FIND v(dout0_66) AT=710.025n

.meas tran vdout0_67ck1410 FIND v(dout0_67) AT=710.025n

.meas tran vdout0_68ck1410 FIND v(dout0_68) AT=710.025n

.meas tran vdout0_69ck1410 FIND v(dout0_69) AT=710.025n

.meas tran vdout0_70ck1410 FIND v(dout0_70) AT=710.025n

.meas tran vdout0_71ck1410 FIND v(dout0_71) AT=710.025n

.meas tran vdout0_72ck1410 FIND v(dout0_72) AT=710.025n

.meas tran vdout0_73ck1410 FIND v(dout0_73) AT=710.025n

.meas tran vdout0_74ck1410 FIND v(dout0_74) AT=710.025n

.meas tran vdout0_75ck1410 FIND v(dout0_75) AT=710.025n

.meas tran vdout0_76ck1410 FIND v(dout0_76) AT=710.025n

.meas tran vdout0_77ck1410 FIND v(dout0_77) AT=710.025n

.meas tran vdout0_78ck1410 FIND v(dout0_78) AT=710.025n

.meas tran vdout0_79ck1410 FIND v(dout0_79) AT=710.025n

.meas tran vdout0_80ck1410 FIND v(dout0_80) AT=710.025n

.meas tran vdout0_81ck1410 FIND v(dout0_81) AT=710.025n

.meas tran vdout0_82ck1410 FIND v(dout0_82) AT=710.025n

.meas tran vdout0_83ck1410 FIND v(dout0_83) AT=710.025n

.meas tran vdout0_84ck1410 FIND v(dout0_84) AT=710.025n

.meas tran vdout0_85ck1410 FIND v(dout0_85) AT=710.025n

.meas tran vdout0_86ck1410 FIND v(dout0_86) AT=710.025n

.meas tran vdout0_87ck1410 FIND v(dout0_87) AT=710.025n

.meas tran vdout0_88ck1410 FIND v(dout0_88) AT=710.025n

.meas tran vdout0_89ck1410 FIND v(dout0_89) AT=710.025n

.meas tran vdout0_90ck1410 FIND v(dout0_90) AT=710.025n

.meas tran vdout0_91ck1410 FIND v(dout0_91) AT=710.025n

.meas tran vdout0_92ck1410 FIND v(dout0_92) AT=710.025n

.meas tran vdout0_93ck1410 FIND v(dout0_93) AT=710.025n

.meas tran vdout0_94ck1410 FIND v(dout0_94) AT=710.025n

.meas tran vdout0_95ck1410 FIND v(dout0_95) AT=710.025n

.meas tran vdout0_96ck1410 FIND v(dout0_96) AT=710.025n

.meas tran vdout0_97ck1410 FIND v(dout0_97) AT=710.025n

.meas tran vdout0_98ck1410 FIND v(dout0_98) AT=710.025n

.meas tran vdout0_99ck1410 FIND v(dout0_99) AT=710.025n

.meas tran vdout0_100ck1410 FIND v(dout0_100) AT=710.025n

.meas tran vdout0_101ck1410 FIND v(dout0_101) AT=710.025n

.meas tran vdout0_102ck1410 FIND v(dout0_102) AT=710.025n

.meas tran vdout0_103ck1410 FIND v(dout0_103) AT=710.025n

.meas tran vdout0_104ck1410 FIND v(dout0_104) AT=710.025n

.meas tran vdout0_105ck1410 FIND v(dout0_105) AT=710.025n

.meas tran vdout0_106ck1410 FIND v(dout0_106) AT=710.025n

.meas tran vdout0_107ck1410 FIND v(dout0_107) AT=710.025n

.meas tran vdout0_108ck1410 FIND v(dout0_108) AT=710.025n

.meas tran vdout0_109ck1410 FIND v(dout0_109) AT=710.025n

.meas tran vdout0_110ck1410 FIND v(dout0_110) AT=710.025n

.meas tran vdout0_111ck1410 FIND v(dout0_111) AT=710.025n

.meas tran vdout0_112ck1410 FIND v(dout0_112) AT=710.025n

.meas tran vdout0_113ck1410 FIND v(dout0_113) AT=710.025n

.meas tran vdout0_114ck1410 FIND v(dout0_114) AT=710.025n

.meas tran vdout0_115ck1410 FIND v(dout0_115) AT=710.025n

.meas tran vdout0_116ck1410 FIND v(dout0_116) AT=710.025n

.meas tran vdout0_117ck1410 FIND v(dout0_117) AT=710.025n

.meas tran vdout0_118ck1410 FIND v(dout0_118) AT=710.025n

.meas tran vdout0_119ck1410 FIND v(dout0_119) AT=710.025n

.meas tran vdout0_120ck1410 FIND v(dout0_120) AT=710.025n

.meas tran vdout0_121ck1410 FIND v(dout0_121) AT=710.025n

.meas tran vdout0_122ck1410 FIND v(dout0_122) AT=710.025n

.meas tran vdout0_123ck1410 FIND v(dout0_123) AT=710.025n

.meas tran vdout0_124ck1410 FIND v(dout0_124) AT=710.025n

.meas tran vdout0_125ck1410 FIND v(dout0_125) AT=710.025n

.meas tran vdout0_126ck1410 FIND v(dout0_126) AT=710.025n

.meas tran vdout0_127ck1410 FIND v(dout0_127) AT=710.025n

.meas tran vdout0_0ck1430 FIND v(dout0_0) AT=720.025n

.meas tran vdout0_1ck1430 FIND v(dout0_1) AT=720.025n

.meas tran vdout0_2ck1430 FIND v(dout0_2) AT=720.025n

.meas tran vdout0_3ck1430 FIND v(dout0_3) AT=720.025n

.meas tran vdout0_4ck1430 FIND v(dout0_4) AT=720.025n

.meas tran vdout0_5ck1430 FIND v(dout0_5) AT=720.025n

.meas tran vdout0_6ck1430 FIND v(dout0_6) AT=720.025n

.meas tran vdout0_7ck1430 FIND v(dout0_7) AT=720.025n

.meas tran vdout0_8ck1430 FIND v(dout0_8) AT=720.025n

.meas tran vdout0_9ck1430 FIND v(dout0_9) AT=720.025n

.meas tran vdout0_10ck1430 FIND v(dout0_10) AT=720.025n

.meas tran vdout0_11ck1430 FIND v(dout0_11) AT=720.025n

.meas tran vdout0_12ck1430 FIND v(dout0_12) AT=720.025n

.meas tran vdout0_13ck1430 FIND v(dout0_13) AT=720.025n

.meas tran vdout0_14ck1430 FIND v(dout0_14) AT=720.025n

.meas tran vdout0_15ck1430 FIND v(dout0_15) AT=720.025n

.meas tran vdout0_16ck1430 FIND v(dout0_16) AT=720.025n

.meas tran vdout0_17ck1430 FIND v(dout0_17) AT=720.025n

.meas tran vdout0_18ck1430 FIND v(dout0_18) AT=720.025n

.meas tran vdout0_19ck1430 FIND v(dout0_19) AT=720.025n

.meas tran vdout0_20ck1430 FIND v(dout0_20) AT=720.025n

.meas tran vdout0_21ck1430 FIND v(dout0_21) AT=720.025n

.meas tran vdout0_22ck1430 FIND v(dout0_22) AT=720.025n

.meas tran vdout0_23ck1430 FIND v(dout0_23) AT=720.025n

.meas tran vdout0_24ck1430 FIND v(dout0_24) AT=720.025n

.meas tran vdout0_25ck1430 FIND v(dout0_25) AT=720.025n

.meas tran vdout0_26ck1430 FIND v(dout0_26) AT=720.025n

.meas tran vdout0_27ck1430 FIND v(dout0_27) AT=720.025n

.meas tran vdout0_28ck1430 FIND v(dout0_28) AT=720.025n

.meas tran vdout0_29ck1430 FIND v(dout0_29) AT=720.025n

.meas tran vdout0_30ck1430 FIND v(dout0_30) AT=720.025n

.meas tran vdout0_31ck1430 FIND v(dout0_31) AT=720.025n

.meas tran vdout0_32ck1430 FIND v(dout0_32) AT=720.025n

.meas tran vdout0_33ck1430 FIND v(dout0_33) AT=720.025n

.meas tran vdout0_34ck1430 FIND v(dout0_34) AT=720.025n

.meas tran vdout0_35ck1430 FIND v(dout0_35) AT=720.025n

.meas tran vdout0_36ck1430 FIND v(dout0_36) AT=720.025n

.meas tran vdout0_37ck1430 FIND v(dout0_37) AT=720.025n

.meas tran vdout0_38ck1430 FIND v(dout0_38) AT=720.025n

.meas tran vdout0_39ck1430 FIND v(dout0_39) AT=720.025n

.meas tran vdout0_40ck1430 FIND v(dout0_40) AT=720.025n

.meas tran vdout0_41ck1430 FIND v(dout0_41) AT=720.025n

.meas tran vdout0_42ck1430 FIND v(dout0_42) AT=720.025n

.meas tran vdout0_43ck1430 FIND v(dout0_43) AT=720.025n

.meas tran vdout0_44ck1430 FIND v(dout0_44) AT=720.025n

.meas tran vdout0_45ck1430 FIND v(dout0_45) AT=720.025n

.meas tran vdout0_46ck1430 FIND v(dout0_46) AT=720.025n

.meas tran vdout0_47ck1430 FIND v(dout0_47) AT=720.025n

.meas tran vdout0_48ck1430 FIND v(dout0_48) AT=720.025n

.meas tran vdout0_49ck1430 FIND v(dout0_49) AT=720.025n

.meas tran vdout0_50ck1430 FIND v(dout0_50) AT=720.025n

.meas tran vdout0_51ck1430 FIND v(dout0_51) AT=720.025n

.meas tran vdout0_52ck1430 FIND v(dout0_52) AT=720.025n

.meas tran vdout0_53ck1430 FIND v(dout0_53) AT=720.025n

.meas tran vdout0_54ck1430 FIND v(dout0_54) AT=720.025n

.meas tran vdout0_55ck1430 FIND v(dout0_55) AT=720.025n

.meas tran vdout0_56ck1430 FIND v(dout0_56) AT=720.025n

.meas tran vdout0_57ck1430 FIND v(dout0_57) AT=720.025n

.meas tran vdout0_58ck1430 FIND v(dout0_58) AT=720.025n

.meas tran vdout0_59ck1430 FIND v(dout0_59) AT=720.025n

.meas tran vdout0_60ck1430 FIND v(dout0_60) AT=720.025n

.meas tran vdout0_61ck1430 FIND v(dout0_61) AT=720.025n

.meas tran vdout0_62ck1430 FIND v(dout0_62) AT=720.025n

.meas tran vdout0_63ck1430 FIND v(dout0_63) AT=720.025n

.meas tran vdout0_64ck1430 FIND v(dout0_64) AT=720.025n

.meas tran vdout0_65ck1430 FIND v(dout0_65) AT=720.025n

.meas tran vdout0_66ck1430 FIND v(dout0_66) AT=720.025n

.meas tran vdout0_67ck1430 FIND v(dout0_67) AT=720.025n

.meas tran vdout0_68ck1430 FIND v(dout0_68) AT=720.025n

.meas tran vdout0_69ck1430 FIND v(dout0_69) AT=720.025n

.meas tran vdout0_70ck1430 FIND v(dout0_70) AT=720.025n

.meas tran vdout0_71ck1430 FIND v(dout0_71) AT=720.025n

.meas tran vdout0_72ck1430 FIND v(dout0_72) AT=720.025n

.meas tran vdout0_73ck1430 FIND v(dout0_73) AT=720.025n

.meas tran vdout0_74ck1430 FIND v(dout0_74) AT=720.025n

.meas tran vdout0_75ck1430 FIND v(dout0_75) AT=720.025n

.meas tran vdout0_76ck1430 FIND v(dout0_76) AT=720.025n

.meas tran vdout0_77ck1430 FIND v(dout0_77) AT=720.025n

.meas tran vdout0_78ck1430 FIND v(dout0_78) AT=720.025n

.meas tran vdout0_79ck1430 FIND v(dout0_79) AT=720.025n

.meas tran vdout0_80ck1430 FIND v(dout0_80) AT=720.025n

.meas tran vdout0_81ck1430 FIND v(dout0_81) AT=720.025n

.meas tran vdout0_82ck1430 FIND v(dout0_82) AT=720.025n

.meas tran vdout0_83ck1430 FIND v(dout0_83) AT=720.025n

.meas tran vdout0_84ck1430 FIND v(dout0_84) AT=720.025n

.meas tran vdout0_85ck1430 FIND v(dout0_85) AT=720.025n

.meas tran vdout0_86ck1430 FIND v(dout0_86) AT=720.025n

.meas tran vdout0_87ck1430 FIND v(dout0_87) AT=720.025n

.meas tran vdout0_88ck1430 FIND v(dout0_88) AT=720.025n

.meas tran vdout0_89ck1430 FIND v(dout0_89) AT=720.025n

.meas tran vdout0_90ck1430 FIND v(dout0_90) AT=720.025n

.meas tran vdout0_91ck1430 FIND v(dout0_91) AT=720.025n

.meas tran vdout0_92ck1430 FIND v(dout0_92) AT=720.025n

.meas tran vdout0_93ck1430 FIND v(dout0_93) AT=720.025n

.meas tran vdout0_94ck1430 FIND v(dout0_94) AT=720.025n

.meas tran vdout0_95ck1430 FIND v(dout0_95) AT=720.025n

.meas tran vdout0_96ck1430 FIND v(dout0_96) AT=720.025n

.meas tran vdout0_97ck1430 FIND v(dout0_97) AT=720.025n

.meas tran vdout0_98ck1430 FIND v(dout0_98) AT=720.025n

.meas tran vdout0_99ck1430 FIND v(dout0_99) AT=720.025n

.meas tran vdout0_100ck1430 FIND v(dout0_100) AT=720.025n

.meas tran vdout0_101ck1430 FIND v(dout0_101) AT=720.025n

.meas tran vdout0_102ck1430 FIND v(dout0_102) AT=720.025n

.meas tran vdout0_103ck1430 FIND v(dout0_103) AT=720.025n

.meas tran vdout0_104ck1430 FIND v(dout0_104) AT=720.025n

.meas tran vdout0_105ck1430 FIND v(dout0_105) AT=720.025n

.meas tran vdout0_106ck1430 FIND v(dout0_106) AT=720.025n

.meas tran vdout0_107ck1430 FIND v(dout0_107) AT=720.025n

.meas tran vdout0_108ck1430 FIND v(dout0_108) AT=720.025n

.meas tran vdout0_109ck1430 FIND v(dout0_109) AT=720.025n

.meas tran vdout0_110ck1430 FIND v(dout0_110) AT=720.025n

.meas tran vdout0_111ck1430 FIND v(dout0_111) AT=720.025n

.meas tran vdout0_112ck1430 FIND v(dout0_112) AT=720.025n

.meas tran vdout0_113ck1430 FIND v(dout0_113) AT=720.025n

.meas tran vdout0_114ck1430 FIND v(dout0_114) AT=720.025n

.meas tran vdout0_115ck1430 FIND v(dout0_115) AT=720.025n

.meas tran vdout0_116ck1430 FIND v(dout0_116) AT=720.025n

.meas tran vdout0_117ck1430 FIND v(dout0_117) AT=720.025n

.meas tran vdout0_118ck1430 FIND v(dout0_118) AT=720.025n

.meas tran vdout0_119ck1430 FIND v(dout0_119) AT=720.025n

.meas tran vdout0_120ck1430 FIND v(dout0_120) AT=720.025n

.meas tran vdout0_121ck1430 FIND v(dout0_121) AT=720.025n

.meas tran vdout0_122ck1430 FIND v(dout0_122) AT=720.025n

.meas tran vdout0_123ck1430 FIND v(dout0_123) AT=720.025n

.meas tran vdout0_124ck1430 FIND v(dout0_124) AT=720.025n

.meas tran vdout0_125ck1430 FIND v(dout0_125) AT=720.025n

.meas tran vdout0_126ck1430 FIND v(dout0_126) AT=720.025n

.meas tran vdout0_127ck1430 FIND v(dout0_127) AT=720.025n

.meas tran vdout0_0ck1480 FIND v(dout0_0) AT=745.025n

.meas tran vdout0_1ck1480 FIND v(dout0_1) AT=745.025n

.meas tran vdout0_2ck1480 FIND v(dout0_2) AT=745.025n

.meas tran vdout0_3ck1480 FIND v(dout0_3) AT=745.025n

.meas tran vdout0_4ck1480 FIND v(dout0_4) AT=745.025n

.meas tran vdout0_5ck1480 FIND v(dout0_5) AT=745.025n

.meas tran vdout0_6ck1480 FIND v(dout0_6) AT=745.025n

.meas tran vdout0_7ck1480 FIND v(dout0_7) AT=745.025n

.meas tran vdout0_8ck1480 FIND v(dout0_8) AT=745.025n

.meas tran vdout0_9ck1480 FIND v(dout0_9) AT=745.025n

.meas tran vdout0_10ck1480 FIND v(dout0_10) AT=745.025n

.meas tran vdout0_11ck1480 FIND v(dout0_11) AT=745.025n

.meas tran vdout0_12ck1480 FIND v(dout0_12) AT=745.025n

.meas tran vdout0_13ck1480 FIND v(dout0_13) AT=745.025n

.meas tran vdout0_14ck1480 FIND v(dout0_14) AT=745.025n

.meas tran vdout0_15ck1480 FIND v(dout0_15) AT=745.025n

.meas tran vdout0_16ck1480 FIND v(dout0_16) AT=745.025n

.meas tran vdout0_17ck1480 FIND v(dout0_17) AT=745.025n

.meas tran vdout0_18ck1480 FIND v(dout0_18) AT=745.025n

.meas tran vdout0_19ck1480 FIND v(dout0_19) AT=745.025n

.meas tran vdout0_20ck1480 FIND v(dout0_20) AT=745.025n

.meas tran vdout0_21ck1480 FIND v(dout0_21) AT=745.025n

.meas tran vdout0_22ck1480 FIND v(dout0_22) AT=745.025n

.meas tran vdout0_23ck1480 FIND v(dout0_23) AT=745.025n

.meas tran vdout0_24ck1480 FIND v(dout0_24) AT=745.025n

.meas tran vdout0_25ck1480 FIND v(dout0_25) AT=745.025n

.meas tran vdout0_26ck1480 FIND v(dout0_26) AT=745.025n

.meas tran vdout0_27ck1480 FIND v(dout0_27) AT=745.025n

.meas tran vdout0_28ck1480 FIND v(dout0_28) AT=745.025n

.meas tran vdout0_29ck1480 FIND v(dout0_29) AT=745.025n

.meas tran vdout0_30ck1480 FIND v(dout0_30) AT=745.025n

.meas tran vdout0_31ck1480 FIND v(dout0_31) AT=745.025n

.meas tran vdout0_32ck1480 FIND v(dout0_32) AT=745.025n

.meas tran vdout0_33ck1480 FIND v(dout0_33) AT=745.025n

.meas tran vdout0_34ck1480 FIND v(dout0_34) AT=745.025n

.meas tran vdout0_35ck1480 FIND v(dout0_35) AT=745.025n

.meas tran vdout0_36ck1480 FIND v(dout0_36) AT=745.025n

.meas tran vdout0_37ck1480 FIND v(dout0_37) AT=745.025n

.meas tran vdout0_38ck1480 FIND v(dout0_38) AT=745.025n

.meas tran vdout0_39ck1480 FIND v(dout0_39) AT=745.025n

.meas tran vdout0_40ck1480 FIND v(dout0_40) AT=745.025n

.meas tran vdout0_41ck1480 FIND v(dout0_41) AT=745.025n

.meas tran vdout0_42ck1480 FIND v(dout0_42) AT=745.025n

.meas tran vdout0_43ck1480 FIND v(dout0_43) AT=745.025n

.meas tran vdout0_44ck1480 FIND v(dout0_44) AT=745.025n

.meas tran vdout0_45ck1480 FIND v(dout0_45) AT=745.025n

.meas tran vdout0_46ck1480 FIND v(dout0_46) AT=745.025n

.meas tran vdout0_47ck1480 FIND v(dout0_47) AT=745.025n

.meas tran vdout0_48ck1480 FIND v(dout0_48) AT=745.025n

.meas tran vdout0_49ck1480 FIND v(dout0_49) AT=745.025n

.meas tran vdout0_50ck1480 FIND v(dout0_50) AT=745.025n

.meas tran vdout0_51ck1480 FIND v(dout0_51) AT=745.025n

.meas tran vdout0_52ck1480 FIND v(dout0_52) AT=745.025n

.meas tran vdout0_53ck1480 FIND v(dout0_53) AT=745.025n

.meas tran vdout0_54ck1480 FIND v(dout0_54) AT=745.025n

.meas tran vdout0_55ck1480 FIND v(dout0_55) AT=745.025n

.meas tran vdout0_56ck1480 FIND v(dout0_56) AT=745.025n

.meas tran vdout0_57ck1480 FIND v(dout0_57) AT=745.025n

.meas tran vdout0_58ck1480 FIND v(dout0_58) AT=745.025n

.meas tran vdout0_59ck1480 FIND v(dout0_59) AT=745.025n

.meas tran vdout0_60ck1480 FIND v(dout0_60) AT=745.025n

.meas tran vdout0_61ck1480 FIND v(dout0_61) AT=745.025n

.meas tran vdout0_62ck1480 FIND v(dout0_62) AT=745.025n

.meas tran vdout0_63ck1480 FIND v(dout0_63) AT=745.025n

.meas tran vdout0_64ck1480 FIND v(dout0_64) AT=745.025n

.meas tran vdout0_65ck1480 FIND v(dout0_65) AT=745.025n

.meas tran vdout0_66ck1480 FIND v(dout0_66) AT=745.025n

.meas tran vdout0_67ck1480 FIND v(dout0_67) AT=745.025n

.meas tran vdout0_68ck1480 FIND v(dout0_68) AT=745.025n

.meas tran vdout0_69ck1480 FIND v(dout0_69) AT=745.025n

.meas tran vdout0_70ck1480 FIND v(dout0_70) AT=745.025n

.meas tran vdout0_71ck1480 FIND v(dout0_71) AT=745.025n

.meas tran vdout0_72ck1480 FIND v(dout0_72) AT=745.025n

.meas tran vdout0_73ck1480 FIND v(dout0_73) AT=745.025n

.meas tran vdout0_74ck1480 FIND v(dout0_74) AT=745.025n

.meas tran vdout0_75ck1480 FIND v(dout0_75) AT=745.025n

.meas tran vdout0_76ck1480 FIND v(dout0_76) AT=745.025n

.meas tran vdout0_77ck1480 FIND v(dout0_77) AT=745.025n

.meas tran vdout0_78ck1480 FIND v(dout0_78) AT=745.025n

.meas tran vdout0_79ck1480 FIND v(dout0_79) AT=745.025n

.meas tran vdout0_80ck1480 FIND v(dout0_80) AT=745.025n

.meas tran vdout0_81ck1480 FIND v(dout0_81) AT=745.025n

.meas tran vdout0_82ck1480 FIND v(dout0_82) AT=745.025n

.meas tran vdout0_83ck1480 FIND v(dout0_83) AT=745.025n

.meas tran vdout0_84ck1480 FIND v(dout0_84) AT=745.025n

.meas tran vdout0_85ck1480 FIND v(dout0_85) AT=745.025n

.meas tran vdout0_86ck1480 FIND v(dout0_86) AT=745.025n

.meas tran vdout0_87ck1480 FIND v(dout0_87) AT=745.025n

.meas tran vdout0_88ck1480 FIND v(dout0_88) AT=745.025n

.meas tran vdout0_89ck1480 FIND v(dout0_89) AT=745.025n

.meas tran vdout0_90ck1480 FIND v(dout0_90) AT=745.025n

.meas tran vdout0_91ck1480 FIND v(dout0_91) AT=745.025n

.meas tran vdout0_92ck1480 FIND v(dout0_92) AT=745.025n

.meas tran vdout0_93ck1480 FIND v(dout0_93) AT=745.025n

.meas tran vdout0_94ck1480 FIND v(dout0_94) AT=745.025n

.meas tran vdout0_95ck1480 FIND v(dout0_95) AT=745.025n

.meas tran vdout0_96ck1480 FIND v(dout0_96) AT=745.025n

.meas tran vdout0_97ck1480 FIND v(dout0_97) AT=745.025n

.meas tran vdout0_98ck1480 FIND v(dout0_98) AT=745.025n

.meas tran vdout0_99ck1480 FIND v(dout0_99) AT=745.025n

.meas tran vdout0_100ck1480 FIND v(dout0_100) AT=745.025n

.meas tran vdout0_101ck1480 FIND v(dout0_101) AT=745.025n

.meas tran vdout0_102ck1480 FIND v(dout0_102) AT=745.025n

.meas tran vdout0_103ck1480 FIND v(dout0_103) AT=745.025n

.meas tran vdout0_104ck1480 FIND v(dout0_104) AT=745.025n

.meas tran vdout0_105ck1480 FIND v(dout0_105) AT=745.025n

.meas tran vdout0_106ck1480 FIND v(dout0_106) AT=745.025n

.meas tran vdout0_107ck1480 FIND v(dout0_107) AT=745.025n

.meas tran vdout0_108ck1480 FIND v(dout0_108) AT=745.025n

.meas tran vdout0_109ck1480 FIND v(dout0_109) AT=745.025n

.meas tran vdout0_110ck1480 FIND v(dout0_110) AT=745.025n

.meas tran vdout0_111ck1480 FIND v(dout0_111) AT=745.025n

.meas tran vdout0_112ck1480 FIND v(dout0_112) AT=745.025n

.meas tran vdout0_113ck1480 FIND v(dout0_113) AT=745.025n

.meas tran vdout0_114ck1480 FIND v(dout0_114) AT=745.025n

.meas tran vdout0_115ck1480 FIND v(dout0_115) AT=745.025n

.meas tran vdout0_116ck1480 FIND v(dout0_116) AT=745.025n

.meas tran vdout0_117ck1480 FIND v(dout0_117) AT=745.025n

.meas tran vdout0_118ck1480 FIND v(dout0_118) AT=745.025n

.meas tran vdout0_119ck1480 FIND v(dout0_119) AT=745.025n

.meas tran vdout0_120ck1480 FIND v(dout0_120) AT=745.025n

.meas tran vdout0_121ck1480 FIND v(dout0_121) AT=745.025n

.meas tran vdout0_122ck1480 FIND v(dout0_122) AT=745.025n

.meas tran vdout0_123ck1480 FIND v(dout0_123) AT=745.025n

.meas tran vdout0_124ck1480 FIND v(dout0_124) AT=745.025n

.meas tran vdout0_125ck1480 FIND v(dout0_125) AT=745.025n

.meas tran vdout0_126ck1480 FIND v(dout0_126) AT=745.025n

.meas tran vdout0_127ck1480 FIND v(dout0_127) AT=745.025n

.meas tran vdout0_0ck1510 FIND v(dout0_0) AT=760.025n

.meas tran vdout0_1ck1510 FIND v(dout0_1) AT=760.025n

.meas tran vdout0_2ck1510 FIND v(dout0_2) AT=760.025n

.meas tran vdout0_3ck1510 FIND v(dout0_3) AT=760.025n

.meas tran vdout0_4ck1510 FIND v(dout0_4) AT=760.025n

.meas tran vdout0_5ck1510 FIND v(dout0_5) AT=760.025n

.meas tran vdout0_6ck1510 FIND v(dout0_6) AT=760.025n

.meas tran vdout0_7ck1510 FIND v(dout0_7) AT=760.025n

.meas tran vdout0_8ck1510 FIND v(dout0_8) AT=760.025n

.meas tran vdout0_9ck1510 FIND v(dout0_9) AT=760.025n

.meas tran vdout0_10ck1510 FIND v(dout0_10) AT=760.025n

.meas tran vdout0_11ck1510 FIND v(dout0_11) AT=760.025n

.meas tran vdout0_12ck1510 FIND v(dout0_12) AT=760.025n

.meas tran vdout0_13ck1510 FIND v(dout0_13) AT=760.025n

.meas tran vdout0_14ck1510 FIND v(dout0_14) AT=760.025n

.meas tran vdout0_15ck1510 FIND v(dout0_15) AT=760.025n

.meas tran vdout0_16ck1510 FIND v(dout0_16) AT=760.025n

.meas tran vdout0_17ck1510 FIND v(dout0_17) AT=760.025n

.meas tran vdout0_18ck1510 FIND v(dout0_18) AT=760.025n

.meas tran vdout0_19ck1510 FIND v(dout0_19) AT=760.025n

.meas tran vdout0_20ck1510 FIND v(dout0_20) AT=760.025n

.meas tran vdout0_21ck1510 FIND v(dout0_21) AT=760.025n

.meas tran vdout0_22ck1510 FIND v(dout0_22) AT=760.025n

.meas tran vdout0_23ck1510 FIND v(dout0_23) AT=760.025n

.meas tran vdout0_24ck1510 FIND v(dout0_24) AT=760.025n

.meas tran vdout0_25ck1510 FIND v(dout0_25) AT=760.025n

.meas tran vdout0_26ck1510 FIND v(dout0_26) AT=760.025n

.meas tran vdout0_27ck1510 FIND v(dout0_27) AT=760.025n

.meas tran vdout0_28ck1510 FIND v(dout0_28) AT=760.025n

.meas tran vdout0_29ck1510 FIND v(dout0_29) AT=760.025n

.meas tran vdout0_30ck1510 FIND v(dout0_30) AT=760.025n

.meas tran vdout0_31ck1510 FIND v(dout0_31) AT=760.025n

.meas tran vdout0_32ck1510 FIND v(dout0_32) AT=760.025n

.meas tran vdout0_33ck1510 FIND v(dout0_33) AT=760.025n

.meas tran vdout0_34ck1510 FIND v(dout0_34) AT=760.025n

.meas tran vdout0_35ck1510 FIND v(dout0_35) AT=760.025n

.meas tran vdout0_36ck1510 FIND v(dout0_36) AT=760.025n

.meas tran vdout0_37ck1510 FIND v(dout0_37) AT=760.025n

.meas tran vdout0_38ck1510 FIND v(dout0_38) AT=760.025n

.meas tran vdout0_39ck1510 FIND v(dout0_39) AT=760.025n

.meas tran vdout0_40ck1510 FIND v(dout0_40) AT=760.025n

.meas tran vdout0_41ck1510 FIND v(dout0_41) AT=760.025n

.meas tran vdout0_42ck1510 FIND v(dout0_42) AT=760.025n

.meas tran vdout0_43ck1510 FIND v(dout0_43) AT=760.025n

.meas tran vdout0_44ck1510 FIND v(dout0_44) AT=760.025n

.meas tran vdout0_45ck1510 FIND v(dout0_45) AT=760.025n

.meas tran vdout0_46ck1510 FIND v(dout0_46) AT=760.025n

.meas tran vdout0_47ck1510 FIND v(dout0_47) AT=760.025n

.meas tran vdout0_48ck1510 FIND v(dout0_48) AT=760.025n

.meas tran vdout0_49ck1510 FIND v(dout0_49) AT=760.025n

.meas tran vdout0_50ck1510 FIND v(dout0_50) AT=760.025n

.meas tran vdout0_51ck1510 FIND v(dout0_51) AT=760.025n

.meas tran vdout0_52ck1510 FIND v(dout0_52) AT=760.025n

.meas tran vdout0_53ck1510 FIND v(dout0_53) AT=760.025n

.meas tran vdout0_54ck1510 FIND v(dout0_54) AT=760.025n

.meas tran vdout0_55ck1510 FIND v(dout0_55) AT=760.025n

.meas tran vdout0_56ck1510 FIND v(dout0_56) AT=760.025n

.meas tran vdout0_57ck1510 FIND v(dout0_57) AT=760.025n

.meas tran vdout0_58ck1510 FIND v(dout0_58) AT=760.025n

.meas tran vdout0_59ck1510 FIND v(dout0_59) AT=760.025n

.meas tran vdout0_60ck1510 FIND v(dout0_60) AT=760.025n

.meas tran vdout0_61ck1510 FIND v(dout0_61) AT=760.025n

.meas tran vdout0_62ck1510 FIND v(dout0_62) AT=760.025n

.meas tran vdout0_63ck1510 FIND v(dout0_63) AT=760.025n

.meas tran vdout0_64ck1510 FIND v(dout0_64) AT=760.025n

.meas tran vdout0_65ck1510 FIND v(dout0_65) AT=760.025n

.meas tran vdout0_66ck1510 FIND v(dout0_66) AT=760.025n

.meas tran vdout0_67ck1510 FIND v(dout0_67) AT=760.025n

.meas tran vdout0_68ck1510 FIND v(dout0_68) AT=760.025n

.meas tran vdout0_69ck1510 FIND v(dout0_69) AT=760.025n

.meas tran vdout0_70ck1510 FIND v(dout0_70) AT=760.025n

.meas tran vdout0_71ck1510 FIND v(dout0_71) AT=760.025n

.meas tran vdout0_72ck1510 FIND v(dout0_72) AT=760.025n

.meas tran vdout0_73ck1510 FIND v(dout0_73) AT=760.025n

.meas tran vdout0_74ck1510 FIND v(dout0_74) AT=760.025n

.meas tran vdout0_75ck1510 FIND v(dout0_75) AT=760.025n

.meas tran vdout0_76ck1510 FIND v(dout0_76) AT=760.025n

.meas tran vdout0_77ck1510 FIND v(dout0_77) AT=760.025n

.meas tran vdout0_78ck1510 FIND v(dout0_78) AT=760.025n

.meas tran vdout0_79ck1510 FIND v(dout0_79) AT=760.025n

.meas tran vdout0_80ck1510 FIND v(dout0_80) AT=760.025n

.meas tran vdout0_81ck1510 FIND v(dout0_81) AT=760.025n

.meas tran vdout0_82ck1510 FIND v(dout0_82) AT=760.025n

.meas tran vdout0_83ck1510 FIND v(dout0_83) AT=760.025n

.meas tran vdout0_84ck1510 FIND v(dout0_84) AT=760.025n

.meas tran vdout0_85ck1510 FIND v(dout0_85) AT=760.025n

.meas tran vdout0_86ck1510 FIND v(dout0_86) AT=760.025n

.meas tran vdout0_87ck1510 FIND v(dout0_87) AT=760.025n

.meas tran vdout0_88ck1510 FIND v(dout0_88) AT=760.025n

.meas tran vdout0_89ck1510 FIND v(dout0_89) AT=760.025n

.meas tran vdout0_90ck1510 FIND v(dout0_90) AT=760.025n

.meas tran vdout0_91ck1510 FIND v(dout0_91) AT=760.025n

.meas tran vdout0_92ck1510 FIND v(dout0_92) AT=760.025n

.meas tran vdout0_93ck1510 FIND v(dout0_93) AT=760.025n

.meas tran vdout0_94ck1510 FIND v(dout0_94) AT=760.025n

.meas tran vdout0_95ck1510 FIND v(dout0_95) AT=760.025n

.meas tran vdout0_96ck1510 FIND v(dout0_96) AT=760.025n

.meas tran vdout0_97ck1510 FIND v(dout0_97) AT=760.025n

.meas tran vdout0_98ck1510 FIND v(dout0_98) AT=760.025n

.meas tran vdout0_99ck1510 FIND v(dout0_99) AT=760.025n

.meas tran vdout0_100ck1510 FIND v(dout0_100) AT=760.025n

.meas tran vdout0_101ck1510 FIND v(dout0_101) AT=760.025n

.meas tran vdout0_102ck1510 FIND v(dout0_102) AT=760.025n

.meas tran vdout0_103ck1510 FIND v(dout0_103) AT=760.025n

.meas tran vdout0_104ck1510 FIND v(dout0_104) AT=760.025n

.meas tran vdout0_105ck1510 FIND v(dout0_105) AT=760.025n

.meas tran vdout0_106ck1510 FIND v(dout0_106) AT=760.025n

.meas tran vdout0_107ck1510 FIND v(dout0_107) AT=760.025n

.meas tran vdout0_108ck1510 FIND v(dout0_108) AT=760.025n

.meas tran vdout0_109ck1510 FIND v(dout0_109) AT=760.025n

.meas tran vdout0_110ck1510 FIND v(dout0_110) AT=760.025n

.meas tran vdout0_111ck1510 FIND v(dout0_111) AT=760.025n

.meas tran vdout0_112ck1510 FIND v(dout0_112) AT=760.025n

.meas tran vdout0_113ck1510 FIND v(dout0_113) AT=760.025n

.meas tran vdout0_114ck1510 FIND v(dout0_114) AT=760.025n

.meas tran vdout0_115ck1510 FIND v(dout0_115) AT=760.025n

.meas tran vdout0_116ck1510 FIND v(dout0_116) AT=760.025n

.meas tran vdout0_117ck1510 FIND v(dout0_117) AT=760.025n

.meas tran vdout0_118ck1510 FIND v(dout0_118) AT=760.025n

.meas tran vdout0_119ck1510 FIND v(dout0_119) AT=760.025n

.meas tran vdout0_120ck1510 FIND v(dout0_120) AT=760.025n

.meas tran vdout0_121ck1510 FIND v(dout0_121) AT=760.025n

.meas tran vdout0_122ck1510 FIND v(dout0_122) AT=760.025n

.meas tran vdout0_123ck1510 FIND v(dout0_123) AT=760.025n

.meas tran vdout0_124ck1510 FIND v(dout0_124) AT=760.025n

.meas tran vdout0_125ck1510 FIND v(dout0_125) AT=760.025n

.meas tran vdout0_126ck1510 FIND v(dout0_126) AT=760.025n

.meas tran vdout0_127ck1510 FIND v(dout0_127) AT=760.025n

.meas tran vdout0_0ck1530 FIND v(dout0_0) AT=770.025n

.meas tran vdout0_1ck1530 FIND v(dout0_1) AT=770.025n

.meas tran vdout0_2ck1530 FIND v(dout0_2) AT=770.025n

.meas tran vdout0_3ck1530 FIND v(dout0_3) AT=770.025n

.meas tran vdout0_4ck1530 FIND v(dout0_4) AT=770.025n

.meas tran vdout0_5ck1530 FIND v(dout0_5) AT=770.025n

.meas tran vdout0_6ck1530 FIND v(dout0_6) AT=770.025n

.meas tran vdout0_7ck1530 FIND v(dout0_7) AT=770.025n

.meas tran vdout0_8ck1530 FIND v(dout0_8) AT=770.025n

.meas tran vdout0_9ck1530 FIND v(dout0_9) AT=770.025n

.meas tran vdout0_10ck1530 FIND v(dout0_10) AT=770.025n

.meas tran vdout0_11ck1530 FIND v(dout0_11) AT=770.025n

.meas tran vdout0_12ck1530 FIND v(dout0_12) AT=770.025n

.meas tran vdout0_13ck1530 FIND v(dout0_13) AT=770.025n

.meas tran vdout0_14ck1530 FIND v(dout0_14) AT=770.025n

.meas tran vdout0_15ck1530 FIND v(dout0_15) AT=770.025n

.meas tran vdout0_16ck1530 FIND v(dout0_16) AT=770.025n

.meas tran vdout0_17ck1530 FIND v(dout0_17) AT=770.025n

.meas tran vdout0_18ck1530 FIND v(dout0_18) AT=770.025n

.meas tran vdout0_19ck1530 FIND v(dout0_19) AT=770.025n

.meas tran vdout0_20ck1530 FIND v(dout0_20) AT=770.025n

.meas tran vdout0_21ck1530 FIND v(dout0_21) AT=770.025n

.meas tran vdout0_22ck1530 FIND v(dout0_22) AT=770.025n

.meas tran vdout0_23ck1530 FIND v(dout0_23) AT=770.025n

.meas tran vdout0_24ck1530 FIND v(dout0_24) AT=770.025n

.meas tran vdout0_25ck1530 FIND v(dout0_25) AT=770.025n

.meas tran vdout0_26ck1530 FIND v(dout0_26) AT=770.025n

.meas tran vdout0_27ck1530 FIND v(dout0_27) AT=770.025n

.meas tran vdout0_28ck1530 FIND v(dout0_28) AT=770.025n

.meas tran vdout0_29ck1530 FIND v(dout0_29) AT=770.025n

.meas tran vdout0_30ck1530 FIND v(dout0_30) AT=770.025n

.meas tran vdout0_31ck1530 FIND v(dout0_31) AT=770.025n

.meas tran vdout0_32ck1530 FIND v(dout0_32) AT=770.025n

.meas tran vdout0_33ck1530 FIND v(dout0_33) AT=770.025n

.meas tran vdout0_34ck1530 FIND v(dout0_34) AT=770.025n

.meas tran vdout0_35ck1530 FIND v(dout0_35) AT=770.025n

.meas tran vdout0_36ck1530 FIND v(dout0_36) AT=770.025n

.meas tran vdout0_37ck1530 FIND v(dout0_37) AT=770.025n

.meas tran vdout0_38ck1530 FIND v(dout0_38) AT=770.025n

.meas tran vdout0_39ck1530 FIND v(dout0_39) AT=770.025n

.meas tran vdout0_40ck1530 FIND v(dout0_40) AT=770.025n

.meas tran vdout0_41ck1530 FIND v(dout0_41) AT=770.025n

.meas tran vdout0_42ck1530 FIND v(dout0_42) AT=770.025n

.meas tran vdout0_43ck1530 FIND v(dout0_43) AT=770.025n

.meas tran vdout0_44ck1530 FIND v(dout0_44) AT=770.025n

.meas tran vdout0_45ck1530 FIND v(dout0_45) AT=770.025n

.meas tran vdout0_46ck1530 FIND v(dout0_46) AT=770.025n

.meas tran vdout0_47ck1530 FIND v(dout0_47) AT=770.025n

.meas tran vdout0_48ck1530 FIND v(dout0_48) AT=770.025n

.meas tran vdout0_49ck1530 FIND v(dout0_49) AT=770.025n

.meas tran vdout0_50ck1530 FIND v(dout0_50) AT=770.025n

.meas tran vdout0_51ck1530 FIND v(dout0_51) AT=770.025n

.meas tran vdout0_52ck1530 FIND v(dout0_52) AT=770.025n

.meas tran vdout0_53ck1530 FIND v(dout0_53) AT=770.025n

.meas tran vdout0_54ck1530 FIND v(dout0_54) AT=770.025n

.meas tran vdout0_55ck1530 FIND v(dout0_55) AT=770.025n

.meas tran vdout0_56ck1530 FIND v(dout0_56) AT=770.025n

.meas tran vdout0_57ck1530 FIND v(dout0_57) AT=770.025n

.meas tran vdout0_58ck1530 FIND v(dout0_58) AT=770.025n

.meas tran vdout0_59ck1530 FIND v(dout0_59) AT=770.025n

.meas tran vdout0_60ck1530 FIND v(dout0_60) AT=770.025n

.meas tran vdout0_61ck1530 FIND v(dout0_61) AT=770.025n

.meas tran vdout0_62ck1530 FIND v(dout0_62) AT=770.025n

.meas tran vdout0_63ck1530 FIND v(dout0_63) AT=770.025n

.meas tran vdout0_64ck1530 FIND v(dout0_64) AT=770.025n

.meas tran vdout0_65ck1530 FIND v(dout0_65) AT=770.025n

.meas tran vdout0_66ck1530 FIND v(dout0_66) AT=770.025n

.meas tran vdout0_67ck1530 FIND v(dout0_67) AT=770.025n

.meas tran vdout0_68ck1530 FIND v(dout0_68) AT=770.025n

.meas tran vdout0_69ck1530 FIND v(dout0_69) AT=770.025n

.meas tran vdout0_70ck1530 FIND v(dout0_70) AT=770.025n

.meas tran vdout0_71ck1530 FIND v(dout0_71) AT=770.025n

.meas tran vdout0_72ck1530 FIND v(dout0_72) AT=770.025n

.meas tran vdout0_73ck1530 FIND v(dout0_73) AT=770.025n

.meas tran vdout0_74ck1530 FIND v(dout0_74) AT=770.025n

.meas tran vdout0_75ck1530 FIND v(dout0_75) AT=770.025n

.meas tran vdout0_76ck1530 FIND v(dout0_76) AT=770.025n

.meas tran vdout0_77ck1530 FIND v(dout0_77) AT=770.025n

.meas tran vdout0_78ck1530 FIND v(dout0_78) AT=770.025n

.meas tran vdout0_79ck1530 FIND v(dout0_79) AT=770.025n

.meas tran vdout0_80ck1530 FIND v(dout0_80) AT=770.025n

.meas tran vdout0_81ck1530 FIND v(dout0_81) AT=770.025n

.meas tran vdout0_82ck1530 FIND v(dout0_82) AT=770.025n

.meas tran vdout0_83ck1530 FIND v(dout0_83) AT=770.025n

.meas tran vdout0_84ck1530 FIND v(dout0_84) AT=770.025n

.meas tran vdout0_85ck1530 FIND v(dout0_85) AT=770.025n

.meas tran vdout0_86ck1530 FIND v(dout0_86) AT=770.025n

.meas tran vdout0_87ck1530 FIND v(dout0_87) AT=770.025n

.meas tran vdout0_88ck1530 FIND v(dout0_88) AT=770.025n

.meas tran vdout0_89ck1530 FIND v(dout0_89) AT=770.025n

.meas tran vdout0_90ck1530 FIND v(dout0_90) AT=770.025n

.meas tran vdout0_91ck1530 FIND v(dout0_91) AT=770.025n

.meas tran vdout0_92ck1530 FIND v(dout0_92) AT=770.025n

.meas tran vdout0_93ck1530 FIND v(dout0_93) AT=770.025n

.meas tran vdout0_94ck1530 FIND v(dout0_94) AT=770.025n

.meas tran vdout0_95ck1530 FIND v(dout0_95) AT=770.025n

.meas tran vdout0_96ck1530 FIND v(dout0_96) AT=770.025n

.meas tran vdout0_97ck1530 FIND v(dout0_97) AT=770.025n

.meas tran vdout0_98ck1530 FIND v(dout0_98) AT=770.025n

.meas tran vdout0_99ck1530 FIND v(dout0_99) AT=770.025n

.meas tran vdout0_100ck1530 FIND v(dout0_100) AT=770.025n

.meas tran vdout0_101ck1530 FIND v(dout0_101) AT=770.025n

.meas tran vdout0_102ck1530 FIND v(dout0_102) AT=770.025n

.meas tran vdout0_103ck1530 FIND v(dout0_103) AT=770.025n

.meas tran vdout0_104ck1530 FIND v(dout0_104) AT=770.025n

.meas tran vdout0_105ck1530 FIND v(dout0_105) AT=770.025n

.meas tran vdout0_106ck1530 FIND v(dout0_106) AT=770.025n

.meas tran vdout0_107ck1530 FIND v(dout0_107) AT=770.025n

.meas tran vdout0_108ck1530 FIND v(dout0_108) AT=770.025n

.meas tran vdout0_109ck1530 FIND v(dout0_109) AT=770.025n

.meas tran vdout0_110ck1530 FIND v(dout0_110) AT=770.025n

.meas tran vdout0_111ck1530 FIND v(dout0_111) AT=770.025n

.meas tran vdout0_112ck1530 FIND v(dout0_112) AT=770.025n

.meas tran vdout0_113ck1530 FIND v(dout0_113) AT=770.025n

.meas tran vdout0_114ck1530 FIND v(dout0_114) AT=770.025n

.meas tran vdout0_115ck1530 FIND v(dout0_115) AT=770.025n

.meas tran vdout0_116ck1530 FIND v(dout0_116) AT=770.025n

.meas tran vdout0_117ck1530 FIND v(dout0_117) AT=770.025n

.meas tran vdout0_118ck1530 FIND v(dout0_118) AT=770.025n

.meas tran vdout0_119ck1530 FIND v(dout0_119) AT=770.025n

.meas tran vdout0_120ck1530 FIND v(dout0_120) AT=770.025n

.meas tran vdout0_121ck1530 FIND v(dout0_121) AT=770.025n

.meas tran vdout0_122ck1530 FIND v(dout0_122) AT=770.025n

.meas tran vdout0_123ck1530 FIND v(dout0_123) AT=770.025n

.meas tran vdout0_124ck1530 FIND v(dout0_124) AT=770.025n

.meas tran vdout0_125ck1530 FIND v(dout0_125) AT=770.025n

.meas tran vdout0_126ck1530 FIND v(dout0_126) AT=770.025n

.meas tran vdout0_127ck1530 FIND v(dout0_127) AT=770.025n

.meas tran vdout0_0ck1550 FIND v(dout0_0) AT=780.025n

.meas tran vdout0_1ck1550 FIND v(dout0_1) AT=780.025n

.meas tran vdout0_2ck1550 FIND v(dout0_2) AT=780.025n

.meas tran vdout0_3ck1550 FIND v(dout0_3) AT=780.025n

.meas tran vdout0_4ck1550 FIND v(dout0_4) AT=780.025n

.meas tran vdout0_5ck1550 FIND v(dout0_5) AT=780.025n

.meas tran vdout0_6ck1550 FIND v(dout0_6) AT=780.025n

.meas tran vdout0_7ck1550 FIND v(dout0_7) AT=780.025n

.meas tran vdout0_8ck1550 FIND v(dout0_8) AT=780.025n

.meas tran vdout0_9ck1550 FIND v(dout0_9) AT=780.025n

.meas tran vdout0_10ck1550 FIND v(dout0_10) AT=780.025n

.meas tran vdout0_11ck1550 FIND v(dout0_11) AT=780.025n

.meas tran vdout0_12ck1550 FIND v(dout0_12) AT=780.025n

.meas tran vdout0_13ck1550 FIND v(dout0_13) AT=780.025n

.meas tran vdout0_14ck1550 FIND v(dout0_14) AT=780.025n

.meas tran vdout0_15ck1550 FIND v(dout0_15) AT=780.025n

.meas tran vdout0_16ck1550 FIND v(dout0_16) AT=780.025n

.meas tran vdout0_17ck1550 FIND v(dout0_17) AT=780.025n

.meas tran vdout0_18ck1550 FIND v(dout0_18) AT=780.025n

.meas tran vdout0_19ck1550 FIND v(dout0_19) AT=780.025n

.meas tran vdout0_20ck1550 FIND v(dout0_20) AT=780.025n

.meas tran vdout0_21ck1550 FIND v(dout0_21) AT=780.025n

.meas tran vdout0_22ck1550 FIND v(dout0_22) AT=780.025n

.meas tran vdout0_23ck1550 FIND v(dout0_23) AT=780.025n

.meas tran vdout0_24ck1550 FIND v(dout0_24) AT=780.025n

.meas tran vdout0_25ck1550 FIND v(dout0_25) AT=780.025n

.meas tran vdout0_26ck1550 FIND v(dout0_26) AT=780.025n

.meas tran vdout0_27ck1550 FIND v(dout0_27) AT=780.025n

.meas tran vdout0_28ck1550 FIND v(dout0_28) AT=780.025n

.meas tran vdout0_29ck1550 FIND v(dout0_29) AT=780.025n

.meas tran vdout0_30ck1550 FIND v(dout0_30) AT=780.025n

.meas tran vdout0_31ck1550 FIND v(dout0_31) AT=780.025n

.meas tran vdout0_32ck1550 FIND v(dout0_32) AT=780.025n

.meas tran vdout0_33ck1550 FIND v(dout0_33) AT=780.025n

.meas tran vdout0_34ck1550 FIND v(dout0_34) AT=780.025n

.meas tran vdout0_35ck1550 FIND v(dout0_35) AT=780.025n

.meas tran vdout0_36ck1550 FIND v(dout0_36) AT=780.025n

.meas tran vdout0_37ck1550 FIND v(dout0_37) AT=780.025n

.meas tran vdout0_38ck1550 FIND v(dout0_38) AT=780.025n

.meas tran vdout0_39ck1550 FIND v(dout0_39) AT=780.025n

.meas tran vdout0_40ck1550 FIND v(dout0_40) AT=780.025n

.meas tran vdout0_41ck1550 FIND v(dout0_41) AT=780.025n

.meas tran vdout0_42ck1550 FIND v(dout0_42) AT=780.025n

.meas tran vdout0_43ck1550 FIND v(dout0_43) AT=780.025n

.meas tran vdout0_44ck1550 FIND v(dout0_44) AT=780.025n

.meas tran vdout0_45ck1550 FIND v(dout0_45) AT=780.025n

.meas tran vdout0_46ck1550 FIND v(dout0_46) AT=780.025n

.meas tran vdout0_47ck1550 FIND v(dout0_47) AT=780.025n

.meas tran vdout0_48ck1550 FIND v(dout0_48) AT=780.025n

.meas tran vdout0_49ck1550 FIND v(dout0_49) AT=780.025n

.meas tran vdout0_50ck1550 FIND v(dout0_50) AT=780.025n

.meas tran vdout0_51ck1550 FIND v(dout0_51) AT=780.025n

.meas tran vdout0_52ck1550 FIND v(dout0_52) AT=780.025n

.meas tran vdout0_53ck1550 FIND v(dout0_53) AT=780.025n

.meas tran vdout0_54ck1550 FIND v(dout0_54) AT=780.025n

.meas tran vdout0_55ck1550 FIND v(dout0_55) AT=780.025n

.meas tran vdout0_56ck1550 FIND v(dout0_56) AT=780.025n

.meas tran vdout0_57ck1550 FIND v(dout0_57) AT=780.025n

.meas tran vdout0_58ck1550 FIND v(dout0_58) AT=780.025n

.meas tran vdout0_59ck1550 FIND v(dout0_59) AT=780.025n

.meas tran vdout0_60ck1550 FIND v(dout0_60) AT=780.025n

.meas tran vdout0_61ck1550 FIND v(dout0_61) AT=780.025n

.meas tran vdout0_62ck1550 FIND v(dout0_62) AT=780.025n

.meas tran vdout0_63ck1550 FIND v(dout0_63) AT=780.025n

.meas tran vdout0_64ck1550 FIND v(dout0_64) AT=780.025n

.meas tran vdout0_65ck1550 FIND v(dout0_65) AT=780.025n

.meas tran vdout0_66ck1550 FIND v(dout0_66) AT=780.025n

.meas tran vdout0_67ck1550 FIND v(dout0_67) AT=780.025n

.meas tran vdout0_68ck1550 FIND v(dout0_68) AT=780.025n

.meas tran vdout0_69ck1550 FIND v(dout0_69) AT=780.025n

.meas tran vdout0_70ck1550 FIND v(dout0_70) AT=780.025n

.meas tran vdout0_71ck1550 FIND v(dout0_71) AT=780.025n

.meas tran vdout0_72ck1550 FIND v(dout0_72) AT=780.025n

.meas tran vdout0_73ck1550 FIND v(dout0_73) AT=780.025n

.meas tran vdout0_74ck1550 FIND v(dout0_74) AT=780.025n

.meas tran vdout0_75ck1550 FIND v(dout0_75) AT=780.025n

.meas tran vdout0_76ck1550 FIND v(dout0_76) AT=780.025n

.meas tran vdout0_77ck1550 FIND v(dout0_77) AT=780.025n

.meas tran vdout0_78ck1550 FIND v(dout0_78) AT=780.025n

.meas tran vdout0_79ck1550 FIND v(dout0_79) AT=780.025n

.meas tran vdout0_80ck1550 FIND v(dout0_80) AT=780.025n

.meas tran vdout0_81ck1550 FIND v(dout0_81) AT=780.025n

.meas tran vdout0_82ck1550 FIND v(dout0_82) AT=780.025n

.meas tran vdout0_83ck1550 FIND v(dout0_83) AT=780.025n

.meas tran vdout0_84ck1550 FIND v(dout0_84) AT=780.025n

.meas tran vdout0_85ck1550 FIND v(dout0_85) AT=780.025n

.meas tran vdout0_86ck1550 FIND v(dout0_86) AT=780.025n

.meas tran vdout0_87ck1550 FIND v(dout0_87) AT=780.025n

.meas tran vdout0_88ck1550 FIND v(dout0_88) AT=780.025n

.meas tran vdout0_89ck1550 FIND v(dout0_89) AT=780.025n

.meas tran vdout0_90ck1550 FIND v(dout0_90) AT=780.025n

.meas tran vdout0_91ck1550 FIND v(dout0_91) AT=780.025n

.meas tran vdout0_92ck1550 FIND v(dout0_92) AT=780.025n

.meas tran vdout0_93ck1550 FIND v(dout0_93) AT=780.025n

.meas tran vdout0_94ck1550 FIND v(dout0_94) AT=780.025n

.meas tran vdout0_95ck1550 FIND v(dout0_95) AT=780.025n

.meas tran vdout0_96ck1550 FIND v(dout0_96) AT=780.025n

.meas tran vdout0_97ck1550 FIND v(dout0_97) AT=780.025n

.meas tran vdout0_98ck1550 FIND v(dout0_98) AT=780.025n

.meas tran vdout0_99ck1550 FIND v(dout0_99) AT=780.025n

.meas tran vdout0_100ck1550 FIND v(dout0_100) AT=780.025n

.meas tran vdout0_101ck1550 FIND v(dout0_101) AT=780.025n

.meas tran vdout0_102ck1550 FIND v(dout0_102) AT=780.025n

.meas tran vdout0_103ck1550 FIND v(dout0_103) AT=780.025n

.meas tran vdout0_104ck1550 FIND v(dout0_104) AT=780.025n

.meas tran vdout0_105ck1550 FIND v(dout0_105) AT=780.025n

.meas tran vdout0_106ck1550 FIND v(dout0_106) AT=780.025n

.meas tran vdout0_107ck1550 FIND v(dout0_107) AT=780.025n

.meas tran vdout0_108ck1550 FIND v(dout0_108) AT=780.025n

.meas tran vdout0_109ck1550 FIND v(dout0_109) AT=780.025n

.meas tran vdout0_110ck1550 FIND v(dout0_110) AT=780.025n

.meas tran vdout0_111ck1550 FIND v(dout0_111) AT=780.025n

.meas tran vdout0_112ck1550 FIND v(dout0_112) AT=780.025n

.meas tran vdout0_113ck1550 FIND v(dout0_113) AT=780.025n

.meas tran vdout0_114ck1550 FIND v(dout0_114) AT=780.025n

.meas tran vdout0_115ck1550 FIND v(dout0_115) AT=780.025n

.meas tran vdout0_116ck1550 FIND v(dout0_116) AT=780.025n

.meas tran vdout0_117ck1550 FIND v(dout0_117) AT=780.025n

.meas tran vdout0_118ck1550 FIND v(dout0_118) AT=780.025n

.meas tran vdout0_119ck1550 FIND v(dout0_119) AT=780.025n

.meas tran vdout0_120ck1550 FIND v(dout0_120) AT=780.025n

.meas tran vdout0_121ck1550 FIND v(dout0_121) AT=780.025n

.meas tran vdout0_122ck1550 FIND v(dout0_122) AT=780.025n

.meas tran vdout0_123ck1550 FIND v(dout0_123) AT=780.025n

.meas tran vdout0_124ck1550 FIND v(dout0_124) AT=780.025n

.meas tran vdout0_125ck1550 FIND v(dout0_125) AT=780.025n

.meas tran vdout0_126ck1550 FIND v(dout0_126) AT=780.025n

.meas tran vdout0_127ck1550 FIND v(dout0_127) AT=780.025n

.meas tran vdout0_0ck1580 FIND v(dout0_0) AT=795.025n

.meas tran vdout0_1ck1580 FIND v(dout0_1) AT=795.025n

.meas tran vdout0_2ck1580 FIND v(dout0_2) AT=795.025n

.meas tran vdout0_3ck1580 FIND v(dout0_3) AT=795.025n

.meas tran vdout0_4ck1580 FIND v(dout0_4) AT=795.025n

.meas tran vdout0_5ck1580 FIND v(dout0_5) AT=795.025n

.meas tran vdout0_6ck1580 FIND v(dout0_6) AT=795.025n

.meas tran vdout0_7ck1580 FIND v(dout0_7) AT=795.025n

.meas tran vdout0_8ck1580 FIND v(dout0_8) AT=795.025n

.meas tran vdout0_9ck1580 FIND v(dout0_9) AT=795.025n

.meas tran vdout0_10ck1580 FIND v(dout0_10) AT=795.025n

.meas tran vdout0_11ck1580 FIND v(dout0_11) AT=795.025n

.meas tran vdout0_12ck1580 FIND v(dout0_12) AT=795.025n

.meas tran vdout0_13ck1580 FIND v(dout0_13) AT=795.025n

.meas tran vdout0_14ck1580 FIND v(dout0_14) AT=795.025n

.meas tran vdout0_15ck1580 FIND v(dout0_15) AT=795.025n

.meas tran vdout0_16ck1580 FIND v(dout0_16) AT=795.025n

.meas tran vdout0_17ck1580 FIND v(dout0_17) AT=795.025n

.meas tran vdout0_18ck1580 FIND v(dout0_18) AT=795.025n

.meas tran vdout0_19ck1580 FIND v(dout0_19) AT=795.025n

.meas tran vdout0_20ck1580 FIND v(dout0_20) AT=795.025n

.meas tran vdout0_21ck1580 FIND v(dout0_21) AT=795.025n

.meas tran vdout0_22ck1580 FIND v(dout0_22) AT=795.025n

.meas tran vdout0_23ck1580 FIND v(dout0_23) AT=795.025n

.meas tran vdout0_24ck1580 FIND v(dout0_24) AT=795.025n

.meas tran vdout0_25ck1580 FIND v(dout0_25) AT=795.025n

.meas tran vdout0_26ck1580 FIND v(dout0_26) AT=795.025n

.meas tran vdout0_27ck1580 FIND v(dout0_27) AT=795.025n

.meas tran vdout0_28ck1580 FIND v(dout0_28) AT=795.025n

.meas tran vdout0_29ck1580 FIND v(dout0_29) AT=795.025n

.meas tran vdout0_30ck1580 FIND v(dout0_30) AT=795.025n

.meas tran vdout0_31ck1580 FIND v(dout0_31) AT=795.025n

.meas tran vdout0_32ck1580 FIND v(dout0_32) AT=795.025n

.meas tran vdout0_33ck1580 FIND v(dout0_33) AT=795.025n

.meas tran vdout0_34ck1580 FIND v(dout0_34) AT=795.025n

.meas tran vdout0_35ck1580 FIND v(dout0_35) AT=795.025n

.meas tran vdout0_36ck1580 FIND v(dout0_36) AT=795.025n

.meas tran vdout0_37ck1580 FIND v(dout0_37) AT=795.025n

.meas tran vdout0_38ck1580 FIND v(dout0_38) AT=795.025n

.meas tran vdout0_39ck1580 FIND v(dout0_39) AT=795.025n

.meas tran vdout0_40ck1580 FIND v(dout0_40) AT=795.025n

.meas tran vdout0_41ck1580 FIND v(dout0_41) AT=795.025n

.meas tran vdout0_42ck1580 FIND v(dout0_42) AT=795.025n

.meas tran vdout0_43ck1580 FIND v(dout0_43) AT=795.025n

.meas tran vdout0_44ck1580 FIND v(dout0_44) AT=795.025n

.meas tran vdout0_45ck1580 FIND v(dout0_45) AT=795.025n

.meas tran vdout0_46ck1580 FIND v(dout0_46) AT=795.025n

.meas tran vdout0_47ck1580 FIND v(dout0_47) AT=795.025n

.meas tran vdout0_48ck1580 FIND v(dout0_48) AT=795.025n

.meas tran vdout0_49ck1580 FIND v(dout0_49) AT=795.025n

.meas tran vdout0_50ck1580 FIND v(dout0_50) AT=795.025n

.meas tran vdout0_51ck1580 FIND v(dout0_51) AT=795.025n

.meas tran vdout0_52ck1580 FIND v(dout0_52) AT=795.025n

.meas tran vdout0_53ck1580 FIND v(dout0_53) AT=795.025n

.meas tran vdout0_54ck1580 FIND v(dout0_54) AT=795.025n

.meas tran vdout0_55ck1580 FIND v(dout0_55) AT=795.025n

.meas tran vdout0_56ck1580 FIND v(dout0_56) AT=795.025n

.meas tran vdout0_57ck1580 FIND v(dout0_57) AT=795.025n

.meas tran vdout0_58ck1580 FIND v(dout0_58) AT=795.025n

.meas tran vdout0_59ck1580 FIND v(dout0_59) AT=795.025n

.meas tran vdout0_60ck1580 FIND v(dout0_60) AT=795.025n

.meas tran vdout0_61ck1580 FIND v(dout0_61) AT=795.025n

.meas tran vdout0_62ck1580 FIND v(dout0_62) AT=795.025n

.meas tran vdout0_63ck1580 FIND v(dout0_63) AT=795.025n

.meas tran vdout0_64ck1580 FIND v(dout0_64) AT=795.025n

.meas tran vdout0_65ck1580 FIND v(dout0_65) AT=795.025n

.meas tran vdout0_66ck1580 FIND v(dout0_66) AT=795.025n

.meas tran vdout0_67ck1580 FIND v(dout0_67) AT=795.025n

.meas tran vdout0_68ck1580 FIND v(dout0_68) AT=795.025n

.meas tran vdout0_69ck1580 FIND v(dout0_69) AT=795.025n

.meas tran vdout0_70ck1580 FIND v(dout0_70) AT=795.025n

.meas tran vdout0_71ck1580 FIND v(dout0_71) AT=795.025n

.meas tran vdout0_72ck1580 FIND v(dout0_72) AT=795.025n

.meas tran vdout0_73ck1580 FIND v(dout0_73) AT=795.025n

.meas tran vdout0_74ck1580 FIND v(dout0_74) AT=795.025n

.meas tran vdout0_75ck1580 FIND v(dout0_75) AT=795.025n

.meas tran vdout0_76ck1580 FIND v(dout0_76) AT=795.025n

.meas tran vdout0_77ck1580 FIND v(dout0_77) AT=795.025n

.meas tran vdout0_78ck1580 FIND v(dout0_78) AT=795.025n

.meas tran vdout0_79ck1580 FIND v(dout0_79) AT=795.025n

.meas tran vdout0_80ck1580 FIND v(dout0_80) AT=795.025n

.meas tran vdout0_81ck1580 FIND v(dout0_81) AT=795.025n

.meas tran vdout0_82ck1580 FIND v(dout0_82) AT=795.025n

.meas tran vdout0_83ck1580 FIND v(dout0_83) AT=795.025n

.meas tran vdout0_84ck1580 FIND v(dout0_84) AT=795.025n

.meas tran vdout0_85ck1580 FIND v(dout0_85) AT=795.025n

.meas tran vdout0_86ck1580 FIND v(dout0_86) AT=795.025n

.meas tran vdout0_87ck1580 FIND v(dout0_87) AT=795.025n

.meas tran vdout0_88ck1580 FIND v(dout0_88) AT=795.025n

.meas tran vdout0_89ck1580 FIND v(dout0_89) AT=795.025n

.meas tran vdout0_90ck1580 FIND v(dout0_90) AT=795.025n

.meas tran vdout0_91ck1580 FIND v(dout0_91) AT=795.025n

.meas tran vdout0_92ck1580 FIND v(dout0_92) AT=795.025n

.meas tran vdout0_93ck1580 FIND v(dout0_93) AT=795.025n

.meas tran vdout0_94ck1580 FIND v(dout0_94) AT=795.025n

.meas tran vdout0_95ck1580 FIND v(dout0_95) AT=795.025n

.meas tran vdout0_96ck1580 FIND v(dout0_96) AT=795.025n

.meas tran vdout0_97ck1580 FIND v(dout0_97) AT=795.025n

.meas tran vdout0_98ck1580 FIND v(dout0_98) AT=795.025n

.meas tran vdout0_99ck1580 FIND v(dout0_99) AT=795.025n

.meas tran vdout0_100ck1580 FIND v(dout0_100) AT=795.025n

.meas tran vdout0_101ck1580 FIND v(dout0_101) AT=795.025n

.meas tran vdout0_102ck1580 FIND v(dout0_102) AT=795.025n

.meas tran vdout0_103ck1580 FIND v(dout0_103) AT=795.025n

.meas tran vdout0_104ck1580 FIND v(dout0_104) AT=795.025n

.meas tran vdout0_105ck1580 FIND v(dout0_105) AT=795.025n

.meas tran vdout0_106ck1580 FIND v(dout0_106) AT=795.025n

.meas tran vdout0_107ck1580 FIND v(dout0_107) AT=795.025n

.meas tran vdout0_108ck1580 FIND v(dout0_108) AT=795.025n

.meas tran vdout0_109ck1580 FIND v(dout0_109) AT=795.025n

.meas tran vdout0_110ck1580 FIND v(dout0_110) AT=795.025n

.meas tran vdout0_111ck1580 FIND v(dout0_111) AT=795.025n

.meas tran vdout0_112ck1580 FIND v(dout0_112) AT=795.025n

.meas tran vdout0_113ck1580 FIND v(dout0_113) AT=795.025n

.meas tran vdout0_114ck1580 FIND v(dout0_114) AT=795.025n

.meas tran vdout0_115ck1580 FIND v(dout0_115) AT=795.025n

.meas tran vdout0_116ck1580 FIND v(dout0_116) AT=795.025n

.meas tran vdout0_117ck1580 FIND v(dout0_117) AT=795.025n

.meas tran vdout0_118ck1580 FIND v(dout0_118) AT=795.025n

.meas tran vdout0_119ck1580 FIND v(dout0_119) AT=795.025n

.meas tran vdout0_120ck1580 FIND v(dout0_120) AT=795.025n

.meas tran vdout0_121ck1580 FIND v(dout0_121) AT=795.025n

.meas tran vdout0_122ck1580 FIND v(dout0_122) AT=795.025n

.meas tran vdout0_123ck1580 FIND v(dout0_123) AT=795.025n

.meas tran vdout0_124ck1580 FIND v(dout0_124) AT=795.025n

.meas tran vdout0_125ck1580 FIND v(dout0_125) AT=795.025n

.meas tran vdout0_126ck1580 FIND v(dout0_126) AT=795.025n

.meas tran vdout0_127ck1580 FIND v(dout0_127) AT=795.025n

.meas tran vdout0_0ck1590 FIND v(dout0_0) AT=800.025n

.meas tran vdout0_1ck1590 FIND v(dout0_1) AT=800.025n

.meas tran vdout0_2ck1590 FIND v(dout0_2) AT=800.025n

.meas tran vdout0_3ck1590 FIND v(dout0_3) AT=800.025n

.meas tran vdout0_4ck1590 FIND v(dout0_4) AT=800.025n

.meas tran vdout0_5ck1590 FIND v(dout0_5) AT=800.025n

.meas tran vdout0_6ck1590 FIND v(dout0_6) AT=800.025n

.meas tran vdout0_7ck1590 FIND v(dout0_7) AT=800.025n

.meas tran vdout0_8ck1590 FIND v(dout0_8) AT=800.025n

.meas tran vdout0_9ck1590 FIND v(dout0_9) AT=800.025n

.meas tran vdout0_10ck1590 FIND v(dout0_10) AT=800.025n

.meas tran vdout0_11ck1590 FIND v(dout0_11) AT=800.025n

.meas tran vdout0_12ck1590 FIND v(dout0_12) AT=800.025n

.meas tran vdout0_13ck1590 FIND v(dout0_13) AT=800.025n

.meas tran vdout0_14ck1590 FIND v(dout0_14) AT=800.025n

.meas tran vdout0_15ck1590 FIND v(dout0_15) AT=800.025n

.meas tran vdout0_16ck1590 FIND v(dout0_16) AT=800.025n

.meas tran vdout0_17ck1590 FIND v(dout0_17) AT=800.025n

.meas tran vdout0_18ck1590 FIND v(dout0_18) AT=800.025n

.meas tran vdout0_19ck1590 FIND v(dout0_19) AT=800.025n

.meas tran vdout0_20ck1590 FIND v(dout0_20) AT=800.025n

.meas tran vdout0_21ck1590 FIND v(dout0_21) AT=800.025n

.meas tran vdout0_22ck1590 FIND v(dout0_22) AT=800.025n

.meas tran vdout0_23ck1590 FIND v(dout0_23) AT=800.025n

.meas tran vdout0_24ck1590 FIND v(dout0_24) AT=800.025n

.meas tran vdout0_25ck1590 FIND v(dout0_25) AT=800.025n

.meas tran vdout0_26ck1590 FIND v(dout0_26) AT=800.025n

.meas tran vdout0_27ck1590 FIND v(dout0_27) AT=800.025n

.meas tran vdout0_28ck1590 FIND v(dout0_28) AT=800.025n

.meas tran vdout0_29ck1590 FIND v(dout0_29) AT=800.025n

.meas tran vdout0_30ck1590 FIND v(dout0_30) AT=800.025n

.meas tran vdout0_31ck1590 FIND v(dout0_31) AT=800.025n

.meas tran vdout0_32ck1590 FIND v(dout0_32) AT=800.025n

.meas tran vdout0_33ck1590 FIND v(dout0_33) AT=800.025n

.meas tran vdout0_34ck1590 FIND v(dout0_34) AT=800.025n

.meas tran vdout0_35ck1590 FIND v(dout0_35) AT=800.025n

.meas tran vdout0_36ck1590 FIND v(dout0_36) AT=800.025n

.meas tran vdout0_37ck1590 FIND v(dout0_37) AT=800.025n

.meas tran vdout0_38ck1590 FIND v(dout0_38) AT=800.025n

.meas tran vdout0_39ck1590 FIND v(dout0_39) AT=800.025n

.meas tran vdout0_40ck1590 FIND v(dout0_40) AT=800.025n

.meas tran vdout0_41ck1590 FIND v(dout0_41) AT=800.025n

.meas tran vdout0_42ck1590 FIND v(dout0_42) AT=800.025n

.meas tran vdout0_43ck1590 FIND v(dout0_43) AT=800.025n

.meas tran vdout0_44ck1590 FIND v(dout0_44) AT=800.025n

.meas tran vdout0_45ck1590 FIND v(dout0_45) AT=800.025n

.meas tran vdout0_46ck1590 FIND v(dout0_46) AT=800.025n

.meas tran vdout0_47ck1590 FIND v(dout0_47) AT=800.025n

.meas tran vdout0_48ck1590 FIND v(dout0_48) AT=800.025n

.meas tran vdout0_49ck1590 FIND v(dout0_49) AT=800.025n

.meas tran vdout0_50ck1590 FIND v(dout0_50) AT=800.025n

.meas tran vdout0_51ck1590 FIND v(dout0_51) AT=800.025n

.meas tran vdout0_52ck1590 FIND v(dout0_52) AT=800.025n

.meas tran vdout0_53ck1590 FIND v(dout0_53) AT=800.025n

.meas tran vdout0_54ck1590 FIND v(dout0_54) AT=800.025n

.meas tran vdout0_55ck1590 FIND v(dout0_55) AT=800.025n

.meas tran vdout0_56ck1590 FIND v(dout0_56) AT=800.025n

.meas tran vdout0_57ck1590 FIND v(dout0_57) AT=800.025n

.meas tran vdout0_58ck1590 FIND v(dout0_58) AT=800.025n

.meas tran vdout0_59ck1590 FIND v(dout0_59) AT=800.025n

.meas tran vdout0_60ck1590 FIND v(dout0_60) AT=800.025n

.meas tran vdout0_61ck1590 FIND v(dout0_61) AT=800.025n

.meas tran vdout0_62ck1590 FIND v(dout0_62) AT=800.025n

.meas tran vdout0_63ck1590 FIND v(dout0_63) AT=800.025n

.meas tran vdout0_64ck1590 FIND v(dout0_64) AT=800.025n

.meas tran vdout0_65ck1590 FIND v(dout0_65) AT=800.025n

.meas tran vdout0_66ck1590 FIND v(dout0_66) AT=800.025n

.meas tran vdout0_67ck1590 FIND v(dout0_67) AT=800.025n

.meas tran vdout0_68ck1590 FIND v(dout0_68) AT=800.025n

.meas tran vdout0_69ck1590 FIND v(dout0_69) AT=800.025n

.meas tran vdout0_70ck1590 FIND v(dout0_70) AT=800.025n

.meas tran vdout0_71ck1590 FIND v(dout0_71) AT=800.025n

.meas tran vdout0_72ck1590 FIND v(dout0_72) AT=800.025n

.meas tran vdout0_73ck1590 FIND v(dout0_73) AT=800.025n

.meas tran vdout0_74ck1590 FIND v(dout0_74) AT=800.025n

.meas tran vdout0_75ck1590 FIND v(dout0_75) AT=800.025n

.meas tran vdout0_76ck1590 FIND v(dout0_76) AT=800.025n

.meas tran vdout0_77ck1590 FIND v(dout0_77) AT=800.025n

.meas tran vdout0_78ck1590 FIND v(dout0_78) AT=800.025n

.meas tran vdout0_79ck1590 FIND v(dout0_79) AT=800.025n

.meas tran vdout0_80ck1590 FIND v(dout0_80) AT=800.025n

.meas tran vdout0_81ck1590 FIND v(dout0_81) AT=800.025n

.meas tran vdout0_82ck1590 FIND v(dout0_82) AT=800.025n

.meas tran vdout0_83ck1590 FIND v(dout0_83) AT=800.025n

.meas tran vdout0_84ck1590 FIND v(dout0_84) AT=800.025n

.meas tran vdout0_85ck1590 FIND v(dout0_85) AT=800.025n

.meas tran vdout0_86ck1590 FIND v(dout0_86) AT=800.025n

.meas tran vdout0_87ck1590 FIND v(dout0_87) AT=800.025n

.meas tran vdout0_88ck1590 FIND v(dout0_88) AT=800.025n

.meas tran vdout0_89ck1590 FIND v(dout0_89) AT=800.025n

.meas tran vdout0_90ck1590 FIND v(dout0_90) AT=800.025n

.meas tran vdout0_91ck1590 FIND v(dout0_91) AT=800.025n

.meas tran vdout0_92ck1590 FIND v(dout0_92) AT=800.025n

.meas tran vdout0_93ck1590 FIND v(dout0_93) AT=800.025n

.meas tran vdout0_94ck1590 FIND v(dout0_94) AT=800.025n

.meas tran vdout0_95ck1590 FIND v(dout0_95) AT=800.025n

.meas tran vdout0_96ck1590 FIND v(dout0_96) AT=800.025n

.meas tran vdout0_97ck1590 FIND v(dout0_97) AT=800.025n

.meas tran vdout0_98ck1590 FIND v(dout0_98) AT=800.025n

.meas tran vdout0_99ck1590 FIND v(dout0_99) AT=800.025n

.meas tran vdout0_100ck1590 FIND v(dout0_100) AT=800.025n

.meas tran vdout0_101ck1590 FIND v(dout0_101) AT=800.025n

.meas tran vdout0_102ck1590 FIND v(dout0_102) AT=800.025n

.meas tran vdout0_103ck1590 FIND v(dout0_103) AT=800.025n

.meas tran vdout0_104ck1590 FIND v(dout0_104) AT=800.025n

.meas tran vdout0_105ck1590 FIND v(dout0_105) AT=800.025n

.meas tran vdout0_106ck1590 FIND v(dout0_106) AT=800.025n

.meas tran vdout0_107ck1590 FIND v(dout0_107) AT=800.025n

.meas tran vdout0_108ck1590 FIND v(dout0_108) AT=800.025n

.meas tran vdout0_109ck1590 FIND v(dout0_109) AT=800.025n

.meas tran vdout0_110ck1590 FIND v(dout0_110) AT=800.025n

.meas tran vdout0_111ck1590 FIND v(dout0_111) AT=800.025n

.meas tran vdout0_112ck1590 FIND v(dout0_112) AT=800.025n

.meas tran vdout0_113ck1590 FIND v(dout0_113) AT=800.025n

.meas tran vdout0_114ck1590 FIND v(dout0_114) AT=800.025n

.meas tran vdout0_115ck1590 FIND v(dout0_115) AT=800.025n

.meas tran vdout0_116ck1590 FIND v(dout0_116) AT=800.025n

.meas tran vdout0_117ck1590 FIND v(dout0_117) AT=800.025n

.meas tran vdout0_118ck1590 FIND v(dout0_118) AT=800.025n

.meas tran vdout0_119ck1590 FIND v(dout0_119) AT=800.025n

.meas tran vdout0_120ck1590 FIND v(dout0_120) AT=800.025n

.meas tran vdout0_121ck1590 FIND v(dout0_121) AT=800.025n

.meas tran vdout0_122ck1590 FIND v(dout0_122) AT=800.025n

.meas tran vdout0_123ck1590 FIND v(dout0_123) AT=800.025n

.meas tran vdout0_124ck1590 FIND v(dout0_124) AT=800.025n

.meas tran vdout0_125ck1590 FIND v(dout0_125) AT=800.025n

.meas tran vdout0_126ck1590 FIND v(dout0_126) AT=800.025n

.meas tran vdout0_127ck1590 FIND v(dout0_127) AT=800.025n

.meas tran vdout0_0ck1600 FIND v(dout0_0) AT=805.025n

.meas tran vdout0_1ck1600 FIND v(dout0_1) AT=805.025n

.meas tran vdout0_2ck1600 FIND v(dout0_2) AT=805.025n

.meas tran vdout0_3ck1600 FIND v(dout0_3) AT=805.025n

.meas tran vdout0_4ck1600 FIND v(dout0_4) AT=805.025n

.meas tran vdout0_5ck1600 FIND v(dout0_5) AT=805.025n

.meas tran vdout0_6ck1600 FIND v(dout0_6) AT=805.025n

.meas tran vdout0_7ck1600 FIND v(dout0_7) AT=805.025n

.meas tran vdout0_8ck1600 FIND v(dout0_8) AT=805.025n

.meas tran vdout0_9ck1600 FIND v(dout0_9) AT=805.025n

.meas tran vdout0_10ck1600 FIND v(dout0_10) AT=805.025n

.meas tran vdout0_11ck1600 FIND v(dout0_11) AT=805.025n

.meas tran vdout0_12ck1600 FIND v(dout0_12) AT=805.025n

.meas tran vdout0_13ck1600 FIND v(dout0_13) AT=805.025n

.meas tran vdout0_14ck1600 FIND v(dout0_14) AT=805.025n

.meas tran vdout0_15ck1600 FIND v(dout0_15) AT=805.025n

.meas tran vdout0_16ck1600 FIND v(dout0_16) AT=805.025n

.meas tran vdout0_17ck1600 FIND v(dout0_17) AT=805.025n

.meas tran vdout0_18ck1600 FIND v(dout0_18) AT=805.025n

.meas tran vdout0_19ck1600 FIND v(dout0_19) AT=805.025n

.meas tran vdout0_20ck1600 FIND v(dout0_20) AT=805.025n

.meas tran vdout0_21ck1600 FIND v(dout0_21) AT=805.025n

.meas tran vdout0_22ck1600 FIND v(dout0_22) AT=805.025n

.meas tran vdout0_23ck1600 FIND v(dout0_23) AT=805.025n

.meas tran vdout0_24ck1600 FIND v(dout0_24) AT=805.025n

.meas tran vdout0_25ck1600 FIND v(dout0_25) AT=805.025n

.meas tran vdout0_26ck1600 FIND v(dout0_26) AT=805.025n

.meas tran vdout0_27ck1600 FIND v(dout0_27) AT=805.025n

.meas tran vdout0_28ck1600 FIND v(dout0_28) AT=805.025n

.meas tran vdout0_29ck1600 FIND v(dout0_29) AT=805.025n

.meas tran vdout0_30ck1600 FIND v(dout0_30) AT=805.025n

.meas tran vdout0_31ck1600 FIND v(dout0_31) AT=805.025n

.meas tran vdout0_32ck1600 FIND v(dout0_32) AT=805.025n

.meas tran vdout0_33ck1600 FIND v(dout0_33) AT=805.025n

.meas tran vdout0_34ck1600 FIND v(dout0_34) AT=805.025n

.meas tran vdout0_35ck1600 FIND v(dout0_35) AT=805.025n

.meas tran vdout0_36ck1600 FIND v(dout0_36) AT=805.025n

.meas tran vdout0_37ck1600 FIND v(dout0_37) AT=805.025n

.meas tran vdout0_38ck1600 FIND v(dout0_38) AT=805.025n

.meas tran vdout0_39ck1600 FIND v(dout0_39) AT=805.025n

.meas tran vdout0_40ck1600 FIND v(dout0_40) AT=805.025n

.meas tran vdout0_41ck1600 FIND v(dout0_41) AT=805.025n

.meas tran vdout0_42ck1600 FIND v(dout0_42) AT=805.025n

.meas tran vdout0_43ck1600 FIND v(dout0_43) AT=805.025n

.meas tran vdout0_44ck1600 FIND v(dout0_44) AT=805.025n

.meas tran vdout0_45ck1600 FIND v(dout0_45) AT=805.025n

.meas tran vdout0_46ck1600 FIND v(dout0_46) AT=805.025n

.meas tran vdout0_47ck1600 FIND v(dout0_47) AT=805.025n

.meas tran vdout0_48ck1600 FIND v(dout0_48) AT=805.025n

.meas tran vdout0_49ck1600 FIND v(dout0_49) AT=805.025n

.meas tran vdout0_50ck1600 FIND v(dout0_50) AT=805.025n

.meas tran vdout0_51ck1600 FIND v(dout0_51) AT=805.025n

.meas tran vdout0_52ck1600 FIND v(dout0_52) AT=805.025n

.meas tran vdout0_53ck1600 FIND v(dout0_53) AT=805.025n

.meas tran vdout0_54ck1600 FIND v(dout0_54) AT=805.025n

.meas tran vdout0_55ck1600 FIND v(dout0_55) AT=805.025n

.meas tran vdout0_56ck1600 FIND v(dout0_56) AT=805.025n

.meas tran vdout0_57ck1600 FIND v(dout0_57) AT=805.025n

.meas tran vdout0_58ck1600 FIND v(dout0_58) AT=805.025n

.meas tran vdout0_59ck1600 FIND v(dout0_59) AT=805.025n

.meas tran vdout0_60ck1600 FIND v(dout0_60) AT=805.025n

.meas tran vdout0_61ck1600 FIND v(dout0_61) AT=805.025n

.meas tran vdout0_62ck1600 FIND v(dout0_62) AT=805.025n

.meas tran vdout0_63ck1600 FIND v(dout0_63) AT=805.025n

.meas tran vdout0_64ck1600 FIND v(dout0_64) AT=805.025n

.meas tran vdout0_65ck1600 FIND v(dout0_65) AT=805.025n

.meas tran vdout0_66ck1600 FIND v(dout0_66) AT=805.025n

.meas tran vdout0_67ck1600 FIND v(dout0_67) AT=805.025n

.meas tran vdout0_68ck1600 FIND v(dout0_68) AT=805.025n

.meas tran vdout0_69ck1600 FIND v(dout0_69) AT=805.025n

.meas tran vdout0_70ck1600 FIND v(dout0_70) AT=805.025n

.meas tran vdout0_71ck1600 FIND v(dout0_71) AT=805.025n

.meas tran vdout0_72ck1600 FIND v(dout0_72) AT=805.025n

.meas tran vdout0_73ck1600 FIND v(dout0_73) AT=805.025n

.meas tran vdout0_74ck1600 FIND v(dout0_74) AT=805.025n

.meas tran vdout0_75ck1600 FIND v(dout0_75) AT=805.025n

.meas tran vdout0_76ck1600 FIND v(dout0_76) AT=805.025n

.meas tran vdout0_77ck1600 FIND v(dout0_77) AT=805.025n

.meas tran vdout0_78ck1600 FIND v(dout0_78) AT=805.025n

.meas tran vdout0_79ck1600 FIND v(dout0_79) AT=805.025n

.meas tran vdout0_80ck1600 FIND v(dout0_80) AT=805.025n

.meas tran vdout0_81ck1600 FIND v(dout0_81) AT=805.025n

.meas tran vdout0_82ck1600 FIND v(dout0_82) AT=805.025n

.meas tran vdout0_83ck1600 FIND v(dout0_83) AT=805.025n

.meas tran vdout0_84ck1600 FIND v(dout0_84) AT=805.025n

.meas tran vdout0_85ck1600 FIND v(dout0_85) AT=805.025n

.meas tran vdout0_86ck1600 FIND v(dout0_86) AT=805.025n

.meas tran vdout0_87ck1600 FIND v(dout0_87) AT=805.025n

.meas tran vdout0_88ck1600 FIND v(dout0_88) AT=805.025n

.meas tran vdout0_89ck1600 FIND v(dout0_89) AT=805.025n

.meas tran vdout0_90ck1600 FIND v(dout0_90) AT=805.025n

.meas tran vdout0_91ck1600 FIND v(dout0_91) AT=805.025n

.meas tran vdout0_92ck1600 FIND v(dout0_92) AT=805.025n

.meas tran vdout0_93ck1600 FIND v(dout0_93) AT=805.025n

.meas tran vdout0_94ck1600 FIND v(dout0_94) AT=805.025n

.meas tran vdout0_95ck1600 FIND v(dout0_95) AT=805.025n

.meas tran vdout0_96ck1600 FIND v(dout0_96) AT=805.025n

.meas tran vdout0_97ck1600 FIND v(dout0_97) AT=805.025n

.meas tran vdout0_98ck1600 FIND v(dout0_98) AT=805.025n

.meas tran vdout0_99ck1600 FIND v(dout0_99) AT=805.025n

.meas tran vdout0_100ck1600 FIND v(dout0_100) AT=805.025n

.meas tran vdout0_101ck1600 FIND v(dout0_101) AT=805.025n

.meas tran vdout0_102ck1600 FIND v(dout0_102) AT=805.025n

.meas tran vdout0_103ck1600 FIND v(dout0_103) AT=805.025n

.meas tran vdout0_104ck1600 FIND v(dout0_104) AT=805.025n

.meas tran vdout0_105ck1600 FIND v(dout0_105) AT=805.025n

.meas tran vdout0_106ck1600 FIND v(dout0_106) AT=805.025n

.meas tran vdout0_107ck1600 FIND v(dout0_107) AT=805.025n

.meas tran vdout0_108ck1600 FIND v(dout0_108) AT=805.025n

.meas tran vdout0_109ck1600 FIND v(dout0_109) AT=805.025n

.meas tran vdout0_110ck1600 FIND v(dout0_110) AT=805.025n

.meas tran vdout0_111ck1600 FIND v(dout0_111) AT=805.025n

.meas tran vdout0_112ck1600 FIND v(dout0_112) AT=805.025n

.meas tran vdout0_113ck1600 FIND v(dout0_113) AT=805.025n

.meas tran vdout0_114ck1600 FIND v(dout0_114) AT=805.025n

.meas tran vdout0_115ck1600 FIND v(dout0_115) AT=805.025n

.meas tran vdout0_116ck1600 FIND v(dout0_116) AT=805.025n

.meas tran vdout0_117ck1600 FIND v(dout0_117) AT=805.025n

.meas tran vdout0_118ck1600 FIND v(dout0_118) AT=805.025n

.meas tran vdout0_119ck1600 FIND v(dout0_119) AT=805.025n

.meas tran vdout0_120ck1600 FIND v(dout0_120) AT=805.025n

.meas tran vdout0_121ck1600 FIND v(dout0_121) AT=805.025n

.meas tran vdout0_122ck1600 FIND v(dout0_122) AT=805.025n

.meas tran vdout0_123ck1600 FIND v(dout0_123) AT=805.025n

.meas tran vdout0_124ck1600 FIND v(dout0_124) AT=805.025n

.meas tran vdout0_125ck1600 FIND v(dout0_125) AT=805.025n

.meas tran vdout0_126ck1600 FIND v(dout0_126) AT=805.025n

.meas tran vdout0_127ck1600 FIND v(dout0_127) AT=805.025n

.meas tran vdout0_0ck1630 FIND v(dout0_0) AT=820.025n

.meas tran vdout0_1ck1630 FIND v(dout0_1) AT=820.025n

.meas tran vdout0_2ck1630 FIND v(dout0_2) AT=820.025n

.meas tran vdout0_3ck1630 FIND v(dout0_3) AT=820.025n

.meas tran vdout0_4ck1630 FIND v(dout0_4) AT=820.025n

.meas tran vdout0_5ck1630 FIND v(dout0_5) AT=820.025n

.meas tran vdout0_6ck1630 FIND v(dout0_6) AT=820.025n

.meas tran vdout0_7ck1630 FIND v(dout0_7) AT=820.025n

.meas tran vdout0_8ck1630 FIND v(dout0_8) AT=820.025n

.meas tran vdout0_9ck1630 FIND v(dout0_9) AT=820.025n

.meas tran vdout0_10ck1630 FIND v(dout0_10) AT=820.025n

.meas tran vdout0_11ck1630 FIND v(dout0_11) AT=820.025n

.meas tran vdout0_12ck1630 FIND v(dout0_12) AT=820.025n

.meas tran vdout0_13ck1630 FIND v(dout0_13) AT=820.025n

.meas tran vdout0_14ck1630 FIND v(dout0_14) AT=820.025n

.meas tran vdout0_15ck1630 FIND v(dout0_15) AT=820.025n

.meas tran vdout0_16ck1630 FIND v(dout0_16) AT=820.025n

.meas tran vdout0_17ck1630 FIND v(dout0_17) AT=820.025n

.meas tran vdout0_18ck1630 FIND v(dout0_18) AT=820.025n

.meas tran vdout0_19ck1630 FIND v(dout0_19) AT=820.025n

.meas tran vdout0_20ck1630 FIND v(dout0_20) AT=820.025n

.meas tran vdout0_21ck1630 FIND v(dout0_21) AT=820.025n

.meas tran vdout0_22ck1630 FIND v(dout0_22) AT=820.025n

.meas tran vdout0_23ck1630 FIND v(dout0_23) AT=820.025n

.meas tran vdout0_24ck1630 FIND v(dout0_24) AT=820.025n

.meas tran vdout0_25ck1630 FIND v(dout0_25) AT=820.025n

.meas tran vdout0_26ck1630 FIND v(dout0_26) AT=820.025n

.meas tran vdout0_27ck1630 FIND v(dout0_27) AT=820.025n

.meas tran vdout0_28ck1630 FIND v(dout0_28) AT=820.025n

.meas tran vdout0_29ck1630 FIND v(dout0_29) AT=820.025n

.meas tran vdout0_30ck1630 FIND v(dout0_30) AT=820.025n

.meas tran vdout0_31ck1630 FIND v(dout0_31) AT=820.025n

.meas tran vdout0_32ck1630 FIND v(dout0_32) AT=820.025n

.meas tran vdout0_33ck1630 FIND v(dout0_33) AT=820.025n

.meas tran vdout0_34ck1630 FIND v(dout0_34) AT=820.025n

.meas tran vdout0_35ck1630 FIND v(dout0_35) AT=820.025n

.meas tran vdout0_36ck1630 FIND v(dout0_36) AT=820.025n

.meas tran vdout0_37ck1630 FIND v(dout0_37) AT=820.025n

.meas tran vdout0_38ck1630 FIND v(dout0_38) AT=820.025n

.meas tran vdout0_39ck1630 FIND v(dout0_39) AT=820.025n

.meas tran vdout0_40ck1630 FIND v(dout0_40) AT=820.025n

.meas tran vdout0_41ck1630 FIND v(dout0_41) AT=820.025n

.meas tran vdout0_42ck1630 FIND v(dout0_42) AT=820.025n

.meas tran vdout0_43ck1630 FIND v(dout0_43) AT=820.025n

.meas tran vdout0_44ck1630 FIND v(dout0_44) AT=820.025n

.meas tran vdout0_45ck1630 FIND v(dout0_45) AT=820.025n

.meas tran vdout0_46ck1630 FIND v(dout0_46) AT=820.025n

.meas tran vdout0_47ck1630 FIND v(dout0_47) AT=820.025n

.meas tran vdout0_48ck1630 FIND v(dout0_48) AT=820.025n

.meas tran vdout0_49ck1630 FIND v(dout0_49) AT=820.025n

.meas tran vdout0_50ck1630 FIND v(dout0_50) AT=820.025n

.meas tran vdout0_51ck1630 FIND v(dout0_51) AT=820.025n

.meas tran vdout0_52ck1630 FIND v(dout0_52) AT=820.025n

.meas tran vdout0_53ck1630 FIND v(dout0_53) AT=820.025n

.meas tran vdout0_54ck1630 FIND v(dout0_54) AT=820.025n

.meas tran vdout0_55ck1630 FIND v(dout0_55) AT=820.025n

.meas tran vdout0_56ck1630 FIND v(dout0_56) AT=820.025n

.meas tran vdout0_57ck1630 FIND v(dout0_57) AT=820.025n

.meas tran vdout0_58ck1630 FIND v(dout0_58) AT=820.025n

.meas tran vdout0_59ck1630 FIND v(dout0_59) AT=820.025n

.meas tran vdout0_60ck1630 FIND v(dout0_60) AT=820.025n

.meas tran vdout0_61ck1630 FIND v(dout0_61) AT=820.025n

.meas tran vdout0_62ck1630 FIND v(dout0_62) AT=820.025n

.meas tran vdout0_63ck1630 FIND v(dout0_63) AT=820.025n

.meas tran vdout0_64ck1630 FIND v(dout0_64) AT=820.025n

.meas tran vdout0_65ck1630 FIND v(dout0_65) AT=820.025n

.meas tran vdout0_66ck1630 FIND v(dout0_66) AT=820.025n

.meas tran vdout0_67ck1630 FIND v(dout0_67) AT=820.025n

.meas tran vdout0_68ck1630 FIND v(dout0_68) AT=820.025n

.meas tran vdout0_69ck1630 FIND v(dout0_69) AT=820.025n

.meas tran vdout0_70ck1630 FIND v(dout0_70) AT=820.025n

.meas tran vdout0_71ck1630 FIND v(dout0_71) AT=820.025n

.meas tran vdout0_72ck1630 FIND v(dout0_72) AT=820.025n

.meas tran vdout0_73ck1630 FIND v(dout0_73) AT=820.025n

.meas tran vdout0_74ck1630 FIND v(dout0_74) AT=820.025n

.meas tran vdout0_75ck1630 FIND v(dout0_75) AT=820.025n

.meas tran vdout0_76ck1630 FIND v(dout0_76) AT=820.025n

.meas tran vdout0_77ck1630 FIND v(dout0_77) AT=820.025n

.meas tran vdout0_78ck1630 FIND v(dout0_78) AT=820.025n

.meas tran vdout0_79ck1630 FIND v(dout0_79) AT=820.025n

.meas tran vdout0_80ck1630 FIND v(dout0_80) AT=820.025n

.meas tran vdout0_81ck1630 FIND v(dout0_81) AT=820.025n

.meas tran vdout0_82ck1630 FIND v(dout0_82) AT=820.025n

.meas tran vdout0_83ck1630 FIND v(dout0_83) AT=820.025n

.meas tran vdout0_84ck1630 FIND v(dout0_84) AT=820.025n

.meas tran vdout0_85ck1630 FIND v(dout0_85) AT=820.025n

.meas tran vdout0_86ck1630 FIND v(dout0_86) AT=820.025n

.meas tran vdout0_87ck1630 FIND v(dout0_87) AT=820.025n

.meas tran vdout0_88ck1630 FIND v(dout0_88) AT=820.025n

.meas tran vdout0_89ck1630 FIND v(dout0_89) AT=820.025n

.meas tran vdout0_90ck1630 FIND v(dout0_90) AT=820.025n

.meas tran vdout0_91ck1630 FIND v(dout0_91) AT=820.025n

.meas tran vdout0_92ck1630 FIND v(dout0_92) AT=820.025n

.meas tran vdout0_93ck1630 FIND v(dout0_93) AT=820.025n

.meas tran vdout0_94ck1630 FIND v(dout0_94) AT=820.025n

.meas tran vdout0_95ck1630 FIND v(dout0_95) AT=820.025n

.meas tran vdout0_96ck1630 FIND v(dout0_96) AT=820.025n

.meas tran vdout0_97ck1630 FIND v(dout0_97) AT=820.025n

.meas tran vdout0_98ck1630 FIND v(dout0_98) AT=820.025n

.meas tran vdout0_99ck1630 FIND v(dout0_99) AT=820.025n

.meas tran vdout0_100ck1630 FIND v(dout0_100) AT=820.025n

.meas tran vdout0_101ck1630 FIND v(dout0_101) AT=820.025n

.meas tran vdout0_102ck1630 FIND v(dout0_102) AT=820.025n

.meas tran vdout0_103ck1630 FIND v(dout0_103) AT=820.025n

.meas tran vdout0_104ck1630 FIND v(dout0_104) AT=820.025n

.meas tran vdout0_105ck1630 FIND v(dout0_105) AT=820.025n

.meas tran vdout0_106ck1630 FIND v(dout0_106) AT=820.025n

.meas tran vdout0_107ck1630 FIND v(dout0_107) AT=820.025n

.meas tran vdout0_108ck1630 FIND v(dout0_108) AT=820.025n

.meas tran vdout0_109ck1630 FIND v(dout0_109) AT=820.025n

.meas tran vdout0_110ck1630 FIND v(dout0_110) AT=820.025n

.meas tran vdout0_111ck1630 FIND v(dout0_111) AT=820.025n

.meas tran vdout0_112ck1630 FIND v(dout0_112) AT=820.025n

.meas tran vdout0_113ck1630 FIND v(dout0_113) AT=820.025n

.meas tran vdout0_114ck1630 FIND v(dout0_114) AT=820.025n

.meas tran vdout0_115ck1630 FIND v(dout0_115) AT=820.025n

.meas tran vdout0_116ck1630 FIND v(dout0_116) AT=820.025n

.meas tran vdout0_117ck1630 FIND v(dout0_117) AT=820.025n

.meas tran vdout0_118ck1630 FIND v(dout0_118) AT=820.025n

.meas tran vdout0_119ck1630 FIND v(dout0_119) AT=820.025n

.meas tran vdout0_120ck1630 FIND v(dout0_120) AT=820.025n

.meas tran vdout0_121ck1630 FIND v(dout0_121) AT=820.025n

.meas tran vdout0_122ck1630 FIND v(dout0_122) AT=820.025n

.meas tran vdout0_123ck1630 FIND v(dout0_123) AT=820.025n

.meas tran vdout0_124ck1630 FIND v(dout0_124) AT=820.025n

.meas tran vdout0_125ck1630 FIND v(dout0_125) AT=820.025n

.meas tran vdout0_126ck1630 FIND v(dout0_126) AT=820.025n

.meas tran vdout0_127ck1630 FIND v(dout0_127) AT=820.025n

.meas tran vdout0_0ck1650 FIND v(dout0_0) AT=830.025n

.meas tran vdout0_1ck1650 FIND v(dout0_1) AT=830.025n

.meas tran vdout0_2ck1650 FIND v(dout0_2) AT=830.025n

.meas tran vdout0_3ck1650 FIND v(dout0_3) AT=830.025n

.meas tran vdout0_4ck1650 FIND v(dout0_4) AT=830.025n

.meas tran vdout0_5ck1650 FIND v(dout0_5) AT=830.025n

.meas tran vdout0_6ck1650 FIND v(dout0_6) AT=830.025n

.meas tran vdout0_7ck1650 FIND v(dout0_7) AT=830.025n

.meas tran vdout0_8ck1650 FIND v(dout0_8) AT=830.025n

.meas tran vdout0_9ck1650 FIND v(dout0_9) AT=830.025n

.meas tran vdout0_10ck1650 FIND v(dout0_10) AT=830.025n

.meas tran vdout0_11ck1650 FIND v(dout0_11) AT=830.025n

.meas tran vdout0_12ck1650 FIND v(dout0_12) AT=830.025n

.meas tran vdout0_13ck1650 FIND v(dout0_13) AT=830.025n

.meas tran vdout0_14ck1650 FIND v(dout0_14) AT=830.025n

.meas tran vdout0_15ck1650 FIND v(dout0_15) AT=830.025n

.meas tran vdout0_16ck1650 FIND v(dout0_16) AT=830.025n

.meas tran vdout0_17ck1650 FIND v(dout0_17) AT=830.025n

.meas tran vdout0_18ck1650 FIND v(dout0_18) AT=830.025n

.meas tran vdout0_19ck1650 FIND v(dout0_19) AT=830.025n

.meas tran vdout0_20ck1650 FIND v(dout0_20) AT=830.025n

.meas tran vdout0_21ck1650 FIND v(dout0_21) AT=830.025n

.meas tran vdout0_22ck1650 FIND v(dout0_22) AT=830.025n

.meas tran vdout0_23ck1650 FIND v(dout0_23) AT=830.025n

.meas tran vdout0_24ck1650 FIND v(dout0_24) AT=830.025n

.meas tran vdout0_25ck1650 FIND v(dout0_25) AT=830.025n

.meas tran vdout0_26ck1650 FIND v(dout0_26) AT=830.025n

.meas tran vdout0_27ck1650 FIND v(dout0_27) AT=830.025n

.meas tran vdout0_28ck1650 FIND v(dout0_28) AT=830.025n

.meas tran vdout0_29ck1650 FIND v(dout0_29) AT=830.025n

.meas tran vdout0_30ck1650 FIND v(dout0_30) AT=830.025n

.meas tran vdout0_31ck1650 FIND v(dout0_31) AT=830.025n

.meas tran vdout0_32ck1650 FIND v(dout0_32) AT=830.025n

.meas tran vdout0_33ck1650 FIND v(dout0_33) AT=830.025n

.meas tran vdout0_34ck1650 FIND v(dout0_34) AT=830.025n

.meas tran vdout0_35ck1650 FIND v(dout0_35) AT=830.025n

.meas tran vdout0_36ck1650 FIND v(dout0_36) AT=830.025n

.meas tran vdout0_37ck1650 FIND v(dout0_37) AT=830.025n

.meas tran vdout0_38ck1650 FIND v(dout0_38) AT=830.025n

.meas tran vdout0_39ck1650 FIND v(dout0_39) AT=830.025n

.meas tran vdout0_40ck1650 FIND v(dout0_40) AT=830.025n

.meas tran vdout0_41ck1650 FIND v(dout0_41) AT=830.025n

.meas tran vdout0_42ck1650 FIND v(dout0_42) AT=830.025n

.meas tran vdout0_43ck1650 FIND v(dout0_43) AT=830.025n

.meas tran vdout0_44ck1650 FIND v(dout0_44) AT=830.025n

.meas tran vdout0_45ck1650 FIND v(dout0_45) AT=830.025n

.meas tran vdout0_46ck1650 FIND v(dout0_46) AT=830.025n

.meas tran vdout0_47ck1650 FIND v(dout0_47) AT=830.025n

.meas tran vdout0_48ck1650 FIND v(dout0_48) AT=830.025n

.meas tran vdout0_49ck1650 FIND v(dout0_49) AT=830.025n

.meas tran vdout0_50ck1650 FIND v(dout0_50) AT=830.025n

.meas tran vdout0_51ck1650 FIND v(dout0_51) AT=830.025n

.meas tran vdout0_52ck1650 FIND v(dout0_52) AT=830.025n

.meas tran vdout0_53ck1650 FIND v(dout0_53) AT=830.025n

.meas tran vdout0_54ck1650 FIND v(dout0_54) AT=830.025n

.meas tran vdout0_55ck1650 FIND v(dout0_55) AT=830.025n

.meas tran vdout0_56ck1650 FIND v(dout0_56) AT=830.025n

.meas tran vdout0_57ck1650 FIND v(dout0_57) AT=830.025n

.meas tran vdout0_58ck1650 FIND v(dout0_58) AT=830.025n

.meas tran vdout0_59ck1650 FIND v(dout0_59) AT=830.025n

.meas tran vdout0_60ck1650 FIND v(dout0_60) AT=830.025n

.meas tran vdout0_61ck1650 FIND v(dout0_61) AT=830.025n

.meas tran vdout0_62ck1650 FIND v(dout0_62) AT=830.025n

.meas tran vdout0_63ck1650 FIND v(dout0_63) AT=830.025n

.meas tran vdout0_64ck1650 FIND v(dout0_64) AT=830.025n

.meas tran vdout0_65ck1650 FIND v(dout0_65) AT=830.025n

.meas tran vdout0_66ck1650 FIND v(dout0_66) AT=830.025n

.meas tran vdout0_67ck1650 FIND v(dout0_67) AT=830.025n

.meas tran vdout0_68ck1650 FIND v(dout0_68) AT=830.025n

.meas tran vdout0_69ck1650 FIND v(dout0_69) AT=830.025n

.meas tran vdout0_70ck1650 FIND v(dout0_70) AT=830.025n

.meas tran vdout0_71ck1650 FIND v(dout0_71) AT=830.025n

.meas tran vdout0_72ck1650 FIND v(dout0_72) AT=830.025n

.meas tran vdout0_73ck1650 FIND v(dout0_73) AT=830.025n

.meas tran vdout0_74ck1650 FIND v(dout0_74) AT=830.025n

.meas tran vdout0_75ck1650 FIND v(dout0_75) AT=830.025n

.meas tran vdout0_76ck1650 FIND v(dout0_76) AT=830.025n

.meas tran vdout0_77ck1650 FIND v(dout0_77) AT=830.025n

.meas tran vdout0_78ck1650 FIND v(dout0_78) AT=830.025n

.meas tran vdout0_79ck1650 FIND v(dout0_79) AT=830.025n

.meas tran vdout0_80ck1650 FIND v(dout0_80) AT=830.025n

.meas tran vdout0_81ck1650 FIND v(dout0_81) AT=830.025n

.meas tran vdout0_82ck1650 FIND v(dout0_82) AT=830.025n

.meas tran vdout0_83ck1650 FIND v(dout0_83) AT=830.025n

.meas tran vdout0_84ck1650 FIND v(dout0_84) AT=830.025n

.meas tran vdout0_85ck1650 FIND v(dout0_85) AT=830.025n

.meas tran vdout0_86ck1650 FIND v(dout0_86) AT=830.025n

.meas tran vdout0_87ck1650 FIND v(dout0_87) AT=830.025n

.meas tran vdout0_88ck1650 FIND v(dout0_88) AT=830.025n

.meas tran vdout0_89ck1650 FIND v(dout0_89) AT=830.025n

.meas tran vdout0_90ck1650 FIND v(dout0_90) AT=830.025n

.meas tran vdout0_91ck1650 FIND v(dout0_91) AT=830.025n

.meas tran vdout0_92ck1650 FIND v(dout0_92) AT=830.025n

.meas tran vdout0_93ck1650 FIND v(dout0_93) AT=830.025n

.meas tran vdout0_94ck1650 FIND v(dout0_94) AT=830.025n

.meas tran vdout0_95ck1650 FIND v(dout0_95) AT=830.025n

.meas tran vdout0_96ck1650 FIND v(dout0_96) AT=830.025n

.meas tran vdout0_97ck1650 FIND v(dout0_97) AT=830.025n

.meas tran vdout0_98ck1650 FIND v(dout0_98) AT=830.025n

.meas tran vdout0_99ck1650 FIND v(dout0_99) AT=830.025n

.meas tran vdout0_100ck1650 FIND v(dout0_100) AT=830.025n

.meas tran vdout0_101ck1650 FIND v(dout0_101) AT=830.025n

.meas tran vdout0_102ck1650 FIND v(dout0_102) AT=830.025n

.meas tran vdout0_103ck1650 FIND v(dout0_103) AT=830.025n

.meas tran vdout0_104ck1650 FIND v(dout0_104) AT=830.025n

.meas tran vdout0_105ck1650 FIND v(dout0_105) AT=830.025n

.meas tran vdout0_106ck1650 FIND v(dout0_106) AT=830.025n

.meas tran vdout0_107ck1650 FIND v(dout0_107) AT=830.025n

.meas tran vdout0_108ck1650 FIND v(dout0_108) AT=830.025n

.meas tran vdout0_109ck1650 FIND v(dout0_109) AT=830.025n

.meas tran vdout0_110ck1650 FIND v(dout0_110) AT=830.025n

.meas tran vdout0_111ck1650 FIND v(dout0_111) AT=830.025n

.meas tran vdout0_112ck1650 FIND v(dout0_112) AT=830.025n

.meas tran vdout0_113ck1650 FIND v(dout0_113) AT=830.025n

.meas tran vdout0_114ck1650 FIND v(dout0_114) AT=830.025n

.meas tran vdout0_115ck1650 FIND v(dout0_115) AT=830.025n

.meas tran vdout0_116ck1650 FIND v(dout0_116) AT=830.025n

.meas tran vdout0_117ck1650 FIND v(dout0_117) AT=830.025n

.meas tran vdout0_118ck1650 FIND v(dout0_118) AT=830.025n

.meas tran vdout0_119ck1650 FIND v(dout0_119) AT=830.025n

.meas tran vdout0_120ck1650 FIND v(dout0_120) AT=830.025n

.meas tran vdout0_121ck1650 FIND v(dout0_121) AT=830.025n

.meas tran vdout0_122ck1650 FIND v(dout0_122) AT=830.025n

.meas tran vdout0_123ck1650 FIND v(dout0_123) AT=830.025n

.meas tran vdout0_124ck1650 FIND v(dout0_124) AT=830.025n

.meas tran vdout0_125ck1650 FIND v(dout0_125) AT=830.025n

.meas tran vdout0_126ck1650 FIND v(dout0_126) AT=830.025n

.meas tran vdout0_127ck1650 FIND v(dout0_127) AT=830.025n

.meas tran vdout0_0ck1670 FIND v(dout0_0) AT=840.025n

.meas tran vdout0_1ck1670 FIND v(dout0_1) AT=840.025n

.meas tran vdout0_2ck1670 FIND v(dout0_2) AT=840.025n

.meas tran vdout0_3ck1670 FIND v(dout0_3) AT=840.025n

.meas tran vdout0_4ck1670 FIND v(dout0_4) AT=840.025n

.meas tran vdout0_5ck1670 FIND v(dout0_5) AT=840.025n

.meas tran vdout0_6ck1670 FIND v(dout0_6) AT=840.025n

.meas tran vdout0_7ck1670 FIND v(dout0_7) AT=840.025n

.meas tran vdout0_8ck1670 FIND v(dout0_8) AT=840.025n

.meas tran vdout0_9ck1670 FIND v(dout0_9) AT=840.025n

.meas tran vdout0_10ck1670 FIND v(dout0_10) AT=840.025n

.meas tran vdout0_11ck1670 FIND v(dout0_11) AT=840.025n

.meas tran vdout0_12ck1670 FIND v(dout0_12) AT=840.025n

.meas tran vdout0_13ck1670 FIND v(dout0_13) AT=840.025n

.meas tran vdout0_14ck1670 FIND v(dout0_14) AT=840.025n

.meas tran vdout0_15ck1670 FIND v(dout0_15) AT=840.025n

.meas tran vdout0_16ck1670 FIND v(dout0_16) AT=840.025n

.meas tran vdout0_17ck1670 FIND v(dout0_17) AT=840.025n

.meas tran vdout0_18ck1670 FIND v(dout0_18) AT=840.025n

.meas tran vdout0_19ck1670 FIND v(dout0_19) AT=840.025n

.meas tran vdout0_20ck1670 FIND v(dout0_20) AT=840.025n

.meas tran vdout0_21ck1670 FIND v(dout0_21) AT=840.025n

.meas tran vdout0_22ck1670 FIND v(dout0_22) AT=840.025n

.meas tran vdout0_23ck1670 FIND v(dout0_23) AT=840.025n

.meas tran vdout0_24ck1670 FIND v(dout0_24) AT=840.025n

.meas tran vdout0_25ck1670 FIND v(dout0_25) AT=840.025n

.meas tran vdout0_26ck1670 FIND v(dout0_26) AT=840.025n

.meas tran vdout0_27ck1670 FIND v(dout0_27) AT=840.025n

.meas tran vdout0_28ck1670 FIND v(dout0_28) AT=840.025n

.meas tran vdout0_29ck1670 FIND v(dout0_29) AT=840.025n

.meas tran vdout0_30ck1670 FIND v(dout0_30) AT=840.025n

.meas tran vdout0_31ck1670 FIND v(dout0_31) AT=840.025n

.meas tran vdout0_32ck1670 FIND v(dout0_32) AT=840.025n

.meas tran vdout0_33ck1670 FIND v(dout0_33) AT=840.025n

.meas tran vdout0_34ck1670 FIND v(dout0_34) AT=840.025n

.meas tran vdout0_35ck1670 FIND v(dout0_35) AT=840.025n

.meas tran vdout0_36ck1670 FIND v(dout0_36) AT=840.025n

.meas tran vdout0_37ck1670 FIND v(dout0_37) AT=840.025n

.meas tran vdout0_38ck1670 FIND v(dout0_38) AT=840.025n

.meas tran vdout0_39ck1670 FIND v(dout0_39) AT=840.025n

.meas tran vdout0_40ck1670 FIND v(dout0_40) AT=840.025n

.meas tran vdout0_41ck1670 FIND v(dout0_41) AT=840.025n

.meas tran vdout0_42ck1670 FIND v(dout0_42) AT=840.025n

.meas tran vdout0_43ck1670 FIND v(dout0_43) AT=840.025n

.meas tran vdout0_44ck1670 FIND v(dout0_44) AT=840.025n

.meas tran vdout0_45ck1670 FIND v(dout0_45) AT=840.025n

.meas tran vdout0_46ck1670 FIND v(dout0_46) AT=840.025n

.meas tran vdout0_47ck1670 FIND v(dout0_47) AT=840.025n

.meas tran vdout0_48ck1670 FIND v(dout0_48) AT=840.025n

.meas tran vdout0_49ck1670 FIND v(dout0_49) AT=840.025n

.meas tran vdout0_50ck1670 FIND v(dout0_50) AT=840.025n

.meas tran vdout0_51ck1670 FIND v(dout0_51) AT=840.025n

.meas tran vdout0_52ck1670 FIND v(dout0_52) AT=840.025n

.meas tran vdout0_53ck1670 FIND v(dout0_53) AT=840.025n

.meas tran vdout0_54ck1670 FIND v(dout0_54) AT=840.025n

.meas tran vdout0_55ck1670 FIND v(dout0_55) AT=840.025n

.meas tran vdout0_56ck1670 FIND v(dout0_56) AT=840.025n

.meas tran vdout0_57ck1670 FIND v(dout0_57) AT=840.025n

.meas tran vdout0_58ck1670 FIND v(dout0_58) AT=840.025n

.meas tran vdout0_59ck1670 FIND v(dout0_59) AT=840.025n

.meas tran vdout0_60ck1670 FIND v(dout0_60) AT=840.025n

.meas tran vdout0_61ck1670 FIND v(dout0_61) AT=840.025n

.meas tran vdout0_62ck1670 FIND v(dout0_62) AT=840.025n

.meas tran vdout0_63ck1670 FIND v(dout0_63) AT=840.025n

.meas tran vdout0_64ck1670 FIND v(dout0_64) AT=840.025n

.meas tran vdout0_65ck1670 FIND v(dout0_65) AT=840.025n

.meas tran vdout0_66ck1670 FIND v(dout0_66) AT=840.025n

.meas tran vdout0_67ck1670 FIND v(dout0_67) AT=840.025n

.meas tran vdout0_68ck1670 FIND v(dout0_68) AT=840.025n

.meas tran vdout0_69ck1670 FIND v(dout0_69) AT=840.025n

.meas tran vdout0_70ck1670 FIND v(dout0_70) AT=840.025n

.meas tran vdout0_71ck1670 FIND v(dout0_71) AT=840.025n

.meas tran vdout0_72ck1670 FIND v(dout0_72) AT=840.025n

.meas tran vdout0_73ck1670 FIND v(dout0_73) AT=840.025n

.meas tran vdout0_74ck1670 FIND v(dout0_74) AT=840.025n

.meas tran vdout0_75ck1670 FIND v(dout0_75) AT=840.025n

.meas tran vdout0_76ck1670 FIND v(dout0_76) AT=840.025n

.meas tran vdout0_77ck1670 FIND v(dout0_77) AT=840.025n

.meas tran vdout0_78ck1670 FIND v(dout0_78) AT=840.025n

.meas tran vdout0_79ck1670 FIND v(dout0_79) AT=840.025n

.meas tran vdout0_80ck1670 FIND v(dout0_80) AT=840.025n

.meas tran vdout0_81ck1670 FIND v(dout0_81) AT=840.025n

.meas tran vdout0_82ck1670 FIND v(dout0_82) AT=840.025n

.meas tran vdout0_83ck1670 FIND v(dout0_83) AT=840.025n

.meas tran vdout0_84ck1670 FIND v(dout0_84) AT=840.025n

.meas tran vdout0_85ck1670 FIND v(dout0_85) AT=840.025n

.meas tran vdout0_86ck1670 FIND v(dout0_86) AT=840.025n

.meas tran vdout0_87ck1670 FIND v(dout0_87) AT=840.025n

.meas tran vdout0_88ck1670 FIND v(dout0_88) AT=840.025n

.meas tran vdout0_89ck1670 FIND v(dout0_89) AT=840.025n

.meas tran vdout0_90ck1670 FIND v(dout0_90) AT=840.025n

.meas tran vdout0_91ck1670 FIND v(dout0_91) AT=840.025n

.meas tran vdout0_92ck1670 FIND v(dout0_92) AT=840.025n

.meas tran vdout0_93ck1670 FIND v(dout0_93) AT=840.025n

.meas tran vdout0_94ck1670 FIND v(dout0_94) AT=840.025n

.meas tran vdout0_95ck1670 FIND v(dout0_95) AT=840.025n

.meas tran vdout0_96ck1670 FIND v(dout0_96) AT=840.025n

.meas tran vdout0_97ck1670 FIND v(dout0_97) AT=840.025n

.meas tran vdout0_98ck1670 FIND v(dout0_98) AT=840.025n

.meas tran vdout0_99ck1670 FIND v(dout0_99) AT=840.025n

.meas tran vdout0_100ck1670 FIND v(dout0_100) AT=840.025n

.meas tran vdout0_101ck1670 FIND v(dout0_101) AT=840.025n

.meas tran vdout0_102ck1670 FIND v(dout0_102) AT=840.025n

.meas tran vdout0_103ck1670 FIND v(dout0_103) AT=840.025n

.meas tran vdout0_104ck1670 FIND v(dout0_104) AT=840.025n

.meas tran vdout0_105ck1670 FIND v(dout0_105) AT=840.025n

.meas tran vdout0_106ck1670 FIND v(dout0_106) AT=840.025n

.meas tran vdout0_107ck1670 FIND v(dout0_107) AT=840.025n

.meas tran vdout0_108ck1670 FIND v(dout0_108) AT=840.025n

.meas tran vdout0_109ck1670 FIND v(dout0_109) AT=840.025n

.meas tran vdout0_110ck1670 FIND v(dout0_110) AT=840.025n

.meas tran vdout0_111ck1670 FIND v(dout0_111) AT=840.025n

.meas tran vdout0_112ck1670 FIND v(dout0_112) AT=840.025n

.meas tran vdout0_113ck1670 FIND v(dout0_113) AT=840.025n

.meas tran vdout0_114ck1670 FIND v(dout0_114) AT=840.025n

.meas tran vdout0_115ck1670 FIND v(dout0_115) AT=840.025n

.meas tran vdout0_116ck1670 FIND v(dout0_116) AT=840.025n

.meas tran vdout0_117ck1670 FIND v(dout0_117) AT=840.025n

.meas tran vdout0_118ck1670 FIND v(dout0_118) AT=840.025n

.meas tran vdout0_119ck1670 FIND v(dout0_119) AT=840.025n

.meas tran vdout0_120ck1670 FIND v(dout0_120) AT=840.025n

.meas tran vdout0_121ck1670 FIND v(dout0_121) AT=840.025n

.meas tran vdout0_122ck1670 FIND v(dout0_122) AT=840.025n

.meas tran vdout0_123ck1670 FIND v(dout0_123) AT=840.025n

.meas tran vdout0_124ck1670 FIND v(dout0_124) AT=840.025n

.meas tran vdout0_125ck1670 FIND v(dout0_125) AT=840.025n

.meas tran vdout0_126ck1670 FIND v(dout0_126) AT=840.025n

.meas tran vdout0_127ck1670 FIND v(dout0_127) AT=840.025n

.meas tran vdout0_0ck1700 FIND v(dout0_0) AT=855.025n

.meas tran vdout0_1ck1700 FIND v(dout0_1) AT=855.025n

.meas tran vdout0_2ck1700 FIND v(dout0_2) AT=855.025n

.meas tran vdout0_3ck1700 FIND v(dout0_3) AT=855.025n

.meas tran vdout0_4ck1700 FIND v(dout0_4) AT=855.025n

.meas tran vdout0_5ck1700 FIND v(dout0_5) AT=855.025n

.meas tran vdout0_6ck1700 FIND v(dout0_6) AT=855.025n

.meas tran vdout0_7ck1700 FIND v(dout0_7) AT=855.025n

.meas tran vdout0_8ck1700 FIND v(dout0_8) AT=855.025n

.meas tran vdout0_9ck1700 FIND v(dout0_9) AT=855.025n

.meas tran vdout0_10ck1700 FIND v(dout0_10) AT=855.025n

.meas tran vdout0_11ck1700 FIND v(dout0_11) AT=855.025n

.meas tran vdout0_12ck1700 FIND v(dout0_12) AT=855.025n

.meas tran vdout0_13ck1700 FIND v(dout0_13) AT=855.025n

.meas tran vdout0_14ck1700 FIND v(dout0_14) AT=855.025n

.meas tran vdout0_15ck1700 FIND v(dout0_15) AT=855.025n

.meas tran vdout0_16ck1700 FIND v(dout0_16) AT=855.025n

.meas tran vdout0_17ck1700 FIND v(dout0_17) AT=855.025n

.meas tran vdout0_18ck1700 FIND v(dout0_18) AT=855.025n

.meas tran vdout0_19ck1700 FIND v(dout0_19) AT=855.025n

.meas tran vdout0_20ck1700 FIND v(dout0_20) AT=855.025n

.meas tran vdout0_21ck1700 FIND v(dout0_21) AT=855.025n

.meas tran vdout0_22ck1700 FIND v(dout0_22) AT=855.025n

.meas tran vdout0_23ck1700 FIND v(dout0_23) AT=855.025n

.meas tran vdout0_24ck1700 FIND v(dout0_24) AT=855.025n

.meas tran vdout0_25ck1700 FIND v(dout0_25) AT=855.025n

.meas tran vdout0_26ck1700 FIND v(dout0_26) AT=855.025n

.meas tran vdout0_27ck1700 FIND v(dout0_27) AT=855.025n

.meas tran vdout0_28ck1700 FIND v(dout0_28) AT=855.025n

.meas tran vdout0_29ck1700 FIND v(dout0_29) AT=855.025n

.meas tran vdout0_30ck1700 FIND v(dout0_30) AT=855.025n

.meas tran vdout0_31ck1700 FIND v(dout0_31) AT=855.025n

.meas tran vdout0_32ck1700 FIND v(dout0_32) AT=855.025n

.meas tran vdout0_33ck1700 FIND v(dout0_33) AT=855.025n

.meas tran vdout0_34ck1700 FIND v(dout0_34) AT=855.025n

.meas tran vdout0_35ck1700 FIND v(dout0_35) AT=855.025n

.meas tran vdout0_36ck1700 FIND v(dout0_36) AT=855.025n

.meas tran vdout0_37ck1700 FIND v(dout0_37) AT=855.025n

.meas tran vdout0_38ck1700 FIND v(dout0_38) AT=855.025n

.meas tran vdout0_39ck1700 FIND v(dout0_39) AT=855.025n

.meas tran vdout0_40ck1700 FIND v(dout0_40) AT=855.025n

.meas tran vdout0_41ck1700 FIND v(dout0_41) AT=855.025n

.meas tran vdout0_42ck1700 FIND v(dout0_42) AT=855.025n

.meas tran vdout0_43ck1700 FIND v(dout0_43) AT=855.025n

.meas tran vdout0_44ck1700 FIND v(dout0_44) AT=855.025n

.meas tran vdout0_45ck1700 FIND v(dout0_45) AT=855.025n

.meas tran vdout0_46ck1700 FIND v(dout0_46) AT=855.025n

.meas tran vdout0_47ck1700 FIND v(dout0_47) AT=855.025n

.meas tran vdout0_48ck1700 FIND v(dout0_48) AT=855.025n

.meas tran vdout0_49ck1700 FIND v(dout0_49) AT=855.025n

.meas tran vdout0_50ck1700 FIND v(dout0_50) AT=855.025n

.meas tran vdout0_51ck1700 FIND v(dout0_51) AT=855.025n

.meas tran vdout0_52ck1700 FIND v(dout0_52) AT=855.025n

.meas tran vdout0_53ck1700 FIND v(dout0_53) AT=855.025n

.meas tran vdout0_54ck1700 FIND v(dout0_54) AT=855.025n

.meas tran vdout0_55ck1700 FIND v(dout0_55) AT=855.025n

.meas tran vdout0_56ck1700 FIND v(dout0_56) AT=855.025n

.meas tran vdout0_57ck1700 FIND v(dout0_57) AT=855.025n

.meas tran vdout0_58ck1700 FIND v(dout0_58) AT=855.025n

.meas tran vdout0_59ck1700 FIND v(dout0_59) AT=855.025n

.meas tran vdout0_60ck1700 FIND v(dout0_60) AT=855.025n

.meas tran vdout0_61ck1700 FIND v(dout0_61) AT=855.025n

.meas tran vdout0_62ck1700 FIND v(dout0_62) AT=855.025n

.meas tran vdout0_63ck1700 FIND v(dout0_63) AT=855.025n

.meas tran vdout0_64ck1700 FIND v(dout0_64) AT=855.025n

.meas tran vdout0_65ck1700 FIND v(dout0_65) AT=855.025n

.meas tran vdout0_66ck1700 FIND v(dout0_66) AT=855.025n

.meas tran vdout0_67ck1700 FIND v(dout0_67) AT=855.025n

.meas tran vdout0_68ck1700 FIND v(dout0_68) AT=855.025n

.meas tran vdout0_69ck1700 FIND v(dout0_69) AT=855.025n

.meas tran vdout0_70ck1700 FIND v(dout0_70) AT=855.025n

.meas tran vdout0_71ck1700 FIND v(dout0_71) AT=855.025n

.meas tran vdout0_72ck1700 FIND v(dout0_72) AT=855.025n

.meas tran vdout0_73ck1700 FIND v(dout0_73) AT=855.025n

.meas tran vdout0_74ck1700 FIND v(dout0_74) AT=855.025n

.meas tran vdout0_75ck1700 FIND v(dout0_75) AT=855.025n

.meas tran vdout0_76ck1700 FIND v(dout0_76) AT=855.025n

.meas tran vdout0_77ck1700 FIND v(dout0_77) AT=855.025n

.meas tran vdout0_78ck1700 FIND v(dout0_78) AT=855.025n

.meas tran vdout0_79ck1700 FIND v(dout0_79) AT=855.025n

.meas tran vdout0_80ck1700 FIND v(dout0_80) AT=855.025n

.meas tran vdout0_81ck1700 FIND v(dout0_81) AT=855.025n

.meas tran vdout0_82ck1700 FIND v(dout0_82) AT=855.025n

.meas tran vdout0_83ck1700 FIND v(dout0_83) AT=855.025n

.meas tran vdout0_84ck1700 FIND v(dout0_84) AT=855.025n

.meas tran vdout0_85ck1700 FIND v(dout0_85) AT=855.025n

.meas tran vdout0_86ck1700 FIND v(dout0_86) AT=855.025n

.meas tran vdout0_87ck1700 FIND v(dout0_87) AT=855.025n

.meas tran vdout0_88ck1700 FIND v(dout0_88) AT=855.025n

.meas tran vdout0_89ck1700 FIND v(dout0_89) AT=855.025n

.meas tran vdout0_90ck1700 FIND v(dout0_90) AT=855.025n

.meas tran vdout0_91ck1700 FIND v(dout0_91) AT=855.025n

.meas tran vdout0_92ck1700 FIND v(dout0_92) AT=855.025n

.meas tran vdout0_93ck1700 FIND v(dout0_93) AT=855.025n

.meas tran vdout0_94ck1700 FIND v(dout0_94) AT=855.025n

.meas tran vdout0_95ck1700 FIND v(dout0_95) AT=855.025n

.meas tran vdout0_96ck1700 FIND v(dout0_96) AT=855.025n

.meas tran vdout0_97ck1700 FIND v(dout0_97) AT=855.025n

.meas tran vdout0_98ck1700 FIND v(dout0_98) AT=855.025n

.meas tran vdout0_99ck1700 FIND v(dout0_99) AT=855.025n

.meas tran vdout0_100ck1700 FIND v(dout0_100) AT=855.025n

.meas tran vdout0_101ck1700 FIND v(dout0_101) AT=855.025n

.meas tran vdout0_102ck1700 FIND v(dout0_102) AT=855.025n

.meas tran vdout0_103ck1700 FIND v(dout0_103) AT=855.025n

.meas tran vdout0_104ck1700 FIND v(dout0_104) AT=855.025n

.meas tran vdout0_105ck1700 FIND v(dout0_105) AT=855.025n

.meas tran vdout0_106ck1700 FIND v(dout0_106) AT=855.025n

.meas tran vdout0_107ck1700 FIND v(dout0_107) AT=855.025n

.meas tran vdout0_108ck1700 FIND v(dout0_108) AT=855.025n

.meas tran vdout0_109ck1700 FIND v(dout0_109) AT=855.025n

.meas tran vdout0_110ck1700 FIND v(dout0_110) AT=855.025n

.meas tran vdout0_111ck1700 FIND v(dout0_111) AT=855.025n

.meas tran vdout0_112ck1700 FIND v(dout0_112) AT=855.025n

.meas tran vdout0_113ck1700 FIND v(dout0_113) AT=855.025n

.meas tran vdout0_114ck1700 FIND v(dout0_114) AT=855.025n

.meas tran vdout0_115ck1700 FIND v(dout0_115) AT=855.025n

.meas tran vdout0_116ck1700 FIND v(dout0_116) AT=855.025n

.meas tran vdout0_117ck1700 FIND v(dout0_117) AT=855.025n

.meas tran vdout0_118ck1700 FIND v(dout0_118) AT=855.025n

.meas tran vdout0_119ck1700 FIND v(dout0_119) AT=855.025n

.meas tran vdout0_120ck1700 FIND v(dout0_120) AT=855.025n

.meas tran vdout0_121ck1700 FIND v(dout0_121) AT=855.025n

.meas tran vdout0_122ck1700 FIND v(dout0_122) AT=855.025n

.meas tran vdout0_123ck1700 FIND v(dout0_123) AT=855.025n

.meas tran vdout0_124ck1700 FIND v(dout0_124) AT=855.025n

.meas tran vdout0_125ck1700 FIND v(dout0_125) AT=855.025n

.meas tran vdout0_126ck1700 FIND v(dout0_126) AT=855.025n

.meas tran vdout0_127ck1700 FIND v(dout0_127) AT=855.025n

.meas tran vdout0_0ck1740 FIND v(dout0_0) AT=875.025n

.meas tran vdout0_1ck1740 FIND v(dout0_1) AT=875.025n

.meas tran vdout0_2ck1740 FIND v(dout0_2) AT=875.025n

.meas tran vdout0_3ck1740 FIND v(dout0_3) AT=875.025n

.meas tran vdout0_4ck1740 FIND v(dout0_4) AT=875.025n

.meas tran vdout0_5ck1740 FIND v(dout0_5) AT=875.025n

.meas tran vdout0_6ck1740 FIND v(dout0_6) AT=875.025n

.meas tran vdout0_7ck1740 FIND v(dout0_7) AT=875.025n

.meas tran vdout0_8ck1740 FIND v(dout0_8) AT=875.025n

.meas tran vdout0_9ck1740 FIND v(dout0_9) AT=875.025n

.meas tran vdout0_10ck1740 FIND v(dout0_10) AT=875.025n

.meas tran vdout0_11ck1740 FIND v(dout0_11) AT=875.025n

.meas tran vdout0_12ck1740 FIND v(dout0_12) AT=875.025n

.meas tran vdout0_13ck1740 FIND v(dout0_13) AT=875.025n

.meas tran vdout0_14ck1740 FIND v(dout0_14) AT=875.025n

.meas tran vdout0_15ck1740 FIND v(dout0_15) AT=875.025n

.meas tran vdout0_16ck1740 FIND v(dout0_16) AT=875.025n

.meas tran vdout0_17ck1740 FIND v(dout0_17) AT=875.025n

.meas tran vdout0_18ck1740 FIND v(dout0_18) AT=875.025n

.meas tran vdout0_19ck1740 FIND v(dout0_19) AT=875.025n

.meas tran vdout0_20ck1740 FIND v(dout0_20) AT=875.025n

.meas tran vdout0_21ck1740 FIND v(dout0_21) AT=875.025n

.meas tran vdout0_22ck1740 FIND v(dout0_22) AT=875.025n

.meas tran vdout0_23ck1740 FIND v(dout0_23) AT=875.025n

.meas tran vdout0_24ck1740 FIND v(dout0_24) AT=875.025n

.meas tran vdout0_25ck1740 FIND v(dout0_25) AT=875.025n

.meas tran vdout0_26ck1740 FIND v(dout0_26) AT=875.025n

.meas tran vdout0_27ck1740 FIND v(dout0_27) AT=875.025n

.meas tran vdout0_28ck1740 FIND v(dout0_28) AT=875.025n

.meas tran vdout0_29ck1740 FIND v(dout0_29) AT=875.025n

.meas tran vdout0_30ck1740 FIND v(dout0_30) AT=875.025n

.meas tran vdout0_31ck1740 FIND v(dout0_31) AT=875.025n

.meas tran vdout0_32ck1740 FIND v(dout0_32) AT=875.025n

.meas tran vdout0_33ck1740 FIND v(dout0_33) AT=875.025n

.meas tran vdout0_34ck1740 FIND v(dout0_34) AT=875.025n

.meas tran vdout0_35ck1740 FIND v(dout0_35) AT=875.025n

.meas tran vdout0_36ck1740 FIND v(dout0_36) AT=875.025n

.meas tran vdout0_37ck1740 FIND v(dout0_37) AT=875.025n

.meas tran vdout0_38ck1740 FIND v(dout0_38) AT=875.025n

.meas tran vdout0_39ck1740 FIND v(dout0_39) AT=875.025n

.meas tran vdout0_40ck1740 FIND v(dout0_40) AT=875.025n

.meas tran vdout0_41ck1740 FIND v(dout0_41) AT=875.025n

.meas tran vdout0_42ck1740 FIND v(dout0_42) AT=875.025n

.meas tran vdout0_43ck1740 FIND v(dout0_43) AT=875.025n

.meas tran vdout0_44ck1740 FIND v(dout0_44) AT=875.025n

.meas tran vdout0_45ck1740 FIND v(dout0_45) AT=875.025n

.meas tran vdout0_46ck1740 FIND v(dout0_46) AT=875.025n

.meas tran vdout0_47ck1740 FIND v(dout0_47) AT=875.025n

.meas tran vdout0_48ck1740 FIND v(dout0_48) AT=875.025n

.meas tran vdout0_49ck1740 FIND v(dout0_49) AT=875.025n

.meas tran vdout0_50ck1740 FIND v(dout0_50) AT=875.025n

.meas tran vdout0_51ck1740 FIND v(dout0_51) AT=875.025n

.meas tran vdout0_52ck1740 FIND v(dout0_52) AT=875.025n

.meas tran vdout0_53ck1740 FIND v(dout0_53) AT=875.025n

.meas tran vdout0_54ck1740 FIND v(dout0_54) AT=875.025n

.meas tran vdout0_55ck1740 FIND v(dout0_55) AT=875.025n

.meas tran vdout0_56ck1740 FIND v(dout0_56) AT=875.025n

.meas tran vdout0_57ck1740 FIND v(dout0_57) AT=875.025n

.meas tran vdout0_58ck1740 FIND v(dout0_58) AT=875.025n

.meas tran vdout0_59ck1740 FIND v(dout0_59) AT=875.025n

.meas tran vdout0_60ck1740 FIND v(dout0_60) AT=875.025n

.meas tran vdout0_61ck1740 FIND v(dout0_61) AT=875.025n

.meas tran vdout0_62ck1740 FIND v(dout0_62) AT=875.025n

.meas tran vdout0_63ck1740 FIND v(dout0_63) AT=875.025n

.meas tran vdout0_64ck1740 FIND v(dout0_64) AT=875.025n

.meas tran vdout0_65ck1740 FIND v(dout0_65) AT=875.025n

.meas tran vdout0_66ck1740 FIND v(dout0_66) AT=875.025n

.meas tran vdout0_67ck1740 FIND v(dout0_67) AT=875.025n

.meas tran vdout0_68ck1740 FIND v(dout0_68) AT=875.025n

.meas tran vdout0_69ck1740 FIND v(dout0_69) AT=875.025n

.meas tran vdout0_70ck1740 FIND v(dout0_70) AT=875.025n

.meas tran vdout0_71ck1740 FIND v(dout0_71) AT=875.025n

.meas tran vdout0_72ck1740 FIND v(dout0_72) AT=875.025n

.meas tran vdout0_73ck1740 FIND v(dout0_73) AT=875.025n

.meas tran vdout0_74ck1740 FIND v(dout0_74) AT=875.025n

.meas tran vdout0_75ck1740 FIND v(dout0_75) AT=875.025n

.meas tran vdout0_76ck1740 FIND v(dout0_76) AT=875.025n

.meas tran vdout0_77ck1740 FIND v(dout0_77) AT=875.025n

.meas tran vdout0_78ck1740 FIND v(dout0_78) AT=875.025n

.meas tran vdout0_79ck1740 FIND v(dout0_79) AT=875.025n

.meas tran vdout0_80ck1740 FIND v(dout0_80) AT=875.025n

.meas tran vdout0_81ck1740 FIND v(dout0_81) AT=875.025n

.meas tran vdout0_82ck1740 FIND v(dout0_82) AT=875.025n

.meas tran vdout0_83ck1740 FIND v(dout0_83) AT=875.025n

.meas tran vdout0_84ck1740 FIND v(dout0_84) AT=875.025n

.meas tran vdout0_85ck1740 FIND v(dout0_85) AT=875.025n

.meas tran vdout0_86ck1740 FIND v(dout0_86) AT=875.025n

.meas tran vdout0_87ck1740 FIND v(dout0_87) AT=875.025n

.meas tran vdout0_88ck1740 FIND v(dout0_88) AT=875.025n

.meas tran vdout0_89ck1740 FIND v(dout0_89) AT=875.025n

.meas tran vdout0_90ck1740 FIND v(dout0_90) AT=875.025n

.meas tran vdout0_91ck1740 FIND v(dout0_91) AT=875.025n

.meas tran vdout0_92ck1740 FIND v(dout0_92) AT=875.025n

.meas tran vdout0_93ck1740 FIND v(dout0_93) AT=875.025n

.meas tran vdout0_94ck1740 FIND v(dout0_94) AT=875.025n

.meas tran vdout0_95ck1740 FIND v(dout0_95) AT=875.025n

.meas tran vdout0_96ck1740 FIND v(dout0_96) AT=875.025n

.meas tran vdout0_97ck1740 FIND v(dout0_97) AT=875.025n

.meas tran vdout0_98ck1740 FIND v(dout0_98) AT=875.025n

.meas tran vdout0_99ck1740 FIND v(dout0_99) AT=875.025n

.meas tran vdout0_100ck1740 FIND v(dout0_100) AT=875.025n

.meas tran vdout0_101ck1740 FIND v(dout0_101) AT=875.025n

.meas tran vdout0_102ck1740 FIND v(dout0_102) AT=875.025n

.meas tran vdout0_103ck1740 FIND v(dout0_103) AT=875.025n

.meas tran vdout0_104ck1740 FIND v(dout0_104) AT=875.025n

.meas tran vdout0_105ck1740 FIND v(dout0_105) AT=875.025n

.meas tran vdout0_106ck1740 FIND v(dout0_106) AT=875.025n

.meas tran vdout0_107ck1740 FIND v(dout0_107) AT=875.025n

.meas tran vdout0_108ck1740 FIND v(dout0_108) AT=875.025n

.meas tran vdout0_109ck1740 FIND v(dout0_109) AT=875.025n

.meas tran vdout0_110ck1740 FIND v(dout0_110) AT=875.025n

.meas tran vdout0_111ck1740 FIND v(dout0_111) AT=875.025n

.meas tran vdout0_112ck1740 FIND v(dout0_112) AT=875.025n

.meas tran vdout0_113ck1740 FIND v(dout0_113) AT=875.025n

.meas tran vdout0_114ck1740 FIND v(dout0_114) AT=875.025n

.meas tran vdout0_115ck1740 FIND v(dout0_115) AT=875.025n

.meas tran vdout0_116ck1740 FIND v(dout0_116) AT=875.025n

.meas tran vdout0_117ck1740 FIND v(dout0_117) AT=875.025n

.meas tran vdout0_118ck1740 FIND v(dout0_118) AT=875.025n

.meas tran vdout0_119ck1740 FIND v(dout0_119) AT=875.025n

.meas tran vdout0_120ck1740 FIND v(dout0_120) AT=875.025n

.meas tran vdout0_121ck1740 FIND v(dout0_121) AT=875.025n

.meas tran vdout0_122ck1740 FIND v(dout0_122) AT=875.025n

.meas tran vdout0_123ck1740 FIND v(dout0_123) AT=875.025n

.meas tran vdout0_124ck1740 FIND v(dout0_124) AT=875.025n

.meas tran vdout0_125ck1740 FIND v(dout0_125) AT=875.025n

.meas tran vdout0_126ck1740 FIND v(dout0_126) AT=875.025n

.meas tran vdout0_127ck1740 FIND v(dout0_127) AT=875.025n

.meas tran vdout0_0ck1750 FIND v(dout0_0) AT=880.025n

.meas tran vdout0_1ck1750 FIND v(dout0_1) AT=880.025n

.meas tran vdout0_2ck1750 FIND v(dout0_2) AT=880.025n

.meas tran vdout0_3ck1750 FIND v(dout0_3) AT=880.025n

.meas tran vdout0_4ck1750 FIND v(dout0_4) AT=880.025n

.meas tran vdout0_5ck1750 FIND v(dout0_5) AT=880.025n

.meas tran vdout0_6ck1750 FIND v(dout0_6) AT=880.025n

.meas tran vdout0_7ck1750 FIND v(dout0_7) AT=880.025n

.meas tran vdout0_8ck1750 FIND v(dout0_8) AT=880.025n

.meas tran vdout0_9ck1750 FIND v(dout0_9) AT=880.025n

.meas tran vdout0_10ck1750 FIND v(dout0_10) AT=880.025n

.meas tran vdout0_11ck1750 FIND v(dout0_11) AT=880.025n

.meas tran vdout0_12ck1750 FIND v(dout0_12) AT=880.025n

.meas tran vdout0_13ck1750 FIND v(dout0_13) AT=880.025n

.meas tran vdout0_14ck1750 FIND v(dout0_14) AT=880.025n

.meas tran vdout0_15ck1750 FIND v(dout0_15) AT=880.025n

.meas tran vdout0_16ck1750 FIND v(dout0_16) AT=880.025n

.meas tran vdout0_17ck1750 FIND v(dout0_17) AT=880.025n

.meas tran vdout0_18ck1750 FIND v(dout0_18) AT=880.025n

.meas tran vdout0_19ck1750 FIND v(dout0_19) AT=880.025n

.meas tran vdout0_20ck1750 FIND v(dout0_20) AT=880.025n

.meas tran vdout0_21ck1750 FIND v(dout0_21) AT=880.025n

.meas tran vdout0_22ck1750 FIND v(dout0_22) AT=880.025n

.meas tran vdout0_23ck1750 FIND v(dout0_23) AT=880.025n

.meas tran vdout0_24ck1750 FIND v(dout0_24) AT=880.025n

.meas tran vdout0_25ck1750 FIND v(dout0_25) AT=880.025n

.meas tran vdout0_26ck1750 FIND v(dout0_26) AT=880.025n

.meas tran vdout0_27ck1750 FIND v(dout0_27) AT=880.025n

.meas tran vdout0_28ck1750 FIND v(dout0_28) AT=880.025n

.meas tran vdout0_29ck1750 FIND v(dout0_29) AT=880.025n

.meas tran vdout0_30ck1750 FIND v(dout0_30) AT=880.025n

.meas tran vdout0_31ck1750 FIND v(dout0_31) AT=880.025n

.meas tran vdout0_32ck1750 FIND v(dout0_32) AT=880.025n

.meas tran vdout0_33ck1750 FIND v(dout0_33) AT=880.025n

.meas tran vdout0_34ck1750 FIND v(dout0_34) AT=880.025n

.meas tran vdout0_35ck1750 FIND v(dout0_35) AT=880.025n

.meas tran vdout0_36ck1750 FIND v(dout0_36) AT=880.025n

.meas tran vdout0_37ck1750 FIND v(dout0_37) AT=880.025n

.meas tran vdout0_38ck1750 FIND v(dout0_38) AT=880.025n

.meas tran vdout0_39ck1750 FIND v(dout0_39) AT=880.025n

.meas tran vdout0_40ck1750 FIND v(dout0_40) AT=880.025n

.meas tran vdout0_41ck1750 FIND v(dout0_41) AT=880.025n

.meas tran vdout0_42ck1750 FIND v(dout0_42) AT=880.025n

.meas tran vdout0_43ck1750 FIND v(dout0_43) AT=880.025n

.meas tran vdout0_44ck1750 FIND v(dout0_44) AT=880.025n

.meas tran vdout0_45ck1750 FIND v(dout0_45) AT=880.025n

.meas tran vdout0_46ck1750 FIND v(dout0_46) AT=880.025n

.meas tran vdout0_47ck1750 FIND v(dout0_47) AT=880.025n

.meas tran vdout0_48ck1750 FIND v(dout0_48) AT=880.025n

.meas tran vdout0_49ck1750 FIND v(dout0_49) AT=880.025n

.meas tran vdout0_50ck1750 FIND v(dout0_50) AT=880.025n

.meas tran vdout0_51ck1750 FIND v(dout0_51) AT=880.025n

.meas tran vdout0_52ck1750 FIND v(dout0_52) AT=880.025n

.meas tran vdout0_53ck1750 FIND v(dout0_53) AT=880.025n

.meas tran vdout0_54ck1750 FIND v(dout0_54) AT=880.025n

.meas tran vdout0_55ck1750 FIND v(dout0_55) AT=880.025n

.meas tran vdout0_56ck1750 FIND v(dout0_56) AT=880.025n

.meas tran vdout0_57ck1750 FIND v(dout0_57) AT=880.025n

.meas tran vdout0_58ck1750 FIND v(dout0_58) AT=880.025n

.meas tran vdout0_59ck1750 FIND v(dout0_59) AT=880.025n

.meas tran vdout0_60ck1750 FIND v(dout0_60) AT=880.025n

.meas tran vdout0_61ck1750 FIND v(dout0_61) AT=880.025n

.meas tran vdout0_62ck1750 FIND v(dout0_62) AT=880.025n

.meas tran vdout0_63ck1750 FIND v(dout0_63) AT=880.025n

.meas tran vdout0_64ck1750 FIND v(dout0_64) AT=880.025n

.meas tran vdout0_65ck1750 FIND v(dout0_65) AT=880.025n

.meas tran vdout0_66ck1750 FIND v(dout0_66) AT=880.025n

.meas tran vdout0_67ck1750 FIND v(dout0_67) AT=880.025n

.meas tran vdout0_68ck1750 FIND v(dout0_68) AT=880.025n

.meas tran vdout0_69ck1750 FIND v(dout0_69) AT=880.025n

.meas tran vdout0_70ck1750 FIND v(dout0_70) AT=880.025n

.meas tran vdout0_71ck1750 FIND v(dout0_71) AT=880.025n

.meas tran vdout0_72ck1750 FIND v(dout0_72) AT=880.025n

.meas tran vdout0_73ck1750 FIND v(dout0_73) AT=880.025n

.meas tran vdout0_74ck1750 FIND v(dout0_74) AT=880.025n

.meas tran vdout0_75ck1750 FIND v(dout0_75) AT=880.025n

.meas tran vdout0_76ck1750 FIND v(dout0_76) AT=880.025n

.meas tran vdout0_77ck1750 FIND v(dout0_77) AT=880.025n

.meas tran vdout0_78ck1750 FIND v(dout0_78) AT=880.025n

.meas tran vdout0_79ck1750 FIND v(dout0_79) AT=880.025n

.meas tran vdout0_80ck1750 FIND v(dout0_80) AT=880.025n

.meas tran vdout0_81ck1750 FIND v(dout0_81) AT=880.025n

.meas tran vdout0_82ck1750 FIND v(dout0_82) AT=880.025n

.meas tran vdout0_83ck1750 FIND v(dout0_83) AT=880.025n

.meas tran vdout0_84ck1750 FIND v(dout0_84) AT=880.025n

.meas tran vdout0_85ck1750 FIND v(dout0_85) AT=880.025n

.meas tran vdout0_86ck1750 FIND v(dout0_86) AT=880.025n

.meas tran vdout0_87ck1750 FIND v(dout0_87) AT=880.025n

.meas tran vdout0_88ck1750 FIND v(dout0_88) AT=880.025n

.meas tran vdout0_89ck1750 FIND v(dout0_89) AT=880.025n

.meas tran vdout0_90ck1750 FIND v(dout0_90) AT=880.025n

.meas tran vdout0_91ck1750 FIND v(dout0_91) AT=880.025n

.meas tran vdout0_92ck1750 FIND v(dout0_92) AT=880.025n

.meas tran vdout0_93ck1750 FIND v(dout0_93) AT=880.025n

.meas tran vdout0_94ck1750 FIND v(dout0_94) AT=880.025n

.meas tran vdout0_95ck1750 FIND v(dout0_95) AT=880.025n

.meas tran vdout0_96ck1750 FIND v(dout0_96) AT=880.025n

.meas tran vdout0_97ck1750 FIND v(dout0_97) AT=880.025n

.meas tran vdout0_98ck1750 FIND v(dout0_98) AT=880.025n

.meas tran vdout0_99ck1750 FIND v(dout0_99) AT=880.025n

.meas tran vdout0_100ck1750 FIND v(dout0_100) AT=880.025n

.meas tran vdout0_101ck1750 FIND v(dout0_101) AT=880.025n

.meas tran vdout0_102ck1750 FIND v(dout0_102) AT=880.025n

.meas tran vdout0_103ck1750 FIND v(dout0_103) AT=880.025n

.meas tran vdout0_104ck1750 FIND v(dout0_104) AT=880.025n

.meas tran vdout0_105ck1750 FIND v(dout0_105) AT=880.025n

.meas tran vdout0_106ck1750 FIND v(dout0_106) AT=880.025n

.meas tran vdout0_107ck1750 FIND v(dout0_107) AT=880.025n

.meas tran vdout0_108ck1750 FIND v(dout0_108) AT=880.025n

.meas tran vdout0_109ck1750 FIND v(dout0_109) AT=880.025n

.meas tran vdout0_110ck1750 FIND v(dout0_110) AT=880.025n

.meas tran vdout0_111ck1750 FIND v(dout0_111) AT=880.025n

.meas tran vdout0_112ck1750 FIND v(dout0_112) AT=880.025n

.meas tran vdout0_113ck1750 FIND v(dout0_113) AT=880.025n

.meas tran vdout0_114ck1750 FIND v(dout0_114) AT=880.025n

.meas tran vdout0_115ck1750 FIND v(dout0_115) AT=880.025n

.meas tran vdout0_116ck1750 FIND v(dout0_116) AT=880.025n

.meas tran vdout0_117ck1750 FIND v(dout0_117) AT=880.025n

.meas tran vdout0_118ck1750 FIND v(dout0_118) AT=880.025n

.meas tran vdout0_119ck1750 FIND v(dout0_119) AT=880.025n

.meas tran vdout0_120ck1750 FIND v(dout0_120) AT=880.025n

.meas tran vdout0_121ck1750 FIND v(dout0_121) AT=880.025n

.meas tran vdout0_122ck1750 FIND v(dout0_122) AT=880.025n

.meas tran vdout0_123ck1750 FIND v(dout0_123) AT=880.025n

.meas tran vdout0_124ck1750 FIND v(dout0_124) AT=880.025n

.meas tran vdout0_125ck1750 FIND v(dout0_125) AT=880.025n

.meas tran vdout0_126ck1750 FIND v(dout0_126) AT=880.025n

.meas tran vdout0_127ck1750 FIND v(dout0_127) AT=880.025n

.meas tran vdout0_0ck1760 FIND v(dout0_0) AT=885.025n

.meas tran vdout0_1ck1760 FIND v(dout0_1) AT=885.025n

.meas tran vdout0_2ck1760 FIND v(dout0_2) AT=885.025n

.meas tran vdout0_3ck1760 FIND v(dout0_3) AT=885.025n

.meas tran vdout0_4ck1760 FIND v(dout0_4) AT=885.025n

.meas tran vdout0_5ck1760 FIND v(dout0_5) AT=885.025n

.meas tran vdout0_6ck1760 FIND v(dout0_6) AT=885.025n

.meas tran vdout0_7ck1760 FIND v(dout0_7) AT=885.025n

.meas tran vdout0_8ck1760 FIND v(dout0_8) AT=885.025n

.meas tran vdout0_9ck1760 FIND v(dout0_9) AT=885.025n

.meas tran vdout0_10ck1760 FIND v(dout0_10) AT=885.025n

.meas tran vdout0_11ck1760 FIND v(dout0_11) AT=885.025n

.meas tran vdout0_12ck1760 FIND v(dout0_12) AT=885.025n

.meas tran vdout0_13ck1760 FIND v(dout0_13) AT=885.025n

.meas tran vdout0_14ck1760 FIND v(dout0_14) AT=885.025n

.meas tran vdout0_15ck1760 FIND v(dout0_15) AT=885.025n

.meas tran vdout0_16ck1760 FIND v(dout0_16) AT=885.025n

.meas tran vdout0_17ck1760 FIND v(dout0_17) AT=885.025n

.meas tran vdout0_18ck1760 FIND v(dout0_18) AT=885.025n

.meas tran vdout0_19ck1760 FIND v(dout0_19) AT=885.025n

.meas tran vdout0_20ck1760 FIND v(dout0_20) AT=885.025n

.meas tran vdout0_21ck1760 FIND v(dout0_21) AT=885.025n

.meas tran vdout0_22ck1760 FIND v(dout0_22) AT=885.025n

.meas tran vdout0_23ck1760 FIND v(dout0_23) AT=885.025n

.meas tran vdout0_24ck1760 FIND v(dout0_24) AT=885.025n

.meas tran vdout0_25ck1760 FIND v(dout0_25) AT=885.025n

.meas tran vdout0_26ck1760 FIND v(dout0_26) AT=885.025n

.meas tran vdout0_27ck1760 FIND v(dout0_27) AT=885.025n

.meas tran vdout0_28ck1760 FIND v(dout0_28) AT=885.025n

.meas tran vdout0_29ck1760 FIND v(dout0_29) AT=885.025n

.meas tran vdout0_30ck1760 FIND v(dout0_30) AT=885.025n

.meas tran vdout0_31ck1760 FIND v(dout0_31) AT=885.025n

.meas tran vdout0_32ck1760 FIND v(dout0_32) AT=885.025n

.meas tran vdout0_33ck1760 FIND v(dout0_33) AT=885.025n

.meas tran vdout0_34ck1760 FIND v(dout0_34) AT=885.025n

.meas tran vdout0_35ck1760 FIND v(dout0_35) AT=885.025n

.meas tran vdout0_36ck1760 FIND v(dout0_36) AT=885.025n

.meas tran vdout0_37ck1760 FIND v(dout0_37) AT=885.025n

.meas tran vdout0_38ck1760 FIND v(dout0_38) AT=885.025n

.meas tran vdout0_39ck1760 FIND v(dout0_39) AT=885.025n

.meas tran vdout0_40ck1760 FIND v(dout0_40) AT=885.025n

.meas tran vdout0_41ck1760 FIND v(dout0_41) AT=885.025n

.meas tran vdout0_42ck1760 FIND v(dout0_42) AT=885.025n

.meas tran vdout0_43ck1760 FIND v(dout0_43) AT=885.025n

.meas tran vdout0_44ck1760 FIND v(dout0_44) AT=885.025n

.meas tran vdout0_45ck1760 FIND v(dout0_45) AT=885.025n

.meas tran vdout0_46ck1760 FIND v(dout0_46) AT=885.025n

.meas tran vdout0_47ck1760 FIND v(dout0_47) AT=885.025n

.meas tran vdout0_48ck1760 FIND v(dout0_48) AT=885.025n

.meas tran vdout0_49ck1760 FIND v(dout0_49) AT=885.025n

.meas tran vdout0_50ck1760 FIND v(dout0_50) AT=885.025n

.meas tran vdout0_51ck1760 FIND v(dout0_51) AT=885.025n

.meas tran vdout0_52ck1760 FIND v(dout0_52) AT=885.025n

.meas tran vdout0_53ck1760 FIND v(dout0_53) AT=885.025n

.meas tran vdout0_54ck1760 FIND v(dout0_54) AT=885.025n

.meas tran vdout0_55ck1760 FIND v(dout0_55) AT=885.025n

.meas tran vdout0_56ck1760 FIND v(dout0_56) AT=885.025n

.meas tran vdout0_57ck1760 FIND v(dout0_57) AT=885.025n

.meas tran vdout0_58ck1760 FIND v(dout0_58) AT=885.025n

.meas tran vdout0_59ck1760 FIND v(dout0_59) AT=885.025n

.meas tran vdout0_60ck1760 FIND v(dout0_60) AT=885.025n

.meas tran vdout0_61ck1760 FIND v(dout0_61) AT=885.025n

.meas tran vdout0_62ck1760 FIND v(dout0_62) AT=885.025n

.meas tran vdout0_63ck1760 FIND v(dout0_63) AT=885.025n

.meas tran vdout0_64ck1760 FIND v(dout0_64) AT=885.025n

.meas tran vdout0_65ck1760 FIND v(dout0_65) AT=885.025n

.meas tran vdout0_66ck1760 FIND v(dout0_66) AT=885.025n

.meas tran vdout0_67ck1760 FIND v(dout0_67) AT=885.025n

.meas tran vdout0_68ck1760 FIND v(dout0_68) AT=885.025n

.meas tran vdout0_69ck1760 FIND v(dout0_69) AT=885.025n

.meas tran vdout0_70ck1760 FIND v(dout0_70) AT=885.025n

.meas tran vdout0_71ck1760 FIND v(dout0_71) AT=885.025n

.meas tran vdout0_72ck1760 FIND v(dout0_72) AT=885.025n

.meas tran vdout0_73ck1760 FIND v(dout0_73) AT=885.025n

.meas tran vdout0_74ck1760 FIND v(dout0_74) AT=885.025n

.meas tran vdout0_75ck1760 FIND v(dout0_75) AT=885.025n

.meas tran vdout0_76ck1760 FIND v(dout0_76) AT=885.025n

.meas tran vdout0_77ck1760 FIND v(dout0_77) AT=885.025n

.meas tran vdout0_78ck1760 FIND v(dout0_78) AT=885.025n

.meas tran vdout0_79ck1760 FIND v(dout0_79) AT=885.025n

.meas tran vdout0_80ck1760 FIND v(dout0_80) AT=885.025n

.meas tran vdout0_81ck1760 FIND v(dout0_81) AT=885.025n

.meas tran vdout0_82ck1760 FIND v(dout0_82) AT=885.025n

.meas tran vdout0_83ck1760 FIND v(dout0_83) AT=885.025n

.meas tran vdout0_84ck1760 FIND v(dout0_84) AT=885.025n

.meas tran vdout0_85ck1760 FIND v(dout0_85) AT=885.025n

.meas tran vdout0_86ck1760 FIND v(dout0_86) AT=885.025n

.meas tran vdout0_87ck1760 FIND v(dout0_87) AT=885.025n

.meas tran vdout0_88ck1760 FIND v(dout0_88) AT=885.025n

.meas tran vdout0_89ck1760 FIND v(dout0_89) AT=885.025n

.meas tran vdout0_90ck1760 FIND v(dout0_90) AT=885.025n

.meas tran vdout0_91ck1760 FIND v(dout0_91) AT=885.025n

.meas tran vdout0_92ck1760 FIND v(dout0_92) AT=885.025n

.meas tran vdout0_93ck1760 FIND v(dout0_93) AT=885.025n

.meas tran vdout0_94ck1760 FIND v(dout0_94) AT=885.025n

.meas tran vdout0_95ck1760 FIND v(dout0_95) AT=885.025n

.meas tran vdout0_96ck1760 FIND v(dout0_96) AT=885.025n

.meas tran vdout0_97ck1760 FIND v(dout0_97) AT=885.025n

.meas tran vdout0_98ck1760 FIND v(dout0_98) AT=885.025n

.meas tran vdout0_99ck1760 FIND v(dout0_99) AT=885.025n

.meas tran vdout0_100ck1760 FIND v(dout0_100) AT=885.025n

.meas tran vdout0_101ck1760 FIND v(dout0_101) AT=885.025n

.meas tran vdout0_102ck1760 FIND v(dout0_102) AT=885.025n

.meas tran vdout0_103ck1760 FIND v(dout0_103) AT=885.025n

.meas tran vdout0_104ck1760 FIND v(dout0_104) AT=885.025n

.meas tran vdout0_105ck1760 FIND v(dout0_105) AT=885.025n

.meas tran vdout0_106ck1760 FIND v(dout0_106) AT=885.025n

.meas tran vdout0_107ck1760 FIND v(dout0_107) AT=885.025n

.meas tran vdout0_108ck1760 FIND v(dout0_108) AT=885.025n

.meas tran vdout0_109ck1760 FIND v(dout0_109) AT=885.025n

.meas tran vdout0_110ck1760 FIND v(dout0_110) AT=885.025n

.meas tran vdout0_111ck1760 FIND v(dout0_111) AT=885.025n

.meas tran vdout0_112ck1760 FIND v(dout0_112) AT=885.025n

.meas tran vdout0_113ck1760 FIND v(dout0_113) AT=885.025n

.meas tran vdout0_114ck1760 FIND v(dout0_114) AT=885.025n

.meas tran vdout0_115ck1760 FIND v(dout0_115) AT=885.025n

.meas tran vdout0_116ck1760 FIND v(dout0_116) AT=885.025n

.meas tran vdout0_117ck1760 FIND v(dout0_117) AT=885.025n

.meas tran vdout0_118ck1760 FIND v(dout0_118) AT=885.025n

.meas tran vdout0_119ck1760 FIND v(dout0_119) AT=885.025n

.meas tran vdout0_120ck1760 FIND v(dout0_120) AT=885.025n

.meas tran vdout0_121ck1760 FIND v(dout0_121) AT=885.025n

.meas tran vdout0_122ck1760 FIND v(dout0_122) AT=885.025n

.meas tran vdout0_123ck1760 FIND v(dout0_123) AT=885.025n

.meas tran vdout0_124ck1760 FIND v(dout0_124) AT=885.025n

.meas tran vdout0_125ck1760 FIND v(dout0_125) AT=885.025n

.meas tran vdout0_126ck1760 FIND v(dout0_126) AT=885.025n

.meas tran vdout0_127ck1760 FIND v(dout0_127) AT=885.025n

.meas tran vdout0_0ck1770 FIND v(dout0_0) AT=890.025n

.meas tran vdout0_1ck1770 FIND v(dout0_1) AT=890.025n

.meas tran vdout0_2ck1770 FIND v(dout0_2) AT=890.025n

.meas tran vdout0_3ck1770 FIND v(dout0_3) AT=890.025n

.meas tran vdout0_4ck1770 FIND v(dout0_4) AT=890.025n

.meas tran vdout0_5ck1770 FIND v(dout0_5) AT=890.025n

.meas tran vdout0_6ck1770 FIND v(dout0_6) AT=890.025n

.meas tran vdout0_7ck1770 FIND v(dout0_7) AT=890.025n

.meas tran vdout0_8ck1770 FIND v(dout0_8) AT=890.025n

.meas tran vdout0_9ck1770 FIND v(dout0_9) AT=890.025n

.meas tran vdout0_10ck1770 FIND v(dout0_10) AT=890.025n

.meas tran vdout0_11ck1770 FIND v(dout0_11) AT=890.025n

.meas tran vdout0_12ck1770 FIND v(dout0_12) AT=890.025n

.meas tran vdout0_13ck1770 FIND v(dout0_13) AT=890.025n

.meas tran vdout0_14ck1770 FIND v(dout0_14) AT=890.025n

.meas tran vdout0_15ck1770 FIND v(dout0_15) AT=890.025n

.meas tran vdout0_16ck1770 FIND v(dout0_16) AT=890.025n

.meas tran vdout0_17ck1770 FIND v(dout0_17) AT=890.025n

.meas tran vdout0_18ck1770 FIND v(dout0_18) AT=890.025n

.meas tran vdout0_19ck1770 FIND v(dout0_19) AT=890.025n

.meas tran vdout0_20ck1770 FIND v(dout0_20) AT=890.025n

.meas tran vdout0_21ck1770 FIND v(dout0_21) AT=890.025n

.meas tran vdout0_22ck1770 FIND v(dout0_22) AT=890.025n

.meas tran vdout0_23ck1770 FIND v(dout0_23) AT=890.025n

.meas tran vdout0_24ck1770 FIND v(dout0_24) AT=890.025n

.meas tran vdout0_25ck1770 FIND v(dout0_25) AT=890.025n

.meas tran vdout0_26ck1770 FIND v(dout0_26) AT=890.025n

.meas tran vdout0_27ck1770 FIND v(dout0_27) AT=890.025n

.meas tran vdout0_28ck1770 FIND v(dout0_28) AT=890.025n

.meas tran vdout0_29ck1770 FIND v(dout0_29) AT=890.025n

.meas tran vdout0_30ck1770 FIND v(dout0_30) AT=890.025n

.meas tran vdout0_31ck1770 FIND v(dout0_31) AT=890.025n

.meas tran vdout0_32ck1770 FIND v(dout0_32) AT=890.025n

.meas tran vdout0_33ck1770 FIND v(dout0_33) AT=890.025n

.meas tran vdout0_34ck1770 FIND v(dout0_34) AT=890.025n

.meas tran vdout0_35ck1770 FIND v(dout0_35) AT=890.025n

.meas tran vdout0_36ck1770 FIND v(dout0_36) AT=890.025n

.meas tran vdout0_37ck1770 FIND v(dout0_37) AT=890.025n

.meas tran vdout0_38ck1770 FIND v(dout0_38) AT=890.025n

.meas tran vdout0_39ck1770 FIND v(dout0_39) AT=890.025n

.meas tran vdout0_40ck1770 FIND v(dout0_40) AT=890.025n

.meas tran vdout0_41ck1770 FIND v(dout0_41) AT=890.025n

.meas tran vdout0_42ck1770 FIND v(dout0_42) AT=890.025n

.meas tran vdout0_43ck1770 FIND v(dout0_43) AT=890.025n

.meas tran vdout0_44ck1770 FIND v(dout0_44) AT=890.025n

.meas tran vdout0_45ck1770 FIND v(dout0_45) AT=890.025n

.meas tran vdout0_46ck1770 FIND v(dout0_46) AT=890.025n

.meas tran vdout0_47ck1770 FIND v(dout0_47) AT=890.025n

.meas tran vdout0_48ck1770 FIND v(dout0_48) AT=890.025n

.meas tran vdout0_49ck1770 FIND v(dout0_49) AT=890.025n

.meas tran vdout0_50ck1770 FIND v(dout0_50) AT=890.025n

.meas tran vdout0_51ck1770 FIND v(dout0_51) AT=890.025n

.meas tran vdout0_52ck1770 FIND v(dout0_52) AT=890.025n

.meas tran vdout0_53ck1770 FIND v(dout0_53) AT=890.025n

.meas tran vdout0_54ck1770 FIND v(dout0_54) AT=890.025n

.meas tran vdout0_55ck1770 FIND v(dout0_55) AT=890.025n

.meas tran vdout0_56ck1770 FIND v(dout0_56) AT=890.025n

.meas tran vdout0_57ck1770 FIND v(dout0_57) AT=890.025n

.meas tran vdout0_58ck1770 FIND v(dout0_58) AT=890.025n

.meas tran vdout0_59ck1770 FIND v(dout0_59) AT=890.025n

.meas tran vdout0_60ck1770 FIND v(dout0_60) AT=890.025n

.meas tran vdout0_61ck1770 FIND v(dout0_61) AT=890.025n

.meas tran vdout0_62ck1770 FIND v(dout0_62) AT=890.025n

.meas tran vdout0_63ck1770 FIND v(dout0_63) AT=890.025n

.meas tran vdout0_64ck1770 FIND v(dout0_64) AT=890.025n

.meas tran vdout0_65ck1770 FIND v(dout0_65) AT=890.025n

.meas tran vdout0_66ck1770 FIND v(dout0_66) AT=890.025n

.meas tran vdout0_67ck1770 FIND v(dout0_67) AT=890.025n

.meas tran vdout0_68ck1770 FIND v(dout0_68) AT=890.025n

.meas tran vdout0_69ck1770 FIND v(dout0_69) AT=890.025n

.meas tran vdout0_70ck1770 FIND v(dout0_70) AT=890.025n

.meas tran vdout0_71ck1770 FIND v(dout0_71) AT=890.025n

.meas tran vdout0_72ck1770 FIND v(dout0_72) AT=890.025n

.meas tran vdout0_73ck1770 FIND v(dout0_73) AT=890.025n

.meas tran vdout0_74ck1770 FIND v(dout0_74) AT=890.025n

.meas tran vdout0_75ck1770 FIND v(dout0_75) AT=890.025n

.meas tran vdout0_76ck1770 FIND v(dout0_76) AT=890.025n

.meas tran vdout0_77ck1770 FIND v(dout0_77) AT=890.025n

.meas tran vdout0_78ck1770 FIND v(dout0_78) AT=890.025n

.meas tran vdout0_79ck1770 FIND v(dout0_79) AT=890.025n

.meas tran vdout0_80ck1770 FIND v(dout0_80) AT=890.025n

.meas tran vdout0_81ck1770 FIND v(dout0_81) AT=890.025n

.meas tran vdout0_82ck1770 FIND v(dout0_82) AT=890.025n

.meas tran vdout0_83ck1770 FIND v(dout0_83) AT=890.025n

.meas tran vdout0_84ck1770 FIND v(dout0_84) AT=890.025n

.meas tran vdout0_85ck1770 FIND v(dout0_85) AT=890.025n

.meas tran vdout0_86ck1770 FIND v(dout0_86) AT=890.025n

.meas tran vdout0_87ck1770 FIND v(dout0_87) AT=890.025n

.meas tran vdout0_88ck1770 FIND v(dout0_88) AT=890.025n

.meas tran vdout0_89ck1770 FIND v(dout0_89) AT=890.025n

.meas tran vdout0_90ck1770 FIND v(dout0_90) AT=890.025n

.meas tran vdout0_91ck1770 FIND v(dout0_91) AT=890.025n

.meas tran vdout0_92ck1770 FIND v(dout0_92) AT=890.025n

.meas tran vdout0_93ck1770 FIND v(dout0_93) AT=890.025n

.meas tran vdout0_94ck1770 FIND v(dout0_94) AT=890.025n

.meas tran vdout0_95ck1770 FIND v(dout0_95) AT=890.025n

.meas tran vdout0_96ck1770 FIND v(dout0_96) AT=890.025n

.meas tran vdout0_97ck1770 FIND v(dout0_97) AT=890.025n

.meas tran vdout0_98ck1770 FIND v(dout0_98) AT=890.025n

.meas tran vdout0_99ck1770 FIND v(dout0_99) AT=890.025n

.meas tran vdout0_100ck1770 FIND v(dout0_100) AT=890.025n

.meas tran vdout0_101ck1770 FIND v(dout0_101) AT=890.025n

.meas tran vdout0_102ck1770 FIND v(dout0_102) AT=890.025n

.meas tran vdout0_103ck1770 FIND v(dout0_103) AT=890.025n

.meas tran vdout0_104ck1770 FIND v(dout0_104) AT=890.025n

.meas tran vdout0_105ck1770 FIND v(dout0_105) AT=890.025n

.meas tran vdout0_106ck1770 FIND v(dout0_106) AT=890.025n

.meas tran vdout0_107ck1770 FIND v(dout0_107) AT=890.025n

.meas tran vdout0_108ck1770 FIND v(dout0_108) AT=890.025n

.meas tran vdout0_109ck1770 FIND v(dout0_109) AT=890.025n

.meas tran vdout0_110ck1770 FIND v(dout0_110) AT=890.025n

.meas tran vdout0_111ck1770 FIND v(dout0_111) AT=890.025n

.meas tran vdout0_112ck1770 FIND v(dout0_112) AT=890.025n

.meas tran vdout0_113ck1770 FIND v(dout0_113) AT=890.025n

.meas tran vdout0_114ck1770 FIND v(dout0_114) AT=890.025n

.meas tran vdout0_115ck1770 FIND v(dout0_115) AT=890.025n

.meas tran vdout0_116ck1770 FIND v(dout0_116) AT=890.025n

.meas tran vdout0_117ck1770 FIND v(dout0_117) AT=890.025n

.meas tran vdout0_118ck1770 FIND v(dout0_118) AT=890.025n

.meas tran vdout0_119ck1770 FIND v(dout0_119) AT=890.025n

.meas tran vdout0_120ck1770 FIND v(dout0_120) AT=890.025n

.meas tran vdout0_121ck1770 FIND v(dout0_121) AT=890.025n

.meas tran vdout0_122ck1770 FIND v(dout0_122) AT=890.025n

.meas tran vdout0_123ck1770 FIND v(dout0_123) AT=890.025n

.meas tran vdout0_124ck1770 FIND v(dout0_124) AT=890.025n

.meas tran vdout0_125ck1770 FIND v(dout0_125) AT=890.025n

.meas tran vdout0_126ck1770 FIND v(dout0_126) AT=890.025n

.meas tran vdout0_127ck1770 FIND v(dout0_127) AT=890.025n

.meas tran vdout0_0ck1800 FIND v(dout0_0) AT=905.025n

.meas tran vdout0_1ck1800 FIND v(dout0_1) AT=905.025n

.meas tran vdout0_2ck1800 FIND v(dout0_2) AT=905.025n

.meas tran vdout0_3ck1800 FIND v(dout0_3) AT=905.025n

.meas tran vdout0_4ck1800 FIND v(dout0_4) AT=905.025n

.meas tran vdout0_5ck1800 FIND v(dout0_5) AT=905.025n

.meas tran vdout0_6ck1800 FIND v(dout0_6) AT=905.025n

.meas tran vdout0_7ck1800 FIND v(dout0_7) AT=905.025n

.meas tran vdout0_8ck1800 FIND v(dout0_8) AT=905.025n

.meas tran vdout0_9ck1800 FIND v(dout0_9) AT=905.025n

.meas tran vdout0_10ck1800 FIND v(dout0_10) AT=905.025n

.meas tran vdout0_11ck1800 FIND v(dout0_11) AT=905.025n

.meas tran vdout0_12ck1800 FIND v(dout0_12) AT=905.025n

.meas tran vdout0_13ck1800 FIND v(dout0_13) AT=905.025n

.meas tran vdout0_14ck1800 FIND v(dout0_14) AT=905.025n

.meas tran vdout0_15ck1800 FIND v(dout0_15) AT=905.025n

.meas tran vdout0_16ck1800 FIND v(dout0_16) AT=905.025n

.meas tran vdout0_17ck1800 FIND v(dout0_17) AT=905.025n

.meas tran vdout0_18ck1800 FIND v(dout0_18) AT=905.025n

.meas tran vdout0_19ck1800 FIND v(dout0_19) AT=905.025n

.meas tran vdout0_20ck1800 FIND v(dout0_20) AT=905.025n

.meas tran vdout0_21ck1800 FIND v(dout0_21) AT=905.025n

.meas tran vdout0_22ck1800 FIND v(dout0_22) AT=905.025n

.meas tran vdout0_23ck1800 FIND v(dout0_23) AT=905.025n

.meas tran vdout0_24ck1800 FIND v(dout0_24) AT=905.025n

.meas tran vdout0_25ck1800 FIND v(dout0_25) AT=905.025n

.meas tran vdout0_26ck1800 FIND v(dout0_26) AT=905.025n

.meas tran vdout0_27ck1800 FIND v(dout0_27) AT=905.025n

.meas tran vdout0_28ck1800 FIND v(dout0_28) AT=905.025n

.meas tran vdout0_29ck1800 FIND v(dout0_29) AT=905.025n

.meas tran vdout0_30ck1800 FIND v(dout0_30) AT=905.025n

.meas tran vdout0_31ck1800 FIND v(dout0_31) AT=905.025n

.meas tran vdout0_32ck1800 FIND v(dout0_32) AT=905.025n

.meas tran vdout0_33ck1800 FIND v(dout0_33) AT=905.025n

.meas tran vdout0_34ck1800 FIND v(dout0_34) AT=905.025n

.meas tran vdout0_35ck1800 FIND v(dout0_35) AT=905.025n

.meas tran vdout0_36ck1800 FIND v(dout0_36) AT=905.025n

.meas tran vdout0_37ck1800 FIND v(dout0_37) AT=905.025n

.meas tran vdout0_38ck1800 FIND v(dout0_38) AT=905.025n

.meas tran vdout0_39ck1800 FIND v(dout0_39) AT=905.025n

.meas tran vdout0_40ck1800 FIND v(dout0_40) AT=905.025n

.meas tran vdout0_41ck1800 FIND v(dout0_41) AT=905.025n

.meas tran vdout0_42ck1800 FIND v(dout0_42) AT=905.025n

.meas tran vdout0_43ck1800 FIND v(dout0_43) AT=905.025n

.meas tran vdout0_44ck1800 FIND v(dout0_44) AT=905.025n

.meas tran vdout0_45ck1800 FIND v(dout0_45) AT=905.025n

.meas tran vdout0_46ck1800 FIND v(dout0_46) AT=905.025n

.meas tran vdout0_47ck1800 FIND v(dout0_47) AT=905.025n

.meas tran vdout0_48ck1800 FIND v(dout0_48) AT=905.025n

.meas tran vdout0_49ck1800 FIND v(dout0_49) AT=905.025n

.meas tran vdout0_50ck1800 FIND v(dout0_50) AT=905.025n

.meas tran vdout0_51ck1800 FIND v(dout0_51) AT=905.025n

.meas tran vdout0_52ck1800 FIND v(dout0_52) AT=905.025n

.meas tran vdout0_53ck1800 FIND v(dout0_53) AT=905.025n

.meas tran vdout0_54ck1800 FIND v(dout0_54) AT=905.025n

.meas tran vdout0_55ck1800 FIND v(dout0_55) AT=905.025n

.meas tran vdout0_56ck1800 FIND v(dout0_56) AT=905.025n

.meas tran vdout0_57ck1800 FIND v(dout0_57) AT=905.025n

.meas tran vdout0_58ck1800 FIND v(dout0_58) AT=905.025n

.meas tran vdout0_59ck1800 FIND v(dout0_59) AT=905.025n

.meas tran vdout0_60ck1800 FIND v(dout0_60) AT=905.025n

.meas tran vdout0_61ck1800 FIND v(dout0_61) AT=905.025n

.meas tran vdout0_62ck1800 FIND v(dout0_62) AT=905.025n

.meas tran vdout0_63ck1800 FIND v(dout0_63) AT=905.025n

.meas tran vdout0_64ck1800 FIND v(dout0_64) AT=905.025n

.meas tran vdout0_65ck1800 FIND v(dout0_65) AT=905.025n

.meas tran vdout0_66ck1800 FIND v(dout0_66) AT=905.025n

.meas tran vdout0_67ck1800 FIND v(dout0_67) AT=905.025n

.meas tran vdout0_68ck1800 FIND v(dout0_68) AT=905.025n

.meas tran vdout0_69ck1800 FIND v(dout0_69) AT=905.025n

.meas tran vdout0_70ck1800 FIND v(dout0_70) AT=905.025n

.meas tran vdout0_71ck1800 FIND v(dout0_71) AT=905.025n

.meas tran vdout0_72ck1800 FIND v(dout0_72) AT=905.025n

.meas tran vdout0_73ck1800 FIND v(dout0_73) AT=905.025n

.meas tran vdout0_74ck1800 FIND v(dout0_74) AT=905.025n

.meas tran vdout0_75ck1800 FIND v(dout0_75) AT=905.025n

.meas tran vdout0_76ck1800 FIND v(dout0_76) AT=905.025n

.meas tran vdout0_77ck1800 FIND v(dout0_77) AT=905.025n

.meas tran vdout0_78ck1800 FIND v(dout0_78) AT=905.025n

.meas tran vdout0_79ck1800 FIND v(dout0_79) AT=905.025n

.meas tran vdout0_80ck1800 FIND v(dout0_80) AT=905.025n

.meas tran vdout0_81ck1800 FIND v(dout0_81) AT=905.025n

.meas tran vdout0_82ck1800 FIND v(dout0_82) AT=905.025n

.meas tran vdout0_83ck1800 FIND v(dout0_83) AT=905.025n

.meas tran vdout0_84ck1800 FIND v(dout0_84) AT=905.025n

.meas tran vdout0_85ck1800 FIND v(dout0_85) AT=905.025n

.meas tran vdout0_86ck1800 FIND v(dout0_86) AT=905.025n

.meas tran vdout0_87ck1800 FIND v(dout0_87) AT=905.025n

.meas tran vdout0_88ck1800 FIND v(dout0_88) AT=905.025n

.meas tran vdout0_89ck1800 FIND v(dout0_89) AT=905.025n

.meas tran vdout0_90ck1800 FIND v(dout0_90) AT=905.025n

.meas tran vdout0_91ck1800 FIND v(dout0_91) AT=905.025n

.meas tran vdout0_92ck1800 FIND v(dout0_92) AT=905.025n

.meas tran vdout0_93ck1800 FIND v(dout0_93) AT=905.025n

.meas tran vdout0_94ck1800 FIND v(dout0_94) AT=905.025n

.meas tran vdout0_95ck1800 FIND v(dout0_95) AT=905.025n

.meas tran vdout0_96ck1800 FIND v(dout0_96) AT=905.025n

.meas tran vdout0_97ck1800 FIND v(dout0_97) AT=905.025n

.meas tran vdout0_98ck1800 FIND v(dout0_98) AT=905.025n

.meas tran vdout0_99ck1800 FIND v(dout0_99) AT=905.025n

.meas tran vdout0_100ck1800 FIND v(dout0_100) AT=905.025n

.meas tran vdout0_101ck1800 FIND v(dout0_101) AT=905.025n

.meas tran vdout0_102ck1800 FIND v(dout0_102) AT=905.025n

.meas tran vdout0_103ck1800 FIND v(dout0_103) AT=905.025n

.meas tran vdout0_104ck1800 FIND v(dout0_104) AT=905.025n

.meas tran vdout0_105ck1800 FIND v(dout0_105) AT=905.025n

.meas tran vdout0_106ck1800 FIND v(dout0_106) AT=905.025n

.meas tran vdout0_107ck1800 FIND v(dout0_107) AT=905.025n

.meas tran vdout0_108ck1800 FIND v(dout0_108) AT=905.025n

.meas tran vdout0_109ck1800 FIND v(dout0_109) AT=905.025n

.meas tran vdout0_110ck1800 FIND v(dout0_110) AT=905.025n

.meas tran vdout0_111ck1800 FIND v(dout0_111) AT=905.025n

.meas tran vdout0_112ck1800 FIND v(dout0_112) AT=905.025n

.meas tran vdout0_113ck1800 FIND v(dout0_113) AT=905.025n

.meas tran vdout0_114ck1800 FIND v(dout0_114) AT=905.025n

.meas tran vdout0_115ck1800 FIND v(dout0_115) AT=905.025n

.meas tran vdout0_116ck1800 FIND v(dout0_116) AT=905.025n

.meas tran vdout0_117ck1800 FIND v(dout0_117) AT=905.025n

.meas tran vdout0_118ck1800 FIND v(dout0_118) AT=905.025n

.meas tran vdout0_119ck1800 FIND v(dout0_119) AT=905.025n

.meas tran vdout0_120ck1800 FIND v(dout0_120) AT=905.025n

.meas tran vdout0_121ck1800 FIND v(dout0_121) AT=905.025n

.meas tran vdout0_122ck1800 FIND v(dout0_122) AT=905.025n

.meas tran vdout0_123ck1800 FIND v(dout0_123) AT=905.025n

.meas tran vdout0_124ck1800 FIND v(dout0_124) AT=905.025n

.meas tran vdout0_125ck1800 FIND v(dout0_125) AT=905.025n

.meas tran vdout0_126ck1800 FIND v(dout0_126) AT=905.025n

.meas tran vdout0_127ck1800 FIND v(dout0_127) AT=905.025n

.meas tran vdout0_0ck1820 FIND v(dout0_0) AT=915.025n

.meas tran vdout0_1ck1820 FIND v(dout0_1) AT=915.025n

.meas tran vdout0_2ck1820 FIND v(dout0_2) AT=915.025n

.meas tran vdout0_3ck1820 FIND v(dout0_3) AT=915.025n

.meas tran vdout0_4ck1820 FIND v(dout0_4) AT=915.025n

.meas tran vdout0_5ck1820 FIND v(dout0_5) AT=915.025n

.meas tran vdout0_6ck1820 FIND v(dout0_6) AT=915.025n

.meas tran vdout0_7ck1820 FIND v(dout0_7) AT=915.025n

.meas tran vdout0_8ck1820 FIND v(dout0_8) AT=915.025n

.meas tran vdout0_9ck1820 FIND v(dout0_9) AT=915.025n

.meas tran vdout0_10ck1820 FIND v(dout0_10) AT=915.025n

.meas tran vdout0_11ck1820 FIND v(dout0_11) AT=915.025n

.meas tran vdout0_12ck1820 FIND v(dout0_12) AT=915.025n

.meas tran vdout0_13ck1820 FIND v(dout0_13) AT=915.025n

.meas tran vdout0_14ck1820 FIND v(dout0_14) AT=915.025n

.meas tran vdout0_15ck1820 FIND v(dout0_15) AT=915.025n

.meas tran vdout0_16ck1820 FIND v(dout0_16) AT=915.025n

.meas tran vdout0_17ck1820 FIND v(dout0_17) AT=915.025n

.meas tran vdout0_18ck1820 FIND v(dout0_18) AT=915.025n

.meas tran vdout0_19ck1820 FIND v(dout0_19) AT=915.025n

.meas tran vdout0_20ck1820 FIND v(dout0_20) AT=915.025n

.meas tran vdout0_21ck1820 FIND v(dout0_21) AT=915.025n

.meas tran vdout0_22ck1820 FIND v(dout0_22) AT=915.025n

.meas tran vdout0_23ck1820 FIND v(dout0_23) AT=915.025n

.meas tran vdout0_24ck1820 FIND v(dout0_24) AT=915.025n

.meas tran vdout0_25ck1820 FIND v(dout0_25) AT=915.025n

.meas tran vdout0_26ck1820 FIND v(dout0_26) AT=915.025n

.meas tran vdout0_27ck1820 FIND v(dout0_27) AT=915.025n

.meas tran vdout0_28ck1820 FIND v(dout0_28) AT=915.025n

.meas tran vdout0_29ck1820 FIND v(dout0_29) AT=915.025n

.meas tran vdout0_30ck1820 FIND v(dout0_30) AT=915.025n

.meas tran vdout0_31ck1820 FIND v(dout0_31) AT=915.025n

.meas tran vdout0_32ck1820 FIND v(dout0_32) AT=915.025n

.meas tran vdout0_33ck1820 FIND v(dout0_33) AT=915.025n

.meas tran vdout0_34ck1820 FIND v(dout0_34) AT=915.025n

.meas tran vdout0_35ck1820 FIND v(dout0_35) AT=915.025n

.meas tran vdout0_36ck1820 FIND v(dout0_36) AT=915.025n

.meas tran vdout0_37ck1820 FIND v(dout0_37) AT=915.025n

.meas tran vdout0_38ck1820 FIND v(dout0_38) AT=915.025n

.meas tran vdout0_39ck1820 FIND v(dout0_39) AT=915.025n

.meas tran vdout0_40ck1820 FIND v(dout0_40) AT=915.025n

.meas tran vdout0_41ck1820 FIND v(dout0_41) AT=915.025n

.meas tran vdout0_42ck1820 FIND v(dout0_42) AT=915.025n

.meas tran vdout0_43ck1820 FIND v(dout0_43) AT=915.025n

.meas tran vdout0_44ck1820 FIND v(dout0_44) AT=915.025n

.meas tran vdout0_45ck1820 FIND v(dout0_45) AT=915.025n

.meas tran vdout0_46ck1820 FIND v(dout0_46) AT=915.025n

.meas tran vdout0_47ck1820 FIND v(dout0_47) AT=915.025n

.meas tran vdout0_48ck1820 FIND v(dout0_48) AT=915.025n

.meas tran vdout0_49ck1820 FIND v(dout0_49) AT=915.025n

.meas tran vdout0_50ck1820 FIND v(dout0_50) AT=915.025n

.meas tran vdout0_51ck1820 FIND v(dout0_51) AT=915.025n

.meas tran vdout0_52ck1820 FIND v(dout0_52) AT=915.025n

.meas tran vdout0_53ck1820 FIND v(dout0_53) AT=915.025n

.meas tran vdout0_54ck1820 FIND v(dout0_54) AT=915.025n

.meas tran vdout0_55ck1820 FIND v(dout0_55) AT=915.025n

.meas tran vdout0_56ck1820 FIND v(dout0_56) AT=915.025n

.meas tran vdout0_57ck1820 FIND v(dout0_57) AT=915.025n

.meas tran vdout0_58ck1820 FIND v(dout0_58) AT=915.025n

.meas tran vdout0_59ck1820 FIND v(dout0_59) AT=915.025n

.meas tran vdout0_60ck1820 FIND v(dout0_60) AT=915.025n

.meas tran vdout0_61ck1820 FIND v(dout0_61) AT=915.025n

.meas tran vdout0_62ck1820 FIND v(dout0_62) AT=915.025n

.meas tran vdout0_63ck1820 FIND v(dout0_63) AT=915.025n

.meas tran vdout0_64ck1820 FIND v(dout0_64) AT=915.025n

.meas tran vdout0_65ck1820 FIND v(dout0_65) AT=915.025n

.meas tran vdout0_66ck1820 FIND v(dout0_66) AT=915.025n

.meas tran vdout0_67ck1820 FIND v(dout0_67) AT=915.025n

.meas tran vdout0_68ck1820 FIND v(dout0_68) AT=915.025n

.meas tran vdout0_69ck1820 FIND v(dout0_69) AT=915.025n

.meas tran vdout0_70ck1820 FIND v(dout0_70) AT=915.025n

.meas tran vdout0_71ck1820 FIND v(dout0_71) AT=915.025n

.meas tran vdout0_72ck1820 FIND v(dout0_72) AT=915.025n

.meas tran vdout0_73ck1820 FIND v(dout0_73) AT=915.025n

.meas tran vdout0_74ck1820 FIND v(dout0_74) AT=915.025n

.meas tran vdout0_75ck1820 FIND v(dout0_75) AT=915.025n

.meas tran vdout0_76ck1820 FIND v(dout0_76) AT=915.025n

.meas tran vdout0_77ck1820 FIND v(dout0_77) AT=915.025n

.meas tran vdout0_78ck1820 FIND v(dout0_78) AT=915.025n

.meas tran vdout0_79ck1820 FIND v(dout0_79) AT=915.025n

.meas tran vdout0_80ck1820 FIND v(dout0_80) AT=915.025n

.meas tran vdout0_81ck1820 FIND v(dout0_81) AT=915.025n

.meas tran vdout0_82ck1820 FIND v(dout0_82) AT=915.025n

.meas tran vdout0_83ck1820 FIND v(dout0_83) AT=915.025n

.meas tran vdout0_84ck1820 FIND v(dout0_84) AT=915.025n

.meas tran vdout0_85ck1820 FIND v(dout0_85) AT=915.025n

.meas tran vdout0_86ck1820 FIND v(dout0_86) AT=915.025n

.meas tran vdout0_87ck1820 FIND v(dout0_87) AT=915.025n

.meas tran vdout0_88ck1820 FIND v(dout0_88) AT=915.025n

.meas tran vdout0_89ck1820 FIND v(dout0_89) AT=915.025n

.meas tran vdout0_90ck1820 FIND v(dout0_90) AT=915.025n

.meas tran vdout0_91ck1820 FIND v(dout0_91) AT=915.025n

.meas tran vdout0_92ck1820 FIND v(dout0_92) AT=915.025n

.meas tran vdout0_93ck1820 FIND v(dout0_93) AT=915.025n

.meas tran vdout0_94ck1820 FIND v(dout0_94) AT=915.025n

.meas tran vdout0_95ck1820 FIND v(dout0_95) AT=915.025n

.meas tran vdout0_96ck1820 FIND v(dout0_96) AT=915.025n

.meas tran vdout0_97ck1820 FIND v(dout0_97) AT=915.025n

.meas tran vdout0_98ck1820 FIND v(dout0_98) AT=915.025n

.meas tran vdout0_99ck1820 FIND v(dout0_99) AT=915.025n

.meas tran vdout0_100ck1820 FIND v(dout0_100) AT=915.025n

.meas tran vdout0_101ck1820 FIND v(dout0_101) AT=915.025n

.meas tran vdout0_102ck1820 FIND v(dout0_102) AT=915.025n

.meas tran vdout0_103ck1820 FIND v(dout0_103) AT=915.025n

.meas tran vdout0_104ck1820 FIND v(dout0_104) AT=915.025n

.meas tran vdout0_105ck1820 FIND v(dout0_105) AT=915.025n

.meas tran vdout0_106ck1820 FIND v(dout0_106) AT=915.025n

.meas tran vdout0_107ck1820 FIND v(dout0_107) AT=915.025n

.meas tran vdout0_108ck1820 FIND v(dout0_108) AT=915.025n

.meas tran vdout0_109ck1820 FIND v(dout0_109) AT=915.025n

.meas tran vdout0_110ck1820 FIND v(dout0_110) AT=915.025n

.meas tran vdout0_111ck1820 FIND v(dout0_111) AT=915.025n

.meas tran vdout0_112ck1820 FIND v(dout0_112) AT=915.025n

.meas tran vdout0_113ck1820 FIND v(dout0_113) AT=915.025n

.meas tran vdout0_114ck1820 FIND v(dout0_114) AT=915.025n

.meas tran vdout0_115ck1820 FIND v(dout0_115) AT=915.025n

.meas tran vdout0_116ck1820 FIND v(dout0_116) AT=915.025n

.meas tran vdout0_117ck1820 FIND v(dout0_117) AT=915.025n

.meas tran vdout0_118ck1820 FIND v(dout0_118) AT=915.025n

.meas tran vdout0_119ck1820 FIND v(dout0_119) AT=915.025n

.meas tran vdout0_120ck1820 FIND v(dout0_120) AT=915.025n

.meas tran vdout0_121ck1820 FIND v(dout0_121) AT=915.025n

.meas tran vdout0_122ck1820 FIND v(dout0_122) AT=915.025n

.meas tran vdout0_123ck1820 FIND v(dout0_123) AT=915.025n

.meas tran vdout0_124ck1820 FIND v(dout0_124) AT=915.025n

.meas tran vdout0_125ck1820 FIND v(dout0_125) AT=915.025n

.meas tran vdout0_126ck1820 FIND v(dout0_126) AT=915.025n

.meas tran vdout0_127ck1820 FIND v(dout0_127) AT=915.025n

.meas tran vdout0_0ck1830 FIND v(dout0_0) AT=920.025n

.meas tran vdout0_1ck1830 FIND v(dout0_1) AT=920.025n

.meas tran vdout0_2ck1830 FIND v(dout0_2) AT=920.025n

.meas tran vdout0_3ck1830 FIND v(dout0_3) AT=920.025n

.meas tran vdout0_4ck1830 FIND v(dout0_4) AT=920.025n

.meas tran vdout0_5ck1830 FIND v(dout0_5) AT=920.025n

.meas tran vdout0_6ck1830 FIND v(dout0_6) AT=920.025n

.meas tran vdout0_7ck1830 FIND v(dout0_7) AT=920.025n

.meas tran vdout0_8ck1830 FIND v(dout0_8) AT=920.025n

.meas tran vdout0_9ck1830 FIND v(dout0_9) AT=920.025n

.meas tran vdout0_10ck1830 FIND v(dout0_10) AT=920.025n

.meas tran vdout0_11ck1830 FIND v(dout0_11) AT=920.025n

.meas tran vdout0_12ck1830 FIND v(dout0_12) AT=920.025n

.meas tran vdout0_13ck1830 FIND v(dout0_13) AT=920.025n

.meas tran vdout0_14ck1830 FIND v(dout0_14) AT=920.025n

.meas tran vdout0_15ck1830 FIND v(dout0_15) AT=920.025n

.meas tran vdout0_16ck1830 FIND v(dout0_16) AT=920.025n

.meas tran vdout0_17ck1830 FIND v(dout0_17) AT=920.025n

.meas tran vdout0_18ck1830 FIND v(dout0_18) AT=920.025n

.meas tran vdout0_19ck1830 FIND v(dout0_19) AT=920.025n

.meas tran vdout0_20ck1830 FIND v(dout0_20) AT=920.025n

.meas tran vdout0_21ck1830 FIND v(dout0_21) AT=920.025n

.meas tran vdout0_22ck1830 FIND v(dout0_22) AT=920.025n

.meas tran vdout0_23ck1830 FIND v(dout0_23) AT=920.025n

.meas tran vdout0_24ck1830 FIND v(dout0_24) AT=920.025n

.meas tran vdout0_25ck1830 FIND v(dout0_25) AT=920.025n

.meas tran vdout0_26ck1830 FIND v(dout0_26) AT=920.025n

.meas tran vdout0_27ck1830 FIND v(dout0_27) AT=920.025n

.meas tran vdout0_28ck1830 FIND v(dout0_28) AT=920.025n

.meas tran vdout0_29ck1830 FIND v(dout0_29) AT=920.025n

.meas tran vdout0_30ck1830 FIND v(dout0_30) AT=920.025n

.meas tran vdout0_31ck1830 FIND v(dout0_31) AT=920.025n

.meas tran vdout0_32ck1830 FIND v(dout0_32) AT=920.025n

.meas tran vdout0_33ck1830 FIND v(dout0_33) AT=920.025n

.meas tran vdout0_34ck1830 FIND v(dout0_34) AT=920.025n

.meas tran vdout0_35ck1830 FIND v(dout0_35) AT=920.025n

.meas tran vdout0_36ck1830 FIND v(dout0_36) AT=920.025n

.meas tran vdout0_37ck1830 FIND v(dout0_37) AT=920.025n

.meas tran vdout0_38ck1830 FIND v(dout0_38) AT=920.025n

.meas tran vdout0_39ck1830 FIND v(dout0_39) AT=920.025n

.meas tran vdout0_40ck1830 FIND v(dout0_40) AT=920.025n

.meas tran vdout0_41ck1830 FIND v(dout0_41) AT=920.025n

.meas tran vdout0_42ck1830 FIND v(dout0_42) AT=920.025n

.meas tran vdout0_43ck1830 FIND v(dout0_43) AT=920.025n

.meas tran vdout0_44ck1830 FIND v(dout0_44) AT=920.025n

.meas tran vdout0_45ck1830 FIND v(dout0_45) AT=920.025n

.meas tran vdout0_46ck1830 FIND v(dout0_46) AT=920.025n

.meas tran vdout0_47ck1830 FIND v(dout0_47) AT=920.025n

.meas tran vdout0_48ck1830 FIND v(dout0_48) AT=920.025n

.meas tran vdout0_49ck1830 FIND v(dout0_49) AT=920.025n

.meas tran vdout0_50ck1830 FIND v(dout0_50) AT=920.025n

.meas tran vdout0_51ck1830 FIND v(dout0_51) AT=920.025n

.meas tran vdout0_52ck1830 FIND v(dout0_52) AT=920.025n

.meas tran vdout0_53ck1830 FIND v(dout0_53) AT=920.025n

.meas tran vdout0_54ck1830 FIND v(dout0_54) AT=920.025n

.meas tran vdout0_55ck1830 FIND v(dout0_55) AT=920.025n

.meas tran vdout0_56ck1830 FIND v(dout0_56) AT=920.025n

.meas tran vdout0_57ck1830 FIND v(dout0_57) AT=920.025n

.meas tran vdout0_58ck1830 FIND v(dout0_58) AT=920.025n

.meas tran vdout0_59ck1830 FIND v(dout0_59) AT=920.025n

.meas tran vdout0_60ck1830 FIND v(dout0_60) AT=920.025n

.meas tran vdout0_61ck1830 FIND v(dout0_61) AT=920.025n

.meas tran vdout0_62ck1830 FIND v(dout0_62) AT=920.025n

.meas tran vdout0_63ck1830 FIND v(dout0_63) AT=920.025n

.meas tran vdout0_64ck1830 FIND v(dout0_64) AT=920.025n

.meas tran vdout0_65ck1830 FIND v(dout0_65) AT=920.025n

.meas tran vdout0_66ck1830 FIND v(dout0_66) AT=920.025n

.meas tran vdout0_67ck1830 FIND v(dout0_67) AT=920.025n

.meas tran vdout0_68ck1830 FIND v(dout0_68) AT=920.025n

.meas tran vdout0_69ck1830 FIND v(dout0_69) AT=920.025n

.meas tran vdout0_70ck1830 FIND v(dout0_70) AT=920.025n

.meas tran vdout0_71ck1830 FIND v(dout0_71) AT=920.025n

.meas tran vdout0_72ck1830 FIND v(dout0_72) AT=920.025n

.meas tran vdout0_73ck1830 FIND v(dout0_73) AT=920.025n

.meas tran vdout0_74ck1830 FIND v(dout0_74) AT=920.025n

.meas tran vdout0_75ck1830 FIND v(dout0_75) AT=920.025n

.meas tran vdout0_76ck1830 FIND v(dout0_76) AT=920.025n

.meas tran vdout0_77ck1830 FIND v(dout0_77) AT=920.025n

.meas tran vdout0_78ck1830 FIND v(dout0_78) AT=920.025n

.meas tran vdout0_79ck1830 FIND v(dout0_79) AT=920.025n

.meas tran vdout0_80ck1830 FIND v(dout0_80) AT=920.025n

.meas tran vdout0_81ck1830 FIND v(dout0_81) AT=920.025n

.meas tran vdout0_82ck1830 FIND v(dout0_82) AT=920.025n

.meas tran vdout0_83ck1830 FIND v(dout0_83) AT=920.025n

.meas tran vdout0_84ck1830 FIND v(dout0_84) AT=920.025n

.meas tran vdout0_85ck1830 FIND v(dout0_85) AT=920.025n

.meas tran vdout0_86ck1830 FIND v(dout0_86) AT=920.025n

.meas tran vdout0_87ck1830 FIND v(dout0_87) AT=920.025n

.meas tran vdout0_88ck1830 FIND v(dout0_88) AT=920.025n

.meas tran vdout0_89ck1830 FIND v(dout0_89) AT=920.025n

.meas tran vdout0_90ck1830 FIND v(dout0_90) AT=920.025n

.meas tran vdout0_91ck1830 FIND v(dout0_91) AT=920.025n

.meas tran vdout0_92ck1830 FIND v(dout0_92) AT=920.025n

.meas tran vdout0_93ck1830 FIND v(dout0_93) AT=920.025n

.meas tran vdout0_94ck1830 FIND v(dout0_94) AT=920.025n

.meas tran vdout0_95ck1830 FIND v(dout0_95) AT=920.025n

.meas tran vdout0_96ck1830 FIND v(dout0_96) AT=920.025n

.meas tran vdout0_97ck1830 FIND v(dout0_97) AT=920.025n

.meas tran vdout0_98ck1830 FIND v(dout0_98) AT=920.025n

.meas tran vdout0_99ck1830 FIND v(dout0_99) AT=920.025n

.meas tran vdout0_100ck1830 FIND v(dout0_100) AT=920.025n

.meas tran vdout0_101ck1830 FIND v(dout0_101) AT=920.025n

.meas tran vdout0_102ck1830 FIND v(dout0_102) AT=920.025n

.meas tran vdout0_103ck1830 FIND v(dout0_103) AT=920.025n

.meas tran vdout0_104ck1830 FIND v(dout0_104) AT=920.025n

.meas tran vdout0_105ck1830 FIND v(dout0_105) AT=920.025n

.meas tran vdout0_106ck1830 FIND v(dout0_106) AT=920.025n

.meas tran vdout0_107ck1830 FIND v(dout0_107) AT=920.025n

.meas tran vdout0_108ck1830 FIND v(dout0_108) AT=920.025n

.meas tran vdout0_109ck1830 FIND v(dout0_109) AT=920.025n

.meas tran vdout0_110ck1830 FIND v(dout0_110) AT=920.025n

.meas tran vdout0_111ck1830 FIND v(dout0_111) AT=920.025n

.meas tran vdout0_112ck1830 FIND v(dout0_112) AT=920.025n

.meas tran vdout0_113ck1830 FIND v(dout0_113) AT=920.025n

.meas tran vdout0_114ck1830 FIND v(dout0_114) AT=920.025n

.meas tran vdout0_115ck1830 FIND v(dout0_115) AT=920.025n

.meas tran vdout0_116ck1830 FIND v(dout0_116) AT=920.025n

.meas tran vdout0_117ck1830 FIND v(dout0_117) AT=920.025n

.meas tran vdout0_118ck1830 FIND v(dout0_118) AT=920.025n

.meas tran vdout0_119ck1830 FIND v(dout0_119) AT=920.025n

.meas tran vdout0_120ck1830 FIND v(dout0_120) AT=920.025n

.meas tran vdout0_121ck1830 FIND v(dout0_121) AT=920.025n

.meas tran vdout0_122ck1830 FIND v(dout0_122) AT=920.025n

.meas tran vdout0_123ck1830 FIND v(dout0_123) AT=920.025n

.meas tran vdout0_124ck1830 FIND v(dout0_124) AT=920.025n

.meas tran vdout0_125ck1830 FIND v(dout0_125) AT=920.025n

.meas tran vdout0_126ck1830 FIND v(dout0_126) AT=920.025n

.meas tran vdout0_127ck1830 FIND v(dout0_127) AT=920.025n

.meas tran vdout0_0ck1860 FIND v(dout0_0) AT=935.025n

.meas tran vdout0_1ck1860 FIND v(dout0_1) AT=935.025n

.meas tran vdout0_2ck1860 FIND v(dout0_2) AT=935.025n

.meas tran vdout0_3ck1860 FIND v(dout0_3) AT=935.025n

.meas tran vdout0_4ck1860 FIND v(dout0_4) AT=935.025n

.meas tran vdout0_5ck1860 FIND v(dout0_5) AT=935.025n

.meas tran vdout0_6ck1860 FIND v(dout0_6) AT=935.025n

.meas tran vdout0_7ck1860 FIND v(dout0_7) AT=935.025n

.meas tran vdout0_8ck1860 FIND v(dout0_8) AT=935.025n

.meas tran vdout0_9ck1860 FIND v(dout0_9) AT=935.025n

.meas tran vdout0_10ck1860 FIND v(dout0_10) AT=935.025n

.meas tran vdout0_11ck1860 FIND v(dout0_11) AT=935.025n

.meas tran vdout0_12ck1860 FIND v(dout0_12) AT=935.025n

.meas tran vdout0_13ck1860 FIND v(dout0_13) AT=935.025n

.meas tran vdout0_14ck1860 FIND v(dout0_14) AT=935.025n

.meas tran vdout0_15ck1860 FIND v(dout0_15) AT=935.025n

.meas tran vdout0_16ck1860 FIND v(dout0_16) AT=935.025n

.meas tran vdout0_17ck1860 FIND v(dout0_17) AT=935.025n

.meas tran vdout0_18ck1860 FIND v(dout0_18) AT=935.025n

.meas tran vdout0_19ck1860 FIND v(dout0_19) AT=935.025n

.meas tran vdout0_20ck1860 FIND v(dout0_20) AT=935.025n

.meas tran vdout0_21ck1860 FIND v(dout0_21) AT=935.025n

.meas tran vdout0_22ck1860 FIND v(dout0_22) AT=935.025n

.meas tran vdout0_23ck1860 FIND v(dout0_23) AT=935.025n

.meas tran vdout0_24ck1860 FIND v(dout0_24) AT=935.025n

.meas tran vdout0_25ck1860 FIND v(dout0_25) AT=935.025n

.meas tran vdout0_26ck1860 FIND v(dout0_26) AT=935.025n

.meas tran vdout0_27ck1860 FIND v(dout0_27) AT=935.025n

.meas tran vdout0_28ck1860 FIND v(dout0_28) AT=935.025n

.meas tran vdout0_29ck1860 FIND v(dout0_29) AT=935.025n

.meas tran vdout0_30ck1860 FIND v(dout0_30) AT=935.025n

.meas tran vdout0_31ck1860 FIND v(dout0_31) AT=935.025n

.meas tran vdout0_32ck1860 FIND v(dout0_32) AT=935.025n

.meas tran vdout0_33ck1860 FIND v(dout0_33) AT=935.025n

.meas tran vdout0_34ck1860 FIND v(dout0_34) AT=935.025n

.meas tran vdout0_35ck1860 FIND v(dout0_35) AT=935.025n

.meas tran vdout0_36ck1860 FIND v(dout0_36) AT=935.025n

.meas tran vdout0_37ck1860 FIND v(dout0_37) AT=935.025n

.meas tran vdout0_38ck1860 FIND v(dout0_38) AT=935.025n

.meas tran vdout0_39ck1860 FIND v(dout0_39) AT=935.025n

.meas tran vdout0_40ck1860 FIND v(dout0_40) AT=935.025n

.meas tran vdout0_41ck1860 FIND v(dout0_41) AT=935.025n

.meas tran vdout0_42ck1860 FIND v(dout0_42) AT=935.025n

.meas tran vdout0_43ck1860 FIND v(dout0_43) AT=935.025n

.meas tran vdout0_44ck1860 FIND v(dout0_44) AT=935.025n

.meas tran vdout0_45ck1860 FIND v(dout0_45) AT=935.025n

.meas tran vdout0_46ck1860 FIND v(dout0_46) AT=935.025n

.meas tran vdout0_47ck1860 FIND v(dout0_47) AT=935.025n

.meas tran vdout0_48ck1860 FIND v(dout0_48) AT=935.025n

.meas tran vdout0_49ck1860 FIND v(dout0_49) AT=935.025n

.meas tran vdout0_50ck1860 FIND v(dout0_50) AT=935.025n

.meas tran vdout0_51ck1860 FIND v(dout0_51) AT=935.025n

.meas tran vdout0_52ck1860 FIND v(dout0_52) AT=935.025n

.meas tran vdout0_53ck1860 FIND v(dout0_53) AT=935.025n

.meas tran vdout0_54ck1860 FIND v(dout0_54) AT=935.025n

.meas tran vdout0_55ck1860 FIND v(dout0_55) AT=935.025n

.meas tran vdout0_56ck1860 FIND v(dout0_56) AT=935.025n

.meas tran vdout0_57ck1860 FIND v(dout0_57) AT=935.025n

.meas tran vdout0_58ck1860 FIND v(dout0_58) AT=935.025n

.meas tran vdout0_59ck1860 FIND v(dout0_59) AT=935.025n

.meas tran vdout0_60ck1860 FIND v(dout0_60) AT=935.025n

.meas tran vdout0_61ck1860 FIND v(dout0_61) AT=935.025n

.meas tran vdout0_62ck1860 FIND v(dout0_62) AT=935.025n

.meas tran vdout0_63ck1860 FIND v(dout0_63) AT=935.025n

.meas tran vdout0_64ck1860 FIND v(dout0_64) AT=935.025n

.meas tran vdout0_65ck1860 FIND v(dout0_65) AT=935.025n

.meas tran vdout0_66ck1860 FIND v(dout0_66) AT=935.025n

.meas tran vdout0_67ck1860 FIND v(dout0_67) AT=935.025n

.meas tran vdout0_68ck1860 FIND v(dout0_68) AT=935.025n

.meas tran vdout0_69ck1860 FIND v(dout0_69) AT=935.025n

.meas tran vdout0_70ck1860 FIND v(dout0_70) AT=935.025n

.meas tran vdout0_71ck1860 FIND v(dout0_71) AT=935.025n

.meas tran vdout0_72ck1860 FIND v(dout0_72) AT=935.025n

.meas tran vdout0_73ck1860 FIND v(dout0_73) AT=935.025n

.meas tran vdout0_74ck1860 FIND v(dout0_74) AT=935.025n

.meas tran vdout0_75ck1860 FIND v(dout0_75) AT=935.025n

.meas tran vdout0_76ck1860 FIND v(dout0_76) AT=935.025n

.meas tran vdout0_77ck1860 FIND v(dout0_77) AT=935.025n

.meas tran vdout0_78ck1860 FIND v(dout0_78) AT=935.025n

.meas tran vdout0_79ck1860 FIND v(dout0_79) AT=935.025n

.meas tran vdout0_80ck1860 FIND v(dout0_80) AT=935.025n

.meas tran vdout0_81ck1860 FIND v(dout0_81) AT=935.025n

.meas tran vdout0_82ck1860 FIND v(dout0_82) AT=935.025n

.meas tran vdout0_83ck1860 FIND v(dout0_83) AT=935.025n

.meas tran vdout0_84ck1860 FIND v(dout0_84) AT=935.025n

.meas tran vdout0_85ck1860 FIND v(dout0_85) AT=935.025n

.meas tran vdout0_86ck1860 FIND v(dout0_86) AT=935.025n

.meas tran vdout0_87ck1860 FIND v(dout0_87) AT=935.025n

.meas tran vdout0_88ck1860 FIND v(dout0_88) AT=935.025n

.meas tran vdout0_89ck1860 FIND v(dout0_89) AT=935.025n

.meas tran vdout0_90ck1860 FIND v(dout0_90) AT=935.025n

.meas tran vdout0_91ck1860 FIND v(dout0_91) AT=935.025n

.meas tran vdout0_92ck1860 FIND v(dout0_92) AT=935.025n

.meas tran vdout0_93ck1860 FIND v(dout0_93) AT=935.025n

.meas tran vdout0_94ck1860 FIND v(dout0_94) AT=935.025n

.meas tran vdout0_95ck1860 FIND v(dout0_95) AT=935.025n

.meas tran vdout0_96ck1860 FIND v(dout0_96) AT=935.025n

.meas tran vdout0_97ck1860 FIND v(dout0_97) AT=935.025n

.meas tran vdout0_98ck1860 FIND v(dout0_98) AT=935.025n

.meas tran vdout0_99ck1860 FIND v(dout0_99) AT=935.025n

.meas tran vdout0_100ck1860 FIND v(dout0_100) AT=935.025n

.meas tran vdout0_101ck1860 FIND v(dout0_101) AT=935.025n

.meas tran vdout0_102ck1860 FIND v(dout0_102) AT=935.025n

.meas tran vdout0_103ck1860 FIND v(dout0_103) AT=935.025n

.meas tran vdout0_104ck1860 FIND v(dout0_104) AT=935.025n

.meas tran vdout0_105ck1860 FIND v(dout0_105) AT=935.025n

.meas tran vdout0_106ck1860 FIND v(dout0_106) AT=935.025n

.meas tran vdout0_107ck1860 FIND v(dout0_107) AT=935.025n

.meas tran vdout0_108ck1860 FIND v(dout0_108) AT=935.025n

.meas tran vdout0_109ck1860 FIND v(dout0_109) AT=935.025n

.meas tran vdout0_110ck1860 FIND v(dout0_110) AT=935.025n

.meas tran vdout0_111ck1860 FIND v(dout0_111) AT=935.025n

.meas tran vdout0_112ck1860 FIND v(dout0_112) AT=935.025n

.meas tran vdout0_113ck1860 FIND v(dout0_113) AT=935.025n

.meas tran vdout0_114ck1860 FIND v(dout0_114) AT=935.025n

.meas tran vdout0_115ck1860 FIND v(dout0_115) AT=935.025n

.meas tran vdout0_116ck1860 FIND v(dout0_116) AT=935.025n

.meas tran vdout0_117ck1860 FIND v(dout0_117) AT=935.025n

.meas tran vdout0_118ck1860 FIND v(dout0_118) AT=935.025n

.meas tran vdout0_119ck1860 FIND v(dout0_119) AT=935.025n

.meas tran vdout0_120ck1860 FIND v(dout0_120) AT=935.025n

.meas tran vdout0_121ck1860 FIND v(dout0_121) AT=935.025n

.meas tran vdout0_122ck1860 FIND v(dout0_122) AT=935.025n

.meas tran vdout0_123ck1860 FIND v(dout0_123) AT=935.025n

.meas tran vdout0_124ck1860 FIND v(dout0_124) AT=935.025n

.meas tran vdout0_125ck1860 FIND v(dout0_125) AT=935.025n

.meas tran vdout0_126ck1860 FIND v(dout0_126) AT=935.025n

.meas tran vdout0_127ck1860 FIND v(dout0_127) AT=935.025n

.meas tran vdout0_0ck1940 FIND v(dout0_0) AT=975.025n

.meas tran vdout0_1ck1940 FIND v(dout0_1) AT=975.025n

.meas tran vdout0_2ck1940 FIND v(dout0_2) AT=975.025n

.meas tran vdout0_3ck1940 FIND v(dout0_3) AT=975.025n

.meas tran vdout0_4ck1940 FIND v(dout0_4) AT=975.025n

.meas tran vdout0_5ck1940 FIND v(dout0_5) AT=975.025n

.meas tran vdout0_6ck1940 FIND v(dout0_6) AT=975.025n

.meas tran vdout0_7ck1940 FIND v(dout0_7) AT=975.025n

.meas tran vdout0_8ck1940 FIND v(dout0_8) AT=975.025n

.meas tran vdout0_9ck1940 FIND v(dout0_9) AT=975.025n

.meas tran vdout0_10ck1940 FIND v(dout0_10) AT=975.025n

.meas tran vdout0_11ck1940 FIND v(dout0_11) AT=975.025n

.meas tran vdout0_12ck1940 FIND v(dout0_12) AT=975.025n

.meas tran vdout0_13ck1940 FIND v(dout0_13) AT=975.025n

.meas tran vdout0_14ck1940 FIND v(dout0_14) AT=975.025n

.meas tran vdout0_15ck1940 FIND v(dout0_15) AT=975.025n

.meas tran vdout0_16ck1940 FIND v(dout0_16) AT=975.025n

.meas tran vdout0_17ck1940 FIND v(dout0_17) AT=975.025n

.meas tran vdout0_18ck1940 FIND v(dout0_18) AT=975.025n

.meas tran vdout0_19ck1940 FIND v(dout0_19) AT=975.025n

.meas tran vdout0_20ck1940 FIND v(dout0_20) AT=975.025n

.meas tran vdout0_21ck1940 FIND v(dout0_21) AT=975.025n

.meas tran vdout0_22ck1940 FIND v(dout0_22) AT=975.025n

.meas tran vdout0_23ck1940 FIND v(dout0_23) AT=975.025n

.meas tran vdout0_24ck1940 FIND v(dout0_24) AT=975.025n

.meas tran vdout0_25ck1940 FIND v(dout0_25) AT=975.025n

.meas tran vdout0_26ck1940 FIND v(dout0_26) AT=975.025n

.meas tran vdout0_27ck1940 FIND v(dout0_27) AT=975.025n

.meas tran vdout0_28ck1940 FIND v(dout0_28) AT=975.025n

.meas tran vdout0_29ck1940 FIND v(dout0_29) AT=975.025n

.meas tran vdout0_30ck1940 FIND v(dout0_30) AT=975.025n

.meas tran vdout0_31ck1940 FIND v(dout0_31) AT=975.025n

.meas tran vdout0_32ck1940 FIND v(dout0_32) AT=975.025n

.meas tran vdout0_33ck1940 FIND v(dout0_33) AT=975.025n

.meas tran vdout0_34ck1940 FIND v(dout0_34) AT=975.025n

.meas tran vdout0_35ck1940 FIND v(dout0_35) AT=975.025n

.meas tran vdout0_36ck1940 FIND v(dout0_36) AT=975.025n

.meas tran vdout0_37ck1940 FIND v(dout0_37) AT=975.025n

.meas tran vdout0_38ck1940 FIND v(dout0_38) AT=975.025n

.meas tran vdout0_39ck1940 FIND v(dout0_39) AT=975.025n

.meas tran vdout0_40ck1940 FIND v(dout0_40) AT=975.025n

.meas tran vdout0_41ck1940 FIND v(dout0_41) AT=975.025n

.meas tran vdout0_42ck1940 FIND v(dout0_42) AT=975.025n

.meas tran vdout0_43ck1940 FIND v(dout0_43) AT=975.025n

.meas tran vdout0_44ck1940 FIND v(dout0_44) AT=975.025n

.meas tran vdout0_45ck1940 FIND v(dout0_45) AT=975.025n

.meas tran vdout0_46ck1940 FIND v(dout0_46) AT=975.025n

.meas tran vdout0_47ck1940 FIND v(dout0_47) AT=975.025n

.meas tran vdout0_48ck1940 FIND v(dout0_48) AT=975.025n

.meas tran vdout0_49ck1940 FIND v(dout0_49) AT=975.025n

.meas tran vdout0_50ck1940 FIND v(dout0_50) AT=975.025n

.meas tran vdout0_51ck1940 FIND v(dout0_51) AT=975.025n

.meas tran vdout0_52ck1940 FIND v(dout0_52) AT=975.025n

.meas tran vdout0_53ck1940 FIND v(dout0_53) AT=975.025n

.meas tran vdout0_54ck1940 FIND v(dout0_54) AT=975.025n

.meas tran vdout0_55ck1940 FIND v(dout0_55) AT=975.025n

.meas tran vdout0_56ck1940 FIND v(dout0_56) AT=975.025n

.meas tran vdout0_57ck1940 FIND v(dout0_57) AT=975.025n

.meas tran vdout0_58ck1940 FIND v(dout0_58) AT=975.025n

.meas tran vdout0_59ck1940 FIND v(dout0_59) AT=975.025n

.meas tran vdout0_60ck1940 FIND v(dout0_60) AT=975.025n

.meas tran vdout0_61ck1940 FIND v(dout0_61) AT=975.025n

.meas tran vdout0_62ck1940 FIND v(dout0_62) AT=975.025n

.meas tran vdout0_63ck1940 FIND v(dout0_63) AT=975.025n

.meas tran vdout0_64ck1940 FIND v(dout0_64) AT=975.025n

.meas tran vdout0_65ck1940 FIND v(dout0_65) AT=975.025n

.meas tran vdout0_66ck1940 FIND v(dout0_66) AT=975.025n

.meas tran vdout0_67ck1940 FIND v(dout0_67) AT=975.025n

.meas tran vdout0_68ck1940 FIND v(dout0_68) AT=975.025n

.meas tran vdout0_69ck1940 FIND v(dout0_69) AT=975.025n

.meas tran vdout0_70ck1940 FIND v(dout0_70) AT=975.025n

.meas tran vdout0_71ck1940 FIND v(dout0_71) AT=975.025n

.meas tran vdout0_72ck1940 FIND v(dout0_72) AT=975.025n

.meas tran vdout0_73ck1940 FIND v(dout0_73) AT=975.025n

.meas tran vdout0_74ck1940 FIND v(dout0_74) AT=975.025n

.meas tran vdout0_75ck1940 FIND v(dout0_75) AT=975.025n

.meas tran vdout0_76ck1940 FIND v(dout0_76) AT=975.025n

.meas tran vdout0_77ck1940 FIND v(dout0_77) AT=975.025n

.meas tran vdout0_78ck1940 FIND v(dout0_78) AT=975.025n

.meas tran vdout0_79ck1940 FIND v(dout0_79) AT=975.025n

.meas tran vdout0_80ck1940 FIND v(dout0_80) AT=975.025n

.meas tran vdout0_81ck1940 FIND v(dout0_81) AT=975.025n

.meas tran vdout0_82ck1940 FIND v(dout0_82) AT=975.025n

.meas tran vdout0_83ck1940 FIND v(dout0_83) AT=975.025n

.meas tran vdout0_84ck1940 FIND v(dout0_84) AT=975.025n

.meas tran vdout0_85ck1940 FIND v(dout0_85) AT=975.025n

.meas tran vdout0_86ck1940 FIND v(dout0_86) AT=975.025n

.meas tran vdout0_87ck1940 FIND v(dout0_87) AT=975.025n

.meas tran vdout0_88ck1940 FIND v(dout0_88) AT=975.025n

.meas tran vdout0_89ck1940 FIND v(dout0_89) AT=975.025n

.meas tran vdout0_90ck1940 FIND v(dout0_90) AT=975.025n

.meas tran vdout0_91ck1940 FIND v(dout0_91) AT=975.025n

.meas tran vdout0_92ck1940 FIND v(dout0_92) AT=975.025n

.meas tran vdout0_93ck1940 FIND v(dout0_93) AT=975.025n

.meas tran vdout0_94ck1940 FIND v(dout0_94) AT=975.025n

.meas tran vdout0_95ck1940 FIND v(dout0_95) AT=975.025n

.meas tran vdout0_96ck1940 FIND v(dout0_96) AT=975.025n

.meas tran vdout0_97ck1940 FIND v(dout0_97) AT=975.025n

.meas tran vdout0_98ck1940 FIND v(dout0_98) AT=975.025n

.meas tran vdout0_99ck1940 FIND v(dout0_99) AT=975.025n

.meas tran vdout0_100ck1940 FIND v(dout0_100) AT=975.025n

.meas tran vdout0_101ck1940 FIND v(dout0_101) AT=975.025n

.meas tran vdout0_102ck1940 FIND v(dout0_102) AT=975.025n

.meas tran vdout0_103ck1940 FIND v(dout0_103) AT=975.025n

.meas tran vdout0_104ck1940 FIND v(dout0_104) AT=975.025n

.meas tran vdout0_105ck1940 FIND v(dout0_105) AT=975.025n

.meas tran vdout0_106ck1940 FIND v(dout0_106) AT=975.025n

.meas tran vdout0_107ck1940 FIND v(dout0_107) AT=975.025n

.meas tran vdout0_108ck1940 FIND v(dout0_108) AT=975.025n

.meas tran vdout0_109ck1940 FIND v(dout0_109) AT=975.025n

.meas tran vdout0_110ck1940 FIND v(dout0_110) AT=975.025n

.meas tran vdout0_111ck1940 FIND v(dout0_111) AT=975.025n

.meas tran vdout0_112ck1940 FIND v(dout0_112) AT=975.025n

.meas tran vdout0_113ck1940 FIND v(dout0_113) AT=975.025n

.meas tran vdout0_114ck1940 FIND v(dout0_114) AT=975.025n

.meas tran vdout0_115ck1940 FIND v(dout0_115) AT=975.025n

.meas tran vdout0_116ck1940 FIND v(dout0_116) AT=975.025n

.meas tran vdout0_117ck1940 FIND v(dout0_117) AT=975.025n

.meas tran vdout0_118ck1940 FIND v(dout0_118) AT=975.025n

.meas tran vdout0_119ck1940 FIND v(dout0_119) AT=975.025n

.meas tran vdout0_120ck1940 FIND v(dout0_120) AT=975.025n

.meas tran vdout0_121ck1940 FIND v(dout0_121) AT=975.025n

.meas tran vdout0_122ck1940 FIND v(dout0_122) AT=975.025n

.meas tran vdout0_123ck1940 FIND v(dout0_123) AT=975.025n

.meas tran vdout0_124ck1940 FIND v(dout0_124) AT=975.025n

.meas tran vdout0_125ck1940 FIND v(dout0_125) AT=975.025n

.meas tran vdout0_126ck1940 FIND v(dout0_126) AT=975.025n

.meas tran vdout0_127ck1940 FIND v(dout0_127) AT=975.025n

.meas tran vdout0_0ck1960 FIND v(dout0_0) AT=985.025n

.meas tran vdout0_1ck1960 FIND v(dout0_1) AT=985.025n

.meas tran vdout0_2ck1960 FIND v(dout0_2) AT=985.025n

.meas tran vdout0_3ck1960 FIND v(dout0_3) AT=985.025n

.meas tran vdout0_4ck1960 FIND v(dout0_4) AT=985.025n

.meas tran vdout0_5ck1960 FIND v(dout0_5) AT=985.025n

.meas tran vdout0_6ck1960 FIND v(dout0_6) AT=985.025n

.meas tran vdout0_7ck1960 FIND v(dout0_7) AT=985.025n

.meas tran vdout0_8ck1960 FIND v(dout0_8) AT=985.025n

.meas tran vdout0_9ck1960 FIND v(dout0_9) AT=985.025n

.meas tran vdout0_10ck1960 FIND v(dout0_10) AT=985.025n

.meas tran vdout0_11ck1960 FIND v(dout0_11) AT=985.025n

.meas tran vdout0_12ck1960 FIND v(dout0_12) AT=985.025n

.meas tran vdout0_13ck1960 FIND v(dout0_13) AT=985.025n

.meas tran vdout0_14ck1960 FIND v(dout0_14) AT=985.025n

.meas tran vdout0_15ck1960 FIND v(dout0_15) AT=985.025n

.meas tran vdout0_16ck1960 FIND v(dout0_16) AT=985.025n

.meas tran vdout0_17ck1960 FIND v(dout0_17) AT=985.025n

.meas tran vdout0_18ck1960 FIND v(dout0_18) AT=985.025n

.meas tran vdout0_19ck1960 FIND v(dout0_19) AT=985.025n

.meas tran vdout0_20ck1960 FIND v(dout0_20) AT=985.025n

.meas tran vdout0_21ck1960 FIND v(dout0_21) AT=985.025n

.meas tran vdout0_22ck1960 FIND v(dout0_22) AT=985.025n

.meas tran vdout0_23ck1960 FIND v(dout0_23) AT=985.025n

.meas tran vdout0_24ck1960 FIND v(dout0_24) AT=985.025n

.meas tran vdout0_25ck1960 FIND v(dout0_25) AT=985.025n

.meas tran vdout0_26ck1960 FIND v(dout0_26) AT=985.025n

.meas tran vdout0_27ck1960 FIND v(dout0_27) AT=985.025n

.meas tran vdout0_28ck1960 FIND v(dout0_28) AT=985.025n

.meas tran vdout0_29ck1960 FIND v(dout0_29) AT=985.025n

.meas tran vdout0_30ck1960 FIND v(dout0_30) AT=985.025n

.meas tran vdout0_31ck1960 FIND v(dout0_31) AT=985.025n

.meas tran vdout0_32ck1960 FIND v(dout0_32) AT=985.025n

.meas tran vdout0_33ck1960 FIND v(dout0_33) AT=985.025n

.meas tran vdout0_34ck1960 FIND v(dout0_34) AT=985.025n

.meas tran vdout0_35ck1960 FIND v(dout0_35) AT=985.025n

.meas tran vdout0_36ck1960 FIND v(dout0_36) AT=985.025n

.meas tran vdout0_37ck1960 FIND v(dout0_37) AT=985.025n

.meas tran vdout0_38ck1960 FIND v(dout0_38) AT=985.025n

.meas tran vdout0_39ck1960 FIND v(dout0_39) AT=985.025n

.meas tran vdout0_40ck1960 FIND v(dout0_40) AT=985.025n

.meas tran vdout0_41ck1960 FIND v(dout0_41) AT=985.025n

.meas tran vdout0_42ck1960 FIND v(dout0_42) AT=985.025n

.meas tran vdout0_43ck1960 FIND v(dout0_43) AT=985.025n

.meas tran vdout0_44ck1960 FIND v(dout0_44) AT=985.025n

.meas tran vdout0_45ck1960 FIND v(dout0_45) AT=985.025n

.meas tran vdout0_46ck1960 FIND v(dout0_46) AT=985.025n

.meas tran vdout0_47ck1960 FIND v(dout0_47) AT=985.025n

.meas tran vdout0_48ck1960 FIND v(dout0_48) AT=985.025n

.meas tran vdout0_49ck1960 FIND v(dout0_49) AT=985.025n

.meas tran vdout0_50ck1960 FIND v(dout0_50) AT=985.025n

.meas tran vdout0_51ck1960 FIND v(dout0_51) AT=985.025n

.meas tran vdout0_52ck1960 FIND v(dout0_52) AT=985.025n

.meas tran vdout0_53ck1960 FIND v(dout0_53) AT=985.025n

.meas tran vdout0_54ck1960 FIND v(dout0_54) AT=985.025n

.meas tran vdout0_55ck1960 FIND v(dout0_55) AT=985.025n

.meas tran vdout0_56ck1960 FIND v(dout0_56) AT=985.025n

.meas tran vdout0_57ck1960 FIND v(dout0_57) AT=985.025n

.meas tran vdout0_58ck1960 FIND v(dout0_58) AT=985.025n

.meas tran vdout0_59ck1960 FIND v(dout0_59) AT=985.025n

.meas tran vdout0_60ck1960 FIND v(dout0_60) AT=985.025n

.meas tran vdout0_61ck1960 FIND v(dout0_61) AT=985.025n

.meas tran vdout0_62ck1960 FIND v(dout0_62) AT=985.025n

.meas tran vdout0_63ck1960 FIND v(dout0_63) AT=985.025n

.meas tran vdout0_64ck1960 FIND v(dout0_64) AT=985.025n

.meas tran vdout0_65ck1960 FIND v(dout0_65) AT=985.025n

.meas tran vdout0_66ck1960 FIND v(dout0_66) AT=985.025n

.meas tran vdout0_67ck1960 FIND v(dout0_67) AT=985.025n

.meas tran vdout0_68ck1960 FIND v(dout0_68) AT=985.025n

.meas tran vdout0_69ck1960 FIND v(dout0_69) AT=985.025n

.meas tran vdout0_70ck1960 FIND v(dout0_70) AT=985.025n

.meas tran vdout0_71ck1960 FIND v(dout0_71) AT=985.025n

.meas tran vdout0_72ck1960 FIND v(dout0_72) AT=985.025n

.meas tran vdout0_73ck1960 FIND v(dout0_73) AT=985.025n

.meas tran vdout0_74ck1960 FIND v(dout0_74) AT=985.025n

.meas tran vdout0_75ck1960 FIND v(dout0_75) AT=985.025n

.meas tran vdout0_76ck1960 FIND v(dout0_76) AT=985.025n

.meas tran vdout0_77ck1960 FIND v(dout0_77) AT=985.025n

.meas tran vdout0_78ck1960 FIND v(dout0_78) AT=985.025n

.meas tran vdout0_79ck1960 FIND v(dout0_79) AT=985.025n

.meas tran vdout0_80ck1960 FIND v(dout0_80) AT=985.025n

.meas tran vdout0_81ck1960 FIND v(dout0_81) AT=985.025n

.meas tran vdout0_82ck1960 FIND v(dout0_82) AT=985.025n

.meas tran vdout0_83ck1960 FIND v(dout0_83) AT=985.025n

.meas tran vdout0_84ck1960 FIND v(dout0_84) AT=985.025n

.meas tran vdout0_85ck1960 FIND v(dout0_85) AT=985.025n

.meas tran vdout0_86ck1960 FIND v(dout0_86) AT=985.025n

.meas tran vdout0_87ck1960 FIND v(dout0_87) AT=985.025n

.meas tran vdout0_88ck1960 FIND v(dout0_88) AT=985.025n

.meas tran vdout0_89ck1960 FIND v(dout0_89) AT=985.025n

.meas tran vdout0_90ck1960 FIND v(dout0_90) AT=985.025n

.meas tran vdout0_91ck1960 FIND v(dout0_91) AT=985.025n

.meas tran vdout0_92ck1960 FIND v(dout0_92) AT=985.025n

.meas tran vdout0_93ck1960 FIND v(dout0_93) AT=985.025n

.meas tran vdout0_94ck1960 FIND v(dout0_94) AT=985.025n

.meas tran vdout0_95ck1960 FIND v(dout0_95) AT=985.025n

.meas tran vdout0_96ck1960 FIND v(dout0_96) AT=985.025n

.meas tran vdout0_97ck1960 FIND v(dout0_97) AT=985.025n

.meas tran vdout0_98ck1960 FIND v(dout0_98) AT=985.025n

.meas tran vdout0_99ck1960 FIND v(dout0_99) AT=985.025n

.meas tran vdout0_100ck1960 FIND v(dout0_100) AT=985.025n

.meas tran vdout0_101ck1960 FIND v(dout0_101) AT=985.025n

.meas tran vdout0_102ck1960 FIND v(dout0_102) AT=985.025n

.meas tran vdout0_103ck1960 FIND v(dout0_103) AT=985.025n

.meas tran vdout0_104ck1960 FIND v(dout0_104) AT=985.025n

.meas tran vdout0_105ck1960 FIND v(dout0_105) AT=985.025n

.meas tran vdout0_106ck1960 FIND v(dout0_106) AT=985.025n

.meas tran vdout0_107ck1960 FIND v(dout0_107) AT=985.025n

.meas tran vdout0_108ck1960 FIND v(dout0_108) AT=985.025n

.meas tran vdout0_109ck1960 FIND v(dout0_109) AT=985.025n

.meas tran vdout0_110ck1960 FIND v(dout0_110) AT=985.025n

.meas tran vdout0_111ck1960 FIND v(dout0_111) AT=985.025n

.meas tran vdout0_112ck1960 FIND v(dout0_112) AT=985.025n

.meas tran vdout0_113ck1960 FIND v(dout0_113) AT=985.025n

.meas tran vdout0_114ck1960 FIND v(dout0_114) AT=985.025n

.meas tran vdout0_115ck1960 FIND v(dout0_115) AT=985.025n

.meas tran vdout0_116ck1960 FIND v(dout0_116) AT=985.025n

.meas tran vdout0_117ck1960 FIND v(dout0_117) AT=985.025n

.meas tran vdout0_118ck1960 FIND v(dout0_118) AT=985.025n

.meas tran vdout0_119ck1960 FIND v(dout0_119) AT=985.025n

.meas tran vdout0_120ck1960 FIND v(dout0_120) AT=985.025n

.meas tran vdout0_121ck1960 FIND v(dout0_121) AT=985.025n

.meas tran vdout0_122ck1960 FIND v(dout0_122) AT=985.025n

.meas tran vdout0_123ck1960 FIND v(dout0_123) AT=985.025n

.meas tran vdout0_124ck1960 FIND v(dout0_124) AT=985.025n

.meas tran vdout0_125ck1960 FIND v(dout0_125) AT=985.025n

.meas tran vdout0_126ck1960 FIND v(dout0_126) AT=985.025n

.meas tran vdout0_127ck1960 FIND v(dout0_127) AT=985.025n

.meas tran vdout0_0ck2020 FIND v(dout0_0) AT=1015.025n

.meas tran vdout0_1ck2020 FIND v(dout0_1) AT=1015.025n

.meas tran vdout0_2ck2020 FIND v(dout0_2) AT=1015.025n

.meas tran vdout0_3ck2020 FIND v(dout0_3) AT=1015.025n

.meas tran vdout0_4ck2020 FIND v(dout0_4) AT=1015.025n

.meas tran vdout0_5ck2020 FIND v(dout0_5) AT=1015.025n

.meas tran vdout0_6ck2020 FIND v(dout0_6) AT=1015.025n

.meas tran vdout0_7ck2020 FIND v(dout0_7) AT=1015.025n

.meas tran vdout0_8ck2020 FIND v(dout0_8) AT=1015.025n

.meas tran vdout0_9ck2020 FIND v(dout0_9) AT=1015.025n

.meas tran vdout0_10ck2020 FIND v(dout0_10) AT=1015.025n

.meas tran vdout0_11ck2020 FIND v(dout0_11) AT=1015.025n

.meas tran vdout0_12ck2020 FIND v(dout0_12) AT=1015.025n

.meas tran vdout0_13ck2020 FIND v(dout0_13) AT=1015.025n

.meas tran vdout0_14ck2020 FIND v(dout0_14) AT=1015.025n

.meas tran vdout0_15ck2020 FIND v(dout0_15) AT=1015.025n

.meas tran vdout0_16ck2020 FIND v(dout0_16) AT=1015.025n

.meas tran vdout0_17ck2020 FIND v(dout0_17) AT=1015.025n

.meas tran vdout0_18ck2020 FIND v(dout0_18) AT=1015.025n

.meas tran vdout0_19ck2020 FIND v(dout0_19) AT=1015.025n

.meas tran vdout0_20ck2020 FIND v(dout0_20) AT=1015.025n

.meas tran vdout0_21ck2020 FIND v(dout0_21) AT=1015.025n

.meas tran vdout0_22ck2020 FIND v(dout0_22) AT=1015.025n

.meas tran vdout0_23ck2020 FIND v(dout0_23) AT=1015.025n

.meas tran vdout0_24ck2020 FIND v(dout0_24) AT=1015.025n

.meas tran vdout0_25ck2020 FIND v(dout0_25) AT=1015.025n

.meas tran vdout0_26ck2020 FIND v(dout0_26) AT=1015.025n

.meas tran vdout0_27ck2020 FIND v(dout0_27) AT=1015.025n

.meas tran vdout0_28ck2020 FIND v(dout0_28) AT=1015.025n

.meas tran vdout0_29ck2020 FIND v(dout0_29) AT=1015.025n

.meas tran vdout0_30ck2020 FIND v(dout0_30) AT=1015.025n

.meas tran vdout0_31ck2020 FIND v(dout0_31) AT=1015.025n

.meas tran vdout0_32ck2020 FIND v(dout0_32) AT=1015.025n

.meas tran vdout0_33ck2020 FIND v(dout0_33) AT=1015.025n

.meas tran vdout0_34ck2020 FIND v(dout0_34) AT=1015.025n

.meas tran vdout0_35ck2020 FIND v(dout0_35) AT=1015.025n

.meas tran vdout0_36ck2020 FIND v(dout0_36) AT=1015.025n

.meas tran vdout0_37ck2020 FIND v(dout0_37) AT=1015.025n

.meas tran vdout0_38ck2020 FIND v(dout0_38) AT=1015.025n

.meas tran vdout0_39ck2020 FIND v(dout0_39) AT=1015.025n

.meas tran vdout0_40ck2020 FIND v(dout0_40) AT=1015.025n

.meas tran vdout0_41ck2020 FIND v(dout0_41) AT=1015.025n

.meas tran vdout0_42ck2020 FIND v(dout0_42) AT=1015.025n

.meas tran vdout0_43ck2020 FIND v(dout0_43) AT=1015.025n

.meas tran vdout0_44ck2020 FIND v(dout0_44) AT=1015.025n

.meas tran vdout0_45ck2020 FIND v(dout0_45) AT=1015.025n

.meas tran vdout0_46ck2020 FIND v(dout0_46) AT=1015.025n

.meas tran vdout0_47ck2020 FIND v(dout0_47) AT=1015.025n

.meas tran vdout0_48ck2020 FIND v(dout0_48) AT=1015.025n

.meas tran vdout0_49ck2020 FIND v(dout0_49) AT=1015.025n

.meas tran vdout0_50ck2020 FIND v(dout0_50) AT=1015.025n

.meas tran vdout0_51ck2020 FIND v(dout0_51) AT=1015.025n

.meas tran vdout0_52ck2020 FIND v(dout0_52) AT=1015.025n

.meas tran vdout0_53ck2020 FIND v(dout0_53) AT=1015.025n

.meas tran vdout0_54ck2020 FIND v(dout0_54) AT=1015.025n

.meas tran vdout0_55ck2020 FIND v(dout0_55) AT=1015.025n

.meas tran vdout0_56ck2020 FIND v(dout0_56) AT=1015.025n

.meas tran vdout0_57ck2020 FIND v(dout0_57) AT=1015.025n

.meas tran vdout0_58ck2020 FIND v(dout0_58) AT=1015.025n

.meas tran vdout0_59ck2020 FIND v(dout0_59) AT=1015.025n

.meas tran vdout0_60ck2020 FIND v(dout0_60) AT=1015.025n

.meas tran vdout0_61ck2020 FIND v(dout0_61) AT=1015.025n

.meas tran vdout0_62ck2020 FIND v(dout0_62) AT=1015.025n

.meas tran vdout0_63ck2020 FIND v(dout0_63) AT=1015.025n

.meas tran vdout0_64ck2020 FIND v(dout0_64) AT=1015.025n

.meas tran vdout0_65ck2020 FIND v(dout0_65) AT=1015.025n

.meas tran vdout0_66ck2020 FIND v(dout0_66) AT=1015.025n

.meas tran vdout0_67ck2020 FIND v(dout0_67) AT=1015.025n

.meas tran vdout0_68ck2020 FIND v(dout0_68) AT=1015.025n

.meas tran vdout0_69ck2020 FIND v(dout0_69) AT=1015.025n

.meas tran vdout0_70ck2020 FIND v(dout0_70) AT=1015.025n

.meas tran vdout0_71ck2020 FIND v(dout0_71) AT=1015.025n

.meas tran vdout0_72ck2020 FIND v(dout0_72) AT=1015.025n

.meas tran vdout0_73ck2020 FIND v(dout0_73) AT=1015.025n

.meas tran vdout0_74ck2020 FIND v(dout0_74) AT=1015.025n

.meas tran vdout0_75ck2020 FIND v(dout0_75) AT=1015.025n

.meas tran vdout0_76ck2020 FIND v(dout0_76) AT=1015.025n

.meas tran vdout0_77ck2020 FIND v(dout0_77) AT=1015.025n

.meas tran vdout0_78ck2020 FIND v(dout0_78) AT=1015.025n

.meas tran vdout0_79ck2020 FIND v(dout0_79) AT=1015.025n

.meas tran vdout0_80ck2020 FIND v(dout0_80) AT=1015.025n

.meas tran vdout0_81ck2020 FIND v(dout0_81) AT=1015.025n

.meas tran vdout0_82ck2020 FIND v(dout0_82) AT=1015.025n

.meas tran vdout0_83ck2020 FIND v(dout0_83) AT=1015.025n

.meas tran vdout0_84ck2020 FIND v(dout0_84) AT=1015.025n

.meas tran vdout0_85ck2020 FIND v(dout0_85) AT=1015.025n

.meas tran vdout0_86ck2020 FIND v(dout0_86) AT=1015.025n

.meas tran vdout0_87ck2020 FIND v(dout0_87) AT=1015.025n

.meas tran vdout0_88ck2020 FIND v(dout0_88) AT=1015.025n

.meas tran vdout0_89ck2020 FIND v(dout0_89) AT=1015.025n

.meas tran vdout0_90ck2020 FIND v(dout0_90) AT=1015.025n

.meas tran vdout0_91ck2020 FIND v(dout0_91) AT=1015.025n

.meas tran vdout0_92ck2020 FIND v(dout0_92) AT=1015.025n

.meas tran vdout0_93ck2020 FIND v(dout0_93) AT=1015.025n

.meas tran vdout0_94ck2020 FIND v(dout0_94) AT=1015.025n

.meas tran vdout0_95ck2020 FIND v(dout0_95) AT=1015.025n

.meas tran vdout0_96ck2020 FIND v(dout0_96) AT=1015.025n

.meas tran vdout0_97ck2020 FIND v(dout0_97) AT=1015.025n

.meas tran vdout0_98ck2020 FIND v(dout0_98) AT=1015.025n

.meas tran vdout0_99ck2020 FIND v(dout0_99) AT=1015.025n

.meas tran vdout0_100ck2020 FIND v(dout0_100) AT=1015.025n

.meas tran vdout0_101ck2020 FIND v(dout0_101) AT=1015.025n

.meas tran vdout0_102ck2020 FIND v(dout0_102) AT=1015.025n

.meas tran vdout0_103ck2020 FIND v(dout0_103) AT=1015.025n

.meas tran vdout0_104ck2020 FIND v(dout0_104) AT=1015.025n

.meas tran vdout0_105ck2020 FIND v(dout0_105) AT=1015.025n

.meas tran vdout0_106ck2020 FIND v(dout0_106) AT=1015.025n

.meas tran vdout0_107ck2020 FIND v(dout0_107) AT=1015.025n

.meas tran vdout0_108ck2020 FIND v(dout0_108) AT=1015.025n

.meas tran vdout0_109ck2020 FIND v(dout0_109) AT=1015.025n

.meas tran vdout0_110ck2020 FIND v(dout0_110) AT=1015.025n

.meas tran vdout0_111ck2020 FIND v(dout0_111) AT=1015.025n

.meas tran vdout0_112ck2020 FIND v(dout0_112) AT=1015.025n

.meas tran vdout0_113ck2020 FIND v(dout0_113) AT=1015.025n

.meas tran vdout0_114ck2020 FIND v(dout0_114) AT=1015.025n

.meas tran vdout0_115ck2020 FIND v(dout0_115) AT=1015.025n

.meas tran vdout0_116ck2020 FIND v(dout0_116) AT=1015.025n

.meas tran vdout0_117ck2020 FIND v(dout0_117) AT=1015.025n

.meas tran vdout0_118ck2020 FIND v(dout0_118) AT=1015.025n

.meas tran vdout0_119ck2020 FIND v(dout0_119) AT=1015.025n

.meas tran vdout0_120ck2020 FIND v(dout0_120) AT=1015.025n

.meas tran vdout0_121ck2020 FIND v(dout0_121) AT=1015.025n

.meas tran vdout0_122ck2020 FIND v(dout0_122) AT=1015.025n

.meas tran vdout0_123ck2020 FIND v(dout0_123) AT=1015.025n

.meas tran vdout0_124ck2020 FIND v(dout0_124) AT=1015.025n

.meas tran vdout0_125ck2020 FIND v(dout0_125) AT=1015.025n

.meas tran vdout0_126ck2020 FIND v(dout0_126) AT=1015.025n

.meas tran vdout0_127ck2020 FIND v(dout0_127) AT=1015.025n

.meas tran vdout0_0ck2030 FIND v(dout0_0) AT=1020.025n

.meas tran vdout0_1ck2030 FIND v(dout0_1) AT=1020.025n

.meas tran vdout0_2ck2030 FIND v(dout0_2) AT=1020.025n

.meas tran vdout0_3ck2030 FIND v(dout0_3) AT=1020.025n

.meas tran vdout0_4ck2030 FIND v(dout0_4) AT=1020.025n

.meas tran vdout0_5ck2030 FIND v(dout0_5) AT=1020.025n

.meas tran vdout0_6ck2030 FIND v(dout0_6) AT=1020.025n

.meas tran vdout0_7ck2030 FIND v(dout0_7) AT=1020.025n

.meas tran vdout0_8ck2030 FIND v(dout0_8) AT=1020.025n

.meas tran vdout0_9ck2030 FIND v(dout0_9) AT=1020.025n

.meas tran vdout0_10ck2030 FIND v(dout0_10) AT=1020.025n

.meas tran vdout0_11ck2030 FIND v(dout0_11) AT=1020.025n

.meas tran vdout0_12ck2030 FIND v(dout0_12) AT=1020.025n

.meas tran vdout0_13ck2030 FIND v(dout0_13) AT=1020.025n

.meas tran vdout0_14ck2030 FIND v(dout0_14) AT=1020.025n

.meas tran vdout0_15ck2030 FIND v(dout0_15) AT=1020.025n

.meas tran vdout0_16ck2030 FIND v(dout0_16) AT=1020.025n

.meas tran vdout0_17ck2030 FIND v(dout0_17) AT=1020.025n

.meas tran vdout0_18ck2030 FIND v(dout0_18) AT=1020.025n

.meas tran vdout0_19ck2030 FIND v(dout0_19) AT=1020.025n

.meas tran vdout0_20ck2030 FIND v(dout0_20) AT=1020.025n

.meas tran vdout0_21ck2030 FIND v(dout0_21) AT=1020.025n

.meas tran vdout0_22ck2030 FIND v(dout0_22) AT=1020.025n

.meas tran vdout0_23ck2030 FIND v(dout0_23) AT=1020.025n

.meas tran vdout0_24ck2030 FIND v(dout0_24) AT=1020.025n

.meas tran vdout0_25ck2030 FIND v(dout0_25) AT=1020.025n

.meas tran vdout0_26ck2030 FIND v(dout0_26) AT=1020.025n

.meas tran vdout0_27ck2030 FIND v(dout0_27) AT=1020.025n

.meas tran vdout0_28ck2030 FIND v(dout0_28) AT=1020.025n

.meas tran vdout0_29ck2030 FIND v(dout0_29) AT=1020.025n

.meas tran vdout0_30ck2030 FIND v(dout0_30) AT=1020.025n

.meas tran vdout0_31ck2030 FIND v(dout0_31) AT=1020.025n

.meas tran vdout0_32ck2030 FIND v(dout0_32) AT=1020.025n

.meas tran vdout0_33ck2030 FIND v(dout0_33) AT=1020.025n

.meas tran vdout0_34ck2030 FIND v(dout0_34) AT=1020.025n

.meas tran vdout0_35ck2030 FIND v(dout0_35) AT=1020.025n

.meas tran vdout0_36ck2030 FIND v(dout0_36) AT=1020.025n

.meas tran vdout0_37ck2030 FIND v(dout0_37) AT=1020.025n

.meas tran vdout0_38ck2030 FIND v(dout0_38) AT=1020.025n

.meas tran vdout0_39ck2030 FIND v(dout0_39) AT=1020.025n

.meas tran vdout0_40ck2030 FIND v(dout0_40) AT=1020.025n

.meas tran vdout0_41ck2030 FIND v(dout0_41) AT=1020.025n

.meas tran vdout0_42ck2030 FIND v(dout0_42) AT=1020.025n

.meas tran vdout0_43ck2030 FIND v(dout0_43) AT=1020.025n

.meas tran vdout0_44ck2030 FIND v(dout0_44) AT=1020.025n

.meas tran vdout0_45ck2030 FIND v(dout0_45) AT=1020.025n

.meas tran vdout0_46ck2030 FIND v(dout0_46) AT=1020.025n

.meas tran vdout0_47ck2030 FIND v(dout0_47) AT=1020.025n

.meas tran vdout0_48ck2030 FIND v(dout0_48) AT=1020.025n

.meas tran vdout0_49ck2030 FIND v(dout0_49) AT=1020.025n

.meas tran vdout0_50ck2030 FIND v(dout0_50) AT=1020.025n

.meas tran vdout0_51ck2030 FIND v(dout0_51) AT=1020.025n

.meas tran vdout0_52ck2030 FIND v(dout0_52) AT=1020.025n

.meas tran vdout0_53ck2030 FIND v(dout0_53) AT=1020.025n

.meas tran vdout0_54ck2030 FIND v(dout0_54) AT=1020.025n

.meas tran vdout0_55ck2030 FIND v(dout0_55) AT=1020.025n

.meas tran vdout0_56ck2030 FIND v(dout0_56) AT=1020.025n

.meas tran vdout0_57ck2030 FIND v(dout0_57) AT=1020.025n

.meas tran vdout0_58ck2030 FIND v(dout0_58) AT=1020.025n

.meas tran vdout0_59ck2030 FIND v(dout0_59) AT=1020.025n

.meas tran vdout0_60ck2030 FIND v(dout0_60) AT=1020.025n

.meas tran vdout0_61ck2030 FIND v(dout0_61) AT=1020.025n

.meas tran vdout0_62ck2030 FIND v(dout0_62) AT=1020.025n

.meas tran vdout0_63ck2030 FIND v(dout0_63) AT=1020.025n

.meas tran vdout0_64ck2030 FIND v(dout0_64) AT=1020.025n

.meas tran vdout0_65ck2030 FIND v(dout0_65) AT=1020.025n

.meas tran vdout0_66ck2030 FIND v(dout0_66) AT=1020.025n

.meas tran vdout0_67ck2030 FIND v(dout0_67) AT=1020.025n

.meas tran vdout0_68ck2030 FIND v(dout0_68) AT=1020.025n

.meas tran vdout0_69ck2030 FIND v(dout0_69) AT=1020.025n

.meas tran vdout0_70ck2030 FIND v(dout0_70) AT=1020.025n

.meas tran vdout0_71ck2030 FIND v(dout0_71) AT=1020.025n

.meas tran vdout0_72ck2030 FIND v(dout0_72) AT=1020.025n

.meas tran vdout0_73ck2030 FIND v(dout0_73) AT=1020.025n

.meas tran vdout0_74ck2030 FIND v(dout0_74) AT=1020.025n

.meas tran vdout0_75ck2030 FIND v(dout0_75) AT=1020.025n

.meas tran vdout0_76ck2030 FIND v(dout0_76) AT=1020.025n

.meas tran vdout0_77ck2030 FIND v(dout0_77) AT=1020.025n

.meas tran vdout0_78ck2030 FIND v(dout0_78) AT=1020.025n

.meas tran vdout0_79ck2030 FIND v(dout0_79) AT=1020.025n

.meas tran vdout0_80ck2030 FIND v(dout0_80) AT=1020.025n

.meas tran vdout0_81ck2030 FIND v(dout0_81) AT=1020.025n

.meas tran vdout0_82ck2030 FIND v(dout0_82) AT=1020.025n

.meas tran vdout0_83ck2030 FIND v(dout0_83) AT=1020.025n

.meas tran vdout0_84ck2030 FIND v(dout0_84) AT=1020.025n

.meas tran vdout0_85ck2030 FIND v(dout0_85) AT=1020.025n

.meas tran vdout0_86ck2030 FIND v(dout0_86) AT=1020.025n

.meas tran vdout0_87ck2030 FIND v(dout0_87) AT=1020.025n

.meas tran vdout0_88ck2030 FIND v(dout0_88) AT=1020.025n

.meas tran vdout0_89ck2030 FIND v(dout0_89) AT=1020.025n

.meas tran vdout0_90ck2030 FIND v(dout0_90) AT=1020.025n

.meas tran vdout0_91ck2030 FIND v(dout0_91) AT=1020.025n

.meas tran vdout0_92ck2030 FIND v(dout0_92) AT=1020.025n

.meas tran vdout0_93ck2030 FIND v(dout0_93) AT=1020.025n

.meas tran vdout0_94ck2030 FIND v(dout0_94) AT=1020.025n

.meas tran vdout0_95ck2030 FIND v(dout0_95) AT=1020.025n

.meas tran vdout0_96ck2030 FIND v(dout0_96) AT=1020.025n

.meas tran vdout0_97ck2030 FIND v(dout0_97) AT=1020.025n

.meas tran vdout0_98ck2030 FIND v(dout0_98) AT=1020.025n

.meas tran vdout0_99ck2030 FIND v(dout0_99) AT=1020.025n

.meas tran vdout0_100ck2030 FIND v(dout0_100) AT=1020.025n

.meas tran vdout0_101ck2030 FIND v(dout0_101) AT=1020.025n

.meas tran vdout0_102ck2030 FIND v(dout0_102) AT=1020.025n

.meas tran vdout0_103ck2030 FIND v(dout0_103) AT=1020.025n

.meas tran vdout0_104ck2030 FIND v(dout0_104) AT=1020.025n

.meas tran vdout0_105ck2030 FIND v(dout0_105) AT=1020.025n

.meas tran vdout0_106ck2030 FIND v(dout0_106) AT=1020.025n

.meas tran vdout0_107ck2030 FIND v(dout0_107) AT=1020.025n

.meas tran vdout0_108ck2030 FIND v(dout0_108) AT=1020.025n

.meas tran vdout0_109ck2030 FIND v(dout0_109) AT=1020.025n

.meas tran vdout0_110ck2030 FIND v(dout0_110) AT=1020.025n

.meas tran vdout0_111ck2030 FIND v(dout0_111) AT=1020.025n

.meas tran vdout0_112ck2030 FIND v(dout0_112) AT=1020.025n

.meas tran vdout0_113ck2030 FIND v(dout0_113) AT=1020.025n

.meas tran vdout0_114ck2030 FIND v(dout0_114) AT=1020.025n

.meas tran vdout0_115ck2030 FIND v(dout0_115) AT=1020.025n

.meas tran vdout0_116ck2030 FIND v(dout0_116) AT=1020.025n

.meas tran vdout0_117ck2030 FIND v(dout0_117) AT=1020.025n

.meas tran vdout0_118ck2030 FIND v(dout0_118) AT=1020.025n

.meas tran vdout0_119ck2030 FIND v(dout0_119) AT=1020.025n

.meas tran vdout0_120ck2030 FIND v(dout0_120) AT=1020.025n

.meas tran vdout0_121ck2030 FIND v(dout0_121) AT=1020.025n

.meas tran vdout0_122ck2030 FIND v(dout0_122) AT=1020.025n

.meas tran vdout0_123ck2030 FIND v(dout0_123) AT=1020.025n

.meas tran vdout0_124ck2030 FIND v(dout0_124) AT=1020.025n

.meas tran vdout0_125ck2030 FIND v(dout0_125) AT=1020.025n

.meas tran vdout0_126ck2030 FIND v(dout0_126) AT=1020.025n

.meas tran vdout0_127ck2030 FIND v(dout0_127) AT=1020.025n
